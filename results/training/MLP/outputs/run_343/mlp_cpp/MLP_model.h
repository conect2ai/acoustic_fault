#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.2699106449162493, -0.2220892062080534, -0.437447938017837, -0.8709917884634173, -0.320630921031092, -0.48332586315413967, -0.30399837965757726, 0.41584750734274245, -0.15268179656647224, -0.428332088949464, -0.5324210900689803, 0.9409641677235111, -0.3748863149625248, -0.2146527655037037, -0.20674759505044674, 0.5478470013218728, -0.6455059161640637, -0.4295614621503434, 0.4350721387523264, -0.4391383295336719, -0.5836961888272508, 0.6284465189678415, 0.8627488511682294, 0.1368771789023327, 0.34227735327366765, 0.4454321929553924, -0.6502492606307727, 0.0768065530818429, -0.1886211716464251, -0.4282535241058513, -0.6290851726226804, 0.19132430387553248, 0.7809291396639797, -0.30311738555309437, 0.3470914423464998, -0.17237001745110775, -0.30951543554397226, 0.006401594802816348, 0.4905207961621422, -0.022057772092296844, 0.5650282257717885, -0.20951306298051542, 0.5665653687053467, -0.3545197498360199, 0.8273165967488794, -0.6569859399947062, -0.2112338626018041, 0.5403237265636954, -0.6791685206844422, -0.17607810348529074, 0.21207129000010055, 0.6226931489432795, -0.4073889634825755, -0.5255067542198396, 0.5181750654605116, -0.4668237804984275, 0.6125933509047242, -0.11158576791781333, -0.35688014314248506, -0.2593312319149016, -0.46682472661423724, 0.5642218675667037, -0.6617744671526842, 0.2577856371708985},
    {-0.3286652508057335, -0.13099330793313294, -0.30650627242535977, -0.5173516918666228, -0.009432747420722103, -0.7643383587130859, -0.5259355034623239, 0.6331500047444156, -0.44803944526107137, -0.2579307060899726, -0.26210465846377445, 0.45997030609050793, -0.3408602051695794, -0.1431086482236872, -0.29184468465430713, 0.4967026947928473, -0.5126536419291923, -0.41933992034831347, 0.07093391492056626, -0.47961446141526604, -0.7880872672003671, 0.6142732516510981, 0.4193799922331084, 0.01943642668077241, -0.30840088930029635, 0.6409137661547403, -0.41182564617613426, 0.10791343367871443, 0.06390428216422726, -0.23347077065037847, -0.4772699803948337, 0.1606611907512265, 0.5317890888467616, -0.19017296251751747, 0.025556273161335873, -0.5070111015510187, -0.47035694851729715, -0.08627898000167208, 0.6822856919166135, 0.0655548746576613, 0.30386413563273884, -0.5854212732360888, 0.33584310405267886, -0.6116947449431602, 0.6780681402778929, -0.32170133673465107, -0.6464908573874146, 0.7280357007815869, -0.6604696898484943, -0.03580895156001745, 0.26679942817971175, 0.709206721001042, 0.09480329868698355, -0.6276943721725026, 0.6582779671713545, -0.31968590399581037, 0.7872823793623671, -0.2792746781315575, -0.09118202137271765, -0.23702602064029912, -0.5312181909342587, 0.6592073189864058, -0.42242724767437023, 0.4924437921791739},
    {-0.15027705695321375, -0.5204937164854836, -0.43412933284235017, -0.6667719184918818, -0.42349713817432105, -0.6959897286134086, -0.4202389274742923, 0.6349369002702298, -0.4150166859528153, -0.7526543226070762, -0.5485047173877686, 0.89329082181362, -0.5980648012300083, -0.35869912462626197, -0.37606470263809094, 0.48959996198125516, -0.5577857381117771, -0.5435878474684872, 0.09008159337827039, -0.4766001657189967, -0.7286110981018162, 0.803869100088993, 0.5872830913277015, -0.33563138765838674, 0.21398053440886539, 0.821663646296528, -0.8353275624091528, 0.1526018984963325, -0.2922900538580297, -0.41945421229891605, -0.6604673825088518, -0.00692844617336376, 0.9123390626717854, -0.13955866027168987, 0.38484109281103784, -0.20141984809561303, -0.48353217411586186, -0.3264853417544169, 0.6198419767154156, 0.08402018329985736, 0.30767643891470087, -0.5462808514090629, 0.23737171186322956, -0.46139351994489325, 0.5662624774115426, -0.638418210381089, -0.501751572246947, 0.7939249235465462, -0.481239125578678, -0.34533035123215006, 0.04265886978074466, 0.5603209769916461, 0.10862081135628131, -0.6735196437183842, 0.7645870159668069, -0.48928377682168245, 0.855625728589096, -0.810656632179712, -0.3670322750266827, -0.2430206219542828, -0.7235852386531015, 0.37562127735304807, -0.7075299491014901, 0.5054379052067342},
    {-0.4376308049778939, -0.3767644242560716, -0.5930408084276533, -0.40790109122909235, -0.6439232111556686, -0.9134320716718977, -0.38114533715379767, 0.6706742583031312, -0.3862343431971856, -0.4593427861776664, -0.6534309691399895, 0.823221289896428, -0.6595486279227307, -0.331552222844534, -0.2910197898120385, 0.3907973614817423, -0.7876479493768216, -0.6062463135535634, -0.265127153231917, -0.7733603780696906, -0.4941790320207767, 0.8389206496609566, 0.4975593321673159, -0.13663151844851174, -0.1526267470479792, 1.0098419088166275, -0.7431237379648499, -0.08856354985128835, -0.6000446438462831, -0.5551975368776167, -0.42661681198567497, -0.026978123191316757, 0.7845708663122041, -0.1383201631399762, 0.42614430995336927, -0.48299519943401426, -0.48995952623406397, -0.5360112870057983, 0.7130331040190168, 0.1649948983027613, 0.533141060914954, -0.40323131007082474, 0.0493487206934333, -0.6124457227404304, 0.7873865079257236, -0.7202936874558993, -0.842381974813995, 0.8263172815898806, -0.5133491152554849, -0.4203728849371982, -0.12552604741196124, 0.8175567603406763, 0.11012660302191599, -0.6761472064672404, 1.0688538984106413, -0.5264517214615231, 0.8593218293617643, -0.23305394346664193, -0.49837200808635085, -0.5260553074616622, -0.5708985966818017, 0.5320211643722548, -0.5946271374937593, 0.29809527338371405},
    {-0.5341486316126516, 0.030207963115864902, -0.45770547329252514, -0.5705892524327998, -0.6635546769698817, -0.48142247567672075, -0.5499445597903431, 0.5762747697910898, -0.5901685299105379, -0.6374859876988684, -0.5906840474961124, 0.9105918579103124, -0.9199350121381961, -0.6134526807178523, -0.5428166448833538, 0.5875664575955484, -0.5772259372659032, -0.6532977303238166, -0.3290054310482261, -0.8749044503978031, -0.6102909113571772, 0.8086988758168704, 0.4632084550726135, -0.4031750628773929, -0.09861435687825443, 0.49594250313789473, -0.747329587748737, -0.10608195787638496, -0.445248927706468, -0.6179450129871509, -0.5967876026128701, -0.14561253248337724, 0.8462421946296533, -0.3514986174060129, 0.47198724480084814, -0.701906433365335, -0.48175491402189424, -0.47571933046969006, 0.5640051819238044, -0.028150060473872553, 0.26057986383403914, -0.49829815894154517, 0.011060145512008682, -0.7185478649260438, 0.7124875761885345, -0.9040530094186819, -0.7168897137286212, 0.6228317881117008, -0.6530547875679976, -0.3819272878390584, -0.21897283942617762, 0.533881770597637, 0.2215669080039129, -0.43874769491483256, 0.5004557644133603, -0.3770900612050905, 0.8997715941807152, -0.709448757248607, -0.40786336986359567, -0.6075641416384681, -0.6403866959740772, 0.23328798988380703, -0.8188679843246508, 0.2420573117286197},
    {-0.5471719476183179, -0.06433100379492478, -0.6284546784659729, -0.7006176219711103, -0.53750695976334, -0.5398814065358614, -0.807490749276498, 0.7540063839069325, -0.5490261050829645, -0.6902360870666839, -0.6168215942126438, 0.7663448767056484, -0.6061314726775903, -0.16510969559963162, -0.4507854649351878, 0.27994157097787126, -0.7409332477871852, -0.6382475390488257, -0.26968205027568315, -0.7929254476167441, -0.7447631229749524, 0.6282623691241058, 0.29675605650365683, -0.1874546924173989, 0.1868051203910345, 0.8151661567033166, -0.5194269211641869, -0.12104234826036289, -0.6180726351158524, -0.6311497473359177, -0.48693652183223934, -0.22104217540315357, 0.498370700037517, -0.3274914785668462, -0.0022300979567382276, -0.3373738723098547, -0.24336279167820166, -0.6058925442479842, 0.4151138376427257, -0.1584464553343305, 0.44468476438175325, -0.7962023933602351, -0.09369784374963562, -0.7238413793027796, 0.7228887378233835, -0.5154836686110051, -0.5533468341196564, 0.5106872585318364, -0.8434751708080145, -0.20328594415311696, -0.02022989009924515, 0.6842304014793829, 0.06576342102540798, -0.6116408876969038, 0.6053983317408773, -0.6381698002449053, 0.47942214735480787, -0.36472513424941766, -0.513503492264957, -0.6176943366470341, -0.5282077779782782, 0.22979526046880383, -0.6451512176315959, 0.2483278785591122},
    {-0.46316790157935345, -0.18761399205219587, -0.39496298596476115, -0.41941847728559956, -0.3778131929622487, -0.7000482370335606, -0.590332942100723, 0.7843840606799061, -0.5630651332496315, -0.6200220455272231, -0.6231837108097227, 0.2939594065030255, -0.48713056371441543, -0.3730782802054768, -0.501436926555886, 0.3105799761992655, -0.6691022745873146, -0.6392517010963584, -0.2538020658965451, -0.713816014329603, -0.452703272617141, 0.6017265500945206, 0.22955160001919442, 0.1283445372675305, -0.0674533372995226, 0.4336306715156946, -0.447423721755937, -0.26347256283826037, -0.23582441502076404, -0.43213197904050304, -0.29279788903087267, -0.30274191139434525, 0.6686232893528885, -0.26147432330929155, 0.548970444814758, -0.3254120174225115, -0.6181593721071063, -0.4926684531782544, 0.5072689770643808, -0.1500871071053314, 0.2833725479646528, -0.703790759707783, -0.18434014626463932, -0.6528134219727112, 0.6491440251085611, -0.5792022583623949, -0.4691119214625546, 0.8913303641572627, -0.6873967510335709, -0.3639831783232018, 0.011366834818361279, 0.6728010921585932, 0.05509189529040765, -0.19503829346642368, 0.6196729194861041, -0.5819761859635325, 0.5545470659602444, -0.4563679695147798, -0.6237706213328724, -0.46533881441213254, -0.5427086636750722, 0.43957118330621925, -0.8697672293973914, 0.040092925591913284},
    {-0.410307852972505, -0.10046756432491345, -0.5807937668725318, -0.5101109066775473, -0.5912352480411842, -0.7334921985485594, -0.5886928691279236, 0.5027787042763471, -0.7189253964398636, -0.35274498207099625, -0.7929141757869974, 0.8125197775248223, -0.4823996174768928, -0.25270501756377645, -0.5833018927969847, 0.6482809962194707, -0.680320235534547, -0.7401166545172699, -0.3492949322513345, -0.7585944566621012, -0.66186814978148, 0.7087831309058601, 0.17606220776359585, -0.3118057680514108, -0.12844074687432266, 0.6219988990096514, -0.3917679833923482, -0.23099739724232007, -0.48309762015285773, -0.616211485911889, -0.5220447425326763, -0.32938221453692573, 0.6512365253393736, -0.332291702496938, 0.41901734159661863, -0.5247211236105678, -0.6230521901247685, -0.5501164362950611, 0.5950183693984377, -0.11936390095351562, 0.4114813749547129, -0.5528543631125776, -0.19379855227598755, -0.609015612864614, 0.6520176581350173, -0.7070372974550895, -0.7855531331906999, 0.5361098380874277, -0.4096530714398868, -0.3410077989062214, -0.24321166583551165, 0.5797893664140322, -0.06242395281120865, -0.4545496052545086, 0.655674139218087, -0.6438737057125692, 0.6315998688491457, -0.6640615470443602, -0.5999231951550481, -0.5547218007098692, -0.4489907031750353, 0.46891104719755133, -0.6670692496714666, -0.047924821590898704},
    {-0.3375825926722715, -0.1856721726312254, -0.7653859275542496, -0.5889404307603132, -0.7368999455099327, -0.5538680709027682, -0.5566268783755663, 0.7402235291424656, -0.3419224932448206, -0.554086884496585, -0.5551021602484759, 0.8040129265099433, -0.9647818035474442, -0.2052451181572028, -0.4951957660924964, 0.5014462251444999, -0.5668336105307487, -0.5981559490794798, -0.45397888011985765, -0.500128145767705, -0.6413727532390008, 0.667278932417815, 0.21084755556447923, -0.22091575037351088, -0.10129452730682635, 0.5505229362042909, -0.6486355598456824, 0.006641861302171516, -0.3238572872874842, -0.45160823614626383, -0.6263516022463042, -0.3559050589287008, 0.4917500526397251, -0.41174248207463415, 0.2447963796677637, -0.4735712381071686, -0.6321303297141251, 0.07794012051171638, 0.522495767787626, -0.11309496994987776, 0.20032489462626388, -0.6030456675704452, -0.04319082556808279, -0.9118152906975487, 0.8440078096636968, -0.37306139002892447, -0.7630246187754869, 0.4814619277673097, -0.7637396021990943, -0.4757515156100686, -0.21111343689300333, 0.4857888945567175, -0.15181199049737332, -0.5638188330951891, 0.585390754872226, -0.7207629897945962, 0.5822586887214884, -0.48911483427562596, -0.6204238850867239, -0.4441626287627215, -0.7789223429661921, 0.34942118787739784, -0.7802065397262231, 0.018625547503254337},
    {-0.4495016342342313, -0.23389068956598555, -0.5500260987820459, -0.5600891125940174, -0.5833497708892305, -0.6904037676935756, -0.7218841553868175, 0.4673555302819394, -0.5065458383589814, -0.4313753861585387, -0.6242514131293188, 0.8812631743712533, -0.5929049271372737, -0.5818368694903158, -0.6781812937008691, 0.22776827293544316, -0.5370577432760447, -0.6730739173232007, -0.3482998444652808, -0.8088434456377493, -0.4886102802792646, 0.67534792219775, 0.3551823824469047, -0.3036592980222764, -0.08389347451500695, 0.8123317026772138, -0.6398236885689284, -0.25185038898157563, -0.3825578939172518, -0.4966642882059126, -0.531620337237095, -0.3737053931635564, 0.659426184200985, -0.387282331090974, 0.3758713208155004, -0.48494116004786225, -0.4709514025566234, -0.162190474664573, 0.42714502263074094, -0.09087216580682785, 0.18479889605883962, -0.563590218963939, -0.09289244708379513, -0.5881146851227013, 0.4521685905615144, -0.5939082865760601, -0.7740314724068855, 0.540452042202341, -0.7857802318449816, -0.4856811188179841, -0.1449703953493745, 0.8264250639080636, -0.03499228598576571, -0.6037062139604948, 0.7213492962850078, -0.8350849670354704, 0.5844508481199917, -0.7187900752354712, -0.4939756080485632, -0.3659221493721472, -0.6125386163788974, 0.17164402971094428, -0.7465550721614308, -0.06205778539088459},
    {-0.3872069300320569, -0.21742813635091876, -0.5677505530976116, -0.550768072326662, -0.4505523493482002, -0.410406258554719, -0.6581024514823801, 0.5696743606344966, -0.5304322449262393, -0.5395501812222195, -0.7615356918159376, 0.6989499571236567, -0.4481986895522947, -0.6336160323870208, -0.5856321040448712, 0.25822152042192786, -0.6314771753254954, -0.6445037066446405, -0.4452895015083312, -0.8095478871062625, -0.6681452907072559, 0.6569326732636467, -0.15763104935058672, -0.06675531704684187, -0.47543896052459544, 0.4056312028016538, -0.494202610864636, -0.038364631702462244, -0.43170010588983715, -0.6298261435768638, -0.6273154214108884, -0.45583359841786086, 0.44760056890076677, -0.2488186976646775, 0.21617726572599436, -0.3650777143520688, -0.9197759270493507, -0.5307410812260903, 0.5702574719645392, -0.14778167827457006, 0.05936623363311371, -0.38945217734698656, -0.43441696143334735, -0.7626920244670661, 0.5473205591714249, -0.6035129894102435, -0.6007096225964939, 0.7359249449349808, -0.6155744078212106, -0.4755040093284288, -0.010938104917286653, 0.4012000232076842, -0.11073883299988559, -0.6200085318663086, 0.4605496113680957, -0.7623186105855565, 0.554701315086731, -0.8330655866382936, -0.5224990647808835, -0.40708422839788916, -0.45442428239527294, 0.12797157287405597, -0.7541633571701106, 0.18963425457651364},
    {-0.3952638781602784, -0.10827509146401625, -0.61214877954337, -0.5830981085553647, -0.5208369345246838, -0.9652074051983744, -0.8188363587137343, 0.19992407397899714, -0.42869112567627216, -0.5823566715601394, -0.7539290970820809, 0.3769398876286735, -0.5502122653044336, -0.6274145008267, -0.26439405270892763, 0.21561575477996417, -0.5294390692479166, -0.5836981850431261, -0.5816384291575922, -0.6005549244141081, -0.6613216348810678, 0.3359104528686667, 0.0950929650432729, 0.030900889524981587, -0.242253149997177, 0.5726694253905468, -0.7572043054259556, -0.13370226706544297, -0.3855229542730232, -0.4292893554657968, -0.5456896511750883, -0.06132799711009157, 0.4544027362942857, -0.5364687591909175, 0.1811367214396432, -0.842481681151132, -0.6694235158358364, -0.6487369874564936, 0.4627921636505242, -0.3311214989326313, -0.10653075410113966, -0.6561028969323744, -0.17624465275142825, -0.7879763923194141, 0.30079156536937507, -0.6808935109170476, -0.5104307915660724, 0.47194650123325116, -0.44491009681381394, -0.4715410692929324, -0.13630268595313538, 0.5089137666904032, -0.10538987565309123, -0.4130791868875145, 0.38803107441135426, -0.5162422186969332, 0.4474489486464442, -0.5216673882454337, -0.5722155915798537, -0.4552346311047227, -0.45534028903056045, 0.16754818525032464, -0.5733610081867869, 0.13581222345887364},
    {-0.26663523784875487, -0.11641591694268434, -0.6430920254152155, -0.2496517372523911, -0.31168050482915755, -0.8280130152476434, -0.4809149437255059, 0.583860291681604, -0.6448750407429482, -0.6758727479320529, -0.4551214817383831, 0.663624939111284, -0.5824029911161622, -0.47383022814550185, -0.5256775512282538, 0.1640472147161515, -0.4665504513176751, -0.5589054825705086, -0.4512353189419664, -0.6173415707019386, -0.5890120563761503, 0.4964435966383273, 0.4118935928631223, -0.1201709115285818, -0.41883457932066565, 0.5819066395385137, -0.5695263044226958, -0.39456990429733085, -0.37102462264539343, -0.5035565783515752, -0.5430891129076363, 0.011589597077440103, 0.505067454098565, -0.5377525818997303, 0.1966256036991613, -0.48722022872291054, -0.8395349737999445, -0.5203641056627468, 0.7717610991741847, -0.3114731575872085, 0.3227077502955724, -0.5942570214104369, -0.40181401943013206, -0.682031106232391, 0.45660215328448583, -0.4547929678631152, -0.6552587856496012, 0.6512266887748975, -0.6308293745721684, -0.3468259343224099, -0.4445747385403103, 0.7212473384776044, -0.13027215541463014, -0.3915860607367311, 0.4781214938482796, -0.45303369658664855, 0.9828365512518173, -0.568258976355075, -0.5339014395740697, -0.5934383704745873, -0.9642892676801659, 0.3102737173939579, -0.6166532956623941, 0.3702098494182531},
    {-0.5707177952345224, -0.34132813651260063, -0.6363154890486207, -0.3341326845379191, -0.4822484986830966, -0.817739948964918, -0.6453396172557602, 0.31103815100674687, -0.5412604501544181, -0.8231562727013008, -0.5644513035771217, 0.572927298931539, -0.6532987339248113, -0.35882853806412096, -0.6491689856346798, 0.10825685470522087, -0.5738562280672403, -0.7210217924845131, -0.5391705545155888, -0.4405037777554933, -0.28286502576259476, 0.539408803433001, -0.11919734509740351, -0.2741181961744186, -0.3927160082269983, 0.6542229672516525, -0.5370993522729856, -0.05711987184229589, -0.49530902993836706, -0.4086749385273793, -0.8921816020260096, -0.08386877030734464, 0.26792095927382636, -0.4958900854475856, 0.25767213523171323, -0.5923505212410402, -0.3951087665730347, -0.4562744413250841, 0.5914238877554782, -0.74302380068574, 0.12580754930120552, -0.5440980445899817, -0.22727836553407066, -0.6412574523966251, 0.20007539570143215, -0.8171005774978156, -0.8802559960673901, 0.3377933511771925, -0.6772434479402785, -0.5849684013078662, -0.0023317018491482264, 0.5613797393639443, -0.377717880457875, -0.7447876369433238, 0.31927631173289256, -0.6530277612930595, 0.8064134946504896, -0.6518007407413121, -0.33019265716193424, -0.5453907998336474, -0.6608553396082147, 0.1782681013888752, -0.7344671587915991, 0.014688693966129752},
    {-0.3548058512427885, -0.21478286716735492, -0.5132618428999258, -0.5470496239328224, -0.25466396478040276, -0.760391545974599, -0.6591177088683186, 0.7528018690429672, -0.5200646493950586, -0.6940407207664242, -0.7638391042154253, 0.594769544937727, -0.5640637735724264, -0.41274952959017286, -0.4492827247336614, 0.4382310447592744, -0.5985852807915168, -0.7453978242086635, -0.4549719112483422, -0.6243620630381974, -0.5474808615820612, 0.42277762540920494, 0.5214489232281289, -0.36272111926464096, 0.05032621591264783, 0.6298390334385531, -0.449524930604087, -0.32564206329388345, -0.49717444915743253, -0.5071246878533652, -0.46093603995322474, -0.11268489982883537, 0.8710887029946103, -0.321604168751604, 0.5524209410552539, -0.46770182903151347, -0.7101203789367067, -0.44809378937126415, 0.8032071203113814, -0.05595625125040876, 0.4426212593497776, -0.5129985868073473, -0.41506741775043915, -0.438750336756126, 0.44115294400632954, -0.5200210537318267, -0.5292960500405431, 0.64743591103229, -0.6401776767507193, -0.1520896748630294, -0.24602888340598425, 0.7468976344225801, -0.03907072076812506, -0.3339175949073978, 0.7650388531266116, -0.5027959071545394, 0.7161618804731753, -0.5018003653607095, -0.4697836405091317, -0.4083119072164222, -0.4525480664199159, 0.1806477626434113, -0.7215917256457628, -0.044519168835872196},
    {-0.5056178970174007, -0.10977314748096668, -0.6356177055597326, -0.5697606371640459, -0.48373758574174747, -0.742823416039965, -0.4852426029812205, 0.7683975042578532, -0.5315572497992451, -0.5305294480140799, -0.8104098783658908, 0.8213013121971949, -0.6149794451814583, -0.5433796981064116, -0.5645171421180039, 0.23821510478519356, -0.6919336130747139, -0.8359985408159609, -0.6844438366609185, -0.8352950893327934, -0.6830330819813687, 0.6030948990022192, 0.2737253814803457, -0.17355624526043284, 0.18451758620023773, 0.5613784036817171, -0.6188976269033845, -0.11820666429188836, -0.06582431397261546, -0.5053253399614175, -0.47542227963719386, -0.2766685817049006, 0.5869098392656312, -0.3060696060383547, 0.3199926875292198, -0.5125607225302206, -0.6101298374902281, -0.32310947174613136, 0.7098853556727013, -0.009236164235498652, 0.33290480011252216, -0.7204245943530501, -0.3147117247393065, -0.45789107174794186, 0.6415976745402455, -0.5855680418807088, -0.8298208682192999, 0.7067201930145287, -0.6521838188240847, -0.43162547643491933, -0.1723926462523631, 0.721120845025254, 0.020689168783179557, -0.7148112233396015, 0.7197900939878775, -0.6287321537263998, 0.6800901609967037, -0.7948959132183414, -0.6053786688343039, -0.42739577462429185, -0.6416775000440451, 0.5702436855644055, -0.6996592955467515, 0.023052033780880183},
    {-0.4420535100274248, 0.24688229994715571, -0.6401135869090008, -0.6711696549564022, -0.6197713072239858, -0.5081337407570601, -0.8268487623484438, 0.5417907344085948, -0.5869465541411242, -0.5262409412322817, -0.4966604345794326, 0.6864369253881375, -0.29739508350256255, -0.29699638845165294, -0.6581961655007056, 0.3509514515760827, -0.6351041940309827, -0.7122470993280577, -0.6920913433689933, -0.8628158554878347, -0.7094488600081933, 0.6169009057555117, 0.5351258618219131, -0.22993492299786372, 0.1813127712882638, 0.8527335693882677, -0.65976943488198, -0.27623078360463255, -0.5523505598006945, -0.31045624501206764, -0.6128145731943976, -0.3157322860992557, 0.7252282211939121, -0.10141974132186457, 0.17613105048550515, -0.428614201868262, -0.7201471086143726, -0.7251564688998288, 0.9511805380614788, -0.4092824113398711, 0.5559902443529631, -0.4418843908746142, -0.05735756407988496, -0.4221854101909321, 0.6102688487947039, -0.8546439820631426, -0.41818992532366467, 0.6597816736964939, -0.6932582108849047, -0.2490047424871474, -0.10308674770908931, 0.6052845843017662, -0.10576538796306405, -0.6117812762861223, 0.5543224948895121, -0.4332208694597413, 0.7738642614889778, -0.715967436136288, -0.2524890713091838, -0.4793117852827598, -0.3935628620875233, 0.2775128454335652, -0.5649865509833287, 0.10128975817590603},
    {-0.4209113956618537, -0.14305673200705404, -0.7177818212783713, -0.5213462320915704, -0.34726188313973655, -0.7720997102442771, -0.6016681766151868, 0.6009408007696225, -0.40242406396178265, -0.5914234384323412, -0.5736978420128094, 0.7167668010647849, -0.8424387707697366, -0.46207281840362424, -0.6752713656667769, 0.7203625708839673, -0.41818800415528284, -0.5146032265491243, -0.40579432409218763, -0.9144917870801426, -0.6946364354418806, 0.5463412961501249, 0.7641886835013753, -0.24441787754118763, 0.29089042688654937, 0.6752045412885371, -0.8748511869747453, -0.09075545342150743, -0.6294381828280746, -0.48804940903962973, -0.7123430944824425, -0.20720930165217963, 0.5821533584568809, -0.2725766869165178, 0.4759730006736825, -0.3896673675493786, -0.5833212658894045, -0.5277398136163269, 0.6114235455127778, -0.05882065649090251, 0.42937921613707297, -0.506169173463971, -0.20501042013970952, -0.6110079861052511, 0.7295568657974959, -0.49619224438675813, -0.6091651622191456, 0.7489877994422192, -0.7034070446414997, -0.5353098410804938, -0.40935638959516607, 0.6319166071160819, 0.02220047456354896, -0.5898452217176409, 1.0270271546774572, -0.4842593155048131, 0.7950727472256466, -0.46673181709579714, -0.5850136639537541, -0.16219350039189678, -0.693231725007292, 0.48873375983221873, -0.5963783776351596, 0.17452823069559276},
    {-0.5570601744474515, -0.3241190249188384, -0.6828638984255713, -0.6101449720491064, -0.24466959110787992, -0.4355191364748319, -0.387512674047303, 0.5706841599306663, -0.6277601917873663, -0.5925657447074935, -0.5635157773434891, 0.9380854809848715, -0.5542653641506393, -0.6432949594518264, -0.15683453273963122, 0.43034360259849724, -0.7791525390930759, -0.5205193217468181, -0.5662011048153943, -0.6998544852286839, -0.5690686761007278, 0.882784888049555, 0.6057955084182772, -0.3552462780899909, 0.4203347556355255, 0.7994726429392414, -0.5281168269208777, -0.15345168807894716, -0.3940166569779663, -0.48331939619821274, -0.303992864669471, -0.22959396862675174, 0.5515594116023094, -0.4098712603729549, 0.4380815067769669, -0.5119431799239004, -0.4406700560995684, -0.2101237171553615, 0.6641649842423917, -0.1314982076127736, 0.24599463130186494, -0.5266460370217178, 0.039677173032930974, -0.5413274973782887, 0.498662197887255, -0.4774541110462819, -0.5349795070208717, 0.7002877030586439, -0.8469278419649902, -0.7515514638493966, -0.3234177177589529, 0.6889286862661727, -0.2190081047322842, -0.8202120320528969, 1.0214369252812499, -0.47579449868574697, 0.8062953626524839, -0.5583211705046904, -0.42294929822005817, -0.29666376908609887, -0.6303018386803977, 0.5208542939277451, -0.5865955535224318, 0.1956242227499698},
    {-0.6092110825481092, -0.16760538466955904, -0.6222974034653517, -0.5088146602434048, -0.6727047860896713, -0.8526752974760232, -0.496525588046166, 0.49708768267859327, -0.7605154805582707, -0.6623420459445652, -0.5951728413236965, 0.8862742013049693, -0.6927556832894558, -0.5724104771642955, -0.38324079573567754, 0.4393460430507507, -0.6172583591187278, -0.560675260609218, -0.5751268074162188, -0.7089633158193828, -0.8216999306428198, 0.8337687252435247, 0.33762862193371784, 0.1737853495812613, -0.06336851774783625, 0.7560752022562137, -0.5206912454414068, -0.11668569847861485, -0.4605728296809122, -0.4683982772706715, -0.544085442862875, -0.26050998955419674, 0.8356310385199006, -0.18437194667956408, 0.2456466190943941, -0.5062064151515906, -0.4105611744467652, -0.6673101326532666, 0.717833276628249, -0.02648326147618132, 0.3793127176385897, -0.5940232729811316, -0.09866817608118121, -0.5667497432224401, 0.3655426456434062, -0.4788559111255424, -0.8226885218129983, 0.5590432624902679, -0.786890988815783, -0.25258243667237246, -0.34335546626808927, 0.8126326457380242, 0.03659871647132152, -0.615826730445782, 1.1036578317106582, -0.616999808661073, 0.5645534291865916, -0.5682151783085686, -0.4208988217442307, -0.5856664304608914, -0.2903443086767212, 0.2634096650771436, -0.669690847385186, 0.12040401575715552},
    {-0.11497728729316367, -0.311860222023468, -0.6034666379365634, -0.6000280348471312, -0.6936585398168337, -0.7981801984752661, -0.5437181735438131, 0.5627555995339143, -0.47641471988368084, -0.4826250272782234, -0.7157715370862939, 0.8982229033953647, -0.6286627235530843, -0.7085704533299213, -0.6115987915256721, 0.6153725917801398, -0.5630735409520792, -0.4325571331969061, -0.8337275983450956, -0.783721876520705, -0.6643215120942666, 0.5170291693392003, 0.6520530956027167, -0.04205194404545234, -0.2403024166274234, 0.6141332763111844, -0.7715806291719379, -0.22307014079684212, -0.5620179438018593, -0.605389094246374, -0.41025335557048975, 0.0012110081741413632, 0.6666963808617423, -0.3773180962521353, 0.2416509828943053, -0.5969376798158148, -0.45393307272507116, -0.34285180362129775, 0.7347892684245069, -0.10720701445420963, 0.07098195004248124, -0.5648928217811233, -0.17340193860097014, -0.5563645811382495, 0.2447994809796238, -0.742681880812156, -0.6427577270994378, 0.947949341163565, -0.6936541710350825, -0.4772211655919269, -0.1697610015040489, 0.5997156862391274, -0.22670095167008955, -0.6691380194594827, 0.9582166644145116, -0.631864758481011, 0.791532735199367, -0.36543600608747184, -0.30577261055925203, -0.6026895891818229, -0.5457827088468873, 0.3821691969304332, -0.6167411116630123, 0.3836778930591858},
    {-0.4779593901445138, -0.26410947114548355, -0.519593029217925, -0.5391829473749588, -0.5289928827280641, -0.6949472225976856, -0.46772492130038296, 0.9405739724569481, -0.7752133458142962, -0.5909053790260393, -0.5817634447693191, 0.5980766311728277, -0.7017371551087495, -0.5198944459208549, -0.6233454824871627, 0.4722039020474063, -0.5370291297649177, -0.5876640335010794, -0.48572293076276624, -0.8847332961542478, -0.5726648480600518, 0.9196626518534649, 0.961360572617925, 0.0012403192325979697, -0.006325130568316642, 0.9462065082741321, -0.46562926270030564, -0.011805080484134305, -0.4258375352696242, -0.20985641785668696, -0.6796563837870084, -0.20999599413900794, 0.8471884441196571, -0.033860140501483615, 0.408543093992303, -0.48787700373821963, -0.7285751318749923, -0.29452879080045713, 0.913855680796606, -0.1096173878395541, 0.6538439918982888, -0.6350140181318107, 0.16775487994054863, -0.8806295805558163, 0.8421638989933463, -0.18753114251014372, -0.7570992610707997, 0.8210518736235625, -0.6144838604989665, -0.2736206337880116, -0.03849730578399304, 0.6891744177218578, -0.024932328094365987, -0.6571917281415467, 0.6671135636737815, -0.8157390902429256, 1.0552558820645874, -0.45490702125314875, -0.2932968477932991, -0.28728531729597395, -0.6521388017620919, 0.4349119973727616, -0.3983037757143866, 0.6624902923050655},
    {-0.200066085397489, -0.6329324452222199, -0.2762618163881629, -0.7269262124683337, -0.3130954287053803, -0.6524450303537843, -0.356512422085959, 0.6804436644153171, -0.7875622693181334, -0.4992680420668198, -0.6992711458805714, 0.8146572462765905, -0.44552720059160716, -0.3737807499755519, -0.40278716194069186, 0.31609706906062496, -0.6434597820199822, -0.3284850686931836, -0.3124233326337907, -0.6730545712312553, -0.6147434913421742, 0.8365369595689817, 0.7515717024645766, -0.14192889707480036, 0.10596746767597894, 0.7550461095716337, -0.45275875717438374, -0.21253125758105088, -0.43206377804210017, -0.13647147987432123, -0.38209131343971686, -0.20424681060840494, 0.9104607173484123, -0.2630759673018919, 0.6421586796345382, -0.3289284217986317, -0.5548626815173291, -0.6257179604861975, 0.9342961900852557, -0.13437707674463728, 0.7029003815383419, -0.4827815164985934, 0.08585354874806081, -0.6434253964842926, 0.8215418604239156, -0.6119874430297447, -0.427705336334384, 0.8707606303125627, -0.519018340640029, -0.3325135641182393, -0.2206555083990952, 1.0798223620385414, -0.1502381638565126, -0.7167201397007582, 0.7086022057165635, -0.34293837191430493, 0.73644036134164, -0.3418519808365965, -0.4157752844073162, 0.1295574462731205, -0.5454915821648448, 0.6804523246327755, -0.5005247198934234, 0.6089271864755622},
    {-0.17788367415812023, 0.09938205485155924, -0.29208550538082817, -0.749878506929754, -0.5368477783679958, -0.7027320132931878, -0.6080143809679959, 0.5198171814397843, -0.5298023038977271, -0.4840083562911717, -0.6444991233921344, 0.7919450290559852, -0.44417145270631514, -0.5447552145099273, -0.40409155068984126, 0.45398640259442513, -0.6773056938642322, -0.5536689098524602, -0.47047242997174704, -0.6666685174645118, -0.6060095087886941, 0.6652294565066188, 0.2983591494824009, 0.04346512583981942, -0.26270421877146094, 0.6840680330392371, -0.4827185889766672, -0.29617561157777633, -0.19148023648668236, -0.31007052618983244, -0.5328860410325215, -0.10503478765148794, 0.8872085084342172, -0.34753126780318205, 0.59525234620545, -0.3630291928285527, -0.7999377717825453, -0.4493416413949378, 1.0642395064544425, -0.10384542271786304, 0.3599742623274879, -0.46186469586039275, -0.047862186414945204, -0.5931372951498133, 0.44376898972899076, -0.6073040615831851, -0.6100423967221777, 0.6463321720040366, -0.8502907334762422, -0.39297932893513055, -0.18597276539065094, 0.7927537861074074, -0.05672353288785404, -0.6709894197566965, 0.7917398716090902, -0.5363497417337045, 0.6682011518196181, -0.5065880981866293, -0.770933781664074, -0.30415815165884047, -0.5172949961831577, 0.41790734012463, -0.6992859975250617, 0.262710712129323},
    {-0.46669076589557784, -0.18150669901351438, -0.6479662175233136, -0.5212274759104264, -0.5547447433884108, -0.7498715905443447, -0.5541912237108773, 0.8273428012976223, -0.6886841896299406, -0.5115749835407924, -0.6378741110392375, 0.7546889630044386, -0.44430198619902306, -0.5492315762338529, -0.35652120733729914, 0.28833616709415033, -0.5502552323696991, -0.5543704239352161, -0.5550146319994403, -0.7196504507879894, -0.8207174369802566, 0.7359240904276488, 0.16677575574644302, -0.08653115920416689, 0.06881113215341479, 0.914015328884558, -0.4171019008506987, 0.009077879196300084, -0.45988119758928864, -0.25835139971872795, -0.4613208122186139, -0.15116858359617083, 0.8738454288980702, -0.4524647928551674, 0.5515796869639835, -0.5163899158907735, -0.7831323839503851, -0.3641847111962229, 0.7275555049333268, -0.1506521936017241, 0.07889356281345665, -0.4584707594863809, -0.10772056395274726, -0.4839870003154848, 0.7482725218692124, -0.45140788298398143, -0.6893060260077422, 0.5431381600049683, -0.5596794638352464, -0.6505241764361442, -0.06393488370821714, 0.6952217092950363, -0.261225455371107, -0.764623696757695, 0.715820970848876, -0.7585448203866203, 0.7204708276617302, -0.38665143343804215, -0.4264860718784786, -0.3281698239238875, -0.6863561911009827, 0.16446368820498306, -0.7014942341942395, 0.030360353420876354},
    {-0.17028616424177753, -0.35204838206559563, -0.6814834589515488, -0.5618411164779583, -0.5770165931765531, -0.5844517807528913, -0.6496131559740642, 0.8077104288129815, -0.3986503142145688, -0.39816414411180445, -0.4018573337472072, 0.615351337609691, -0.5875290691405931, -0.6120037701795957, -0.43824196877874755, 0.4884037665446222, -0.5286373023237312, -0.7178713360733638, -0.4127038696044635, -0.6106585940597791, -0.6008802981784793, 0.6504567095790325, 0.7819709651736245, -0.03905628644861524, -0.22300177093047877, 0.6680195230887692, -0.36002014027083984, -0.030483917930149505, -0.4373407205912402, -0.3956259427128099, -0.6223115065779017, -0.33159122594615387, 0.7583026897379658, -0.40097560218155637, 0.37518572926142296, -0.4181505851663095, -0.547802965933559, -0.20219617648487007, 0.5529163170324177, -0.07081144660636975, 0.2593812749610831, -0.7410306316414166, -0.15808320253568653, -0.6434233632678014, 0.79125797800488, -0.42406380471442867, -0.4767297215806576, 0.5738469245926733, -0.7248216334475208, -0.15951604633932645, -0.3022895941136669, 0.6624726550477641, -0.06449906087532711, -0.7173023476155822, 0.7131822110195423, -0.26077738915698523, 1.0688654849357906, -0.452416527285612, -0.45395089040870884, -0.17758950388825906, -0.6006755052904699, 0.5663883361819152, -0.6032536733433983, 0.24393532685722305},
    {-0.24728528631106175, -0.09029423817206195, -0.5570981318452575, -0.45982893522458274, -0.4602321951397846, -0.5479005967553501, -0.7108492612182339, 0.6211490206800749, -0.6082732767860402, -0.5629558532689188, -0.6801141303109696, 0.6496511865587542, -0.5283998901925924, -0.4573207711071788, -0.3983624173665362, 0.534810273271885, -0.6758526874460781, -0.6661062841185791, -0.33619144374120213, -0.7485474437467858, -0.5817038115508706, 0.7260305734085896, 0.42729597282079657, -0.025160856960480156, -0.056138386217105006, 0.6767360147756368, -0.6020730696500304, 0.001934082967260071, -0.4148224776834707, -0.2858487913809078, -0.42652111146969196, 0.09114039854151168, 0.5677224090399118, -0.5545786208772926, 0.5086173847618514, -0.5266635173053413, -0.5810921501148395, -0.5159967841019149, 0.6900394481322435, -0.07663604333366392, 0.3282652292976101, -0.619182404222148, -0.13047887312398687, -0.67135616663993, 0.6635830565113137, -0.621180391642707, -0.6567815585204076, 0.8893408029477956, -0.4262402000532523, -0.3069802312765953, -0.007577518456565706, 0.3449804930003524, 0.04540538481056975, -0.5980788147890403, 0.767343799938615, -0.4771062600853214, 0.8087741844224934, -0.5759625028904244, -0.29077218896283596, -0.6225476354998751, -0.5106051739247996, 0.641532091820152, -0.6665733579062938, 0.3807947091691171},
    {-0.3263864439775891, 0.02542273992769238, -0.5096652185588357, -0.5125311913591781, -0.5402291255616224, -0.8506686148969629, -0.4615515415995534, 0.8248965751699222, -0.35097942450912384, -0.46102091064440986, -0.5401869565122908, 0.9685726953726431, -0.4451514352469195, -0.5356086532891547, -0.780820406047055, 0.4888180675401929, -0.6539062522393446, -0.5749767378651486, -0.25688938300930586, -0.5122914820623446, -0.7413178675338216, 0.7099273953859038, 0.5134829922268084, 0.1390079700143973, 0.13685692442734296, 0.7511283240387898, -0.5169963143285836, -0.01420214303684825, -0.5056120454783618, -0.33500948734843916, -0.5634195307402452, -0.034811242804506426, 0.8366914204291374, -0.27075373479600773, 0.4058176823265959, -0.5757903681266738, -0.5119003187260227, -0.44282183206452475, 0.6103720024236632, 0.03605955670608621, 0.46844366523006986, -0.44383388118277634, -0.02982056410165197, -0.6217922484606832, 0.7694409357755048, -0.47080541792160513, -0.6326979444582433, 0.8180591540774644, -0.632619358892901, -0.3622518511435738, -0.26720367199730494, 0.7548579710359663, 0.10214117889627221, -0.5918223712118511, 0.8149924804741552, -0.583496317111296, 0.7300429077711652, -0.7335723136922093, -0.2983484991888566, -0.5875453121647871, -0.48407057601213893, 0.38461054955997154, -0.5850897662031525, 0.17721470422314436},
    {-0.3151055729691312, -0.24349232960588363, -0.47694663567691686, -0.7603993437600081, -0.3687902278910787, -0.46528434539959196, -0.452545202514118, 0.5399724351356175, -0.2749323568809889, -0.5244369171047912, -0.4002590416211391, 0.8432424662399894, -0.5609020689789694, -0.7272232911767539, -0.43732156330817745, 0.35408377376114397, -0.6466962879557642, -0.25046109584593784, -0.44440363349966266, -0.664680953426983, -0.6348872780393031, 0.8190637980778889, 0.6863836850471461, -0.0858554463069552, -0.06463866371753184, 0.737892916342727, -0.4657566561402278, -0.2849201000548421, -0.4004420013432067, -0.2265812058996384, -0.651003876395898, -0.23133219267359145, 0.5858608700721957, -0.40221571437391207, 0.5606566577152872, -0.540886801925894, -0.527489839579661, -0.3379945213173504, 0.7505725322109646, -0.2417127035999558, 0.1615665235639791, -0.45467643125806784, 0.0017418382912698027, -0.6727948214065695, 0.6435499247340257, -0.6061154578505029, -0.7402527929331159, 0.9005025819803899, -0.7527395632424838, -0.5287314163652186, -0.003735722979687136, 0.7281367275641842, 0.0348660484838019, -0.5030945394479954, 0.7678725833367857, -0.49746856734941225, 0.7164160715239909, -0.6397390211872253, -0.33135072034700525, -0.5212705507670543, -0.3442867918426057, 0.44953440380586385, -0.47800139816519854, 0.35974120697331785},
    {-0.2703187520496225, -0.27329218319932286, -0.4558567543351208, -0.5276485334203294, -0.27760404234659225, -0.6647998749061211, -0.3476930069008315, 0.5850949715112604, -0.5568446971458463, -0.3231064586842866, -0.6843987874345742, 0.8172683756186392, -0.30093167163321, -0.4268283837157329, -0.6042325514558476, 0.6875172259381173, -0.5966178658577795, -0.5864215509133368, -0.42239490647885336, -0.607952510847117, -0.5706812828055711, 0.9032620976288754, 0.551438768512889, -0.1111621952029681, -0.19897984584800815, 0.7373495404770234, -0.5917189447760999, -0.10321810425833611, -0.19387471152662383, -0.3998746221779724, -0.6190042624839294, -0.011465709996659686, 0.5734104636568349, -0.16680148478820184, 0.4183143931724902, -0.540918074018494, -0.48228643855520303, -0.3064831911397842, 0.9325677366564099, -0.06411333122733244, 0.18801278709431288, -0.4136376413495583, -0.0989555802963025, -0.3592204185203605, 0.8723868078777907, -0.5648038991831744, -0.7176289841588217, 0.9418356878457201, -0.8523744483758731, -0.5763744480773856, -0.2438849940161276, 0.6196925596323732, 0.10392985650155705, -0.5300141825402529, 0.9064770878507266, -0.5915032116880393, 0.9405956567372252, -0.6398577626407446, -0.5637328406165704, -0.31223762956534645, -0.6484962633795274, 0.5617487458504355, -0.6718138010871401, 0.34892684784525985},
    {-0.18880112908277558, -0.5485726366816354, 0.01855179291370558, 0.48769306064334356, 0.12956608621721064, -0.038879915234426604, 0.3517778034929296, -0.16147847177995675, 0.16876681218916223, -0.08896490314021939, 0.18582953162429133, -0.6113563696998019, 0.1207266881341586, -0.33849913581234736, -0.01715344423362705, -0.24498583591999892, 0.3023155183006443, -0.25607534345744787, -0.20783914170228743, 0.18245680747406567, 0.021104135352219125, -0.47166162161537856, -0.04292138197948802, -0.3708816098915767, 0.15645917901872022, -0.3132629111895348, 0.19686280920560453, -0.13451023380367466, 0.06938664844105571, 0.019082681255843573, -0.29054407007239696, -0.5624385062856649, -0.5681882247103367, -0.4136226674974112, 0.37555426070975945, 0.17055745381158885, 0.1100759386909333, -0.3086578999932211, -0.4002726661519259, -0.2405194441306771, -0.011277484144669994, 0.2670772673967565, -0.002599324955979586, 0.38505849202455633, -0.6921130141820222, -0.05169907268633692, 0.07475419389042866, -0.47614372442158914, 0.3663664388516018, -0.3428902173908227, 0.09601585077783867, -0.41585069553121196, -0.07175855012994076, -0.1609009344048941, -0.5401658609330511, 0.0451307444413015, -0.7023056845071322, -0.13183205154640906, -0.13696186349759168, -0.2724409869219011, 0.3856665791564959, -0.055915761766699684, 0.4043521866750667, 0.1346842376102384},
    {-0.18939052822861185, 0.15575253018362695, -0.0032005321514213497, -0.1747725267848907, -0.11402394877534791, -0.8070542066263723, -0.3419136749862316, 0.25437826739859987, -0.2640588968509159, 0.003930052032905459, -0.7029331136125329, 0.36877095458104386, -0.6096646428804348, 0.02755394475902064, -0.4119599718343507, 0.5037940852790005, -0.5724778691561632, 0.12137809569375194, 0.08139411874557731, -0.32686565811070367, -0.3584605023863397, 0.313464838775945, 0.2479166695764462, 0.0013709528354478456, -0.1522701193376164, 0.48647531433138724, 0.0556682197890958, -0.3884149736212914, -0.21134592414334843, -0.1304715070450703, -0.2603617511527616, -0.17017030925559076, 0.6641226451888242, -0.07576119982454081, 0.33009221436721764, 0.18640771896725367, -0.18770112513987067, -0.003025316517776655, 0.46718473573867997, 0.11170865024327128, 0.12366669266224822, -0.39408123568733283, 0.15706702698023992, -0.3916571480944517, 0.4719134589716079, -0.344556342023254, -0.05292915294817119, 0.5164493201628324, -0.2685599902754569, 0.059377333390711946, -0.04350888682756546, 0.33874171456026353, -0.007185122979112019, -0.19135285552980785, 0.5386873219870758, -0.22004584403252597, 0.38259265138349574, -0.4489272346692188, -0.1771543298945129, 0.015291946897457092, -0.35962994217321337, -0.2913506747599038, -0.44887143175688904, 0.38924909336575797},
    {-0.5036944603989078, -0.213341954023001, -0.37501847487855805, -0.5845660895106664, -0.3981391725872369, -0.25410534262772255, -0.1178909456185013, -0.006694324538976411, -0.12837470399562823, -0.3858266802996677, -0.34073045378516287, -0.2605777836929255, -0.6071630780316081, -0.5127517527067148, -0.2882983031438583, -0.39298579030671815, -0.10994949223006213, -0.5351806808097219, -0.48767823032361024, -0.44302456124205986, -0.07449352248399366, -0.21460455551889734, 0.06792971104077133, -0.4488022961822509, 0.231669761421409, -0.3670573333789035, -0.6270470799127146, -0.6967931140400455, -0.4557348074358046, -0.5271948151048231, -0.3967779890079411, -0.5640841039194613, -0.3904329962573811, -0.6845363113137042, 0.16380974710766216, -0.33979292096985175, -0.18518847556069742, -0.6732883943347393, -0.5037347255078237, -0.6112803132177617, 0.40523772043679435, -0.3390108090138729, -0.18828150426454457, -0.06234050098833397, -0.12868067381739717, -0.33318328073154035, -0.17944732621042472, -0.4505316030396758, 0.03234133344202614, -0.4720421459354931, -0.5543748413605792, -0.6798993777890824, -0.2435154936401149, -0.3232291334297115, -0.6467833684950238, -0.22739038551445323, -0.5292149158297887, -0.5907461036652094, -0.5816155849817523, -0.29278552127290947, -0.5002698740868334, 0.05198406124020917, -0.6979576501622191, -0.09539227289652924},
    {-0.3482589635846853, -0.4514151520765823, -0.4684426320724468, -0.45870050589797834, -0.5341630845208621, -0.10285018110202467, -0.414601504824976, -0.06868649234696408, -0.5103408186439544, -0.18586454168217692, -0.5978253113110753, -0.3422694968826044, -0.6186878838541625, -0.6055828721456566, -0.12179629860805673, -0.2150152632059064, 0.021698135981157277, -0.3536661412547993, -0.38685136021656436, -0.09140063083614909, -0.13566026654390742, -0.5166974909448723, -0.028879901367241757, -0.5075329706008278, 0.20618511903386347, -0.525074837555534, -0.6163538129588307, -0.6302586061030283, -0.6112946762616909, -0.4573548554590213, -0.48206566304169146, -0.4709337404325518, -0.37772678475886085, -0.44317498142537537, -0.21415096065642913, -0.15562734297819308, -0.29588553573302706, -0.7787377789529933, -0.24514918568502225, -0.36682440548150125, -0.18654416457046413, -0.2843317794072963, -0.3520124827744145, -0.6205690293135702, 0.06682442434966228, -0.5872300703215928, -0.32579746249393643, 0.08629931736760343, -0.47241808056922063, -0.2963696982878815, -0.4083040114319922, -0.21047513014786914, -0.570598579315815, -0.4771621853086375, -0.3580542327261438, -0.2045635481320124, -0.20772722834987434, -0.5307737796408303, -0.5092071140940508, -0.6564939996157171, -0.6600274761416776, -0.1439521760120773, -0.21605157623286492, -0.3417219602692702},
    {-0.6007391236545682, -0.325961012735808, -0.3387085659594446, -0.613456634784834, -0.4693025014463225, -0.7310920854714293, -0.40055823581313427, 0.37417109195680254, -0.3726768281516902, -0.636402668947838, -0.46934095393951436, 0.0937356608562666, -0.493881513622821, -0.5044031960506596, -0.5250409638137199, 0.09448226584633235, -0.349518176929083, -0.5551007363714026, -0.385598729452952, -0.3914414662077443, -0.6172875148645107, 0.10061390461313209, -0.039777830993520225, -0.821536797158645, 0.37082075322463387, -0.09271739965561289, -0.5392490148731632, -0.7468743513404743, -0.45635984904452537, -0.5097851442671232, -0.5185774274969751, -0.45903533128993956, 0.24580472595340186, -0.6604994973337659, 0.0380463663377211, -0.3016159947225308, -0.5408065052573483, -0.4937974140909515, 0.05952348665852738, -0.08182671835630721, 0.46261996878870365, -0.6291906006124485, -0.2596424515430735, -0.3502412790645077, 0.33738348974432997, -0.45712221831835465, -0.39821275055551597, -0.04273425865346409, -0.2745011545103168, -0.5143112299295679, -0.28140601564773665, -0.24880272865563124, -0.3791578290904053, -0.4567978115306788, -0.03399278220660482, -0.6206533066318788, 0.07310542281194278, -0.561295125106725, -0.5558842288048236, -0.2276805407525347, -0.5199059556118515, 0.15734324787755966, -0.22226596640344942, -0.22393298883477528},
    {-0.6467227875661897, -0.23044226618897912, -0.48703995612832696, -0.3880543701293533, -0.4916381156949452, -0.36426564185846866, -0.5946010655505928, -0.17996722130347656, -0.20189972978484955, -0.4438159775376556, -0.35892140087586566, -0.15316006856589578, -0.17601308047021966, -0.4908237382154333, -0.3419059846933756, -0.35393073568775146, -0.6566010669079092, -0.3596782487952574, -0.4255108096870745, -0.6437726563167362, -0.3643193558441948, 0.09145529903257431, 0.09503204287329843, -0.6438500453027067, 0.010097719049485048, -0.030548566350235198, -0.34021720481186934, -0.7220435593922164, -0.38717490415943306, -0.6712548817287732, -0.5246023589379367, -0.5564129795023874, -0.18897630133381726, -0.5035833904889502, 0.029870742683234818, -0.23062320204807657, -0.3289240407765321, -0.7200812191546054, 0.07387186176542522, -0.6182610112921241, 0.40646704993173266, -0.19719458420702465, -0.3050777722874946, -0.1802957078013044, 0.25989806065049037, -0.3029967913584855, -0.5091470833019074, -0.06007055811456314, -0.376878085605641, -0.34417169031820044, -0.2880739309650279, -0.26394166615848424, -0.49247129056960526, -0.5309692469949499, -0.058490143616471285, -0.8062338157541304, 0.16354549437016247, -0.2785426483811604, -0.5062466391765895, -0.5559242022366273, -0.4328842476520431, 0.0815089284860305, -0.5658561219424023, -0.4429510662393415},
    {-0.781773802249572, -0.389539360311569, -0.3831801961767265, -0.6063344128475656, -0.5565889679284509, -0.5459936559870343, -0.5499763469492133, 0.19931191722107106, -0.4235779675609351, -0.7060339364406851, -0.4052381178750712, -0.15669316421426888, -0.4413902084797537, -0.2875551632708319, -0.44128326158152004, -0.12099940932772107, -0.519696246250727, -0.26361992503344395, -0.540578542806169, -0.2796250406079299, -0.6192353223889673, -0.016750838362928178, 0.1702371417417468, -0.5309664781864794, 0.1109794586635288, -0.20771260095402455, -0.3335138228125808, -0.6307953841264424, -0.5598526374815321, -0.6671997155467462, -0.2207951937188733, -0.37682589905236197, 0.2138498093378249, -0.377631984416974, -0.08353660803375851, -0.5743916422622998, -0.511496518843281, -0.7857068463571824, 0.3371822896301468, -0.27172574094784224, 0.06881714145741159, -0.5854776143662915, -0.30282692796805916, -0.229865685750274, 0.1259408906459667, -0.5398831654143459, -0.5744120273912099, -0.16198901062068433, -0.5078917449712066, -0.455551387272064, -0.25103606196526346, -0.2964567786307387, -0.3854302438413823, -0.521284545022504, -0.013659345117822679, -0.7795396915890738, -0.17465408184296755, -0.07745111897929709, -0.5856767304189796, -0.42234486578006625, -0.6336958532846105, 0.06946398615899498, -0.47733018581289677, -0.18078617932567995},
    {-0.717735512381047, -0.12011124497445338, -0.48314451724275126, -0.631699696034465, -0.4440631323673347, -0.37564156910948393, -0.5238305828851226, -0.2672350897119848, -0.5592040420319715, -0.4794523580071445, -0.6101368948784639, 0.08767281022558492, -0.22035468404733108, -0.6105633839863057, -0.19486683041952765, 0.21630449688370426, -0.36721290667001305, -0.5310430386334881, -0.5515566704507208, -0.29270819276341303, -0.4716758887296435, -0.4234711201556575, -0.05091214891040391, -0.4788264924666878, -0.07844467391302176, -0.20643656149115996, -0.6006271187069036, -0.5164135239648602, -0.35886496226111353, -0.5378052725410876, -0.7588417394745091, -0.5383641332306122, 0.0918174245811657, -0.5063320110916636, -0.10706581347778689, -0.010876248161929334, -0.46839440475306043, -0.7350506173201209, 0.18684660140554274, -0.46792672866210744, 0.28757145625527536, -0.15654185648445873, 0.23388916232631632, -0.5518468213307876, -0.0614441392061675, -0.6287689697940609, -0.5765493716730623, -0.17920936080863886, -0.12850791994772903, -0.3703533750380225, -0.37712433016755337, -0.4920409251008662, -0.3222061663357375, -0.43958186299335616, -0.04445469298728477, -0.33321420974307386, -0.26899535025282956, -0.5638501940734154, -0.3173129791589971, -0.2553321680816687, -0.5631023665170569, -0.2716776433862131, -0.21723771408269998, -0.002535923983764309},
    {-0.6605279427109276, -0.2579348065546598, -0.6329677323595784, -0.68064614414185, -0.5281825528365868, -0.48551695968690534, -0.18949630499501854, -0.3326341937498612, -0.5623267568108945, -0.7223971999117806, -0.4914745397674304, 0.23726584049900798, -0.47793279806717326, -0.7645868041897518, -0.5379045387154805, 0.13262575668191878, -0.445093560805806, -0.4399865409368767, -0.6046761213432358, -0.30178626779708795, -0.23861679225577595, -0.17108855987720148, -0.000966853990301411, -0.32644085200586526, -0.25288219220791114, 0.047785879955726515, -0.428781974449982, -0.5997952728823952, -0.6969074883726472, -0.5113747330909445, -0.6266262640061394, -0.3474594714160518, -0.04695744656624551, -0.7087434449621358, -0.08691077285698459, -0.29983284680972067, -0.2990361464327298, -0.5623193266785669, -0.13737139987730423, -0.28788638333122185, 0.32779994369998494, -0.031401136162456815, 0.061144503856846645, -0.16804329135947785, 0.15710330665805333, -0.8256941072725366, -0.6153380193175466, 0.13491471900456153, -0.5266596620020761, -0.5848639852524117, -0.2488891476492066, -0.18564174745843162, -0.6060177592819275, -0.36698242817975724, -0.3047003884735962, -0.8755342937428848, 0.10182513960176594, -0.49730640583070707, -0.5865339264676009, -0.47899912180133913, -0.6958047455605177, -0.21467822666895583, -0.6324191439423372, 0.18252780681570566},
    {-0.6166383471990842, -0.368990642889261, -0.2341796988879582, -0.482314283088944, -0.7460305687577795, -0.3981348368473321, -0.34903026159091693, -0.20378231485096737, -0.33665668220952094, -0.4345086115809705, -0.8269617079535354, 0.23348450531378637, -0.8190879880983993, -0.40655797575718455, -0.4724887840464741, -0.04396193881750604, -0.3792934063897581, -0.4683213533685924, -0.7698350259847623, -0.6103480577932848, -0.5019369487468676, 0.0016677056454011024, 0.03435103192776786, -0.3047406566191411, -0.14208408119859087, -0.2528353554539907, -0.42661209095040525, -0.6268023079515409, -0.5874321988806097, -0.5958403141035006, -0.48887366145921146, -0.5720371056645992, 0.124494787761251, -0.603551209651186, 0.2610703442104157, -0.32688743181789326, -0.4419885142896556, -0.63059214245677, -0.1402399980356664, -0.2701064495020048, 0.18144947401041558, -0.6186780573423704, 0.032365514788861426, -0.18045867443745048, 0.0022355184212026406, -0.5111350202423398, -0.5828043398028605, -0.13802362181550576, -0.7269723246223305, -0.27374090825176417, -0.15255226952366324, -0.4620607444727036, -0.3942213668950724, -0.5875116806808216, 0.012234693118568608, -0.6556094455001601, -0.055476003139966215, -0.4027437254831914, -0.8078327901296802, -0.5369579929439098, -0.5522301521905877, 0.06127210252680486, -0.5836642659264509, 0.021451075933087208},
    {-0.3317767149391072, -0.6650046785546981, -0.24673329529924437, -0.39095935732695125, -0.3794157277164158, -0.449864022457306, -0.6636424636113277, -0.03702013858509626, -0.43412740923465565, -0.30810136849464176, -0.46874252448953624, -0.14513028253895918, -0.73084943542145, -0.2011931684934308, -0.3334770207558404, -0.2895377558538708, -0.28611378441942936, -0.46309673967628123, -0.4420992082693936, -0.7643597079791105, -0.6352547718708459, -0.17403525123566607, -0.42773096829683305, -0.6159132032594143, -0.024735763736164786, -0.048927746797445625, -0.2851651500615914, -0.6053502779219289, -0.5048468731441544, -0.34181627694138345, -0.4005473211781743, -0.5857933679053645, 0.08286625581991978, -0.5164745204943555, 0.24992157210166316, -0.43611358275146167, -0.42627438085299885, -0.5408207483822309, -0.24866927572491804, -0.077586045303921, -0.20088678801150106, -0.2913120396251017, -0.4022056440172189, -0.4309023263439889, -0.17417909120045053, -0.4236103675562265, -0.4199414236751215, -0.46305641693092575, -0.24945181100742964, -0.46639034463261864, -0.29074566995642404, -0.3528286488443597, -0.2170083428070213, -0.7187891355727895, -0.34617392714720857, -0.3590042700682964, -0.16530864842323487, -0.5791011473393853, -0.5119239940424378, -0.41930086966217894, -0.48740279508265083, 0.07295228566840473, -0.346556904650864, -0.28721495651232354},
    {-0.48328979477583345, -0.5627752319632503, -0.4065047097670999, -0.3219751277594977, -0.6492779881729854, -0.6676740202626282, -0.3505987697131461, -0.18065641134964322, -0.3034697411249451, -0.6698949993562029, -0.3599384221308311, 0.15318530931707336, -0.4779982210805888, -0.4959045092250331, -0.4057577235014175, -0.2898377627968968, -0.357125106738887, -0.43240118790243603, -0.6829091497624723, -0.7166889800658703, -0.44433804645500996, -0.14501894678660165, 0.15117273619245702, -0.52943804312003, 0.08509201148848201, -0.2671613278158078, -0.5943498113855903, -0.4698160352283737, -0.5454397771064216, -0.3593508744738504, -0.673706452739712, -0.47651325528761185, 0.2335501453617997, -0.5426718011766528, 0.06455122975954089, -0.35914393471702366, -0.45702685836636736, -0.5837666194028296, 0.009898981623413709, -0.4330052964783826, 0.047073845010823755, -0.3467130741265174, -0.10328964743695646, -0.417514979464569, -0.20710732516796806, -0.4683593332391061, -0.15606838801806308, -0.07492664358302854, -0.2963124820448545, -0.4591409988147291, -0.2437324068117052, -0.1806627798317791, -0.7415287640693426, -0.37437534662154315, -0.09702882578866599, -0.5454079630945559, -0.4362939217745171, -0.3995518995443102, -0.22960291943772504, -0.7608831275701592, -0.5248706381565653, 0.03695602085209541, -0.18392996962536803, -0.08306195874679133},
    {-0.5939045019766181, -0.6424451323749046, -0.37964840814162654, -0.5864532894043936, -0.42218531747775884, -0.7280034663118258, -0.5662188990704305, 0.22638981496818353, -0.14536974850616338, -0.8006957223970493, -0.35186151807085475, -0.0478870569345081, -0.34954625611929524, -0.5773967787441705, -0.5544445760770466, -0.42580285637451193, -0.495258339177788, -0.42768823500353653, -0.24012893414746986, -0.26249507806368666, -0.4951224645902195, 0.3301468477350383, 0.2486830952254385, -0.471788921691091, 0.018024111674409704, -0.10774958575103954, -0.6926865321608646, -0.8512545119826745, -0.5748809920633032, -0.6460691088693821, -0.6693406785820467, -0.535732403291028, -0.008621692378552585, -0.4155288378583405, 0.06077223133007599, -0.2271959503793057, -0.8603057753005301, -0.5950452025924888, 0.23796375521441407, -0.1742494195744909, 0.1903982364121161, -0.4206423338931984, -0.10770890280435223, -0.4314076797295133, -0.0023561576135826285, -0.5423793607610675, -0.41821200985900825, -0.20750031310804595, -0.4663860938465682, -0.6443967354152002, -0.5658078638562645, -0.42624713248839635, -0.3693165109599826, -0.3125546113031536, -0.29120240801149844, -0.5718628404674568, -0.25460993823471506, -0.3847221511157366, -0.6462955764721923, -0.7885544660468621, -0.7191877388457143, 0.23020460833852824, -0.6889009723889553, 0.05086118166291544},
    {-0.4314742598975878, -0.561380767125273, -0.4787762548376986, -0.7060577495527205, -0.7364305853673692, -0.7220029095776226, -0.4590869216352928, 0.0894787121106008, -0.48448922862166804, -0.4458243009611012, -0.6630251539751046, -0.20871406593352934, -0.6085438396447087, -0.6846833953711426, -0.40939416138379925, 0.05815023417326317, -0.45728108919984045, -0.6766061729636593, -0.6294506987321913, -0.6298693509189481, -0.3617297796904027, -0.3134330117076418, -0.17191442759493475, -0.603885079188141, -0.1289075066875934, -0.18035485826447936, -0.17910675523857955, -0.7159058127364223, -0.4286839783868855, -0.6845919238806134, -0.708937047207323, -0.6824855266040283, -0.21151460257183524, -0.6407587629002162, 0.06529259723766408, -0.3350016062205387, -0.65311857198816, -0.54124334188463, -0.010570316139664259, -0.35741070773386696, 0.39980364562474074, -0.6703540871775358, -0.3176214157414935, -0.4009211561853929, -0.12031963077259368, -0.6070064183812371, -0.4197087421574266, -0.046846262066635724, -0.4025258268768158, -0.6840271807383468, -0.5423110371592976, -0.6249986402552655, -0.620430479836758, -0.5822402206774161, -0.26145712610675453, -0.6089881668053446, -0.25132630032779585, -0.6396169026846269, -0.668785586358613, -0.5117669175434412, -0.40357074338946675, -0.05788348635851005, -0.6611727487892234, 0.1512457787887196},
    {-0.34231738448329574, -0.6790596404234631, -0.13605416434139903, -0.48440433997405985, -0.4811797585422977, -0.30899204998251606, -0.46259276126691, -0.029372457947095334, -0.4460523956312199, -0.48888599402529853, -0.36658460752976785, -0.2828854901270001, -0.7303957321426818, -0.6097485789300369, -0.2853887573280411, -0.03469515300088632, -0.4524784530733979, -0.5525309966486118, -0.4631159513113371, -0.4314383972554061, -0.5144716530693031, -0.11716286686897728, 0.08536909671484862, -0.6352370896099434, 0.06177641072691629, -0.09886649716646422, -0.6048320885754402, -0.40614153359762983, -0.6621465942070606, -0.6819899953574708, -0.7886933268717857, -0.6501958631129344, 0.12381454250282535, -0.3904291486581313, 0.07363038292879014, -0.3354273641241596, -0.505251745269369, -0.7241908350673633, -0.2276667418773575, -0.3097662800532119, 0.3127164765140149, -0.4361503375774858, 0.006026729777051348, -0.4436465868196918, -0.15743076911935888, -0.6053047030358434, -0.2725340549103351, 0.18983875493434457, -0.33345150255317674, -0.4080677858496609, -0.2286176749154458, -0.34266802644111544, -0.36999322968159154, -0.605340703738002, -0.21136559253502346, -0.8779290170895049, -0.24880016010256845, -0.564074211374925, -0.5285174459046706, -0.5699341537104172, -0.6307048488065389, 0.16243801378465553, -0.4941232776409915, 0.1730375260834401},
    {-0.4464497975892899, -0.43849854616098594, -0.5604839894248959, -0.5849267107252748, -0.6739956224381254, -0.4592381301419668, -0.4135939657367543, 0.07807975951904135, -0.5992400160371962, -0.6123104897160893, -0.564425925142788, -0.380386272400099, -0.8700726324791813, -0.7314570924196402, -0.37788018305471643, -0.12747629385348064, -0.051242862023386244, -0.5600095804525758, -0.6414082776363644, -0.5657664229774774, -0.18703217066938393, -0.36065143399827676, 0.08080581086807805, -0.5446390457181056, 0.11399514610687402, -0.07330381772168662, -0.47741453433590636, -0.6066053215546211, -0.5204021897257067, -0.8288158434139561, -0.5123023044470644, -0.49886841755788297, 0.003578596662528783, -0.508292093324744, 0.17010565059883084, -0.37929731457944366, -0.30498820244942, -0.5646840090239421, -0.08318509754617966, -0.2783853232822371, 0.26425584791544726, -0.36991396399469, 0.06040156174604992, -0.2044334269867268, 0.01574369077527515, -0.575973959500097, -0.4536251554271086, -0.28632056230825953, -0.5188655961530855, -0.5902091938074914, -0.5388666057461923, -0.5127706898329148, -0.578679930232221, -0.5768718904108907, -0.34815051159614674, -0.283595046554333, -0.34910109967315806, -0.7240448305133104, -0.3409432643097292, -0.36053490524817255, -0.650822643138285, 0.04780292856381402, -0.5075905156699326, 0.11400662875089701},
    {-0.6882746241727115, -0.4849284185797794, -0.13304405043259745, -0.3834497955417063, -0.437037308383982, -0.38078212879594703, -0.3073989925722498, 0.019058546572367642, -0.1824119725374414, -0.5502516256039627, -0.710979908789178, -0.1628870766873246, -0.7490290620948846, -0.52518063719666, -0.5358852377902572, 0.07074494547236132, -0.22530277533944604, -0.28711157148478406, -0.531922202709013, -0.46376745031633365, -0.6438775895903285, -0.038368109229710345, 0.1350499317471898, -0.6875283869940643, 0.03868065996142871, 0.06555210585849786, -0.4816914895606255, -0.6486714626656046, -0.5021040657618376, -0.6550691429837799, -0.48838637642565985, -0.6924318981037783, 0.14276713415569064, -0.7114260527499938, 0.05983958247178408, -0.5834903887327794, -0.5837826142073189, -0.566325720699881, -0.02097366351271356, -0.675623142962134, 0.2285984436305977, -0.19835158859425409, 0.001977377241396254, -0.5341212352717787, 0.09331579540263954, -0.08702239225783556, -0.5163839138832325, -0.1520878080551989, -0.358329808722629, -0.38113328758954895, -0.6190832670341069, -0.23511183519328177, -0.8253373058233252, -0.45598872286558145, -0.3157031530667133, -0.5082905786474915, -0.32467181966238756, -0.43257304036311417, -0.6829785822482984, -0.4323230769849724, -0.6040042280013753, -0.08683030635694901, -0.4208690321653487, -0.30554976544220114},
    {-0.520488541468211, -0.6030082987883782, -0.2625510305287649, -0.6109325519837167, -0.05025808041718538, -0.4262316808217377, -0.3670200596985095, 0.16562490921632064, -0.25870679910832106, -0.43853953761045994, -0.5738149543903011, 0.2701455275776261, -0.4760678049915623, -0.788790910623191, -0.3528458978045803, 0.28469881260392427, 0.00792693347242869, -0.6190367306255132, -0.5058515247490354, -0.47813270402721586, -0.494327444421424, 0.051311557453629184, 0.3951709533564912, -0.5656339809691843, 0.05328493803095715, -0.2912962166465187, -0.696458221917389, -0.6089140593509205, -0.37617581998355676, -0.3192538007498034, -0.5090164578794528, -0.5339745632996639, 0.05146487401748736, -0.6345478974782776, 0.30926559244719887, -0.2593672449046037, -0.6207710092882877, -0.7074717300289228, -0.28617466151758436, -0.35492917788353917, -0.08475205660173299, -0.39964521424326155, 0.10322513729805384, -0.2708358327405137, -0.01373914462263192, -0.44173887176692916, -0.06394472754958265, 0.008052622432388114, -0.537566344538861, -0.44900864687810726, -0.31878077102310504, -0.30167991675281225, -0.6993536917171378, -0.3561842030403778, 0.10895799840375661, -0.2167948865417709, -0.19441105975872358, -0.4887794850038875, -0.6667199477682866, -0.2996177358714292, -0.389083492813404, 0.03060830698766811, -0.12545658084859335, -0.3077518768225629},
    {-0.4170165730353038, -0.6163041208799923, -0.34213441797117944, -0.4397886384487461, -0.569124752142211, -0.5230275767693218, -0.5932038837139819, 0.02556472783874291, -0.3498858029191126, -0.29708743716515423, -0.47581658500357216, 0.026564699495844057, -0.6222801919707226, -0.6599528132434433, -0.5793961750572871, 0.09235846778467616, -0.057529717375072176, -0.3988549429137829, -0.4744321735134109, -0.24452561376093707, -0.3527515841177193, -0.2046859599421264, 0.0736185269707973, -0.29418304132740997, -0.02150965720286223, -0.36379462006637825, -0.5499827793329295, -0.8323456269708764, -0.7434103679314643, -0.702786635566913, -0.24886816897694505, -0.4419274964640622, -0.10044248104667568, -0.5576257597524013, -0.03695951722757105, -0.2068269582572171, -0.3347444537389336, -0.5686830230683934, -0.32070443033622725, -0.2773176881312678, 0.13686164860556702, -0.38425181921621376, -0.055455850102321375, -0.3248850413731327, 0.0717168527097423, -0.3667560448573748, -0.504163061290726, -0.054291893247460206, -0.11370960017393733, -0.45256785235720376, -0.5254817514535289, -0.40864058364913647, -0.5124975193413731, -0.09339008549643148, -0.12696621871013372, -0.522044703774671, -0.39407930695439825, -0.26217254134598605, -0.5725871211693827, -0.38350958328200646, -0.6526602519867454, 0.05321317681711543, -0.48369199424219517, -0.1652142889021346},
    {-0.5738988678661759, -0.6562300752145889, -0.38016575541734854, -0.6746877993768639, -0.409716349487498, -0.7247955090776508, -0.462798293843432, 0.09483604170629988, -0.4718485247697357, -0.5128257937382162, -0.4232860616251469, -0.3563884753972313, -0.4498154196085133, -0.6944693369400167, -0.5791594124305549, -0.4099053705510615, -0.2463854236120642, -0.5107313580275066, -0.4438436110712711, -0.3312646818841701, -0.3313161858622904, 0.011599559420681813, 0.05059557160980336, -0.6832557491246585, 0.14475720880146184, -0.33978510114286054, -0.5332978350994635, -0.704263039717756, -0.6137857998327462, -0.6649894872652568, -0.6141407940900608, -0.38720268881388575, -0.3694406499168226, -0.5366294816624617, 0.08999111221230012, -0.32631959360234536, -0.7512392318052269, -0.4932705339891711, -0.5451083687325928, -0.5001635773454002, 0.28213601256268367, -0.34141380385768283, -0.20888749995850922, -0.5359177611146198, 0.06168858173869028, -0.803880855130321, -0.5732254697649678, 0.09678882872404822, -0.36008602530850164, -0.5759836833362566, -0.22011225171596988, -0.590703819619823, -0.44178395103158746, -0.35628455173615325, -0.15845384397181203, -0.7034000815978526, -0.11871760737710017, -0.45482173882364857, -0.796368656087624, -0.545558295513721, -0.7974242584625979, -0.0549471123707319, -0.34291199187940247, -0.15164084102284886},
    {-0.6783257799471281, -0.5134794649513494, -0.702936239870871, -0.7226637114833769, -0.4903023135427074, -0.34787798177556434, -0.4297738398750644, 0.41176512822563743, -0.3461455763789785, -0.9262899851182771, -0.6824062185586915, -0.07856309092650336, -0.5888854312584632, -0.6074443394139214, -0.447224568890517, -0.3341789927316546, -0.4498328161776646, -0.747368579161131, -0.4668293286443981, -0.616323635196327, -0.6900211334799619, 0.01691982599263508, 0.0467037452920372, -0.7522224126870842, -0.05700998064305447, -0.21155712805958846, -0.5526648796393501, -0.7318380731198441, -0.43736704698046963, -0.5958302794144972, -0.711030441939493, -0.6915660481317106, 0.017538368173614614, -0.4433479440087695, 0.22087863015230524, -0.3327772954618945, -0.5980629273793204, -0.9060396616701467, 0.04170548999542473, -0.44243768658174093, 0.19371579282167642, -0.6832970905488969, -0.21460031896550383, -0.6704652178411638, -0.07546496579730878, -0.5325385100822743, -0.3565200202138705, 0.0741463743559973, -0.4218732270040046, -0.774780804923468, -0.6775004844602581, -0.40233509420238783, -0.38859103639404935, -0.4498340189961801, -0.3366627048790927, -0.7454714531904241, -0.09693062629734642, -0.4479116761899046, -0.5222094664624561, -0.3881112276512317, -0.9657300311444663, 0.5707080390548146, -0.4893457138194192, -0.005863694510298056},
    {-0.562703445268961, -0.4659395118087939, -0.17439316560456192, -0.5829873993599173, -0.17566631055019566, -0.4932387033725166, -0.27155201607658913, 0.8244267731194405, -0.6328036066966333, -0.6583390320164194, -0.5577224332448978, 0.23946149816551945, -0.7690954331006388, -0.5519027707218254, -0.39683480778540425, 0.29865385262894983, -0.3637419166698062, -0.20282759094769273, -0.2965538847648807, -0.6519588641389708, -0.5007462078621374, 0.38226025113380846, 0.6024892910855724, -0.32230468688568203, 0.41241072431748094, 0.16649075056961668, -0.4439433781944757, -0.45374390445516494, -0.5113822459235233, -0.5299450304918846, -0.2783297830535051, -0.25823280583569536, 0.36376796407998896, -0.4721495334594516, 0.6445930927625373, -0.2473909189755927, -0.42622945340165125, -0.684854296996118, 0.4361721202670589, -0.3813164130757164, 0.3763471281069026, -0.4489093020384045, 0.15823084222125375, -0.12404224588565262, 0.5096059902528738, -0.32015050972678466, -0.21344528072608446, 0.2655128976996853, -0.33106451816846727, -0.5978088053607156, -0.18124690469091884, -0.0785126780679924, -0.5020111363598284, -0.2781523185800971, 0.27512352522803285, -0.35969801779406996, 0.17320474583375808, -0.611395516899384, -0.6714033201400853, -0.38331053357117734, -0.5908822464388531, 0.44718939367232957, -0.4238720057369072, 0.15712761030160338},
    {-0.35918600015041297, -0.4524790040825271, -0.3014560191129292, -0.34434544555891455, -0.203865247004356, -0.17622059248009117, 0.042173399467188386, 0.7136736217001314, -0.46869012878307104, -0.5161197893216002, -0.5826499184756065, -0.10048412186894567, -0.4059745973627522, -0.7405249386327726, -0.43848845320586083, 0.3290978647040838, -0.35064679584451236, 0.024099228142968512, -0.1166104279047825, -0.4941924226550352, -0.4442226531402163, 0.4291727478500966, 0.6677868898989072, -0.5100642690609801, 0.5323789744124103, -0.06341732434981359, -0.5318747597920692, -0.335174842564504, -0.31852292522304, -0.747603820857945, -0.16891935348719034, -0.4867918396574892, 0.5724777547845195, -0.5033230075155479, 0.21669668925532046, -0.6871102676427595, -0.10725003172246861, -0.5711346423992818, -0.2441768337086815, -0.34409626221116185, 0.3391250328872336, -0.3599387491608446, 0.3946529811323761, -0.05723784947140286, 0.6928577736156919, -0.7522889031905231, 0.2127511693209399, 0.25140232708717225, -0.3079115740799151, -0.6207101407281432, -0.06209620521626886, 0.016950800333221726, -0.520103844472653, -0.1808416517618483, 0.21822982809795802, -0.367348046110287, -0.15385800025559584, -0.29727646071595865, -0.7710400600355972, -0.5005683077191818, -0.811212458261946, 0.5753467828723865, -0.5850335364084522, 0.09344127195692022},
    {-0.3999604059981164, -0.523511602724197, -0.229753655987829, -0.6322785354883544, -0.48387380993830825, -0.08453751646795025, -0.3845341682604513, 0.5334587605570056, -0.23339032837923335, -0.7045288521573211, -0.4081160209351667, -0.10625753783051996, -0.21647532882740794, -0.692985557822102, -0.24543830357009064, -0.01141203124396635, -0.24289575163654895, -0.6603687178248845, -0.3993720251398687, -0.6627299353096063, -0.6851394004267384, -0.10376943420744227, 0.44130879431124087, -0.6921161039139022, 0.14726813569465838, -0.2050003647170965, -0.40259736755904063, -0.4326905563202178, -0.5592305679054397, -0.6582038403938294, -0.3701588227704157, -0.4588151392425376, 0.009905708363297945, -0.4655636304334552, 0.24396185929822004, -0.38117553508814694, -0.32318739883255143, -0.7634172052752233, -0.3740324634012754, -0.6132987831152867, 0.4237866686473895, -0.2752964691388288, -0.1396147869496316, -0.17160405189324804, 0.35067459052963473, -0.4845792643377241, -0.3512450577664777, -0.18247800567107827, -0.2703194943696842, -0.6471118286140228, -0.144307824191685, -0.3775159684566967, -0.6254868558223914, -0.48785902643168927, -0.17082419058904544, -0.6575581905696473, -0.3917522966791129, -0.5828571958245428, -0.681605103828918, -0.38608004279315117, -0.8728337169225567, 0.12529894501253466, -0.48190373432689626, -0.24829810291537388},
    {-0.45747392380182794, -0.6493352772870548, -0.25134529129018984, -0.30236173842073083, -0.4358244450712676, -0.28917660638741816, -0.5095064735626041, 0.20885803555014543, -0.5184063371785431, -0.5961817439776179, -0.5601624198549424, -0.2757573247675703, -0.4951352013693864, -0.49030043406609847, -0.4449456862379706, -0.20894709168944464, -0.49573261909023725, -0.29841896114669464, -0.483516476737782, -0.5494673922560546, -0.6181399084533211, -0.17884559885064075, 0.5241640802219522, -0.5288292693310291, -0.031208327068800834, -0.41665344788566716, -0.4987102218072549, -0.6494649724151067, -0.7271639730686281, -0.6584739185836296, -0.5363027354148645, -0.5104266561412409, 0.02270333703552387, -0.5871297831224305, -0.02507454572032628, -0.4710062590946168, -0.23206696581070296, -0.6612828453911931, -0.1584528792599123, -0.5860947929323456, 0.1644550787341386, -0.5556751572097371, -0.143573091893703, -0.52619300927197, 0.04988154642387026, -0.6979173289590996, -0.31180885449152923, 0.0074323133622637835, -0.4856725244084673, -0.6693710234823514, -0.34480746301029497, -0.6418584182258351, -0.5247499746894091, -0.6971719164983505, -0.2900509746481068, -0.5014756911214288, -0.38095980924081513, -0.7020996124406351, -0.5972559759938265, -0.6078283075913915, -0.5565039461075034, 0.16389144461008617, -0.552076542964897, -0.044841474630512905},
    {-0.32048231107990977, -0.8526533461289961, -0.11652669526658747, -0.4191474083415884, -0.370239959706864, -0.117201170040735, -0.25316380987531745, 0.25118458347694567, -0.32779356712447744, -0.8715135431866391, -0.5549315394808257, -0.32831698735919684, -0.6309660108982115, -0.6467903654998379, -0.3339656878944233, -0.2407922780033386, -0.005804416987994626, -0.37038111334787044, -0.8072930249753051, -0.4654650772251501, -0.4248072196335433, -0.17776743628846356, 0.5791294576014642, -0.3997641171930459, 0.32352727683637755, -0.7775067659234837, -0.4445125809720361, -0.6461627895874664, -0.4029230640592062, -0.5724573086221761, -0.391102401339771, -0.7952726787985307, -0.2656657051662817, -0.5497311871017964, 0.429574637793497, -0.7118284177858838, -0.08181915054713111, -0.8527459929569181, -0.557017175380791, -0.6677872730446006, 0.3159756445327828, -0.2507288001430288, -0.0919959080244652, -0.16609620640677547, 0.12748901235374327, -0.5535169071990442, -0.1400120600539135, -0.08023128313586715, 0.08390321991634181, -0.7404614425262928, -0.29128561345177795, -0.5615416014332119, -0.8780365536762287, -0.35720067167145203, -0.21328210806335396, -0.48920105403611946, -0.5694961137692678, -0.5765231226091336, -0.9176623496338464, -0.5327927993997222, -0.6499128352080897, 0.26023857764752995, -0.21691897405626206, 0.026272230675578618},
    {-0.29010614027928633, -0.852788330506361, -0.007155993330625142, -0.42560282785497155, -0.2926650852781551, -0.16878390258227627, -0.16056286808147216, 0.3849210827169266, -0.30790047503196655, -0.42311017525217176, -0.5879072098543119, 0.07017839054133396, -0.5940630662357652, -0.4403589740549523, -0.19554677822357416, -0.058084619778716005, -0.13612891890095738, -0.3510167292719137, -0.4277970461157113, -0.38733218209217346, -0.5326046933250564, -0.1582953815621901, 0.5081935085650132, -0.5726715646184223, 0.4537461566022493, 0.007056604164813129, -0.5074180615123776, -0.8115178843153166, -0.6716690108489385, -0.5850264004471437, -0.5426633006023028, -0.5609849225420881, 0.2611979509535069, -0.6500536419683416, 0.446261880087134, -0.2275502679019963, -0.34501230769912494, -0.5231634856180727, -0.021993001520530492, -0.3407491540663274, 0.19442501572185486, -0.008047663786612173, 0.41018670500793597, -0.21952661148333702, 0.3616543296077141, -0.6231194067232194, -0.18906450941468578, 0.0994082558183151, -0.18843007829938932, -0.39179709187445927, -0.28736317686071555, -0.7253884182360535, -0.41998681667991505, -0.44924071616925765, -0.18786059627701968, -0.3014849939268652, -0.11465980496075417, -0.21145434243065508, -0.7144874698390798, -0.49385918772838105, -0.32690580135857994, 0.5255476707540297, -0.19874294163633274, 0.15418388178889111},
    {-0.4579156337921432, -0.6746222175899043, -0.5136591881412857, -0.21840744447877383, -0.40596259696936854, -0.17970135966087458, -0.11956960568468218, -0.007117286059839945, -0.44604269698969123, -0.5102950144633714, -0.04535267740654986, -0.33270825339471155, -0.7147216108120332, -0.6138252676755879, -0.5036701020064444, -0.3046539890085327, -0.5376228301881049, -0.4739508795848584, -0.4370919470487237, -0.37091916506654915, -0.22475453385146626, 0.30416346413024964, 0.5479525333326216, -0.4433495639747432, 0.3106559506033024, -0.07106668984156157, -0.348008367310255, -0.7171376033321735, -0.6898918056617416, -0.7481096058161222, -0.42115877430365667, -0.5821943137640597, 0.0735956279362, -0.6668921107148716, 0.04847863719908292, -0.5012248161015008, -0.19800002453820556, -0.7180328216419481, -0.03870373389348997, -0.6533247187683, 0.07158640317260899, -0.5720486759283175, 0.14456580511901337, -0.3006346882228034, 0.12985012820879938, -0.44314456542113145, -0.5028914932022822, -0.1391616313606145, -0.21602045856374022, -0.52156018964685, -0.24334667753492426, -0.6988594477476288, -0.6522724265326977, -0.5012021823749223, -0.09083671049528784, -0.5245440817764994, -0.20247393779297318, -0.4616504436504052, -0.8125976081304677, -0.8038579935428494, -0.5899804303067763, 0.15898978123806465, -0.4463488062800811, 0.16886667115336587},
    {-0.5120908639686562, -1.0140297539634724, -0.16836918885967497, -0.44404990322355853, -0.4733583377658529, -0.2888457741773116, -0.4373271786761731, 0.07806360878887915, -0.6199773175534612, -0.6356318197912542, -0.5498992599015137, -0.09055210565726435, -0.7134987054079871, -0.7581938720475321, -0.6693221557986395, 0.08497034519655093, -0.06758892332594629, -0.5681492835304149, -0.36324699653835957, -0.3664809371332007, -0.6461632870362157, -0.03539278991954041, 0.35446790735285, -0.8673718346552451, 0.579023758649814, -0.22454614349853916, -0.39588194726630743, -0.448399777455382, -0.581070300316656, -0.7112292660441746, -0.5334209298391911, -0.6075319340925196, -0.03518605428923708, -0.6862283750355515, 0.02372760063507922, -0.5773449309906454, -0.2950708837474892, -0.7649547375801291, -0.2637871498526808, -0.5420424905285438, 0.12659207627655855, -0.3987728722798464, 0.08512471993536656, -0.07485069277670782, 0.17077787960937924, -0.3708024635159837, -0.3928935230186221, 0.11110183998210675, -0.009034581923003313, -0.6150756230075972, -0.30348050499818224, -0.7091700047139682, -0.443700041528041, -0.7570908901073531, -0.2179911664761414, -0.4497294715089408, -0.4510924204237165, -0.5009488582447373, -0.567832854361062, -0.562445432652115, -0.8320155510144669, 0.3095579321395655, -0.21703078007784865, 0.1210047624148953},
    {-0.7072247364334245, -0.7108286293615291, -0.36257508344517086, -0.19068408638959736, -0.3323988156281412, -0.15175040904005674, -0.11699165684152053, 0.31310247748996156, -0.3381504886647733, -0.32845235272725987, -0.49146126347733, -0.05790804025364401, -0.7038255044882689, -0.690753650099776, -0.4297359794419219, 0.11369083321967403, -0.3093603012351263, -0.3578232019237487, -0.478100643057137, -0.578337853784216, -0.5332759302945994, 0.1469825188811259, 0.71786736269967, -0.6516477965263131, 0.3607709639705246, -0.5554135892933137, -0.4383760871562481, -0.4261584440245474, -0.5959445122535291, -0.6286967770826543, -0.27542758596303263, -0.6162831709347688, 0.12386232481570669, -0.6835777351792635, 0.3700711638946696, -0.6509852480223892, -0.24888924329765263, -0.6058848157574859, -0.34599903426781037, -0.558482663118935, 0.582297277399586, -0.0902639669488176, 0.13546902831154609, -0.14378555969592563, 0.5026209142895395, -0.46158234900851436, -0.21313544359054373, -0.02242338403726706, 0.011350239286385991, -0.5155820298519769, -0.3680610312276173, -0.5528734863559353, -0.48182246136645995, -0.6813487476597728, -0.05291224211283477, -0.47414545451420015, -0.18362271828081234, -0.654240233708247, -0.6516312967116682, -0.7688984065600304, -0.7436534975871896, 0.4050000296339643, -0.07228954848673028, 0.03384042898277269},
    {0.5507058934549384, 0.2414978884883288, -0.327855999881111, -0.05287024551812665, -0.010522114104169302, 0.06902545410286125, 0.057541318207748215, 0.26798466445629726, -0.5139645276783714, 0.33629341784620226, 0.15943426684719894, -0.23955147970944218, -0.21473861727008273, 0.25698021237413354, -0.38556501058229314, -0.1722856189059542, 0.08097066424472259, 0.31393358134997323, 0.2209467422622013, -0.37218159884608576, -0.3980800525823879, 0.39118214394389067, 0.3230710357567376, -0.36938073703960705, 0.08908998648237051, -0.20123978843182225, 0.10910338050747352, 0.13770358229751373, -0.22076729560446362, 0.16026158277941377, -0.19624519585787262, 0.5196888255256888, 0.03137654348000153, -0.31689896972179776, -0.2897681853462597, -0.25836926345387295, 0.3325864378418182, -0.10484478887373627, -0.24511359577085304, -0.873211057798166, -0.7650538127048385, 0.13508359222173266, -0.3226370027104113, 0.21660596126720236, -0.07761415779269297, -0.06421716765910981, 0.32334897010925884, -0.613727656650795, -0.16601536045684692, 0.3703357178598335, 0.5588274496282669, -0.06592093995154934, -0.4154194704040747, -0.21534840222665483, -0.19674718189189552, 0.011768586264215342, -0.07048100625091464, 0.25988943949916654, -0.4522023944081612, -0.15418145583878198, 0.04002380538250818, 0.45102504987060354, -0.11830458259367388, -0.6280744185252154},
    {0.36250455627145534, 0.26762043339389, -0.459214480330629, -0.19881008397792582, 0.042842940547774044, -0.2365442044636763, 0.003845245658603595, -0.13355044885398717, -0.49286482325488407, 0.29734683455402106, 0.11800216667954144, 0.029742627222046278, -0.34792000260309974, 0.3828502949822425, -0.2591343317889359, -0.1257318533575678, -0.04883670196609631, 0.23507404705922277, -0.03867328873768155, -0.1538453387700355, -0.3058818107372933, 0.2976987682159781, 0.45062482728830944, 0.1665852680738462, 0.20132117428582622, 0.19183422386056306, 0.1906007118360987, 0.588567058488782, -0.22005617545634254, 0.2171779893879079, -0.21560565988976083, 0.7003685054565192, 0.1802532906792758, -0.2286793323496333, -0.21582585457771217, 0.13398683115338553, 0.48850888961839617, -0.6180901736750349, -0.17691930146503784, -0.6394495209622908, -0.6064136513110059, 0.6592093574830864, -0.6779657074134282, 0.19251015023927812, 0.26146594497439696, -0.1965372976565146, 0.38709424427533384, -0.18943364200134644, 0.2161946719999863, 0.4794272566126699, 0.6611183510511197, -0.09639847070185432, -0.33245872449699787, -0.18180049302314455, 0.16267611473265112, 0.030966859747664017, 0.005832163478413018, 0.5906487542022444, -0.5353149250658793, -0.2099017139824004, 0.5013789206644585, 0.6278749054924374, -0.22388885043841508, -0.6993348480651309},
    {0.3954816436656367, 0.41005107004491065, 0.07845074665263596, -0.18795836351456188, 0.4971837989950157, -0.04653607900399321, 0.11495276315859916, 0.25823131149859196, -0.07873684770150734, 0.2582046454719141, 0.43561513453059925, -0.08378268901453326, -0.32036101478280155, 0.3874674859493348, -0.5429149407360356, -0.7737066344376686, 0.06955162548485257, 0.14580224682339643, 0.22776334134548915, -0.32188486409672956, -0.38608302519665544, 0.5174431280462869, 0.3673782685927041, -0.22636973779934408, 0.30209290055276056, -0.030061636508672576, 0.10896287176115506, 0.40457970656914777, -0.417018038554926, 0.5565006824368595, -0.29559178929152136, 0.6314641799901571, 0.21622978637254286, -0.2866538613354877, -0.30110142400899625, -0.02187366479838337, 0.0753998310691569, -0.35730726405551405, -0.22168875014541467, -0.6363445112263022, -0.5357880580063472, 0.6691064961156925, -0.7955313237879009, 0.053584274418245474, 0.32209712341593466, -0.1587768443947833, 0.46019991332630167, -0.5223648141799605, 0.20539204793984595, 0.4471249974725046, 0.4556349574721914, 0.019485126756410624, -0.47570656251898036, -0.0837156028752825, -0.2046318860383712, 0.29053048330164133, -0.40155299218228646, 0.5536107689240016, -0.7551011422029178, -0.1554783347956082, 0.33973077936041784, 0.5718341643925308, -0.09095447102775549, -0.6260472897296435},
    {0.4105057302640225, 0.21354624569582376, -0.15362348723095232, -0.2486239491859965, 0.13454039995115968, -0.1040989176613919, 0.037302834657442115, 0.44996117113372747, -0.3708499242062867, 0.45229344272587146, 0.3035372942273411, -0.11640127582917224, 0.028097288842006848, 0.3523908601963223, -0.2725751656862599, -0.697103103834017, 0.21773754872478585, 0.5053604311634553, 0.45916944081250816, -0.10373855381924023, -0.17485646957211717, 0.3741520210307204, 0.2064317389915041, 0.03689786026668469, 0.4803622634748198, -0.18461496393841628, 0.14831792301065705, 0.014465168993193705, -0.07387873489620189, 0.41351229158710384, -0.32863724342345285, 0.2204732187723107, 0.0625715198878049, -0.3778575419978954, -0.1899128350710107, 0.6227007059761211, 0.1449518835169029, -0.6686122642262008, -0.17638211200053855, -0.4686430588123985, -0.3491528036015012, 0.4109153824678369, -0.5189333798643804, 0.32489615865505206, 0.18200021984458628, 0.018304004091123628, 0.7144444772226397, -0.5083406879304174, 0.12850170197375618, 0.2528290593295629, 0.25845151524765336, 0.040854047624430734, -0.3835508905497374, 0.03070636112593239, -0.05783562801819727, -0.14137098877709325, -0.34299166561664135, 0.35840076861797715, -0.2477272943831742, -0.3581049901382577, 0.033001950089009156, 0.42496373911256347, 0.0397188804313628, -0.4130378642427792},
    {0.5527542718780174, -0.14113477316340728, -0.5814431721591095, -0.26633256876423983, 0.4287336346685005, 0.024623356743682896, 0.5218308996278953, 0.35099765149696893, -0.6161743043677536, 0.3451507344863805, 0.2003289722431165, 0.146056583160699, -0.09440430402393343, 0.6201179528203686, -0.4335360883797156, -0.35561304814860706, -0.2475804477578434, 0.27930358594579613, 0.21312815020752204, -0.0391105992643396, -0.3409807940380489, 0.27603732685002347, 0.09636288255256965, -0.2991791997171509, 0.46242182763159534, 0.21258325705891934, 0.1296805798309284, 0.2459131605571329, -0.0696715796363475, 0.4333989976260197, -0.4390976093753798, 0.46902994176305696, 0.16424017093197993, -0.38090170206849444, -0.2907300570584516, 0.24692996175215062, 0.1389286263034351, -0.2441512815006182, -0.04699443479990745, -0.4129394341890985, -0.3439706958019253, 0.35741054165704866, -0.6208559698056564, 0.10568956572509725, -0.26064147961908385, -0.1357804266075459, 0.34611635390061346, -0.35569463135146095, -0.002447486193500168, 0.42656190650626763, 0.543203179874168, 0.11290045964808235, -0.16392132228903425, -0.11696049224440012, 0.32463649514957676, 0.2548379578269759, 0.09542641589153579, 0.35490892532059265, -0.4873191586429549, -0.03772469936650363, 0.38656233403870455, 0.8256444176839274, -0.3983827195049716, -0.2637052350075357},
    {0.43963059773820773, 0.18371898357227906, -0.41947867279128115, -0.29812159377347874, 0.4027957238224338, 0.002030295418334432, 0.1779459063967276, 0.4728274765789466, -0.46595014610714175, 0.5514804802700621, 0.16442654295098982, -0.12180788350725846, 0.09391956214443564, 0.4211714243178834, -0.3059268537688617, -0.39496993026928523, 0.020299196106558087, 0.25110315228648766, 0.1232631828357846, -0.09784406999532963, 0.1452612198287733, 0.10189537522052729, 0.5314932820992677, -0.10182162815808048, 0.4793712559074337, -0.2824334835011853, 0.024336799013986426, 0.36264783643685267, -0.27361308408095647, 0.1397497934110155, -0.058654286065481766, 0.6984539529452225, -0.11671535316461742, -0.21582235760694835, -0.5956999938642074, 0.2505605305256722, 0.26839163347191886, -0.07991834188441908, -0.12675895834901912, -0.5463112821858587, -0.5227241254279614, 0.4474591206085711, -0.30631154222475687, 0.004881385573072472, 0.23723970947213316, -0.0738756503466901, 0.20911947550738877, -0.1758675827217796, 0.07029794060858797, 0.6619717725338616, 0.24715875036130716, 0.352616486761215, -0.4117664197864214, 0.0688919887036547, 0.20957811772430698, 0.47727328452713325, 0.11975107070027162, 0.3887700295558665, -0.7603315375540038, -0.37561151919303887, 0.6407812895400193, 0.5162222901529058, -0.2392289652828831, -0.5578388347152896},
    {0.43012020089412123, 0.5953234490659755, -0.387031253445479, -0.3681105068941178, 0.5604420698082282, 0.2940066384383467, -0.11201245896081283, 0.3008619413106915, -0.6772788062255195, 0.3478577951288511, 0.35060805893917635, -0.045155001193455356, -0.2288798388544284, 0.27931749176170956, -0.1136106566747076, -0.43761391501838465, 0.12505109362833322, 0.042935174841526376, 0.2323112926540236, -0.328758601069726, -0.1199951618149344, 0.1407593242896143, 0.28979835887280603, -0.16334453073414026, 0.4417292157689744, -0.3909058447610671, 0.0524148701243795, 0.07749516885046724, -0.4945966168413384, 0.5082131914642021, -0.3691839690981496, 0.8133989349010698, 0.221714307660137, -0.49029376070600106, -0.2543090972024859, 0.14982924449336363, 0.12191294517536423, -0.23025658236364152, -0.01327864457446153, -0.5831616982826076, -0.6986347284841381, 0.605567694361104, -0.5320159303886051, 0.32057884381632984, 0.2841034189600748, -0.29048421936745566, 0.36670477231661897, -0.37968152161942, 0.36949495041206987, 0.39725945391299894, 0.7321965949701612, 0.13936058601995255, -0.5266732637902796, -0.098667139691819, 0.06066607439582767, 0.42749164663215944, 0.055973848789324473, 0.4064275791265555, -0.5855288607727559, -0.31298418052635496, 0.38785200593952596, 0.4308700030401294, -0.12096965792290118, -0.7545151093825887},
    {0.5586059307876743, 0.5682481630355021, -0.7297490263110773, -0.39073425066063866, 0.549287144215665, 0.05704539567659723, -0.19004249576169915, 0.25945002488869157, -0.4813105776192076, 0.3937950035166546, 0.39467179991650314, -0.2553659832633287, -0.08824912403436745, 0.30889078292897787, -0.3639702523465879, -0.6953136552242186, 0.10129572255997454, 0.5340675585372823, 0.3915526264471467, -0.24032398536306898, -0.09899172330946727, 0.010302777926243671, 0.3932223634721909, -0.37259781066265735, 0.6531622217598579, -0.3129546297835168, 0.3073124018472823, 0.38582079855794427, -0.4497697211959525, 0.6114239775376171, -0.15278890383010196, 0.43463559462987833, -0.10881165561269192, -0.38321599598225353, -0.43177319681388104, 0.37474048963083867, -0.09852017507606013, -0.14762716262074682, -0.3452902744281259, -0.5746640375562725, -0.6380864987980995, 0.6896622841335511, -0.51869873182733, 0.43753809610269795, 0.46429692310837095, -0.002222940947424579, 0.41164607139986686, -0.029934004415538302, 0.13471141742409617, 0.39600295254749884, 0.592017836188859, 0.3492823461320643, -0.6683328285494998, -0.49213346291122606, -0.11649916560766446, 0.6442447037677079, 0.1735352738661659, 0.5287156914580561, -0.6577825937121445, -0.4710642457511827, 0.17072039578234224, 0.5504253989731008, -0.013349741846174278, -0.46128650145384265},
    {0.606295395664625, 0.6447271666432338, -0.5223029421195852, -0.44082204491180627, 0.5716880685106047, 0.10291417648847931, 0.4381860304686871, 0.10488846534617337, -0.44768795973570996, 0.4779533809120211, 0.06562940237205693, 0.017379065096870806, -0.20731717235226665, 0.49493158315712316, -0.26780648271714846, -0.35939539268388243, -0.18185492099583597, 0.7204428340598469, 0.5169944425156076, -0.32807517100031924, -0.21779597586625582, 0.24363529703671094, 0.6270228571529897, -0.18547947292553138, 0.3569778952576232, 0.09794751057209278, -0.04393378856548413, 0.3217268183581717, -0.24972579562828284, 0.38112378117850926, -0.19114626468262033, 0.6708675630107125, 0.23401178979595708, -0.24020271132810242, -0.5720121184379177, 0.2599319972776579, 0.3387809672198385, -0.2538122955263627, -0.09765374428028309, -0.5333325492260127, -0.9016641156501685, 0.4698225739437751, -0.562937752615133, 0.31319454221666015, 0.26672016181077457, 0.1836982578742292, 0.5808934456352913, -0.4674060480115806, 0.3442057752904956, 0.26650493131688446, 0.5839329481805301, 0.4999406662984071, -0.6006990384859358, -0.4843386226824656, 0.027968822852164583, 0.6290304784258437, 0.04909571393938168, 0.7245684733128614, -0.4346276823720091, -0.31448034533711267, 0.17019488910883396, 0.6232456297040319, -0.12427989137561601, -0.6553058862915618},
    {0.48327263081818206, 0.5771434293699038, -0.27800037664881083, -0.19292602757323146, 0.24907396104203772, 0.001819510974262528, 0.17053215630266305, 0.37773983811150114, -0.5561559613662161, 0.5923383707214945, 0.10088430024271912, -0.04309923150880102, -0.3408763772018358, 0.45294242788456995, -0.5259475639167775, -0.43176535416468526, 0.04393180240359749, 0.40983970683113763, 0.5633448883041698, -0.03000953327201027, 0.04251334930904859, 0.3360770695779434, 0.5197003323320115, -0.5321429465931863, 0.5772386825634889, 0.048349303749189554, 0.03087692677409502, 0.4660777050609477, -0.1548877731001536, 0.26546887300661465, -0.344402321000883, 0.6104931700413605, 0.23300865744372706, -0.2125639000763108, -0.36452410019739384, 0.17847083315976237, -0.03468521153082934, -0.5061716688208654, -0.16387466482705404, -0.7350911918276615, -0.7117579496206082, 0.46273955834599895, -0.4948302997936396, 0.4178902561572615, 0.5159315442713361, -0.20439526833043176, 0.7271823310528501, -0.4577980079878948, 0.3585596885490198, 0.2819249994320555, 0.6047090609595782, 0.18366685511918981, -0.7564859566275725, -0.2545202864534315, -0.21445871281459444, 0.7547329424596163, -0.028310032141654465, 0.5980670888088244, -0.6644486030486204, -0.23581968857556768, 0.3233206729375922, 0.43019343222878614, -0.3230149137542069, -0.4651377765645944},
    {0.3840661044849813, 0.527022068397113, -0.35360159476560066, -0.4780840976778586, 0.060047524497868834, 0.1776973207548546, 0.39728683573364826, 0.08061723099498898, -0.3898870050667605, 0.7473210386611148, 0.24666790379966494, -0.06157856257874278, -0.3414013505846953, 0.21845274431443149, -0.36271850990404325, -0.4405084950522622, -0.08954441746288376, 0.6052153247450052, 0.6050173080763541, 0.06354094976751083, 0.1858622496370245, 0.21126116650599863, 0.3243386187717757, -0.20718398258906584, 0.4744516350450671, 0.14938810185307042, 0.14187701452157606, 0.48443225772032333, -0.6099475270740781, 0.0715222934330327, -0.21825829066459562, 0.6659297777029534, -0.08199493763290626, 0.08084740166296497, -0.4635267078567021, 0.16402871943630967, 0.14918207488828997, -0.31843314489174657, -0.34458715053949623, -0.4173893487864034, -0.5086970219798804, 0.6865151983911829, -0.44843544651257183, 0.38434253122510526, 0.258803490878409, -0.34802787814738084, 0.17869459650930467, -0.5768260589563597, 0.3280212258325208, 0.3082153485444123, 0.819342136313435, 0.5164482882776174, -0.558903970212842, -0.4137497162024497, -0.03147554383494672, 0.3102958270506784, 0.21849906699997126, 0.6657189859379641, -0.15992178958609313, -0.22001729281533264, 0.03381706539572333, 0.3040400009934373, -0.17625924921087732, -0.15441818141768082},
    {0.1674652494294134, 0.6915321638676604, -0.42427108848205636, -0.5414067771089376, 0.27849566721401664, 0.10340471350951923, 0.19034396962981742, 0.3131761236633958, -0.43033792154988787, 0.6562681591399329, 0.1393645824934126, 0.11517985262863516, -0.3734482953827647, 0.45743553478199567, -0.5315325841150044, -0.7021092545106765, 0.2254499232887764, 0.5155577937230883, 0.4478143438784132, -0.1258221050069974, 0.008218468728600591, 0.30715591360457767, 0.47239824554735704, -0.11938339384308082, 0.6703934301169255, 0.05538430905401901, 0.7130916734410689, 0.5648042649424211, -0.45935377125940063, 0.250131583523575, 0.0432022836527187, 0.500187592278127, 0.008729247487183291, -0.28934499925318236, -0.5802447973640676, 0.40903985881313487, 0.4420991855422848, 0.055733300794024936, -0.17983417497154658, -0.7217631031085255, -0.6693494900486303, 0.6543006108524216, -0.8225680237745565, 0.6063530585843976, 0.28562413054552666, -0.31137911867398876, 0.49067345831152176, -0.7210837147688685, 0.3698788333370562, 0.2787818378256529, 0.5637653753200189, 0.3462713346969358, -0.5735043622122203, -0.5780231495394662, -0.2264136771837445, 0.6283816310296528, 0.027230697195397457, 0.7356232145448156, -0.6840952567916643, -0.1818884571098219, -0.2479944005456868, 0.5926510956338644, -0.0063483941868180465, -0.26721346999885454},
    {0.4832544330867624, 0.4371164333737475, -0.3063122618448095, -0.2772241138644971, 0.10536949455895579, 0.0608922593984322, 0.4987211368904086, 0.03159263945590752, -0.5636706667550788, 0.4885044849532528, 0.11023516892457762, -0.05125215559638445, -0.00947306688374966, 0.026314792057431997, -0.3543781950767827, -0.6392397251914544, 0.17726397815714529, 0.32054812914056763, 0.59066956981151, -0.054001840565491434, -0.20985748018751177, 0.5281093306582124, 0.5244046947225943, -0.5605304441710731, 0.45856083312040724, -0.3051788606652393, 0.19769079875027779, 0.5004443723404868, -0.445463650158389, 0.2587423367323478, -0.19695996839090812, 0.631011783525952, 0.22973650260333367, -0.5169348227481796, -0.5013373990788018, 0.6355671480128031, 0.433366445117902, -0.12510433435678045, -0.09868537953648926, -0.7767592036944184, -0.5448067171656874, 0.6038177974612238, -0.5419319214169017, 0.7090757257923339, 0.16374038462584597, 0.00535296300718154, 0.5649142546779093, -0.5058350142144287, 0.13936979001550281, 0.3655141388594782, 0.6719860220245543, 0.3132423161492166, -0.7383984702000259, -0.18463786316582959, -0.22620966670190237, 0.34117256998751894, -0.43905227531897434, 0.3409699862072908, -0.5520346116842653, -0.14733178177464587, 0.17189879411745876, 0.869879807161118, 0.013087543918720032, -0.5512292907982657},
    {0.396145980742105, 0.5286858407977914, -0.0907099722148857, -0.4283181816563104, 0.2511188067921697, 0.34631925805329977, 0.22966805823494463, 0.2624937549817396, -0.6131303247620888, 0.457857975284277, -0.09490553812739308, -0.2618056019650906, 0.03287578642404923, 0.37712523005959653, -0.5671490736706464, -0.6131903335098396, 0.11906825668675981, 0.24244141697459798, 1.0810045912328068, 0.0183440072893102, -0.2631536518330046, 0.2417693248621634, 0.5107259575646813, -0.5989748276754894, 0.6151080347523826, -0.0187229873974879, 0.08404937094763744, 0.6820146536049555, -0.5033790020647393, 0.16032196297895632, -0.41695983997556424, 0.6296671842337311, 0.1709176082315244, -0.53692102229235, -0.26513651303667035, 0.3584058901335313, 0.5432051363064563, -0.27284253033910505, 0.09543125256251607, -0.6797043816116485, -0.6744444037700856, 0.47517950805776965, -0.7245274835643857, 0.5227106307717398, 0.2937775668628817, -0.14641217333855272, 0.37101134916846473, -0.38487121765034443, 0.3835168912412019, 0.471911629888803, 0.44443446284939103, 0.37684426780375596, -0.6148656781998525, -0.3094321529658555, 0.0164162925538242, 0.18205785700193727, -0.33976207973001016, 0.38009179391820863, -0.6239982222498343, -0.5696152762891828, 0.3858685236018966, 0.45723458572745995, -0.05934602289889228, -0.6318992008945716},
    {0.3325697400397607, 0.20889711286111895, -0.5810905439446385, -0.4491186284055559, 0.4031166010298334, 0.06454597150317978, 0.17675320058951452, 0.21226866435729552, -0.6038932284863674, 0.21626620965767965, 0.29357584332396347, -0.38975724100396353, 0.02840843519287855, 0.22132053290991702, -0.5069075532241202, -0.40838128047584255, 0.1736268168876709, 0.6714198307749742, 0.42256349593825326, -0.023043116708161955, -0.08617461980364793, 0.18219168322832222, 0.3772167274284047, -0.18079373409588734, 0.544043069090155, -0.3438206609839935, 0.32170182863250585, 0.6477103016511221, -0.6089417334536701, 0.18675291799087268, -0.45062393023965214, 0.4239172547252543, 0.17249834928475632, -0.32613314579134567, -0.40815831270380737, 0.36093794076234004, 0.5246873122671825, -0.388942029083733, -0.5256712705883994, -0.380049049975694, -0.4200718431756073, 0.461834096244909, -0.9011952590277822, -0.043793048040207234, 0.06275668859499582, -0.5998787150057676, 0.12721352140721462, -0.5099506308663326, 0.19069715981301527, 0.5031665445933878, 0.6228673435255783, 0.16015796774297203, -0.27876688906117797, -0.47904528011263453, -0.3564001159387578, 0.15649132406808175, -0.3104965059069921, 0.31933705264002843, -0.5496599968346961, -0.21212799764865306, -0.071271858605635, 0.6523851605471689, 0.2897846923236142, -0.47107553216287246},
    {0.3070582265037802, 0.5597271691675443, -0.4103863552827724, -0.42199196935136096, 0.42079491915447426, 0.07376847370754774, 0.2479392357079547, 0.1972479486497358, -0.35691091053893126, 0.10770253284602282, -0.006424049066086765, -0.22041278450252477, -0.2517555523546264, 0.24499696916252903, -0.5457973558539885, -0.6172166283107793, 0.09335107493293529, 0.564595914436748, 0.4187490360212139, -0.1393209173681784, -0.32880727185501213, 0.5502449928407374, 0.38668711043856024, -0.4426442511513334, 0.6147240454120326, -0.1726127532806312, 0.4100957596559875, 0.28093023392151667, -0.3175006380484928, 0.05586799275165304, -0.2607469340961302, 0.6927362798318104, 0.23395202867821058, -0.24626993126704966, -0.48962881631767813, 0.17584128821486755, 0.583306045039301, -0.5420618787140933, -0.5428763608295569, -0.3601231237211169, -0.6270023533267031, 0.4590723771812714, -0.8318497309969629, 0.275496441732275, 0.34999197104066987, -0.28604214476046436, 0.46493278468692273, -0.619329547053691, 0.22933975252652458, 0.3799917942701442, 0.608610690545717, 0.06670079443125633, -0.6489638593843305, -0.599961723961849, -0.26120073204962085, 0.3041715969188018, -0.3270662406247438, 0.5453898314790468, -0.6097714545679435, -0.17116644576655918, -0.058647749521920506, 0.5446942224216754, -0.1519245256367516, -0.7829767869989317},
    {0.28595811747362093, 0.636495555519685, -0.464497979383054, -0.3404590609167357, 0.31033570682213346, -0.0023043938137092567, 0.31332368185338166, 0.35174915471204227, -0.18778779249771263, 0.3067128483654216, 0.0008930446660815469, -0.17060243423841762, -0.11500100228643752, 0.5011484150208503, -0.4327332371042753, -0.4358118934556231, 0.03932339669625173, 0.47758852935779633, 0.4085589616708393, -0.01039586832030885, -0.09633497265138308, 0.6858848425293504, 0.6618267482995385, -0.38152289719625854, 0.45306026129757077, 0.19523941902714703, 0.11333380989594062, 0.527943262593388, -0.3561502066545142, 0.1948056871695391, -0.2587185511979632, 0.7021155150776948, 0.2963278199573806, -0.29914838267478217, -0.4399805199882062, -0.0032127142567219716, 0.16163167265673684, -0.023810905573654527, -0.3191879448349179, -0.7646252752569936, -0.7185341920429439, 0.3478200186693901, -1.0277589993892269, 0.4790320972572502, 0.33288794239649927, -0.426359687310604, 0.24111412851395214, -0.2515513224074478, 0.06793465518848878, 0.39620751522948106, 0.7454256773710449, 0.4359129333952283, -0.5550789896035482, -0.435384881324206, 0.2204263071691037, 0.49743963509169864, -0.018090119300926858, 0.4613199522725968, -0.4949862387366237, -0.29798173972297254, 0.09492681107879625, 0.7194378870903306, -0.23097581677464496, -0.8565736817459022},
    {0.4680023923949257, 0.4678664168506613, -0.3998783783958045, -0.4532191044435178, 0.7412639581068016, -0.20444163155377781, 0.3981277326685487, 0.4423037475980192, -0.42310590539479126, 0.337959818169041, 0.20196261001949442, -0.014626147691178426, -0.15484594054508166, 0.532677763319153, -0.6431724880086682, -0.5980362310890561, 0.06903929180981333, 0.5079278735878455, 0.3128008372094424, -0.27088414456651566, -0.24320625109189198, 0.040934487373789644, 0.7377954808526376, -0.45796503615221196, 0.722806677003219, -0.04749771172733415, 0.036509075050803176, 0.34928965309411203, -0.3476144040171041, 0.03407996623507436, -0.5322451722729475, 0.8178070447563884, 0.23758279713643823, -0.27178041057595553, -0.4308690141568618, 0.25869464819640314, 0.12844871107855182, -0.41236618067648534, -0.29456449189510897, -0.8818833494242567, -0.5577268147002999, 0.25350073760461483, -0.6639557319005072, 0.49755592808624627, 0.38384727339883334, -0.28481182869181176, 0.43885044719740957, -0.5529418638127904, 0.43555960900260055, 0.3822655801394977, 0.4495560472638289, 0.5236130065049185, -0.6562245725697644, -0.3536283202006498, -0.14436127254643943, 0.32899327826221314, -0.10125810209979294, 0.30070393116164584, -0.38447893007966266, -0.4590329881721402, -0.04083366525775669, 0.8697423785437856, 0.0941933237709022, -0.8137291761730683},
    {0.38568923098579333, 0.147882704655271, -0.6284635195440056, -0.35812296625910217, 0.7474599811271055, 0.004915813202849096, 0.48188796450001914, 0.12128163910007159, -0.38759490670521196, 0.28895551581423584, 0.2760601372830017, 0.14303429819783026, -0.2574631829751444, 0.2502912777207143, -0.5434383603835409, -0.43282013554229415, -0.10152628481845065, 0.7158194738801007, 0.3448972641442413, -0.32057118280708247, -0.0624497869446342, 0.22782740532203663, 0.8358026260384498, -0.08516777580727232, 0.6878183433513014, -0.2405920483975044, 0.15302295384369888, 0.6577894115719543, -0.2959265189006007, 0.20559440449162866, -0.3368861097822993, 0.5392275058967252, 0.1645720120473872, -0.5556585265134718, -0.4341651644986293, 0.17483066049527698, 0.5135427963961479, -0.427328327204205, -0.2883702778945864, -0.7253682197336923, -0.5479245080855801, 0.2651331191099022, -0.7018706973506855, 0.43394927086533397, 0.49024606391463627, -0.18060322634509884, 0.3127914976468793, 0.1538922045906594, 0.19636153988373675, 0.5638209456380656, 0.5120002469095007, 0.48071065022632176, -0.9345707956462282, -0.318930018002347, 0.2748925996801863, 0.9557327045748646, -0.12191593373746179, 0.5150849063994838, -0.7503255405780938, -0.27017565701220014, -0.10048770801179652, 0.5759262630033722, -0.18053560679195957, -0.633465418007419},
    {0.5465822147119485, 0.3938842575745101, -0.39392021916831466, -0.44173708939163914, 0.6548558865444578, 0.061503387506905975, 0.29802685057478673, 0.3167730361508057, -0.3807358466482887, 0.46585768323865, 0.049193596310491354, -0.21494420865068217, -0.6510641751330325, 0.49262895473651497, -0.2994042852762685, -0.44672371823095325, 0.26949764654513203, 0.7309900106316639, 0.5983958462844414, -0.2641581130277176, -0.09475010832116702, 0.38597702622193397, 0.6656706087509465, 0.11305893707481621, 0.6246034143844739, -0.1287179638752609, 0.3832341188790465, 0.47278992067365383, -0.7376835056221178, 0.32223522241659325, -0.48874675153959146, 0.5543296233361369, 0.10440009377231364, -0.19211040047268454, -0.7682252618075289, 0.4115654944892185, 0.6247320067840212, -0.3487320286435513, -0.2813871258746415, -0.47188633020406673, -0.581637747370859, 0.6458608973725964, -0.6627628785262885, 0.5535523548861506, 0.3887747098944641, -0.24483967622554975, 0.20897659406741903, -0.2345675533721283, 0.4214462165917805, 0.517014526511529, 0.4136577357317122, 0.31704784336535785, -0.6649920596093261, -0.26659366678852475, 0.014966690582891478, 0.5679195829044663, -0.3905029779637922, 0.19426260046447652, -0.6047064833618637, -0.41683282205310845, 0.04984476794218762, 0.8640237977499494, 0.0861211861038826, -0.4282807609830296},
    {0.455837007259194, 0.14302917767221876, -0.14314759995547446, -0.33866508011772467, 0.5218455730717395, 0.3516812619025198, 0.15542279556273816, 0.040154538899467275, -0.581320891979416, 0.3878354216286488, 0.6825445154741827, -0.48906458599221575, -0.22985394833818648, 0.712318720114655, -0.6566599690241643, -0.43349195424535153, 0.21055450590609862, 0.6652351493786031, 0.6804239046932328, -0.28980660352541954, -0.4130923646268083, 0.6656193523023071, 0.5332174252309156, -0.1477985741062774, 0.9301460270149536, -0.2720712231526197, 0.3079644942327789, 0.4834140796209263, -0.40350486634519167, 0.35754241831492856, -0.6977626215709611, 0.5544024581380965, -0.0011616227136474378, -0.3308971390958311, -0.41585572861457254, 0.1729355928934692, 0.1898454348219044, -0.4966022607308788, -0.12777019185542593, -0.3658198243356067, -0.5696047568696516, 0.3971368760446083, -0.4471573627955655, 0.3270800028489596, 0.24625903453999695, -0.4066999982242436, 0.2840153317333677, -0.4372240449811865, 0.48623155231189835, 0.6030406246845181, 0.5210568782090952, 0.47381260281276644, -0.3876396208983236, -0.4353183097231342, 0.007241926490130943, 0.6558808157992715, 0.0259207275155024, 0.4306149741197726, -0.6180023016420224, -0.03650016854427272, -0.004936305807744725, 0.5362636702520451, 0.2623880177084602, -0.6382142488333373},
    {0.7605972041699932, 0.4019354136626391, -0.2676661821935426, -0.2808739592424959, 0.5614311581231672, 0.0035311690747997725, 0.13788026828256456, 0.21137922647120855, -0.5451057983763848, 0.3199410180596567, 0.7069609818302397, -0.05970087603225267, 0.24966817499018268, 0.7141662440291575, -0.7644035425430306, -0.5024030428473836, 0.08500295070108908, 0.35939754881485303, 0.786623521468912, -0.7267495306629219, -0.2837432006526306, 0.4161785126499653, 0.7328935032643159, -0.21848731677128225, 0.8143333395734721, -0.2935492806817335, 0.3579740661313015, 0.4568611217340968, -0.43085143899216916, 0.41638339107269584, -0.47712724853369354, 0.6344045915219165, 0.0975763664395483, -0.32589665677851465, -0.23258444156509114, -0.07203182915718162, 0.3703729344587714, -0.389314609857664, -0.36855908667959403, -0.5982703182543567, -0.2124422413838621, 0.7124287513902338, -0.42004690977196846, 0.5420013539009371, 0.6208776011329756, -0.35184427122732, 0.43347375379480013, -0.6875162138942533, 0.5378302042234093, 0.5956825191168489, 0.6677503460228005, 0.21262588401183438, -0.5443414335181854, -0.38766313120704693, -0.3016111120861894, 0.8167300542138245, 0.08112583897133918, 0.5683130035834469, -0.4463382172917252, -0.03840539452448333, -0.08629979882456283, 0.7404946829709846, 0.12505400249776816, -0.6924902038921114},
    {0.8067235972526285, 0.14329732129843906, -0.3176509876809468, -0.4132059991577314, 0.9097130768624586, 0.2088434020855521, 0.2385756799532678, 0.3331671541602097, -0.5616942718730213, 0.4458032178724942, 0.3239279386132024, -0.3379676634384315, 0.04713189685146877, 0.49383868379405765, -0.6666097591060695, -0.5795506453599589, 0.37502200271861996, 0.3845313485909229, 0.6917127384266427, -0.3202910556966031, -0.03842860868353838, 0.5802432005826469, 0.6497293735654758, -0.2295604149640439, 0.7676758782907066, -0.11559503718788947, 0.06775059337585751, 0.621103179233469, -0.4433877038056611, 0.34681223062578714, -0.5200673385223392, 0.8209978339525023, 0.27230549456920516, -0.43583767166571763, -0.5483359626455672, 0.30375371701839377, 0.33251098567846704, -0.43356718557368196, -0.3783730472648936, -0.47071036788164616, -0.6501405361148477, 0.6495965293883111, -0.5147125821907046, 0.46768998310442494, 0.4678709592025592, -0.14606831081981564, 0.32394810557000353, -0.6377841671270086, 0.5448916481341766, 0.6558234967288474, 0.793047755415634, 0.2761868517214331, -0.47490193700190353, -0.4018207401428603, -0.19042230262582482, 0.48485954918244856, -0.41493210330634456, 0.7915532714664906, -0.6248993486625833, -0.20846338776063456, 0.3630153325464073, 0.9542189616653072, 0.29319226648958296, -0.5365562636414647},
    {0.6682281892664311, 0.5343345037001122, -0.5927878256649877, -0.36282013781255873, 0.47696826270300585, -0.2100294727560186, 0.164323785803071, 0.5139686642786344, -0.3993461846142935, 0.347707571065115, 0.5093636731055201, -0.2336815310628807, -0.18229598139432246, 0.47249647422042235, -0.6241873890195703, -0.5914643665907247, -0.03230324999693641, 0.7637549507537233, 0.3920062234500624, -0.3323470932882823, 0.07984271419373383, 0.6251605601425, 0.554586892694299, -0.4781482610669502, 0.7757321302270895, -0.2127702577146632, 0.2749578200220752, 0.4895849596848303, -0.7714271539054567, 0.10557477191191433, -0.5534671560779963, 0.5879271046241394, 0.3902329118846871, -0.23311278110342187, -0.6131488651777067, 0.4956853270547949, 0.41427535406822824, -0.3653778429539543, -0.4770149031122775, -0.8893175634284283, -0.26255323880212617, 0.47799912547804013, -0.7404723042922691, 0.3999580311316887, 0.35012983495257305, -0.24485053494901413, 0.49826992461833525, -0.5648037825362896, 0.09434111620277853, 0.4321388762162823, 0.6483360353650323, 0.2509106222719369, -0.4778902761929365, -0.26277254183573373, -0.26377221852993554, 0.569594451898066, -0.3069287196654831, 0.6927637518300043, -0.652665514900484, -0.41430708655479304, 0.2529258412848769, 0.898922686598061, -0.10824444661191997, -0.7732483206072753},
    {0.5669699227013246, 0.6044959624666946, -0.27145364009431777, -0.29614101173079926, 0.7131047523483959, -0.17836836506400383, 0.5430105443652724, 0.45424248099354747, -0.39601005419875335, 0.5373567637768232, 0.09452581048014821, 0.06741593207131823, 0.050067467313115455, 0.5112703679116151, -0.43719050807855725, -0.5542905839481809, 0.0018161940912483228, 0.47555657321019257, 0.5342092150488823, -0.16521130954252358, -0.14541308364165081, 0.6814492051812423, 0.4922992810028392, -0.3473314546725754, 0.6874054269095411, 0.006870458347712356, 0.3707052832095117, 0.4314339824555529, -0.7348087764837916, 0.4877150471478118, -0.46965075465495426, 0.47096699651566015, 0.38199322235737204, -0.3863082802066069, -0.5967469200794501, 0.22772387248670156, 0.2870976298071535, -0.3777723606673717, -0.1700598657933496, -0.6162002259177505, -0.4543687742647154, 0.4061947699445725, -0.7641549136726031, 0.4160607368344873, 0.3307765536710904, -0.5363228920970283, 0.5755344752961433, -0.3256113688714213, 0.168861544100646, 0.613797963732446, 0.8564846226162833, 0.1787919282304457, -0.7689756288451127, -0.6126073263110016, -0.28658186358842846, 0.4675599580865214, -0.10088775400588008, 0.5969707883131314, -0.4942242517795849, -0.3599154345127678, 0.02578249914886785, 0.6551694551016726, 0.013646260645037205, -0.4561305150980463},
    {0.5051610687150214, 0.5533545210295746, -0.42836874598621616, -0.38801692956078276, 0.6517800889829423, -0.05240115880448111, 0.14515619555163536, 0.19895044836120135, -0.38476555717205474, 0.4050221112795026, 0.07010820342147929, -0.25764526197437426, 0.002419853892332472, 0.2458358562585204, -0.7732541144843614, -0.5872354275713244, 0.15323322930960057, 0.4666386741913704, 0.5531089504691191, -0.29213030293300707, -0.38593559204981703, 0.4185967963544751, 0.25651954774297964, -0.5662448831682071, 0.5524280060315379, -0.2500074110479218, 0.15842473658301864, 0.8040159941623737, -0.50450308930583, 0.4224625760439457, -0.5228239599162651, 0.6238034424436969, -0.05878094013143675, -0.36668189626147163, -0.4197379673096397, 0.12626833487242442, 0.7304066996491884, -0.550965832288529, -0.45386216995690126, -0.6933194434584915, -0.4787212615697977, 0.5119786177799559, -0.8116039796707331, 0.5001114024179363, -0.14735269854056446, -0.22003810625555528, 0.5185712303231644, -0.48973892687338527, 0.23884409709406462, 0.7586481873730534, 0.9679515930353054, 0.39874144648127136, -0.7924905019575159, -0.4051901969634851, -0.3114502979680023, 0.7984155263120586, -0.15048631273202867, 0.5397139657030579, -0.7470679984669633, -0.25284048689094574, -0.024237201749987596, 0.6508955886219363, -0.1986939858057985, -0.628137821517803},
    {0.8254022460740512, 0.46793963799208155, -0.35886174727413883, -0.3920398798478168, 0.5242835345788771, 0.2766673380321882, 0.6572939526064712, 0.15313319884946658, -0.7325410277087837, 0.8048010665646304, 0.2861803053086776, -0.13764030161108162, 0.1918406573475747, 0.5989859570888539, -0.7335938716636579, -0.6601120282379793, 0.21850882293603455, 0.5240516947252333, 0.7851312246824814, -0.20278210633459556, -0.18897873330077347, 0.24336313656036557, 0.6680787333710793, -0.5193895985447878, 0.7735574336706701, -0.12727203893477837, 0.5818888170198713, 0.6023347216073945, -0.5385138280469141, 0.4598543791504005, -0.5504863788023194, 0.7637939626862669, 0.26576710714308843, -0.06070293364146766, -0.6821853229150047, 0.4037490176623664, 0.3770455961785236, -0.6458313747461292, -0.2337834545742505, -0.4775507752692561, -0.4915810494544367, 0.4076715329153801, -0.7073500700788902, 0.7080540825350794, 0.28168076384405477, -0.11871823989899956, 0.40408538035030694, -0.5959658484834102, 0.36682403806958064, 0.5308295393640362, 0.6528830013775423, 0.29345432102909735, -0.4478573170776551, -0.504042944635479, -0.3400199484314347, 0.6992359006493197, -0.22680712232767544, 0.753694873743833, -0.8132663721857065, -0.4892389214117771, 0.04087295666563534, 0.4389074774317675, -0.18646734686090785, -0.6908802555239982},
    {0.8134609081274357, 0.47760118452465916, -0.25407634949931707, -0.18946798071528237, 0.5499921198594497, 0.44297341039527394, 0.3927881088957003, 0.3275232109579686, -0.7350283861464733, 0.6209664064580586, 0.201955077071808, -0.2605975249745619, -0.11285360298511005, 0.747555211867766, -0.6469685738443843, -0.4339463941010295, 0.04816416471688952, 0.377493432284789, 0.7492076455201249, -0.2779276744418943, 0.06854973553581346, 0.32636523257335054, 0.5977911678173614, -0.5214124781503328, 0.4231448043714854, -0.27714583599397624, 0.2910392027952737, 0.611822037459095, -0.43890327769634724, 0.27651368174634355, -0.39986275492895185, 0.8506515560564507, 0.004727503603279246, -0.22233149797991422, -0.45117068917836806, 0.3490284141054869, 0.35020892079717636, -0.4960340496623495, -0.34252472900278336, -0.7876977417897397, -0.8230162761328185, 0.39743452235015453, -0.5990355245768005, 0.5525382025160842, -0.021105368192777488, -0.018563574953416092, 0.4202751528000483, -0.7442306086756625, 0.2692486742162694, 0.48777514309256376, 0.8148465361621146, 0.1017020122806871, -0.486770923333984, -0.40787111412850874, -0.4558752455633166, 0.6680684173851233, -0.20869576171183235, 0.7823086193846509, -0.5716475436345501, -0.3989976265659487, -0.09131791549942746, 0.7071314338567489, -0.04806810649685944, -0.5458025735716444},
    {0.9674146868776553, 0.2710721072786639, -0.4419252561189881, -0.30247045334462214, 0.40770708115981646, 0.4041643199033982, 0.16740840102818197, 0.11440880099138236, -0.41395555153983987, 0.5739136733063277, 0.15277058803284635, 0.20823563650618296, -0.08455879727205275, 0.7227597680421897, -0.6980594460237635, -0.5426601590157015, -0.1265708499161145, 0.6132813687085645, 0.7829764608054347, 0.044820846321077176, 0.043987328312390044, 0.5527192303736411, 0.6404928028168221, -0.2514062091335803, 0.4881641948603563, -0.32668584118155664, 0.24751296497109326, 0.4005419702174779, -0.487353929933891, 0.4750541245382209, -0.43621229296776687, 0.6736865669435346, 0.11118477793224985, -0.08385603915514647, -0.3548155871402802, 0.33659208818756553, 0.5324006497509309, -0.4389489996679478, -0.637760423526027, -0.3396726408503433, -0.5783262575600148, 0.7679821775193296, -0.5366484172551942, 0.647893386688661, 0.2934012734923216, -0.4551249443249487, 0.5697282628493844, -0.5015193537247306, 0.1687141270017645, 0.6542786980581887, 0.7793049782504863, 0.23968550381383033, -0.5966285843429981, -0.3481639768997808, -0.3126875820132029, 0.7173029341644356, 0.09988196728084235, 0.5659274827028387, -0.6007591465280738, -0.3515549884075729, -0.026922276352959414, 0.7294504200351143, 0.026933141163274874, -0.7613510079670666},
    {0.38748171747683813, 0.45221352767780887, -0.42532990243742835, -0.37364840944410777, 0.7764251909070001, 0.1521292856225283, 0.26949256600530785, 0.23146556288976353, -0.3862465580773656, 0.6944639955055951, 0.3308756625928398, -0.022426493099847476, -0.13475508129008057, 0.5120878263769112, -0.5602316121123404, -0.9590559237508045, 0.07128349773228035, 0.6193745818268156, 0.871637586952989, -0.36424983769608404, 0.1444759632922325, 0.5200890919099109, 0.4260714838986806, -0.547588494038694, 0.25969811024574674, -0.32918790089979516, 0.3415646967672985, 0.46321853891937387, -0.6234430766768846, 0.3357628795684702, -0.4454340286283284, 0.8463040323468544, 0.21646640830802955, -0.25421558299786934, -0.4336192885005581, -0.12167698331247906, 0.5478647740688289, -0.5293418518283227, -0.1711581554484381, -0.5222612895952752, -0.5858073938310102, 0.6316712530906122, -0.5819605122769265, 0.6769766207649114, 0.44892348568914126, -0.3439621035452541, 0.49214028572806784, -0.6738732845536188, 0.3663143537062492, 0.45433772585341126, 0.595556248855171, 0.37242879189169037, -0.6519090674495625, -0.2623725768622555, -0.22692701021472406, 0.4560296141367435, -0.22916083122540784, 0.5444835896346453, -0.6059677519432165, -0.24428584245222293, 0.060963047607036726, 0.5220005896222747, 0.026807839670557266, -0.9481317804377813},
    {0.04770256916995779, -0.07772035565169283, -0.13321504921559, 0.2774913048364881, 0.20371059120409962, 0.44516349406022787, 0.5368234947848028, -0.33729025942343394, 0.3534338371993511, -0.1193034621933849, -0.072322616788312, -0.5036803398867732, 0.14818372558396825, -0.38240068875245287, 0.0780037050086448, -0.1021396791831514, 0.43821374084966996, -0.06260695963808015, -0.370692111984681, 0.30151880750006926, 0.3859485877511245, -0.5741483052893197, 0.24431277942360063, -0.4161938870278239, 0.06699082980045608, -0.12387307367201293, 0.3970652561407254, -0.3591139226284305, -0.09605540491765999, -0.16513277160808476, -0.2681730609219255, -0.5835123720620529, -0.3004609884218619, -0.5988269065545478, 0.1409973615006572, 0.10177418576960634, 0.3752682189363915, -0.34310599458840735, -0.45087413608730836, -0.2939157341141493, 0.22321161652518937, 0.40411958842057716, 0.37140846149341855, 0.1746647888720938, -0.49143531076109864, 0.3041170410958319, -0.03746232174401363, -0.3360977023126945, 0.41360241094106526, -0.38268228391156506, -0.0931269700032926, -0.6529608125805807, -0.5058483265289845, -0.030083569793265503, -0.5400836099423052, 0.1152085935024093, -0.39855892612618377, -0.260046345973638, -0.12687029475252354, -0.1459853406610504, 0.3752545080229921, -0.15708760461140012, 0.2821721794056799, 0.13308011092482083},
    {-0.06030377246850024, 0.1547698314536216, -0.022259412016858517, -0.047541998007701106, -0.20022040637312466, -0.19130793640675897, -0.28943914931364306, 0.30972411628686025, -0.23200903616130472, -0.44279150137914614, -0.42475071613495835, 0.1768325190662549, -0.5629112875873584, 0.10673201432541035, -0.16755431024694753, 0.01139153783234584, 0.2701703124114719, -0.1993069589252495, -0.3513230844928952, 0.1917455000890728, 0.02528448518581191, -0.031102728325756543, -0.020154538234034774, -0.14302071811820807, 0.33191347989277376, -0.19509102389389624, -0.18446330357179289, -0.14390805511945, -0.25990755409464983, -0.1617629876665203, -0.056804985555984365, 0.0003410198688560142, 0.39515552151329764, -0.35331139979576, 0.22427334491261144, 0.3767279820911048, 0.07164960060179813, -0.14755454417643066, -0.17253083932651206, 0.19164905801763546, 0.2550644283284094, -0.07096694211492105, -0.04176913207126048, 0.03783671734368146, -0.0012242542193982226, -0.32683330503009844, 0.1991022741826221, -0.1624760480407773, 0.021160333526080058, -0.006526928848689464, 0.1573857428258436, 0.17203105736781912, -0.3006127311694542, 0.3606988765252948, 0.06364065454469373, -0.04690929425006449, 0.04895232120372125, -0.22167378873028945, -0.36277332142198815, -0.05625278056863202, 0.26663737626720474, 0.05623475847538495, -0.24599378794716076, -0.16715214697765662},
    {-0.4665581211769323, -0.1913492818931687, 0.004889850206312824, -0.4679480972027952, -0.5733435440056582, -0.1941493251278356, -0.11291724424983907, -0.06685126923957276, 0.1213227687443654, -0.6125177223543159, -0.30553951918205613, -0.2951437587040301, -0.24648895826406578, -0.39141192846671097, -0.17777207007201126, -0.0050955929712118665, -0.10077843580977887, -0.19500720743840705, -0.5134723815438419, -0.3215624207034334, -0.11772089114884104, -0.22565157583298354, -0.04056870012556525, -0.5920928834267856, 0.02042907376703845, -0.5209841701162857, -0.4397813155746221, -0.47179333990927425, -0.08496730611294785, -0.2265624078867972, -0.3641934055096984, -0.4069383590731884, -0.22508490039922419, -0.28049690374687025, -0.12568669677921748, 0.05153284203049631, -0.5268413947680212, -0.6128828397237572, -0.4648361831299189, -0.2836838724870704, 0.16643092746538102, -0.3178546021979913, 0.142880730771904, -0.1868300361442803, -0.02740705211451118, -0.6296646454714435, -0.2786645758618423, -0.13225959373933294, 0.07340804933864636, -0.4636575861931568, -0.40964597197795344, -0.32155769572555826, -0.18124122869153975, 0.025381022507075905, -0.5832270913231141, -0.481978539865876, -0.4730742382623742, -0.4126975417711699, -0.3059636525457463, -0.3725564182808797, 0.10586441676519949, 0.17571244387191048, -0.31095673374218696, -0.2823445142764095},
    {-0.26042493815755346, -0.15416582473188367, -0.028488871535570812, -0.2279509207932642, -0.4474294851365342, -0.17734686819536588, -0.043541306076265406, -0.014441038079730352, 0.2818442439302625, -0.4283891582691938, -0.19309212680346272, -0.36650848028517774, -0.07754856089207739, -0.5517198777775958, -0.2526877286283569, -0.54870418585872, 0.19155142678981363, 0.08193239485493954, -0.2569668966114195, -0.2500781211118626, 0.04210512066623387, -0.32634707896172327, 0.3237473731159884, -0.6270205790982977, 0.2607187432197221, -0.5352196503241329, -0.02838090838545899, -0.46457122894232794, -0.37309736054745785, -0.006096388594202553, -0.24990564942149004, 0.03242982333237543, -0.4987895708291506, -0.8994869031459567, 0.12118877470005907, -0.16435216169451267, -0.24421310856932643, -0.3380221895597408, -0.2803352213547583, -0.29436770730241635, 0.13722666673622938, -0.013705491188268882, 0.04312839626295992, -0.30495303223935444, -0.11133691223635742, -0.3965972908640965, 0.1803722565583512, 0.1668775950659687, 0.4890227219402293, -0.5030098854093791, -0.5324826623668703, -0.42153448833293305, -0.535246855609319, -0.1295455832244058, -0.24859465506209424, -0.36606094872447686, -0.3315809587738304, 0.21564325762609066, -0.24196261714224088, 0.09687081659956158, -0.6242518628268745, 0.20290644618417433, -0.34180974423133614, -0.12384371386149616},
    {-0.19472702103240574, -0.3674933995328658, -0.37776210022936246, -0.21818818566614595, -0.1126916626194798, -0.10683916184301685, -0.32214553384977357, 0.2830821092900416, -0.22134082142460684, -0.5936355467648482, -0.41631902623405004, 0.12157385791968432, -0.5847572697893324, -0.275628019347498, -0.3651100197527865, -0.148984929221601, -0.472275184583248, -0.5795586987189422, -0.22113867962423536, -0.3863376495437853, -0.28890347779403075, 0.0055578042194026804, 0.12582166777530654, -0.5538570539693808, 0.581546722989661, -0.1548575773599314, -0.42155462355917506, -0.44651492770495854, -0.48701284347654106, -0.6015103193761329, -0.37783594795733316, -0.5102233595148356, 0.10770725362403334, -0.3608476708575184, 0.17291697964755254, -0.38245479765094875, -0.27348745496769494, -0.5219727184053836, 0.05931002920271907, -0.13178707822478164, 0.4201752242387492, -0.4554888839888419, -0.3564853404987275, -0.128895981862818, 0.1407446798985041, -0.5101577279278335, -0.17629018187135254, 0.06030631188316979, -0.23866987139799567, -0.5336553755749651, -0.480699933652268, -0.15954174296577753, -0.6496146819657382, -0.21130300519390438, -0.1354619078954067, -0.50835726830653, -0.11802627212648091, -0.2291933746451014, -0.31988411703962244, -0.32807113325018405, -0.5806675412233439, 0.32318029124190023, -0.2586349422993686, -0.042921439522232},
    {-0.48319510185096615, -0.3374024151523724, -0.06826093226301153, -0.3102745716273963, -0.33343939218663793, -0.2556761498590265, -0.6449880830122817, 0.22052441571377354, -0.47646474231498864, -0.34170662459302104, -0.5223650723706427, 0.05078747431135179, -0.3850095240234543, -0.4281984797315423, -0.11001141724308801, -0.13579925515161126, -0.2086003664903507, -0.21672082149141944, -0.478248684645663, -0.33153834074262023, -0.452147011261378, 0.03975580452150334, 0.17522651866579814, -0.694305738074577, 0.1657965887585792, -0.09365082827683124, -0.3499284879550903, -0.7735192101372557, -0.32542342979162914, -0.3723701547773264, -0.39939144447513125, -0.4928268069184899, -0.2159984400249473, -0.24296765702908954, 0.07730051574420206, -0.13277144456247028, -0.24935993786741217, -0.48449967797513477, -0.09625429986794301, -0.3682759519492857, 0.2061238237743243, -0.2166951768954896, -0.27986269674736397, -0.15309375845277898, -0.08382156877201631, -0.47509832345523983, -0.3748137707806663, -0.0581021166794453, 0.08546839220101725, -0.3469836298846958, -0.26704250224167203, -0.02689489674293666, -0.41331956170383094, -0.23996659506578558, -0.09885320247534304, -0.356900313631476, -0.0072105197711009655, -0.1835129412182482, -0.35631873046553403, -0.12311217891819665, -0.49459733281486307, 0.10326353171591364, -0.1599363633979943, -0.23509771102802127},
    {-0.6566067626580756, -0.5000775293047436, -0.5447106989189827, -0.4851179626000765, -0.040344714130589876, -0.4862745912803631, -0.3744033690413677, 0.17191348293713204, -0.28551571079379046, -0.4405182928202073, -0.14349700529021153, -0.07459657001614814, -0.5070181655587873, -0.44050406834076367, -0.4713817527934105, -0.0924842963068183, -0.3880892049009677, -0.23881528995575013, -0.4664601524114117, -0.18910929491432016, -0.19819490647177093, -0.40110109815649875, 0.5344946061538167, -0.4688633877539899, -0.07702996097776342, 0.016866468831636967, -0.34847725460881007, -0.3128631933710097, -0.1878361514491545, -0.47721904364819523, -0.5422147458446145, -0.3419400500969647, -0.13512244428766954, -0.5405898366216091, 0.12695776114178503, -0.0008219325160071191, -0.6278005570189333, -0.4511224238323105, -0.0029925674946149135, -0.17642057693676771, 0.045594629417007614, -0.41191760517599846, -0.3182057086703992, -0.20352174786288016, -0.32565773431084905, -0.41138429907705726, -0.2949705453748104, 0.1121252052159651, -0.1469818074511129, -0.5513333081671347, -0.2016638153756598, -0.2891731273722613, -0.42078986710922006, -0.38955172225921575, 0.15958950905188427, -0.7007859002947779, 0.0071362825667075315, -0.14278106028535031, -0.30772670565569193, -0.2875775466055199, -0.580560539343405, 0.3002996693566531, -0.2602015963101772, -0.4103992433534344},
    {-0.4384282008231681, -0.29157908130016924, -0.25328492902329813, -0.5580934689724001, -0.43086437232644975, -0.11801362285248251, -0.14729430270334415, 0.011528237021497112, -0.32400079226604295, -0.2683585958618285, -0.44187041777789554, 0.12653501724322297, -0.18577925445963023, -0.5783466442705941, -0.10745762631906305, 0.257404032985224, -0.1024030699731723, -0.18892225047754144, -0.6023480761388518, -0.07085878619764034, -0.19274421354120336, -0.27130476771275325, 0.15977329588619346, -0.45557713925588667, 0.1442327205518592, -0.3353616375383613, -0.3201649719773852, -0.4966494349236134, -0.33717753295084385, -0.513671346159896, -0.20726326434058387, -0.19485176537399998, 0.024032469964660946, -0.589501432099176, -0.026806322360548137, -0.13952858748935063, -0.17283763715457534, -0.459698353411433, -0.03025837885443528, -0.11471964191502752, 0.2796091217316396, -0.13170995238158778, 0.048853749290185544, -0.2016215952751599, 0.1583824623539357, -0.5142418155773463, -0.06547922975809628, -0.37444616591805097, -0.2380404348457357, -0.4605187692827776, -0.44171704219885455, -0.20262855030964705, -0.5175401419555896, -0.2816254213575221, 0.04092445060008647, -0.07123018043184917, -0.016466713130842876, -0.17742362011259305, -0.3355528290976538, -0.20898553782586998, -0.7579459564486213, 0.02695657815342308, -0.18386525178712532, -0.19280094395779063},
    {-0.1324287913825819, -0.32982915319593276, -0.6866718568841708, -0.4328197820007902, -0.267674012352038, -0.3978893068120582, -0.255595163157551, -0.15035161252854667, -0.2289172314787687, -0.5713541503970997, -0.6816416141562425, 0.08211014291664663, -0.43935588975284773, -0.34035994817242493, -0.4576026674599354, 0.35742630278686727, -0.45023456048056093, -0.4247501252561704, -0.22656765305309587, -0.2242325937384469, -0.24077546170107528, -0.3521312955309246, -0.23110492484903844, -0.17132391008303036, -0.09540613878668548, -0.314675999607781, -0.3342058976709533, -0.5045376277121878, -0.6000060020260478, -0.7212387119002279, -0.6340342914201207, -0.21823842997689874, 0.20745241732232741, -0.5092477081541219, -0.02372449342214268, -0.21496188868478733, -0.2768065104228639, -0.6036948742566277, 0.1919540872420597, -0.36628229811289154, 0.03626169621237588, -0.12430056015537348, 0.11311939782164106, 0.06906704396782468, 0.11922047935238238, -0.4195434825373853, -0.39041413076607184, 0.30886564912307707, -0.17774028059355498, -0.36561424579027546, -0.16938148177421467, -0.021122256194296772, -0.27899255588081046, -0.20322987131256356, -0.092641238865712, -0.5435215265970469, -0.43758492691818734, -0.32691262170167645, -0.4050335712431154, -0.5507784675313845, -0.7543825904386536, 0.09461599096066978, -0.6614060057989977, -0.003260304582331135},
    {-0.502424695130037, -0.5661574330599604, -0.2546372877732536, -0.3127501747971747, -0.4332023959355619, -0.047915251474543716, -0.07093800448690776, -0.3343268785441488, -0.26890081594341353, -0.29595011877602645, -0.3650636918323733, 0.060633031751592216, -0.40095494492909883, -0.6088265751587454, -0.5382898915037103, -0.039443272721426254, -0.21537044542282777, -0.36023502031250193, -0.2749453153832636, -0.1684110437424617, -0.10687582147375496, 0.12489060235943553, 0.10850492213281238, -0.5227825404033022, 0.20356319373585288, 0.0031200206040766006, -0.32650040834760485, -0.3682920469363485, -0.5556857804709269, -0.43330579886819537, -0.49904656811585346, -0.29864513404863535, 0.23047283064580817, -0.3260573026445131, 0.6031578293889894, -0.6247911812732061, -0.3399471737431568, -0.3263381570016676, -0.109978867342624, -0.01674534569824062, 0.21385450470491907, -0.41359580954372394, 0.29728988619226443, -0.2979734976822625, 0.36155153658674294, -0.2804953761556989, -0.29366255266690056, 0.23829999015850115, -0.1824106956267314, -0.10126509898074172, -0.2766197461189536, -0.22113639494758683, -0.3603556996885083, -0.44391305351562166, 0.0011794384025282873, -0.5479600199900618, 0.07573963657632576, -0.6416407257533772, -0.5734597350637305, -0.30095944978128863, -0.43148799044183644, 0.292110040554419, -0.2707942290607676, 0.3383632164535389},
    {-0.45198666152212696, -0.7078669365376267, -0.003579522329848881, -0.015005421614485709, -0.1347384102317117, -0.0011207866669975738, -0.1249377658512329, -0.2147550282403429, -0.25758905909074964, -0.20769386383910576, -0.20710648628631587, -0.21551607796626004, -0.37715090019963504, 0.06643286188759324, -0.3519518712984712, -0.1480544335360559, -0.09430022968948264, 0.1110224025313271, -0.2910623904376015, 0.10424415564112151, -0.38643523362766424, -0.22234002912459727, -0.005528222156463133, -0.5416202083904795, -0.21392167238736626, -0.49563840778859003, -0.18072480361455595, -0.2905374729909823, -0.2139675264547507, -0.11091338080177886, 0.022565396077506843, -0.4445911001400768, -0.054384619387091875, -0.3984409209890354, 0.19647214476387517, -0.3110787628771353, -0.04197372383342196, -0.4325880690858289, 0.0630903247033607, -0.11283868251949, 0.15675465015154535, -0.22852824591619228, -0.08638046865943448, -0.035193680052703645, -0.09465684938712, -0.18335158131870932, -0.125919069322136, -0.12531244635100547, 0.14976867754490994, -0.15986928906368847, -0.14438816378428374, -0.5168365111351535, -0.3114966675277011, -0.11362201624318917, -0.40340584000026075, -0.38998494184623256, -0.2184464396844614, -0.15417769258471467, -0.21452085492356032, -0.521250298121499, -0.18253989888146158, 0.17882186603270955, 0.06218136931322251, 0.3478964692866193},
    {-0.35408930552261614, -0.5254172654883548, -0.22327080381244102, -0.35905488795923696, -0.3911053655732767, -0.4358691496805389, -0.45564881438850163, 0.11664620851001377, -0.3608679878309551, -0.477065860432232, -0.44769632095390555, -0.006782326829217621, -0.3050489453459631, -0.4185314928058894, -0.45005080752350907, 0.004509251199184829, -0.40520385201070885, -0.3239622839797111, -0.2547167744599903, -0.3210291624576353, -0.19166757381183722, -0.19178919617495344, 0.17996905273105127, -0.3481491610284481, 0.21428298568238352, -0.09333012947190834, -0.3684666954705428, -0.6431080591199996, -0.1536464754464466, -0.3475406773722714, -0.44271308981212965, -0.4692094084848724, -0.11682382650973973, -0.8684330025434465, 0.21965233850573138, -0.3834854262916359, -0.17323078457941776, -0.4010437137870299, -0.2204182051265264, -0.37611484715078414, 0.37230360670170276, -0.23467951744866064, 0.012867331022166768, -0.25975492379593146, 0.07733450980691513, -0.39972376071141974, -0.2639850520765413, -0.13669433886928278, -0.02243741975482262, -0.49470157415049026, 0.013354850625825575, -0.39284707061397484, -0.4684932496857165, -0.47109396843781315, -0.34854912913297725, -0.19131929370502826, -0.157950191023229, -0.4063144406559035, -0.2795321979912365, -0.5955692736575567, -0.659110671930474, 0.31047369355065224, -0.23510475159914393, 0.13542395881193026},
    {-0.6758347448855057, -0.428597549088197, -0.17410966556510832, -0.1867407094181691, -0.3723650818421829, -0.5591278581229144, -0.43221043060096653, 0.3035002785351801, -0.07397524357104807, -0.40865775063949905, -0.4056608221617663, 0.08188134111696528, -0.025796214297529957, -0.5359200953826017, -0.15580849342325975, 0.013445922790957996, -0.05775927385652352, -0.18875606416721508, -0.3595444860981703, -0.20509434448860325, -0.2029300240395017, -0.15846983266760356, 0.10701342849643944, -0.2896059449226109, 0.08748982652098883, 0.06682676928753555, -0.3985396451758695, -0.2964576470278074, -0.34656854118911967, -0.5262524506552472, -0.3059140662594468, -0.3629957773021444, -0.0897039789177804, -0.7015004379411574, 0.23713391134681475, -0.2358407403920825, -0.30753350225220416, -0.38741456322863915, -0.049809996758780464, -0.5538592887454226, 0.37411378330761635, -0.22701113161386902, -0.23319380048095892, -0.45141239131036387, 0.14665982079150314, -0.5163715284437401, -0.18990227409298524, -0.06820956251310309, -0.03605211122575157, -0.4332173341965186, -0.20307384808927473, -0.5298986055747505, -0.28424435458050423, -0.24318302137333245, -0.19721251082306304, -0.3763780798186618, -0.31039035449963764, -0.38505849174485673, -0.4465118886770716, -0.28535334245497107, -0.29491764682225075, 0.37761064223353463, -0.6057359655629153, 0.19397068358391364},
    {-0.3383768348845988, -0.4785540285710642, -0.008612671017094176, -0.5916193610757544, -0.5138006738408545, -0.24779933723927003, -0.37286695016603777, 0.22669078131769468, -0.09258795585852041, -0.3944876343545625, -0.5151091556738794, -0.18390046310775007, -0.4599957443274133, -0.648607103700599, -0.15916317626529433, 0.34193856021624786, -0.055803742360728374, -0.5599344542509561, -0.42977076062480196, -0.22254094342682154, -0.2926953356804919, -0.3430500144657129, 0.01746996573423159, -0.48064232351565167, 0.2514841251985668, -0.1906530540658782, -0.26295521829367796, -0.6408131343743825, -0.1324980442556517, -0.8039407604596318, -0.33817363823032465, -0.5554880889979344, -0.24309613552586143, -0.5616734496353731, 0.02388293483090338, -0.3239385840465707, -0.2263666432617958, -0.6150695208192241, -0.1832638834725431, -0.26575893036803466, 0.3443620977361177, -0.1631362341274382, -0.04415695724120342, -0.08798050267336426, -0.0014377409053785142, -0.4518657962982559, -0.5264349018705992, 0.07174341019681206, -0.4786332862039409, -0.4583241076155636, -0.26798844908700914, -0.537902253153869, -0.24555664500043675, -0.02023564132958505, 0.09757708955501487, -0.4475015942819876, 0.017323120361208838, -0.2780044188776066, -0.9219141301067938, -0.20502704206200012, -0.4209849044521671, -0.03185474795013932, -0.21223317630573763, 0.17100808751691585},
    {-0.3576204808805686, -0.7020631088052279, -0.025953186468943724, -0.45216498486085777, -0.4778602869839582, -0.2829606794151449, -0.41207644473485533, 0.18989344711700099, -0.14233332303398372, -0.37818728859649153, -0.45618457313591576, -0.2964725331461648, -0.35160954390376276, -0.6479233581577055, -0.4264941061535753, 0.055256040124425435, -0.25660379780907655, -0.2624315538917287, -0.46024246787353107, -0.40952260379788713, -0.15077512577945665, -0.30177867775044165, 0.4034731869871644, -0.5359601137953994, 0.18321721720515, -0.15390799624253548, -0.5251197272608286, -0.6926131553260948, -0.31606276169089664, -0.9487317450161804, -0.35636342843288055, -0.4317666258372411, -0.16116501061049054, -0.5629902275832082, -0.0004380496292782103, -0.31922686719340304, 0.06001961051439313, -0.5558230989800518, -0.12899645188562306, -0.4367994636490251, 0.34723002054636487, -0.2524369141452371, 0.07883497933631335, -0.27851649235952874, 0.46857561466769376, -0.7299050805079424, -0.3507897278340994, -0.12951021369332352, -0.1418084510975336, -0.26566697394508765, -0.31400705821716685, -0.4166238048566335, -0.46739740725845663, -0.5028319868747523, -0.041111330044382645, -0.44023595629675316, -0.421853269572618, -0.427762242985353, -0.4924312788889164, -0.6002392774965358, -0.4534877070546143, -0.04504692809404549, -0.3631627363571115, 0.3681700547922033},
    {-0.36290283907498744, -0.5084691509363344, -0.3379216434400595, -0.39601664320058755, -0.2557434939922805, -0.18598016690625546, -0.3226386589779787, 0.17638125724833864, 0.06269523982237318, -0.25361122604494385, -0.3870889465613047, -0.4750734394336035, -0.19689141553965167, -0.48840679107884505, -0.2350914357328886, -0.08288337738936812, -0.2756077360265103, -0.3844181423525243, -0.18341742982975154, -0.2869513914901943, -0.309756625336893, -0.06272462498242096, 0.4588654935656085, -0.5546313048651562, 0.11764558994597449, -0.591512301071322, -0.34402787487929204, -0.6537918891214577, -0.5709389123932339, -0.6346027524558052, -0.4864665603455206, -0.4190063290906724, 0.2730984081887015, -0.38536734607005024, 0.08130809992150302, -0.35600101549038277, -0.47527897255093265, -0.31098469137042123, -0.1859509886389038, -0.24284306656821375, 0.3265889379395197, -0.22391732213640525, 0.2622103701014244, -0.15954897810572136, 0.21626092156839533, -0.6255552354822935, -0.28188185133525223, -0.31770263282246847, -0.32123052522848866, -0.362261817661688, -0.3752773652630607, -0.40377726409461706, -0.646186795626147, -0.39958175488189, -0.3312126071145809, -0.7793454165529237, -0.23005998882507575, -0.3208627399860024, -0.23327842012357314, -0.16464992822707386, -0.3759642244895524, 0.17816319078545304, -0.3316903241418594, 0.2780513391864369},
    {-0.3867012571888221, -0.4981332221267118, -0.35384443978856206, -0.42556593430336886, -0.5270112651056537, 0.13109055033588263, -0.23746617668886363, 0.24901979155855436, -0.14330517145029148, -0.6662905864914197, -0.7005074969251027, -0.14322299976679811, -0.5358960459860594, -0.5415608441969771, -0.15949302797887263, -0.1422370471092053, 0.04878149833540234, -0.08092019431665587, -0.20796066582216183, -0.4138230412404983, -0.5587158317033702, -0.49407416109654095, 0.33414877017405725, -0.5390770495486585, -0.17608905024535323, -0.16355041270871862, -0.26606261891646715, -0.6270644956956508, -0.5031093862089234, -0.43515634733010833, -0.5266927750269024, -0.6228092599440505, -0.08429207194749679, -0.4159798817686315, 0.48005126582388713, -0.06183886022162994, -0.4844649143137226, -0.3995880103731823, -0.19697131543401047, -0.3928448269150916, 0.17820002992118783, -0.5031356250690975, -0.15826594557767693, -0.3711652578099068, 0.07857706333214172, -0.2904814003790557, -0.013070728741965357, -0.07361266730037111, -0.5503304132297475, -0.39460152645409985, -0.6757484998173172, -0.39827815938320554, -0.23255772421666432, -0.24698043029066444, -0.2978676619144727, -0.2994218957531578, -0.45891058925262096, -0.4797958908747681, -0.5830846322771173, -0.29541778371784205, -0.31333944447587936, 0.012909723817797406, -0.6705562357760654, 0.06177400158393722},
    {-0.3472992636332523, -0.5400151877498883, -0.21604837066832427, -0.4127806518974687, -0.2729894010750481, 0.25089960685668344, -0.08499121976851762, 0.1832857126712635, -0.02522244348173566, -0.5724905910429705, -0.4721221487325416, -0.13437545099224635, -0.4645269521905724, -0.6660424723994023, -0.08277173712606847, 0.0046526799869505185, 0.11648193067435908, -0.2713621595695473, -0.285338714462596, -0.251096445903605, -0.17670230443497573, -0.11126426349611143, 0.4970544606810027, -0.5593510186965421, 0.19414392020345161, -0.3954462716803604, -0.40315256672439537, -0.4922327135560238, -0.5361641379401277, -0.4691096106089668, -0.46839172520956146, -0.3725851923709424, -0.003520207883811931, -0.01716450882251819, 0.47408919186339316, -0.3365445572567267, -0.46298993741283456, -0.3724900461146137, -0.34927160520165484, -0.01474347208107296, 0.02784232212345023, -0.17972523584316963, 0.15991722025271582, -0.0388432626931831, 0.31768781211625974, -0.4574944093994576, 0.22116910940150397, -0.2827271180142552, -0.38718297602794066, -0.38884737409593745, -0.6390758274846505, -0.6244919893357667, -0.4698168758962145, -0.4915422097152668, -0.2687271490072568, -0.43729328479974244, -0.41208316152755786, -0.23431148035816526, -0.7017728945245912, -0.5365883613996677, -0.6676172642707174, 0.3198632475081768, -0.10638441777572206, -0.1399159608409143},
    {-0.34551580428022827, -0.3480633565199913, -0.16762312785383185, -0.29515606100001024, -0.23550515581232204, 0.28636825009092703, -0.15686750557835383, -0.12064490614992615, -0.17132052226478217, -0.18963182715351243, -0.23895957227594045, -0.14360364417925206, -0.33899980690446424, -0.39603403555236655, -0.0917575962743511, -0.10720103389754042, 0.05880635786990678, -0.24014096554785694, 0.03827479289928313, 0.06188596644930182, -0.19658450460845858, 0.055007061143143306, 0.28849195959265517, -0.6479103845253272, 0.37202070917618146, -0.3527311324094275, 0.030221029971021662, -0.7092280961769963, -0.42385356522906564, -0.6615065822043928, -0.400265529405022, -0.4361056375316219, 0.0496466175478902, -0.5561384597885665, -0.002974736679395799, -0.46260923067692544, -0.6071376574238336, -0.2934333929862456, -0.3449397469580229, -0.43226750320507795, 0.2278397802333149, -0.25246370467833423, 0.013286271265506432, 0.07644825098376253, 0.147246423640807, -0.2987158853766308, 0.13447995776024485, -0.17907705481059177, -0.09031389965704376, -0.5626059890000974, -0.002680705196710769, -0.44494954639870293, -0.44831499375222666, -0.06276747950085171, -0.3442313506740173, -0.2627007220182343, -0.5510519888889459, 0.12730495198850847, -0.6417407891628267, -0.5463626372202333, -0.6110476193154187, 0.3189096206168081, 0.0545666108015915, -0.11541587066569199},
    {-0.4394229022538771, -0.3983399328259776, -0.11776035484888529, -0.48325013799902816, -0.24288852472480854, -0.19589826800752622, -0.13422426890270708, 0.08895979332208523, -0.1934447605435423, -0.36761999992333483, -0.6860683288248509, -0.3051725053207691, -0.3103028225874227, -0.33489323137589533, -0.4263450082908806, -0.42121567352358974, -0.0030984854000288406, -0.2253566642249851, -0.029317211216356703, -0.2834410111710107, -0.606003368907983, -0.31176082508539626, 0.5468971658818368, -0.48692072395847735, 0.11583407402603005, -0.3021979744685624, -0.3070572118185176, -0.7231823566319318, -0.5917219542441939, -0.6966754833619013, -0.36107477791454023, -0.3115525742599457, -0.41110987052380166, -0.42846920198032573, 0.2001733151148557, -0.1430326129790883, -0.3030684798104365, -0.3716376783653344, -0.4260624303138264, -0.24031264354875115, 0.590006981256625, -0.005162642122621821, -0.15380182589789135, 0.054150857176440345, -0.05547666750030367, -0.596708139246189, -0.0606043819951029, 0.11458368753600896, 0.12700804744764235, -0.5729766588332196, -0.3128877108821058, -0.6833481821629234, -0.706715142032934, -0.1138797075186445, -0.3258600182840113, -0.6723234823038041, -0.19948175222724276, -0.19389980906504065, -0.4453989792230462, -0.42582858942778756, -0.6335704482088282, 0.08004959864041675, -0.2736652978699899, -0.24923157446499883},
    {-0.5514568484355348, -0.6187845780045471, -0.1526015710258458, -0.21601955936876574, -0.141914291551421, 0.029089568737667805, -0.15716199090226748, 0.4848948493071885, -0.09023743847658114, -0.3204336048069993, -0.4588251003337737, -0.1514961180145679, -0.36487350242176525, -0.46606838226656594, -0.027138026980877278, -0.4077057770507168, -0.16365699055155739, -0.33200838242292025, -0.14358876561152722, -0.3214331659974677, -0.40195248151796864, 0.20851741141636382, 0.24899081461288794, -0.6765285748193456, 0.331422726742447, -0.2794515879991712, -0.4895459434848153, -0.7331078417936389, -0.5545967395214505, -0.4444527800396588, -0.3357789223561969, -0.42437823388557144, -0.181639083525769, -0.5779943051644738, 0.5518223855113131, -0.219930056752116, -0.23558327439741736, -0.6758370319253847, -0.2961181990343848, -0.4549833436475562, 0.6241604880057762, 0.09501945001402202, 0.1189985823963934, -0.24222661461705988, -0.21209647384530073, -0.5397640687598642, -0.11928690185221187, 0.05736625885741067, 0.056988559655646344, -0.4691499605065711, -0.5781673589586085, -0.5407022945168568, -0.604875859749325, -0.19768133281965772, -0.32661100863696724, -0.336240089942959, -0.29545303049336125, -0.3786125378589307, -0.6202365657031917, -0.7310972632696623, -0.5308905929025317, 0.4819537386529007, -0.24859802290525948, -0.24006489574297976},
    {-0.7623076137373807, -0.45358481550375923, 0.024835027243562822, -0.5295942992575322, -0.1765380951854584, -0.10698306251109563, 0.027949480709828518, 0.4487492120348932, -0.2387155588729479, -0.34460514660906305, -0.4361158500694277, -0.3119291458856185, -0.4721317493653022, -0.504923197446822, -0.30305251114633897, 0.32919382550070886, 0.04425911710878887, -0.46211946518178443, -0.42341295258159894, -0.45382891437573486, -0.22263832367746045, 0.38304923453556633, 0.466810332165321, -0.5269732095521216, 0.4192086317750474, -0.6371200060870298, -0.4850414192820355, -0.6113530046847001, -0.2242804304846984, -0.6503204716068025, -0.09001394976203524, -0.6012785091054345, -0.13465503421767405, -0.583394656956394, 0.20924027153676963, -0.12386019272041933, -0.20026887607381136, -0.8048160176119815, -0.6548743761652597, -0.6285344986567214, 0.5018517665167898, -0.1225552147498944, 0.3731196568467359, -0.10266989070041588, 0.5597823740831707, -0.3814412227241194, 0.10799184330846466, -0.15407435613138196, -0.017277249920062847, -0.368440804144523, -0.4393632263757473, -0.4321914572215153, -0.34452254847153063, -0.07013206640040366, 0.03138016711463146, -0.5760999139189379, -0.4959902914634612, 0.022794828803875344, -0.6035647440825069, -0.39480057558870035, -0.7577203578633198, 0.6156901410876487, -0.309862442448587, 0.09747898269467326},
    {-0.5280132529612916, -0.1748943184822065, 0.1765153430475451, 0.10949727332430519, -0.0384131937828343, 0.5241521697283199, 0.32974093094483803, 0.5638304408249447, 0.0761738462095391, -0.2807705543884102, -0.285453084499617, -0.5414271217571405, -0.4519314798763803, -0.5025189515346263, -0.38778585675730987, 0.3078143027744326, 0.2594624368350414, -0.0628930575240694, -0.034478064624347826, -0.04384752866520265, 0.040998610601027476, -0.1360647752688378, 0.7640928489320457, -0.7240662988638656, 0.6829667957624839, -0.49282537752124367, -0.15075497622421144, -0.2876509744500603, -0.29803829747081134, -0.6787160310633834, -0.37345830496534876, -0.582766200069715, -0.10198135317383449, -0.6779992957690044, 0.40232075342406104, -0.2382766665095413, 0.3577245174343989, -0.5031146639296589, -0.4187077069172977, -0.5465418419071387, 0.5756482686273414, 0.01986141665992971, 0.4681987397510826, 0.11099045017487146, 0.5546673626292646, -0.4393950990932212, 0.2272701778232115, 0.05268177811534019, 0.2827995955194938, -0.36030312161726397, -0.24539358638905628, -0.27052549832851663, -0.39373596636001185, -0.2882089596555574, -0.49931344541856143, -0.1059554187831347, -0.7897771567911506, -0.08336652487693827, -0.8248675901274644, -0.2811829306103812, -0.3115631779189868, 0.4436856242259639, 0.1809423478899228, 0.2931674355171234},
    {-0.5365232466484837, -0.360416692256606, -0.000552500332437106, -0.15246171244101048, -0.23263446889112313, 0.14396766003008474, 0.1115730734853394, 0.05647103760363066, -0.2124091469495988, -0.5502799460136354, -0.34248491426745226, -0.23549368190823988, -0.3477526953481246, -0.4629634402043849, -0.236424792536522, 0.18779349544060084, 0.2164254502013665, -0.29996203812683764, -0.09976724666135862, 0.03733728711168374, 0.10992016165439185, 0.1046147452323924, 0.38744261118109796, -0.7390115190767811, 0.48268458899093886, -0.5331377048690578, -0.1428585188904259, -0.6423866056755386, -0.5236823407364148, -0.5888596431748472, -0.42231646713404813, -0.35625570689837344, -0.33291842628403073, -0.5776917997773738, 0.12594240212724062, -0.16290532571077987, -0.06459475174030095, -0.6868947444023055, -0.5253837521929451, -0.48968372489030954, 0.1711374944980591, -0.03544867483475581, 0.12876915763803717, 0.2821644656775904, 0.3670025281037956, -0.5724723632795035, 0.07358446714076886, -0.23147172409701317, 0.005405853459428292, -0.46508891751748377, -0.02945193331641934, -0.710658213199768, -0.7258076638334269, 0.04991976985628642, -0.519632040729813, -0.4154111867443832, -0.3703040280397182, -0.41827702791176286, -0.46291640090472264, -0.3182861312927775, -0.49749631691429586, 0.2833218306548601, -0.001110040334962388, 0.14761867293601869},
    {-0.4852805984173628, -0.48963529948250245, 0.03831147886430192, -0.20377856100408487, -0.19550608355706195, 0.21685454985392508, -0.1460129291387931, 0.16058238603897684, -0.11796040845530373, -0.5602334007110629, -0.28814338000993844, -0.12613211210435596, -0.5326760663031005, -0.6342515349515689, -0.24351045614108027, -0.07410624146544396, -0.007479627307860082, -0.5613570319256578, -0.43703168984654894, -0.04954898899381795, -0.11591882147900102, 0.07660674073587959, 0.4879398352536851, -0.7316277790864071, 0.22239331300225654, -0.5741888605773313, -0.3959833653141602, -0.6690994972023016, -0.4756744135663637, -0.7167164241162519, -0.5457632382017739, -0.34188213775799076, -0.20198283331555777, -0.7545211668120654, 0.20547172792542848, -0.3027619897742636, -0.39835389907638424, -0.6452374661661404, -0.367518440646444, -0.8765360205302922, 0.5006157341813439, -0.35220333211680016, -0.12205321344616969, -0.03649534318229961, 0.045868031004654516, -0.62340313436204, -0.15836026294711436, -0.24445880526008273, -0.3025756621517633, -0.4825387815611423, -0.3269049660876304, -0.7675891731729455, -0.33908500034643274, -0.5135378498890636, -0.5724847272389679, -0.2741488970855667, -0.7176850498691338, -0.3835879836176107, -0.6813591526038345, -0.5851184951204573, -0.7671507300642284, 0.15819902961113694, -0.24210012829696242, -0.08778653268912431},
    {-0.5425040345699692, -0.5539312447338867, -0.1960930635286677, -0.12366266505001805, -0.3183577962327337, 0.22959929891741857, 0.02187441057762929, 0.10601744928250344, -0.20604503476171518, -0.32955496873047313, -0.4612451682913451, -0.47624303350751396, -0.46596451229611263, -0.4515938091765391, -0.305513905177109, -0.048341264544516774, 0.1506615641326728, 0.16606782319519264, -0.28207837372578054, -0.22788896119508043, -0.21694631637937184, -0.2535653097737788, 0.8384985643793399, -0.49997653661533825, 0.3069084396488741, -0.6643659665791248, -0.20877823416500052, -0.5010347938083068, -0.44399442976865366, -0.5785447860594014, -0.45577756767842886, -0.6862199657338811, -0.5550193598760914, -0.6911779370793578, 0.3673591982328227, -0.22032767603436124, 0.23785776072442263, -0.5529795837434105, -0.5310051234797278, -0.6235777152234924, 0.40302291010973657, 0.28630935802445934, 0.24011053910696076, 0.09999897664091316, 0.29159294167720834, -0.4333457612094583, 0.30885947693527543, -0.34375846019721173, -0.12936587701154678, -0.3312901125029027, -0.5248253199676163, -0.39799435073306405, -0.3559971853424616, -0.2996724571682311, -0.8225670607550342, -0.45338275289125735, -0.6489841349947653, -0.233201532546497, -0.4786733801690415, -0.5644594824470949, -0.6224268415391384, 0.6612065814879612, -0.13172766820023588, 0.35695905080275914},
    {-0.5526150165537036, -0.6639002899689528, -0.045858398823280126, -0.25204153017491765, -0.20045587636441578, 0.37593991720072784, -0.23629738553558144, 0.0951384077493884, -0.4015739363477021, -0.19656141928385798, -0.31490825854071625, -0.42420279247419224, -0.43819718257595747, -0.458740166600958, -0.34138995636775227, -0.03414766885168557, 0.5105371721392414, -0.23187680028723312, -0.35711827633854004, -0.0840929075070129, -0.13916170230189664, 0.16056437634297963, 0.674458585321406, -0.4958674661078033, 0.6594111653923087, -0.37498056589742584, -0.1698146469092143, -0.46637623641488285, -0.5366945970502492, -0.3406802442641792, -0.3194378594360367, -0.6448978589589226, -0.15510823658700484, -0.4652562259166582, 0.6258664396246567, -0.2968839974035664, -0.11674534661631243, -0.6563030928480296, -0.5916977959391023, -0.6328004567074034, 0.6261734072592575, -0.18997674323519637, 0.20612117133995747, 0.08962806768056983, 0.4849043078477984, -0.6501388198977239, 0.04175733314448465, -0.37657390990985695, 0.2577061280819314, -0.3288146915598157, -0.3695459562168501, -0.4939387351644541, -0.4895934530148705, -0.3359284296778595, -0.6043747471939339, -0.45568049948144274, -0.6756452950738097, -0.24677773976444517, -0.4061076191413141, -0.5128832120438968, -0.4440378438701355, 0.5228652540087453, 0.030630102652595335, 0.15449345935248937},
    {-0.5205420613980533, -0.7052628160968979, -0.19628083153713963, -0.3408698540606708, -0.4035953567412366, 0.25308465059788604, -0.09856285789322702, 0.35614124123257007, -0.3124783341072694, -0.4788408856769594, -0.2794901815376384, -0.5350492149700288, -0.7154385877669596, -0.6714120559033198, -0.20365944257404467, 0.008520044066775244, 0.1794596545212799, -0.22219266958250208, -0.23837492020710477, -0.08393154734164748, -0.3096815670537498, -0.27556406274087125, 0.6893808933763819, -0.3025764300235173, 0.5074987515611087, -0.5109756494449381, -0.3173277443186598, -0.7024562109961712, -0.3274228100901778, -0.8409948315656748, -0.4245748299003107, -0.5539160028273654, -0.418044858191199, -0.5944711778830065, 0.5090240894198537, -0.5103060101790462, -0.1976680550410739, -0.6075886165200618, -0.2255788035322411, -0.8844008551806218, 0.4766932890132705, -0.011036389821806927, 0.24345243009482692, 0.3683164870566903, -0.11050506031652116, -0.43915408682999435, -0.1649576518108839, -0.351400066369054, 0.057225033001176755, -0.4056989552972807, -0.19731203112411008, -0.34329735982048715, -0.2639006076200627, -0.21812888171372724, -0.4884617609128752, -0.4970724539585776, -0.6069531534336847, -0.41833578390224874, -0.7108847593428431, -0.5832197065381627, -0.3829507335169415, 0.5149426291502508, 0.14807580064056913, 0.11011723038084742},
    {-0.41142389879692165, -0.6983527172490247, 0.2619806538043693, -0.4084142536342622, -0.287331465734631, 0.44500741564227025, -0.15451199075631222, 0.18333368667588834, 0.07800116690705783, -0.4011881595747818, -0.39736268091216204, -0.44511675649953897, -0.5887581771413429, -0.8121889005892142, -0.20109066291839625, -0.11287955287439869, 0.2131650649867307, -0.22167815197285776, -0.42961349854695924, -0.05811229144281782, 0.055205656553901826, -0.19499432696299326, 0.5909073636611901, -0.6476368462604046, 0.48369541637087693, -0.4665362836798117, -0.26029115448211415, -0.5829741086233415, -0.4630013636436386, -0.5968428172815645, -0.24953219981733893, -0.34524076622798905, -0.3191158459782292, -0.5830736033722126, 0.354972783293098, -0.36355540138986064, -0.016856239472106568, -0.7422982789528662, -0.8028122551429332, -0.6564368140167377, 0.39903291180542555, -0.14840197759225932, 0.12809517321572805, 0.3812179734548308, 0.37377720247418234, -0.793931737668717, 0.1622080286474633, -0.0952901238663841, 0.2549831890843667, -0.6780324486640507, -0.20977713333829728, -0.6968013705946869, -0.6295353105566124, -0.1720140213141761, -0.4746785045757172, -0.0891171438298378, -0.7062318355869674, -0.7102095393770459, -0.6481700551729158, -0.584174004874772, -0.3670116086390335, 0.5170490314406452, 0.23617662301375691, 0.17991841890932156},
    {-0.527443596598733, -0.3306213233804028, 0.005294254947644655, -0.5371797100258898, -0.3348102040907314, 0.360805495058379, 0.12662723193724187, 0.5307766030950412, -0.0488179465329097, -0.11767178277489532, -0.26608045895588955, -0.48038965819852125, -0.4454464814137463, -0.6621371504850119, -0.0999139070174507, 0.051322771698165584, 0.35378308258716595, 0.027469695594514797, -0.43671608294510145, -0.138571141491134, 0.18617002484463055, -0.010368563802259445, 0.49548841811449873, -0.6457563008147714, 0.5127447970164466, -0.5816910374183422, -0.2522576193404215, -0.6333789990116967, -0.24621587317492064, -0.6297016581864218, -0.6880092682425754, -0.6489947199541901, -0.3835634903758757, -0.7452795781605643, 0.209503743483385, -0.10180813595656285, -0.0009037583681421363, -0.5912475573167121, -0.7448935287439724, -0.4861810263550857, 0.4783631014829284, 0.176771313624775, 0.15800390766911054, 0.2665341239111157, 0.2854481824289891, -0.37954405824925674, 0.05102073501766778, -0.3082564109593614, 0.23430321845758345, -0.5647582939836444, -0.3088548429646278, -0.627269150777002, -0.4420938519359645, -0.3726850115541437, -0.49327237919272005, -0.40213499442049044, -0.7561451418435917, -0.37858633977443473, -0.5995008104100807, -0.7341003782875117, -0.38157816717338766, 0.4562798551221709, 0.18947836299537235, -0.02964985525025182}
};

static const float b1[64] = {0.7812420446705336, 0.769325208235146, 0.7521254998432715, 0.6794967537184693, 0.6862835545796024, 0.7962694368758139, 0.7350463328079031, 0.8536935215531918, 0.667554457388556, 0.7896859511721257, 0.7545411197989231, 0.8511438723208213, 0.7479085203927289, 0.7721290761892547, 0.6661563797130124, 0.725133616500259, 0.7268906579215572, 0.773907990306447, 0.7422999578646521, 0.7631173588291821, 0.7433267044574742, 0.8609404621186958, 0.9201436644835104, 0.7144431585508616, 0.8128209414841964, 0.8264070710624174, 0.6013642288521699, 0.7879806596563262, 0.6804769882777666, 0.77080044401685, 0.7181110732901282, 0.7896983615743489, 0.8239818525898562, 0.7547596937730812, 0.6504639144532898, 0.529094152412306, 0.7313349002738769, 0.7769625354911885, 0.8412271564714667, 0.7607373360671973, 0.8357140246617444, 0.7366953622885408, 0.8271865553551088, 0.7315923170812576, 0.8884070558232694, 0.7474212041431547, 0.7547498160255307, 0.845735957349302, 0.7885976116195148, 0.6544028401060386, 0.7482470305999446, 0.7834561066283684, 0.7698603776789732, 0.7361121253250347, 0.8343186598818404, 0.7627582304968066, 0.8368328514524243, 0.7754594635615675, 0.7718217495324294, 0.652940418521547, 0.7683607141174409, 0.8785135549249271, 0.7180010557000001, 0.7937877216659948};

static const float w2[64][32] = {
    {0.8327857906130525, 0.657735108709498, 0.20958737589063892, 0.47482499245041326, 0.9215444375663889, 0.7311375141399028, 0.4225849086949973, -0.17072864431156676, 0.5492802520546869, 0.842866528475487, 0.7876258186085463, 0.7172649205236155, 0.5566828527101817, 0.7498198292231374, 0.3575717256972532, 0.2607275065572824, 0.7268870394308142, 0.4115431201830751, 0.32853444609669974, -0.15567945733230126, 0.5128663609344093, -0.1484585266988264, 0.7020965289471306, 0.5806745541078354, 0.6534448565448955, 0.6118530108393333, 0.6228950476542485, 0.8137198697947771, 0.5335293318772647, 0.3717219923026244, 0.6148453286895775, -0.10208945671859368},
    {0.6966824767078118, 0.8495230523749489, 0.4102180973661497, 0.32173412275814467, 0.7420788265634352, 0.6001117629069026, 0.5066499557437038, 0.1304968440913733, 0.4649959190195137, 0.6326295923032033, 0.4491469114504908, 0.7737540413306088, 0.32741812241811524, 0.6397595997928728, 0.47028629166677194, 0.17146571993389806, 0.7455230145670599, 0.6520191200370484, 0.04641253287367782, -0.07557529307887662, 0.4281557191854344, 0.03837970189746442, 0.5827542470953373, 1.024144112623629, 0.8226056885792258, 0.6753222356819588, 0.6764681199714789, 0.5120376043369116, 0.8642000095106491, 0.45764898535219095, 0.4423945966284168, -0.2923731074065904},
    {0.39594301473093196, 0.39238756092216237, 0.6616324326405557, 0.8103447135001791, 0.8737088651889097, 0.7565640667182476, 0.3380707615248595, -0.18571370545819976, 0.662287126273734, 0.7998525325791134, 0.3775174057033163, 0.623505906237736, -0.052637447411544365, 0.5855002641117587, 0.5947421670837975, -0.04443881730966941, 0.7340610695684201, 0.7886880945110103, 0.17422530183094473, -0.3232401907205119, 0.685252141271662, 0.3357237413326721, 0.673822274395386, 0.778760610521797, 0.8078169330753824, 0.775099401352289, 0.7007764492683779, 0.5707345403288966, 0.8352422090951025, 0.6268967398498795, 0.5244019007846542, 0.0550454634342075},
    {0.8542233054102497, 0.6253233174183733, 0.6120037209446499, 0.9806327805277381, 0.8031784998659119, 0.6435577440406673, 0.18435624397995298, -0.3465358092606855, 0.678579687795302, 0.7486320571415885, 0.39813941342050596, 0.43956725116783746, 0.43293234403453323, 0.35657551291631817, 0.738661946638608, 0.15269701683797868, 0.67595568026695, 0.8583071408066866, 0.16323382198362701, -0.02678194205060287, 0.6395548359783007, -0.016266344537735983, 0.5791860738147138, 0.6383459983229145, 0.41564279120005265, 0.9106994980579307, 0.6580360068203491, 0.8242486921371406, 0.7568688385691399, 0.5910307425342985, 0.3017699258987501, -0.1932857403149706},
    {0.5790067819036191, 0.7897754268819781, 0.41557573524198177, 0.5564583293806334, 0.4255437770971553, 0.6054713045886831, 0.9437491152381748, 0.03538787401044456, 0.7194110441297733, 0.9959196959580432, 0.6491621809135074, 0.6136917461869105, 0.43159208497386814, 0.5407320683424415, 0.6227350972857049, 0.022758700506354, 0.7693771036577538, 0.7057874908150528, 0.2625945885502757, -0.26188337704798753, 0.6203939732251327, -0.1488908739424328, 0.6125990385319283, 0.8197584388200225, 0.9170500946814337, 0.5356853761126855, 0.48602608120468616, 0.5232118341225426, 0.4368934045035053, 0.42804745354143947, 0.534699079280996, -0.3130997704602795},
    {0.16095571197164701, 0.9279690603256805, 0.43174684681218284, 0.7567647653974615, 0.7928884956139111, 0.808775765163136, 0.23724745212734788, 0.1626807837960714, 0.7878116418409562, 0.5519651374965496, 0.4287817128992861, 0.6731844984666938, 0.5185614907159093, 0.5157702775147815, 0.8822992663889934, -0.2736016272276941, 0.5767745772607894, 0.7100241004353165, 0.2789143930758089, -0.06003558969617114, 0.618360358267961, 0.023415076931796303, 0.9283117138635061, 0.6428389160734955, 0.6078242135586909, 0.6457389975588741, 0.32498785287596516, 0.7213547415159787, 0.45949705624901077, 0.24969112030544255, 0.5430801555444889, -0.09341522006534868},
    {0.8585737559876782, 0.603934627542933, 0.7014702905162632, 0.7131110568551472, 0.5970993224832658, 0.5939700261467566, 0.7118209651268725, 0.038608616131725546, 0.4525692945693142, 0.47348727312706856, 0.30605628793104916, 0.7580594350936557, 0.7954291980316348, 0.558274682530946, 0.7485936170062794, -0.00895084531666016, 0.6371298570218916, 0.4557798133982806, 0.5536283077198584, -0.1679375190703035, 0.7469643678482262, -0.14525213448650257, 0.8923070811556585, 0.6960911214158707, 0.538927855379578, 0.413380152048996, 1.1463143460123644, 0.9366521848158588, 0.7429445931925008, 0.6073179981811989, 0.8292761455102814, 0.11641352681024186},
    {0.9212372881431836, 0.8306595904728103, 0.4753697321212011, 0.9476238366737492, 0.6897825698854119, 0.9422016643068571, 0.7763409979563587, 0.04708051630565998, 0.7731762554394817, 0.513300649000485, 0.9822223748659258, 1.0467421881934096, 0.9362350227064529, 0.619279054277906, 0.585611210323173, 0.1706675603700744, 0.5016065813795337, 1.0853511538253366, 0.39226881517006107, -0.05553961685327094, 0.8110684458431933, -0.16711779312764696, 0.7509177558538491, 0.7503446101328525, 0.4485789538236962, 1.015668167154757, 1.2242212723502495, 0.6784150350192526, 0.6525369898920701, 0.704718058254952, 0.8942315114630331, 0.09980929499904354},
    {0.968023717265531, 0.68435015434115, 0.2224977798399474, 0.5807920908343426, 0.7816959265476939, 0.582654641836416, 0.7753491841570154, 0.13192041311112448, 0.6231963713645593, 0.5326561112698177, 0.4263401770936119, 0.4388210184449317, 0.6053049224854802, 0.7507091510426473, 0.6866686588916964, 0.31294470900800636, 0.6590828480613354, 0.6197149363076944, 0.31827660007987374, 0.20974520879478112, 0.6987422904028083, -0.09170669201773282, 0.7319777059438354, 0.35536950731469763, 0.5425347949143521, 0.707675399718875, 0.6356125379681431, 1.0035184137386535, 0.8557386942637517, 0.5240961457347234, 0.7679654520828825, -0.04073960994552007},
    {0.7842191514121106, 0.5463144379135081, 0.4048256632978404, 0.6787482384192621, 0.31856390972471893, 0.5066251681059624, 0.5691095300014747, 0.06139549243610886, 0.5167136627136589, 0.5071547905782415, 0.3140278259987675, 1.1012076243490667, 0.8195155968316594, 0.7610885361774102, 0.4034883365440484, 0.321718380349132, 0.5917694456039425, 0.49430595258916815, 0.2502786646895128, -0.008960282953933788, 0.7268103991762269, 0.0863129925015021, 0.7692894216753595, 0.42445475750175665, 0.41881685775816113, 0.476249661673995, 0.3602669721452071, 0.8594955298915591, 0.4661204967283093, 0.47599890599296674, 0.7087480461025578, -0.03451146085097241},
    {0.521583203326715, 0.42580659068398036, 0.26294697670060446, 0.6552391396771554, 0.42556177173817694, 0.6231313122980237, 0.8065590598070494, -0.1418187290414495, 0.8186190662648125, 0.5871309028176214, 0.04866473398817888, 0.6779093569837578, 0.29792188148978005, 0.6232097746272591, 0.5819591960565681, 0.27569201207037636, 0.7019015858095441, 0.6660086533000902, 0.10881358528905148, 0.027649685971076157, 0.9481418209532954, -0.25924979653778885, 0.6523735183309219, 0.7123613761216333, 0.7943313832552528, 0.6249590931046692, 0.6604201801382764, 0.851958233472882, 0.5301586582783366, 0.49514785387062693, 0.45651430916682106, 0.0719898686634565},
    {0.6054002906435838, 0.832721262144887, 0.5933547750674443, 0.7661454463055571, 0.7469871221194696, 0.8463875419091118, 0.4922289995903282, -0.022095892238639298, 0.6163849091468083, 0.7970499683407704, 0.8481749616257025, 0.781471290383003, 0.9887301400713646, 0.5632981023632205, 0.9146439163211079, -0.18352390811037095, 0.6732240909873253, 0.5902032335539656, 0.44026813123227826, -0.2757602624104773, 0.738838344552679, -0.06147884956959449, 0.6477631015293353, 0.749934503948762, 1.0610583089511174, 0.6898338252860786, 0.520883863555472, 0.7815543403002292, 0.8461876041612064, 0.5698650173185654, 0.7038276740034012, -0.18305679050970758},
    {0.5446764112267592, 0.29038142258905475, 0.529615929763953, 0.44492980668577226, 0.4264681520450259, 0.8146808757070202, 0.3325611610294798, 0.3918640187059602, 0.43358495529810265, 0.5913770193104516, 0.551662574443484, 0.6816870275285029, 0.6430297394963618, 0.6314594937906383, 0.5902195325386366, 0.40496100801902196, 0.4266718638737288, 0.6786634647796859, 0.1203279865326122, -0.029298222093386724, 0.9973309884994478, 0.022721429485238344, 0.8981893289030547, 0.47781031264511326, 0.7537242835844491, 0.7942611406205666, 0.5796451508371798, 0.6916027572766044, 0.5798868967943411, 0.47237477333357064, 0.40873820516932097, 0.04093943860750243},
    {0.6722639113030765, 0.6133475629525266, 0.22717360514659957, 0.46077832369349464, 0.5305042322885472, 0.6548165605954143, 0.2790577059585199, 0.19646953921216267, 0.4840943980884898, 0.7702337168369497, 0.4287532701380063, 1.0561729259560146, 0.28423314577738235, 0.5527724066340666, 1.005755678391956, -0.08399769828510592, 0.5495240029323665, 0.808758087696788, 0.2200992852233464, 0.02284059995623115, 0.5291521512710124, 0.01750021282629157, 0.6876899713262595, 0.05607337753307361, 0.4371799366135278, 0.5875627430372243, 0.7244383905071529, 0.74396084369331, 0.43121673833552837, 0.5621208974336672, 0.5191367379943912, 0.15904032087909414},
    {0.85206538071023, 0.8343747407841029, 0.5409902510668566, 0.5020918870871722, 0.4763598576849014, 0.7773143702031913, 0.6176274100538399, -0.11673580415956616, 0.8229870396135988, 0.5182760619165634, 0.6203383394340592, 0.6014927811622743, 0.8460199916217414, 0.41493693583494334, 0.7030214989235521, 0.1441078686810786, 0.6227532694063341, 0.4966845751002876, 0.5909208621262259, -0.0026331861899815193, 0.555504222904608, 0.003553483802510875, 0.6435877231250402, 0.6419134650909063, 0.39518222836541034, 0.6365748163258639, 0.6542973287832551, 0.41122471372254304, 0.9084037023909082, 0.6203228980781962, 0.6474759238989265, 0.1330464155642247},
    {1.0020639004495844, 0.5027637256392378, 0.865812411540051, 0.8448268807464792, 0.6924110130241778, 0.5292079610972129, 0.559904896259726, -0.1971299962608318, 0.7796678872568362, 0.9683490748655847, 0.6767979106860819, 0.5849470969412282, 0.9653056866060541, 0.5081472906033839, 0.7105871001104618, -0.041186598305836285, 0.6826749165704608, 0.9946056757608823, 0.44544126418994395, -0.17696104268844168, 0.5267271733324372, -0.045300141291924396, 0.6410561724711022, 0.8761001983954805, 0.7106076769482155, 0.5746905925802628, 0.8251133400978947, 0.8945660208662257, 0.9565069069279731, 0.555985145439204, 0.9526814138188905, -0.023196811804549203},
    {0.6797802606158834, 0.23622939244305444, 0.43718981139628993, 0.7799068648534409, 0.3259347781202715, 0.622363751140962, 0.6255209906838802, 0.01888171072276462, 0.6363408870223952, 0.7885690395330942, 0.26393918933630334, 0.4753640522619813, 0.4425077070347897, 0.5180576463774793, 0.6518789510830986, 0.013356615235170491, 0.9274351588736868, 0.6905484606301813, 0.5012020514914463, -0.10277815551436209, 0.8878119463220594, 0.2537616973170916, 0.7030016826967034, 0.6480610218182753, 0.9313252312128232, 1.054603348384935, 0.8523770860486882, 0.7111431867881811, 0.8506148099804349, 0.34279005947955155, 0.7809375977770557, -0.04219428732068738},
    {0.5175264354220238, 1.0046394054938623, 0.4044930166364689, 0.7904589897745822, 0.40419350287126643, 0.47163222344399486, 0.6985425496130718, -0.27443257125330756, 0.5895605616383249, 0.7769512841457465, 0.6982192238812926, 0.8433038819039529, 0.47971834915915074, 0.2674407140624103, 0.9222506422249868, 0.2219957636393366, 0.6389718493373554, 0.5877150436596988, 0.2951659344137348, 0.09399095309453956, 0.7709079404666666, -0.05079717589172939, 0.7952711992562188, 0.4407593519972045, 0.5669626525871235, 0.5442731205290741, 0.44624382693286757, 0.635746026881047, 0.7465975565275498, 0.4187914788452331, 0.6090816183805076, -0.16800533465345538},
    {0.5517921526590656, 0.5555353403381705, 0.3889609097120511, 0.90039200402597, 0.2203239537095014, 0.7432152673905252, 0.5746704479369927, -0.11004077467066814, 0.5701659884069784, 0.55115481175152, 0.5044700267267656, 0.579954639700923, 0.6610748479382925, 0.17022184023381873, 0.5800514461419748, 0.3397954822139944, 0.6636138420636306, 0.5045620060164885, 0.25272478352999816, 0.11300111712427627, 1.0512819840330674, -0.3194060807804586, 0.7001836221800233, 0.6341305185126813, 0.7649098679687123, 0.5241995091430469, 0.7998615367509528, 0.779895286462262, 0.6161807385089633, 0.13180516972591105, 0.6682878141293126, 0.0017053648659482099},
    {0.39966832785896395, 0.5738362961315161, 0.40642325706336657, 0.5297668080696358, 0.3428695331751773, 0.7303099263765507, 0.21718481230398543, 0.07564088456947496, 0.5501637051596315, 0.7875511663659781, 0.5535844401628276, 0.5000948187919146, 0.5788647183561587, 0.06597642386700868, 0.6647732980543347, -0.15727288278851506, 0.7576600251819195, 0.4900421936641485, 0.3350066783841217, 0.01439250395438736, 0.8714978557953971, -0.07534915069066846, 0.6176826491640102, 0.552688296383366, 0.41969053333882983, 0.7893278028573348, 0.6653195599771737, 0.6467800597223009, 0.7083881285772864, 0.6758320026601189, 0.27672959289094173, -0.2957344387836918},
    {0.8356225212458347, 0.6947289203534164, 0.2785072587644342, 0.37687329477383047, 0.1540108261591717, 0.2710061829410363, 0.4359349926812295, 0.010973405580759923, 0.30065789788038216, 0.8631808696683574, 0.46420247736473147, 0.7583021411190373, 0.5784732651292562, 0.46570954738063824, 0.550475065879745, -0.05240470311167102, 0.8455421693308928, 0.46495181937774516, 0.22243191267595241, -0.09780403583571713, 0.9469532603368036, -0.02887614493615273, 0.8249400336784384, 0.26652552642249533, 0.8382400457952837, 0.6653003306749776, 0.43117782733440685, 0.8765912880091165, 0.6732937842010897, 0.4126038571685809, 0.594787997914321, 0.26282833653275134},
    {0.7137847501196323, 0.8881030688867853, 0.5865746726313051, 0.9078949951432413, 0.7792013343120926, 0.9447064398413718, 0.3696905169476579, -0.15889978043205552, 0.69554886943078, 0.950742315583624, 0.9555641990271796, 1.1631869565925719, 0.9152132832861206, 0.5712654052799696, 0.8602897655528495, 0.4171900129968306, 0.8841471824218202, 0.6819498465973912, 0.1374450590514882, -0.004536649053158205, 0.778730893010043, 0.10168601988534097, 1.114938986698106, 0.7330615981374455, 0.7606071243576505, 0.7476261411331578, 0.8453494855767391, 0.7472616949921569, 0.9538864471958558, 0.7272969984242267, 0.8793733434699206, -0.06268209176652315},
    {0.6229210720045475, 0.551025316229961, 0.5416687929082397, 0.8521078000768338, 0.6688904719006744, 0.8904833457314327, 0.10911397191774715, -0.21997983465755283, 0.5471845786825482, 0.6670873140111868, 0.5357600358471779, 0.9532353493327156, 0.8370181506603677, 0.7457183542252771, 0.8650195073863967, 0.5159034372880711, 0.6230649181757767, 0.52025813557443, 0.21953505077201385, 0.09507232838574575, 0.8649944313068099, -0.025472444037098644, 0.8441054877535301, 0.41857667100386486, 0.7890495801303246, 0.49090801160775854, 0.48540946044782857, 0.7907880327379745, 0.7725676194793659, 0.37284267773107566, 0.6735441396201778, 0.026507656408819903},
    {0.9825732794046056, 0.6921946902644397, 0.41132570888706166, 0.5043957712505456, 0.606481235103192, 0.863184572762631, 0.5300660618871097, 0.03839511020550571, 0.8395789717527039, 0.4953537332988262, 0.5734865972576707, 0.6390139831111242, 0.7782337080638521, 0.8606042384886108, 0.8678942637044433, 0.13155291649893208, 0.7897145277134057, 0.9888611953821331, 0.5889732756693691, -0.135657987513641, 0.8263676711407527, 0.37452599041369, 0.46052568656077303, 0.7320059125071734, 0.6984585348651139, 0.2962670792022165, 0.5325493895276985, 0.814232891344289, 1.1045510210414908, 0.6408898724613443, 0.8091550874658741, -0.26673221118065255},
    {0.6699698829270986, 0.6165658153331105, 0.68417601813618, 0.582725697360428, 0.8089508298815777, 0.7507820293263026, 0.5977848600723549, -0.07430917494836223, 0.8180473213309435, 0.9973801386185248, 0.7474085370207117, 0.7531897403636887, 0.48861035267948005, 0.6848513784074203, 0.6778418165799365, 0.052977566917090706, 0.9160693908448486, 0.681952010720444, 0.4116558535618067, 0.12842545676900954, 0.995835906280118, 0.35664751362008046, 0.6577195535023104, 0.6157540234615666, 0.7275260631611487, 0.549922100775503, 0.7238526276346239, 0.608023118923259, 0.9690673099924102, 0.5195585816279732, 0.7202257348094022, -0.21302103038906928},
    {0.6113649915517971, 0.69192576609118, 0.5448067861784013, 1.0663546260394565, 0.9355137053761357, 0.8585783720783529, 0.4333497260316033, -0.2941575375955551, 0.6733542116457987, 0.9430808679604009, 0.7601813273697161, 0.738332136184016, 0.4558543172593841, 0.5332997917240464, 0.8305548340026652, 0.19359458486844702, 0.796741978433534, 0.7679456805135632, -0.006828939384343541, -0.08739412173946866, 0.6265941806525737, 0.02988102194015168, 0.7220742056267877, 1.0337318607841188, 1.0473694970685765, 0.8424612189893476, 0.6572064282635729, 0.9652277316712649, 0.8373923375332831, 0.46352529155311056, 0.5581259166480594, 0.11521473906807078},
    {0.6024262934165499, 0.4302727105090004, 0.6522063160245873, 0.6713490141185232, 0.682272325947159, 0.4782563421757865, 0.3090129170019328, 0.07029349234117135, 0.5911901911615616, 0.9065825964429072, 0.12509389690476744, 0.5257084354601455, 0.6388168491504913, 0.1963755888594155, 0.6657302009144295, 0.48183335493276075, 0.6123855506076786, 0.761755826462506, 0.35766277781749173, -0.12092256416187516, 0.9168401035715764, -0.3046168868216409, 0.5713673951770465, 0.6671575155517556, 0.5113051487982788, 0.6277869321314186, 0.7626516052330473, 0.6279680434589062, 0.38129404591489374, 0.38150613161078256, 0.41609799530177927, 0.11909572638759137},
    {0.8483294130172732, 0.6310671513448722, 0.6292890417310256, 0.5984199846791853, 0.5172428435883887, 0.6137295103774181, 0.5302107752451503, -0.11690657077598553, 1.2151538649721496, 0.5173421677199046, 0.5444284784854453, 1.0833837876447625, 0.8601175989013103, 0.4300025410909916, 0.4192987629979608, -0.10255128005339385, 0.5502482185656523, 0.8218773163466069, 0.32468500802744005, -0.029460920020427564, 0.7778704415870421, -0.18973502514731366, 0.7872210033755207, 0.6413797711192505, 0.8690599933530735, 0.3922026470350277, 0.8348758703084632, 0.7632726264014279, 0.540693839439701, 0.3802679899073551, 0.7345604052673199, 0.13729183665385544},
    {0.5874859819066308, 0.8501077728194704, 0.4442093381353934, 0.631484488676827, 0.7513892911734645, 0.4042417599194181, 0.4613391283622178, -0.26393804129410003, 0.6586287406618325, 0.3920364908066243, 0.4359598732753119, 0.6790974476353642, 0.7743032638976408, 0.3141201725042649, 0.6821697547515904, 0.12355949015331763, 0.8135858895992159, 0.4273278161459315, 0.5018913290745264, 0.22050342469530593, 0.5962096326015106, 0.030470008186664368, 0.8523348962180574, 0.672439865251491, 0.6947939492406675, 0.4986134384240023, 0.7601536224429987, 0.787616544038682, 0.6915024918019123, 0.6247867966186377, 0.5971730768473811, 0.11112227062187097},
    {0.7652439181825721, 0.6640129305207811, 0.3936550820377825, 0.3210763527009243, 0.34873151737986663, 0.7718848542651235, 0.4025002717934704, 0.03301988477376111, 1.1813651089845367, 0.8283490516310261, 0.7748533898718133, 0.6504272368818498, 0.5532418782924684, 0.6546873767261929, 0.9554926335523584, 0.10069987895324693, 0.7962828489443409, 0.4281934061481052, 0.6054189624586219, -0.09704199863568659, 0.4842773526911019, 0.02929414471196156, 0.7841307721874187, 0.4472196695663766, 0.5506435231187288, 0.48303576527789194, 0.6668003585220047, 0.5994768343032225, 0.5050237542287346, 0.3170197286484728, 0.8221147633477073, -0.28433270186501125},
    {0.6563961114905659, 0.6263246844582347, 0.16055246872427315, 0.7118335816962229, 0.49170022618236087, 0.7123605118088204, 0.6694560625558902, -0.11453189257232696, 0.5235806817511895, 0.8542280494658345, 0.4560633751867108, 0.5686721074035438, 0.3795862231687114, 0.6582409500278045, 0.7658443756036523, 0.20138438552015042, 0.5085496642184695, 0.6774160446616709, 0.10913035436411987, -0.24301675874708192, 0.740183397524872, -0.15032983528029045, 0.3525865603403582, 0.24312933031488676, 0.7132955139395613, 0.6553543263628892, 0.7058619919066801, 0.5937818556891803, 0.5210251433721459, 0.13170205337800714, 0.09929099150911538, -0.11942822283211312},
    {0.6352769023935467, 0.46102136339536837, 0.39541905838845515, 0.6236215110023775, 0.6543174399996595, 0.7244245463568569, 0.5484749500128678, -0.08000277624780601, 0.9271841823735325, 0.8671447624382299, 0.864821499272798, 0.9880377780974074, 0.5992949852906624, 0.5074710558453834, 0.623557925776262, 0.26072141044333674, 0.5200646586559653, 0.9569289015701437, -0.06957849357946616, 0.11033916458817088, 0.8844233464006048, 0.20907058813108317, 0.9601770251478754, 0.4748535296010802, 0.8623626802579357, 0.9115755252976329, 0.9118611049393864, 0.8221444088071677, 0.4347532545777901, 0.37413824285356323, 0.8194387857797232, 0.10277977720672311},
    {0.3931550740911738, 0.6696742969742973, 0.7747897687309089, 0.6868168772722678, 0.8474647127618904, 1.018852604338932, 0.41584845452487396, -0.15301471947772968, 0.979536909189887, 0.5873837999802534, 0.7827420669458302, 0.528767263519578, 0.7003586270165102, 0.6266838418847153, 1.0538619906663242, 0.43340374511050883, 0.8485737638855815, 0.7715219820873561, 0.3296701388279624, -0.05739083226772918, 0.9408177726379123, -0.33529822550121136, 0.575873213082307, 0.5137692715572153, 0.7354558067836886, 0.9760025759070778, 0.9002286187526161, 0.5494942750804049, 1.1379137374045825, 0.709812743447221, 1.1775822544491197, -0.04456651398823142},
    {0.7316547192938493, 0.9184122837024671, 0.6030371472306209, 0.5572369086568857, 0.6127703541586302, 0.6175979346304086, 0.7706265412214495, -0.35562665894457934, 1.032112142888612, 0.680434811931238, 0.7899634749399511, 0.7097955757619374, 0.8528608501735926, 0.6374384574519796, 0.7732529243106313, 0.2371190408068438, 0.6481399263193965, 0.3671545792601484, 0.34583351392085265, -0.13376051730318997, 0.46588163417269995, 0.12953299500928486, 1.03936608816031, 0.3448451140750116, 0.8681497557122436, 0.6154204127683253, 0.7296538997593179, 0.4950623254492557, 0.726520759895515, 0.5744412071731028, 0.8300692528527909, -0.11213914067682813},
    {0.7778938681669689, 0.6864484335287068, 0.4567780066170548, 0.5200509909987134, 0.8950614555822866, 0.6824506365011076, 0.7919057849289122, 0.15911618337819475, 0.963643794342314, 0.9284196433590499, 0.5065323419512083, 0.23617907967813515, 0.46782399967295996, 0.6017129052555826, 0.7345342365621146, 0.1682577864289972, 0.8211444040404465, 0.8520665321705561, 0.4407208754403727, -0.13872608060335356, 0.5860912291213987, -0.19698868957638588, 0.5847098035133214, 0.4863622050482835, 0.7110948937417115, 0.8239879462496763, 0.778099618694123, 0.45021823574335007, 0.9997307281754535, 0.37405795846130624, 0.8031425642392555, -0.06588049026200422},
    {0.5138972028875579, 0.32345728013523806, 0.39689718104965394, 0.42411330105586686, 0.23787687031114862, 0.5526089998955429, 0.6301209069678038, 0.08103044934340746, 0.3068509745699966, 0.904307123307982, 0.4259948273165664, 0.15509049792402246, 0.6185982966672195, 0.5908951273869955, 0.61862249802065, 0.1262789509874973, 1.1449037833972748, 0.9230421458443409, 0.05884522872650251, 0.27908377757919756, 0.7974659645907896, 0.20235072331166631, 0.6412597786684907, 0.6236689137449378, 0.505586696438529, 0.808283272024138, 0.5586429736988318, 0.643225791767775, 0.6149943718882109, 0.5990426628093536, 0.5080625559364875, 0.010700649081905402},
    {0.47477625776723686, 0.8159922232476932, 0.4171525074269593, 0.498290010094169, 0.38378803449222537, 0.627533979260774, 0.44634796310050495, -0.2465371264789991, 0.5670224260968697, 0.7006994020161919, 0.4969522910835441, 0.6045483299430778, 0.3709231248481409, 0.36356479800398256, 0.7872815741825302, 0.33695396264818894, 0.7857939171220716, 0.7564749323364743, 0.5292000863355203, -0.28935007438067284, 0.6328623173260127, -0.11861798416619794, 0.64582162512191, 0.6506761244061581, 0.6496403612287869, 0.6965761345060394, 0.5494379300518659, 0.529027949232739, 0.7226985615835146, 0.5100286535613436, 0.6612179429364242, 0.04896235965320109},
    {0.660501281055444, 0.7065759886496772, 0.767856191558039, 0.5768854296236806, 0.5903751681324351, 0.6738418623705622, 0.3710266824590569, -0.21274362648650985, 0.78976737214682, 0.551430535143989, 0.7238897724779412, 0.680702726420889, 0.6818641473929788, 0.6493295953818049, 0.8931409016548847, 0.046594321864172054, 0.9128535174110863, 0.6578639889024034, 0.3228036521196615, 0.09533926587324466, 0.47875304744668834, -0.1631510086097464, 0.6588463601303269, 0.6337332860785876, 0.8263566095259416, 0.5154306842382564, 0.9433385728673583, 0.7375475174520059, 0.5607601714485769, 0.6690437488077202, 0.9460475341116483, -0.1487065322724919},
    {0.7441795663463261, 0.6794517938804082, 0.5058258832390585, 0.9854346662679124, 0.8486392991400197, 1.1314524068379326, 0.5141003168813518, 0.011434829043601144, 0.6424090457860102, 0.47403366429393834, 0.6261348142887574, 1.026633588507476, 0.5832751705068435, 0.7504728968175914, 0.8853138049416835, 0.17996395286104117, 0.9926401828612683, 0.2656210344496121, 0.5163184421034565, 0.062129734781238406, 0.44537239112858595, -0.14025915814578147, 0.629230046719958, 0.7100384003241933, 0.7156279910528446, 0.6163562426267238, 1.0566531489241324, 0.7315996693406682, 0.28769451622597525, 0.37941350283357983, 0.9126255959665305, -0.3544873943198143},
    {0.8846879144053612, 0.9100251837475761, 0.4209657045296343, 0.7875894593157706, 0.7939145658817135, 0.4703124333442881, 0.4377560906935275, -0.02798677339752281, 0.6177328466130705, 0.6540749162284316, 0.4438933600761836, 0.8737188788234135, 1.014500412995526, 0.5935856985090422, 0.9191199772546194, 0.1771549271139687, 0.6639612402994708, 0.6467195687253303, 0.20499635757006482, 0.14567529024691941, 0.8170066372567644, 0.07501925174258262, 0.6576735903953485, 0.7569071786389716, 0.640644027747059, 0.6513526844197586, 0.6915777527797957, 0.6316992309695744, 0.5625076125361888, 0.5119539185334963, 0.6441343299877627, 0.33977436500513297},
    {0.5482318005210887, 0.3971782192608905, 0.5309573039992332, 1.088376124537925, 0.5538878485657958, 0.9476064837582788, 0.4728383716038964, 0.06523686068872045, 0.956791014223197, 0.768716069626954, 0.5856887689474161, 0.7507221296958779, 0.6154546440655553, 0.4623443716904368, 0.39184185854635284, 0.31774958425643707, 0.5849452670885887, 0.5624483732955673, 0.5226551129755246, -0.24417808421566145, 0.7592491315873904, -0.09804905150305263, 0.49771554956932185, 0.7820014512498364, 0.7663396076699115, 0.775933290901505, 0.51541888823302, 0.7946971790337538, 0.9626668639474426, 0.6430619083124129, 0.6789763026158832, -0.13474927048434193},
    {0.3586790421844473, 0.8285102181124803, 0.1710270797276085, 0.6008100576477995, 0.7566017071629605, 0.6612854682142881, 0.4923683186475131, -0.4460056477813211, 0.7101145642862666, 0.42174401965157465, 0.5738767787319982, 0.7094808837937073, 0.770359736564097, 0.5943037093238698, 0.5452941150380879, 0.14974373601858304, 0.4694559503155096, 0.40886828394686325, -0.12119579252099674, 0.019736308087862448, 0.8332327436635787, -0.18250886539521305, 0.7282611114476161, 0.501217016920336, 0.6562364845459778, 0.5453926258342002, 0.5811073975530504, 0.7129658264236292, 0.8525751652649943, 0.32847394990657547, 0.5134295076936033, -0.09001586391439276},
    {0.8055258692423796, 0.8203996858071982, 0.6634557234828684, 0.7091611257642777, 0.6778276737995647, 0.7592586315911937, 0.4640636566468802, -0.0915607637707661, 0.5854706637115097, 0.8093313248953564, 0.4754526844043232, 0.7825637102499544, 0.7621975508919948, 0.6071626983547925, 1.020253830558913, 0.37178469974093015, 0.5351581889672395, 0.7286511975556912, 0.3176620691440297, -0.019928098777147664, 0.692053293530809, -0.13322028700556607, 0.3890522833854739, 0.7850915028931972, 0.7046451525843497, 0.7952805249607889, 0.5987250143274254, 0.5888092318697979, 0.876399572858577, 0.5554687441095157, 0.6762969457929977, -0.05914113408751804},
    {0.8755595578162209, 0.45574625598413876, 0.635305646979844, 0.5453304152621401, 0.3742417046050621, 0.8489485561631216, 0.7123012453661429, 0.020039694647321377, 0.4663955000503784, 0.46927461166868906, 0.6163474812084215, 0.5657233969003574, 0.37646293314991175, 0.6185676079168796, 0.8579714848230876, 0.32769073388392794, 0.6146591628594061, 0.8797499589531267, 0.2796549112951312, 0.07903097429420915, 0.4804807965963292, -0.20811894906039544, 0.6033623741114459, 0.4762807617112688, 0.8168638711402982, 0.583655361174039, 0.7889074531977731, 0.6983924166140604, 0.8195502195536483, 0.3527121737757653, 0.792681835401833, -0.15159734257582727},
    {0.574694549522721, 0.9061644388233522, 0.4512284571395024, 0.9574939354790631, 0.83917604872082, 0.6670513223921497, 0.629309208731279, -0.20931624691704626, 0.6524436610170169, 0.714815978127739, 0.7080087575189681, 0.9029565076606368, 0.8273390917888781, 0.5387508974098083, 0.8234184894508899, 0.20734461804898494, 0.7565169865706131, 1.0474861318998536, 0.17154101131551416, -0.17883934977808633, 0.9516646911624911, -0.18689832263593953, 0.7391085205579506, 0.6700835409561451, 0.6128493687271444, 0.7441647629203553, 0.884579548823079, 0.9350079799570845, 0.7717702944906775, 0.37074669856958425, 0.9690577830284737, -0.22408541751366198},
    {0.7982680597655852, 0.5593115269957982, 0.31157889329834515, 0.7643820567150682, 0.6644542115976578, 0.46024607557253033, 0.38340886117271844, -0.1350836645671172, 0.49201241027764325, 0.8410653425205927, 0.17425610841185787, 0.5241658367859166, 0.684433680449355, 0.3047828722311458, 0.6303645006284373, 0.11951762884525936, 1.1068906366949942, 0.5476803398371988, 0.09776892742104028, -0.2034880696148883, 0.8441819622848421, -0.10984789449649479, 0.6465473326260626, 0.42211222282336963, 0.4549546203854695, 0.6948021076268217, 0.8965625734985068, 0.6254056018462093, 0.5030107336837948, 0.7574841952033227, 0.6255428252301037, -0.08018688296630465},
    {0.3294291218201723, 1.0921003313193813, 0.4768714937370415, 0.6807255609303355, 0.34796046317413803, 0.7419957338488304, 0.5748483775090469, -0.20807303893659423, 0.8038244658980468, 0.6243312259685693, 0.48272625566590405, 0.8133759856730709, 0.5063721764248327, 0.6375123578434162, 0.8666388122497573, -0.08849488443398641, 0.4823027330860616, 0.8227505346823171, 0.488317844779616, 0.21347415853598925, 0.8192321342717853, 0.04785944910389295, 0.9088909766620414, 0.5328670743994005, 0.5370773809317376, 0.4647090314610894, 0.9437983953162741, 0.32982885625977076, 0.26656086321913397, 0.5271781641036215, 0.8949217236077712, 0.2907291669935743},
    {0.817127203023611, 0.6701015943259764, 0.9402385313673379, 0.5644816797161495, 0.7876220741631631, 0.7435942195894005, 0.5477302279233153, -0.22472640698073146, 0.7587804444892945, 0.710379585820617, 0.3387766800912309, 0.6751197702427947, 1.1683154183337268, 0.5247032801330089, 0.934746659253481, -0.009105932001281297, 0.8791457703640355, 0.8586731909592087, 0.34002071394172684, 0.19831310521312587, 0.7303999962278243, -0.021599823900229367, 0.6168383577824125, 0.9057747200933874, 0.944630000323354, 0.9386359704775573, 0.9114420803671485, 0.6927998916687172, 0.9878303074282054, 0.7023410149197717, 0.49157033776984493, -0.06592459636994352},
    {0.5761575174724517, 0.49635764423751155, 0.3905231556990206, 1.175069555877722, 0.6788086281484144, 0.8576562068170422, 0.3436066363292934, -0.23649888707212333, 0.7494394507665485, 0.6743926769620379, 0.35563391993308185, 0.766673797388183, 0.6577650763073869, 0.5026991802751511, 0.31056709286164463, 0.17942387227423703, 0.7447487891858715, 0.44790573465910966, 0.27878071973784374, -0.007643400843715555, 0.9630899989743449, -0.10894008486550778, 0.9750587524865593, 0.3333305110752244, 1.0491690829373106, 0.5820852149569924, 0.5487717848977144, 0.7395276879688207, 0.16509125180341516, 0.5912923337089326, 0.3604413311238256, -0.1563410349107956},
    {0.7103486928419821, 0.5940931795455104, 0.8338320041566418, 0.5797467200183025, 0.3899123041277569, 0.807094795726014, 0.12276869169625267, 0.1459401375491015, 0.44192910945854225, 0.8278223660106628, 0.7321587596468049, 0.4108044572752691, 0.8800983158950978, 0.24929572471542177, 0.41910952230052184, 0.3585667146956123, 0.7485247413789934, 0.5570593082815604, 0.215445819632673, -0.05477037989848763, 0.5935744131658679, -0.2529420021617053, 0.8601010791807862, 0.5751713654184842, 0.538662266691435, 0.8436135270981452, 0.9936538882404906, 0.7663275417791872, 0.6045775631410127, 0.2976104615127229, 0.7500534558652778, -0.15978365812832818},
    {0.5607779505539017, 0.7737088097841908, 0.7179090709527632, 0.6132670883821827, 0.8506507842315248, 0.5945420522355178, 0.374040535790324, -0.40271207396554215, 0.9937432199236182, 0.6907125620547359, 0.26860885477123925, 0.6472285849452082, 0.6324985027821763, 0.5588276786384482, 0.4782884467989093, 0.4116915700428961, 0.7069826187733046, 0.7265050859859904, 0.299892067374779, 0.14264569217386316, 0.9808811459206145, 0.38656105987822764, 0.8261425959112871, 0.2508020059136734, 1.023631242544951, 0.4244688089406472, 0.9166145415143465, 0.7440234895342935, 0.8897830424029001, 0.5904071504297503, 0.7539723275770314, -0.0008207290025058699},
    {0.7530116448793768, 0.9817566829940798, 0.48675521600570526, 0.5487967490046117, 0.6138788595628741, 0.7358907963993909, 0.6216773456921462, 0.22936287145714382, 0.8466799108986074, 0.8114142049493688, 0.6204999016784102, 0.7294156549167075, 0.987944646041111, 0.9254260846270493, 0.874570821259188, 0.5128768427447519, 0.5996416802452297, 0.7942679975635806, 0.20821167453521378, -0.18257581664444453, 0.781301690684046, -0.08237932661819916, 0.8692801211764921, 0.43778317075826284, 0.7707023720261, 0.6816939450356817, 0.9704692072988643, 0.4858832116889093, 0.7295504164106638, 0.8136612110002899, 0.763878742904497, -0.12792913316373436},
    {0.7257947758108765, 0.5922577175750581, 0.6589800899811269, 0.5367972181849144, 0.7073741903038341, 0.9029711273381517, 0.7560054685598555, -0.07101757146609966, 0.7133035290526034, 0.45857705032479606, 0.4775559023035887, 0.5818166556868378, 0.8645994489922523, 0.7271729194929191, 0.9869432397979137, 0.020830234824540866, 0.7999203776569117, 0.6731159337667851, 0.04552937699510196, -0.21042947812125778, 0.9494607154927078, -0.039091644639044174, 0.6524498857707245, 0.5279221847274383, 0.8484030597757619, 0.8581337465283723, 0.48200496836981244, 0.8732969839626138, 0.8162669207534013, 0.5009742482317764, 0.6625878835888594, -0.2921607129189422},
    {0.6876861237443804, 0.5931078266474927, 0.4413516157608705, 0.9770620214115721, 0.5340642712932278, 0.17554495777711115, 0.706317911533683, 0.02215094937785362, 0.35958356830160887, 0.2667623888609391, 0.32545859058378346, 0.9720441572576405, 0.7447539141445966, 0.5409446470202735, 0.5969430308493595, 0.34090601582666524, 0.8761386094029854, 0.49696351592869203, 0.5987732527573288, -0.00656606951234546, 0.839646784889429, -0.051535318980950734, 0.6613299426362751, 0.4440259124137602, 0.8197678802360683, 0.323777265982637, 0.6347546789122631, 0.43728605777643825, 0.7303954663311567, 0.40454715355891907, 0.5746080585255737, 0.022355410493826312},
    {0.3378161102356859, 0.8290879960640588, 0.4903240835011361, 0.252486889384402, 0.5627958923662999, 0.7520538801818022, 0.5851706923265523, 0.09301376476126474, 0.850332948880024, 1.0909395888006506, 0.6715516376787919, 0.9582093222291087, 0.855057574688701, 0.7530585211832578, 0.7877931889406236, 0.2100503657243703, 0.609299939153236, 0.5486812631180881, 0.2773719864158567, -0.12526581703999226, 0.690164982526648, -0.29977760634674805, 0.8978367053048613, 0.16318451162702347, 0.5387651931221605, 0.6019335468225754, 0.6600744505718715, 0.8685799213335695, 0.9049373527912579, 0.32360957138242447, 0.9526890788356908, 0.13780432167575288},
    {0.49021293775306846, 0.8107319662995202, 0.28814144739186476, 0.6812844961186497, 0.5188944109500674, 0.6549653929308682, 0.6984284636970677, -0.1511534449546257, 0.6366983815468217, 0.8984906278967636, 0.41260768669613207, 0.858638547752987, 0.5670574771688431, 0.5655330291520206, 0.6665017754885266, 0.2006264620321504, 0.5295965431558673, 0.7026912815016656, 0.09249230391790206, 0.11560075955822176, 0.9140830862108122, -0.09791437935187196, 0.8318630299340555, 0.5193456086977963, 0.4697241790768413, 0.619547518145832, 0.817709563544214, 0.3802173882920305, 0.6006201821075056, 0.592191125443251, 0.7005083979195262, 0.025618177069823445},
    {0.9572918651402669, 0.7196733895015442, 0.6597820818080923, 0.46040710288661224, 0.48145253731055865, 0.7503593679278089, 0.5780406020570422, 0.19079226541210406, 0.7496516172747394, 0.9462356767891943, 0.5084276407428576, 0.7379584958003379, 0.6127885853526347, 0.9035177824452586, 0.8085484897643042, -0.028912834881436197, 0.6748288499874856, 0.7912109481260147, 0.5620776084486326, -0.15753781124084798, 0.8662180798089009, -0.33094697294921754, 0.7981225660686855, 0.4956909103279877, 0.9514725673468645, 0.7308725784423892, 0.8174492781630239, 0.699226883373503, 0.9199427397297949, 0.5613836290210864, 0.6645637524619413, -0.04560292595850459},
    {0.3041643551635768, 0.9343095478461988, 0.2703058220525893, 0.8592179613915818, 0.37174558685488146, 0.6155115273577374, 0.5807206904738367, 0.2550445553530217, 0.9189642768743098, 0.7362186722595904, 0.5875796387330111, 0.7745465158673475, 0.7694644993130579, 0.45264598657559446, 0.7401157445978997, 0.15150438811859673, 0.5834324952768956, 0.7955990216764401, 0.19748824767539275, 0.03313053512393227, 0.9894537996412937, -0.12473638480014244, 0.5625250692128387, 0.7344275492406662, 0.9316768391382023, 0.518048293542714, 1.1596413629138513, 0.7019951006621185, 0.3757879041486111, 0.5075245526404039, 0.7221746443232993, 0.17390110752496518},
    {0.9043220506161951, 0.5424853660366261, 0.7390244644497037, 0.9175113792560079, 0.49365741512708294, 0.5354085995713485, 0.4767180353716067, 0.10327582767183464, 0.7388067034441005, 0.7244780258514414, 0.7887011444206626, 0.8663708254770285, 0.7877025235313576, 0.5015903593019968, 0.7496907373138647, -0.10522238012860703, 0.7245292073396852, 0.6692206639678288, 0.28304835569554415, 0.09186393067209286, 0.761492609734012, -0.1935555986477914, 0.5404431951420043, 0.5796736420488379, 0.6199633525438104, 0.7914976426123895, 0.8209131846874049, 0.7956667985594525, 0.5999134261023426, 0.252780188025223, 0.723991960564369, -0.008512207775674997},
    {0.8949643594881622, 0.5598409692517915, 0.5092737475410133, 0.5799690316959027, 0.19534520691694776, 0.6000973001594947, 0.4599263911191748, 0.12617370496673644, 0.5039806464688642, 0.8686716939969521, 0.5276326838142191, 0.5615647016960048, 0.26372331511189057, 0.1992025250423774, 0.6077700076108479, 0.057563575340080525, 0.9907335576650915, 0.6468101328026113, 0.3161217408384256, -0.023418071002364094, 0.26779928604184644, -0.048962834226400936, 0.6231587465429118, 0.288194320320382, 0.3900478046512941, 0.35164910106684266, 0.7584385452972215, 0.32766401270480466, 0.7309649614013507, 0.38871743654423285, 0.8695587788702034, 0.13074780551786502},
    {0.5967519324837215, 0.5190384916303827, 0.4442879090740112, 0.550363226817386, 0.5536417494270831, 0.9033380010792559, 0.42348827923391874, -0.10058812526001046, 0.7028543899432358, 0.7177794516452564, 0.34788659593900395, 0.5863056670643555, 0.5398313042251752, 0.2738995596113181, 0.6979748290898502, 0.06063106374887322, 0.6942185800573094, 0.5140676932725663, 0.2632404845678402, -0.42189904633021513, 0.80173347360773, -0.1771521246408851, 0.3947525662832048, 0.4634599999580353, 0.8315213365230827, 0.5474691283673713, 0.6496018832952446, 0.7354192085613755, 0.41235158249906817, 0.014796375090560223, 0.7023712929515685, -0.12859975674226795},
    {0.7834082541001955, 1.1420975093284356, 0.6417264334406948, 0.5292365580629111, 0.8790754243553154, 0.7958683434184011, 0.7575493010810508, 0.010881802827045076, 0.7992751838916088, 0.7834286381842912, 0.47295495940918575, 0.9050267597863214, 0.7705609934532297, 0.8499345347909794, 0.7244390326444781, 0.07319659911241971, 0.5935950333137905, 0.9036858100100994, 0.49080315858452944, -0.26229587512600544, 0.744392165919087, -0.3858261343311943, 0.7870836417375262, 0.868307912244986, 1.1851912192975578, 0.7342256186268158, 0.8036858101911635, 0.7512592605464047, 0.6792994091815636, 0.33544786961152007, 0.9155195624430968, -0.20366092211546255},
    {0.9342345325853223, 0.14519351455411586, 0.2781898619794858, 0.7939462553160366, 0.21638979346506815, 0.7977023984564938, 0.25988434133443933, 0.1415049965767012, 0.6490513066226338, 0.4443580287345869, 0.2934846626093106, 0.600482692584464, 0.48003272782914436, 0.46502816396067853, 0.2825475761384071, 0.1845681006031436, 0.768169972165475, 0.7553244422419253, 0.31451500700446855, -0.013861514780196496, 0.7753210773222882, 0.24964791293332186, 0.7059275728755608, 0.3101968375115568, 0.5622091309530118, 0.9526098410860929, 0.9488487692546694, 0.7967439118756894, 0.5511055053492616, 0.22036587280552514, 0.48121890762785463, -0.155471899825293},
    {0.7649729565121376, 0.43879224413506646, 0.8790337608802445, 0.7357179394144926, 0.5752196234869886, 0.6810148317434901, 0.7171999539374981, 0.17527212712937984, 0.6136511656970041, 0.8277712761016728, 0.7960862344299471, 0.76683596155202, 0.511709023231504, 0.8569004888395387, 0.659943314884464, 0.23187854847024003, 0.5406278960777009, 0.7100146850208784, 0.27188997224046885, -0.07897448749882992, 0.7923354800919151, -0.12151955958230035, 0.595280477115012, 0.7105821293774849, 0.9047515515457634, 0.701912804527814, 0.8156682521753683, 0.8908654686606224, 0.9102801521375878, 0.6776286816358835, 1.0201164878497997, -0.037502169183725224}
};

static const float b2[32] = {0.6821889072791718, 0.618961458976835, 0.5673244642777029, 0.6897669086486428, 0.6533080607240281, 0.6746268766654846, 0.5184341026113193, -0.042551190627373746, 0.6964365719910552, 0.6906494611320673, 0.5630001221226804, 0.6277288535688736, 0.6419841037767816, 0.56688342065161, 0.6780974769412321, 0.1441008836633987, 0.693070514575868, 0.6720035588583461, 0.31906110334776194, -0.017199507112994866, 0.6735073183485069, -0.07872717175630246, 0.6891192095032378, 0.5748951351369945, 0.6679885648090945, 0.6613509574115111, 0.7403205329115511, 0.6964508417152636, 0.6801742730617379, 0.5190543428790338, 0.6796904546090443, -0.03726350350413728};

static const float w3[32][16] = {
    {0.35333381071735576, 0.7213713909917279, 0.7782410655924608, -0.16779131924209867, 1.1613264705212243, -0.08088151461814533, 0.602695230572349, 0.19060786359283324, 0.6566119208857613, 0.5926020715245277, -0.15530342969844577, 0.8417869436541425, 0.5459613533880213, 0.9156790994234711, -0.17565814842244584, -0.008689345564262485},
    {0.6100809772660318, 0.5730742559311474, 0.5756621028300556, -0.303493104669111, 1.0872692397164145, 0.2882906904507859, 0.5864603634422973, -0.2998404842896413, 0.7391196489656654, 0.48820156310190443, 0.0534340765941083, 1.17664398660104, 0.3438982166572736, 0.6509167933264802, -0.33267070631581125, 0.17226503724920741},
    {0.4022685822751451, 0.4036796963863306, 0.9344788882901564, 0.014488894408231067, 0.36027398567894237, 0.2146543665192496, 0.5653431851517077, 0.21429078624214523, 0.7251274644360353, 0.6623156488519026, -0.11257220754520218, 0.7605794921986674, 0.36425293039454304, 0.7538231358109628, -0.08270031815980496, 0.5566736856126755},
    {0.3759295969750985, 0.12635649871732155, 0.30200566346926944, -0.013280467215127543, 0.8474274507175187, 0.3932394261575694, 0.6519304290918801, -0.09677001936419828, 0.7687913096781278, 0.9220286159030351, -0.24161046495340455, 0.8742258189379839, 0.8081911348649095, 0.9388965109424902, 0.35500720832628974, -0.006030926134756204},
    {0.37805715417107405, 0.2931768415766924, 0.7494853545454464, 0.11883372110848711, 1.045228018039809, -0.2760586721508734, 0.6256909760327526, -0.18173900315717603, 0.16447615954024988, 0.8774234330544722, -0.11856989643451965, 0.47928702189682704, 0.8668661726021404, 0.720753357204856, 0.04753105575772902, -0.05273635059299219},
    {0.780675384591885, 0.9298483666578298, 0.8970923066980632, -0.04993837224029111, 0.8088215659952136, 0.204431173434672, 0.6177595661849798, -0.048785523123682215, 0.6026778759330759, 0.7365877106379153, 0.08668654717435521, 1.2542355022535974, 0.7375074982363304, 0.8896519344764444, -0.23324766113468776, -0.059186539237910674},
    {0.9737310011410093, 0.8578531865828554, 0.5954357314592874, -0.024161405777184966, 0.4525707270860975, 0.08818120316277207, 0.4596926384273008, -0.09946727738290562, 0.7992995908542493, 0.5012500951153064, 0.3233648722506715, 0.5016288530165295, 0.8927533452564002, 0.4267085382725653, 0.28164714313591693, 0.6103061775729539},
    {-0.3079465536417254, -0.1169454070269252, 0.02400814553039006, 0.4429132432129561, 0.3124618238384122, -0.6056471981724691, 0.1190443267954579, -0.10285144332517177, -0.07056595096881403, -0.08426939010348326, -0.2347447021383549, -0.11426469257914477, -0.070041284157082, 0.16012353981480637, -0.5720577404582664, -0.2980956052104591},
    {0.43266110617255277, 0.5582010215102551, 0.7579157590655387, -0.455327050788442, 0.9763419313812375, -0.14031121170163174, 0.7898667072969217, -0.048075549063350445, 0.6988971636180035, 0.8117399533798161, 0.02302662054944938, 0.3531169586243154, 0.7118896976409912, 0.978529182478865, 0.05606133942669128, -0.5628658416849923},
    {0.8530964782853742, 0.45378443042725664, 1.0533052400556755, -0.4334050678111805, 0.7452859619355211, 0.2186575521251847, 0.6395485178744134, 0.20057278722467917, 0.8722950129882724, 0.733359093252953, -0.21813307022048675, 0.32330299650907357, 0.6938371867463834, 1.0136313696287758, -0.29901232166333414, -0.22884738188121648},
    {0.5788544408242376, 0.8186006205924236, 0.44070467610857145, -0.4669734784692606, 0.43464470431742225, -0.10448235615051148, 0.9669914692219912, -0.21776744568955583, 1.0337261586164734, 0.7893864993337284, 0.26703197033147097, 0.489293244100784, 0.6802827632647767, 0.8156107825611506, 0.2450681068118607, 0.5347046083254448},
    {0.15777221305127012, 0.3771758595460371, 1.5764057657815576, -0.21551422258249495, 1.3080448168911893, -0.31155566427835746, 0.44381184558017756, -0.11025519039306564, 1.0155284864128422, 0.8461239083176864, 0.07304320871857735, 0.8090142797734808, 0.6352950927613408, 0.9525505185296013, -0.3758242712467969, 0.17553608350076327},
    {0.6666765873736025, 0.4023624132570281, 0.5658061456573271, -0.34979437785863154, 0.6943892928345591, -0.36673510142239263, 0.4287681792010149, -0.291040835991329, 0.5914782062407078, 0.5473258447324809, 0.03216665409399633, 0.7938141532804229, 1.313475201052589, 0.868783425919795, 0.08816115970775497, -0.09936066115996017},
    {0.4936963363396891, 0.7253536921321412, 0.40313036069546226, -0.013579763524729069, 0.7166379502016179, 0.11048372198637388, 0.6147899060739719, -0.2229936663797019, 0.9900359899433955, 0.5823063772383872, -0.006140936204214909, 0.6141164993216676, 0.7469239788581954, 0.5994882025420712, 0.2760471856970584, -0.3486583211859092},
    {0.4961138107970622, 0.6472523715802224, 0.9285613019070753, -0.15252584462876767, 0.5791712408071351, 0.2163877360935211, 0.6543831764206364, -0.006759022750171453, 1.013763891371718, 1.0968106798900379, -0.14086532065841398, 0.7800006030101427, 0.7043347037970438, 0.540219124684401, -0.38011929226805646, -0.16863908984022355},
    {0.2276663151306694, 0.17148880730238222, 0.43392167358713063, -0.14608457040838327, 0.12249972304407362, -0.20845477752371194, 0.3502211589366179, 0.3304290220142895, -0.044204701956222954, 0.4143185299207954, 0.31454134982678644, 0.1639505963973391, 0.26508061779116887, 0.5501680665943383, -0.17343215143159268, -0.0925212274729341},
    {0.7497363724389083, 0.7039098794879606, 0.7321373887866525, -0.006695340458338974, 1.1013435301115522, -0.04398193707487341, 0.3897411605933361, -0.1601058646260044, 1.0243302355509871, 0.7737001022761623, -0.1829774411205001, 0.23669988266392164, 0.5909914947549125, 1.023151222845154, 0.10173935248408862, -0.04186147822219662},
    {0.4827812569548884, 0.9436825475871654, 1.0316957228780574, -0.24123168613851526, 0.7661541348149119, -0.248481752004455, 0.8067465490704057, -0.2584118950579126, 0.6050187263899507, 0.666622741512258, -0.20716840157645003, 0.46202895173731057, 0.46572376667868093, 0.6924246202522976, 0.08981262604280678, -0.0028837383287227164},
    {0.353705452920394, 0.5924526352393806, 0.2590470275414023, -0.16255947615133778, 0.46434615641847743, 0.22323690562069531, 0.5699506410591482, -0.17983239473259155, 0.4785138788778639, 0.39433309897983704, 0.42376991111285217, 0.7091791265608366, 0.7894950747538708, 0.11121183211970806, -0.18066047213659786, 0.08338297210137566},
    {0.018327400076034492, 0.1805975139199735, -0.39328504203351183, 0.08503146961134321, -0.05779856817184864, 0.31841015826067653, 0.33131456502743245, 0.11149842735700077, -0.25446026371121233, 0.33998840192268875, 0.09003898082765503, 0.40831967361684346, 0.27831147800001915, 0.14950504568606185, 0.5745104720436421, -0.48025072148773873},
    {0.7086410018093275, 0.7290023076169466, 0.6761806636146547, 0.04532408968921793, 1.033883118911591, 0.061963563653454685, 0.4747791520293684, -0.13748343884610928, 0.6530938941351501, 0.9974201318389181, 0.30631994481682284, 0.5977744726806542, 0.4583385961471399, 0.4577308818225713, 0.01819464587971195, -0.27054618974667816},
    {0.043830202568188585, -0.1954242192191294, -0.08387588154888043, -0.047806515823387394, 0.3266923096185476, -0.4703151860825716, -0.36393027739406186, 0.250599952366733, -0.3561629467141673, 0.017486940767371232, -0.2043834898237666, 0.13725421150749775, -0.1799726168653632, -0.08962228287054347, -0.4893321163219246, -0.2472093268519287},
    {0.2995567482504643, 0.6445067935680616, 0.6457564395492277, -0.2316443024234762, 0.4773067260959129, -0.18223632630477762, 0.16976546081426772, 0.33617093978642515, 1.0835566008321433, 0.873880982677702, -0.44890286565819715, 0.706844634301811, 0.9033819476902688, 0.9379165100372963, 0.13231255418652915, 0.2212541246217211},
    {0.3243573613297097, 0.627474332403794, 0.7107696078102439, -0.26397630181354875, 0.5650605691053632, -0.360600361914824, 0.8065333138344, -0.2564829914799526, 1.0396315172526904, 0.411266040811631, 0.13330831200064938, 0.6073445094829492, 0.7201170291338355, 0.43644141579528417, -0.010592726241475897, 0.0031759481997195365},
    {0.2532620644054054, 0.7500239010748159, 0.811292840005935, 0.27643752967516594, 0.5959510140868363, 0.3434398631659717, 0.34668637523832124, -0.1599104345690993, 0.738255971245336, 0.7910708968607213, -0.32038603449988123, 0.657255271225563, 1.1075065535463453, 0.6754028643623095, 0.02300729532306287, -0.049398965259863106},
    {0.304102912708827, 1.1199413530891147, 1.2258300136100746, 0.2876990407352227, 0.5490849310071766, -0.46599796934743487, 0.45856500735758515, 0.1970126273159393, 0.7332249002173677, 0.9956709877965679, -0.13738883681256572, 0.4552101183940466, 0.5949158958027781, 0.6673935047580136, -0.3299279032842164, 0.045381077453889244},
    {0.292025053946008, 0.835549075317056, 0.46921764344393924, 0.06048851318832749, 0.7792272188385433, -0.07704313869477343, 0.13151748343647127, -0.0753176798135143, 0.9844842509238968, 0.8865177288708942, -0.15515334519153168, 0.8845729044269984, 0.635534990387634, 0.8197850770485406, 0.14613587013114904, -0.05889588779346867},
    {0.5113042710603128, 0.8055715048478814, 0.5941756748822633, -0.22121829578220967, 0.8270576850226286, 0.07917280769859489, 0.4361103837822733, -0.26294327947136126, 0.7094194079735902, 0.5668726660800234, -0.14431746735197076, 0.831643668441397, 0.7287492740757844, 1.1742729670960905, 0.11255375415391765, 0.04637106552722582},
    {0.8445539796451008, 0.8468193271399843, 0.8421573404267461, -0.04540153025053733, 0.6384730162017823, 0.06457097069266236, 0.3477909686178576, 0.04315545907203711, 1.2089157671992812, 0.9885352024162221, 0.2123086363513304, 1.1566504418712942, 0.8912022018123006, 0.842822577501134, 0.09696983639324534, -0.3210872400174028},
    {0.585875623282015, 0.5350970711063487, 0.6276257261964927, 0.31699615987493956, 0.9782227102003512, 0.12720949432729325, 0.8692220308799458, -0.20927536248728335, 0.7679111325234544, 0.24981687674740785, 0.2708533690198074, 0.4697006164154066, 0.195670130409214, 0.5802379662738176, -0.2906350724999089, 0.32119671260362},
    {1.211760278668493, 0.5487466879645198, 0.7675494518526468, -0.41296744190344054, 1.0161510478889448, -0.06857359428868547, 0.3716642375833274, 0.1436955469694219, 0.6107937289101323, 1.013478496610594, 0.05275596901404032, 0.5591262433031642, 0.8072262713452515, 1.1835838794424924, -0.36120719238911514, -0.44679859744257405},
    {-0.05505646007160484, -0.25517654201232753, -0.17445241886161417, -0.05658793228133527, -0.4084897310025109, -0.3168902239428966, -0.16292368384566472, -0.21628600355704697, -0.22461699795250079, 0.0264893193560904, 0.12100923470037853, -0.006435951159395215, 0.0017343073544966365, -0.08575805992748707, 0.2746625511416379, 0.03209643593099699}
};

static const float b3[16] = {0.3838394084355654, 0.46981843056094297, 0.48987618151012685, 0.0018060161483634, 0.48263222393853433, 0.024117068186526775, 0.44346885783904616, -0.05323963898405049, 0.5222045717600174, 0.47822095612386095, -0.02920832900863016, 0.4593333065068817, 0.5357693645127778, 0.5647461970323595, -0.04714199120250588, -0.04806397744202942};

static const float w4[16][12] = {
    {-0.49725051959685623, -0.32491700991095473, -0.06451603382357012, -0.9895131180741803, -0.006446437683071187, -1.1067971523760718, -0.6574622547168003, -0.6819356366311939, -0.05892598730613939, -0.6775846593444745, -0.05399884628391465, -0.6582369472840782},
    {-0.33026459015036197, -0.26139874236479255, -0.35573190833330476, -0.750268258508409, -0.25302797261493615, -0.30522373463473096, -1.350047673536883, -0.6431913623354077, -0.6655227909558307, -0.6189447393171913, 0.038366794473279835, -0.1552681179787131},
    {-0.46147742917164, -0.40782190219885817, -0.5188090973477035, -0.23860567654775736, -0.6549808730502207, -1.1310628622236147, -0.47887223218380104, -1.2623122381135827, -0.5683548092594198, -0.937156833520342, -0.9999890851154414, -0.5300998868537585},
    {-0.5075882011021772, 0.18651834490794625, -0.02274791346662151, -0.3264822657373371, 0.6684222941706288, -0.1647500785636526, 0.23574928172085738, -0.43904910349052595, 0.06355430606604644, 0.20770548950007306, -0.16770317160397177, 0.7078012611886272},
    {0.08765515308238686, -0.5847420038202512, -0.8176669136222592, -1.0833390678057069, -0.6329860871727692, -0.4059611472495105, -0.7804101770621352, -0.6835309983562137, -1.082773656859903, -0.08509799724319533, -0.6975882337655747, -0.6052611327784636},
    {-0.27141474451518016, -0.5523033061489938, 0.5622006662298725, -0.15595746767705318, 0.07976783959663111, -0.4028456820397772, 0.09823945032706947, -0.7172518503417328, 0.20600722374752795, -0.6172440540574042, -0.3893177359331585, 0.10311435062714025},
    {-0.8136540986470537, -0.7313569732551363, -0.576387054622042, -0.38483499857935966, -0.34047678535597187, -0.6067323112936175, -0.5813391548714888, -0.6709738382433931, -0.5970623652884556, 0.03667687221173034, -0.4909651152757621, -0.7944431792494632},
    {0.8064520022421432, 0.062428012625500774, 0.17861957318476068, 0.41692227351984174, 0.32149757745659335, 0.11171060601784026, 0.13273629057039985, -0.13724491227517618, 0.14286326088070597, 0.16928524843296436, 0.11681937896671106, -0.22472181144015715},
    {-1.1130377966210343, -0.8277198654376681, -0.6246588496298009, -0.4212111390504438, -0.6189501607649717, -0.42817029030494663, -0.36726665744827813, -0.7284909898260145, -0.9331841548727485, -0.8730570441337425, -0.7231667734883223, -1.0147290777001479},
    {-1.2525391292183998, -0.6819165808848713, -0.8931374810262046, -0.0768136830351054, -0.7931809495121604, -0.8854107949491564, -0.43086579578721257, -0.5872209514875776, -0.6287079995814149, -0.9351323019964196, -0.5189689271779216, -1.0284110700052764},
    {0.47340801437351365, 0.22388205118964147, 0.6315933960882926, 0.013183719044919202, 0.20593243311028117, 0.13340907908043878, 0.25803214911399647, -0.7940588283793723, -0.028743950659346287, -0.4104053525933447, -0.44137752970615485, -0.02193446695191847},
    {-0.18456533127410926, -0.7174622808159097, -0.8237610659964723, -0.8667811920532794, -1.3141216082249216, 0.09370281021269355, -1.2736594680093478, -0.25924170602489577, 0.20272564413418878, -0.8104348133230491, -0.8103955863117679, 0.2559838373778013},
    {-0.6951516998371842, -0.9147943804759737, -0.9829806952019293, -0.7478083485055919, -0.6390784572377822, -0.9358559835214664, -0.04619523372367787, -0.2923737043586131, -1.3005047136663943, -0.5064476890518624, -0.7497596921826837, -0.576576230009999},
    {-0.9643280443587341, -0.7314848967773785, -0.46766355702266216, -0.8080716806751008, -0.7527144579261814, -0.5300845834394735, -0.522234859769496, -0.46981424874487054, -0.42296506071166956, -0.6747471234929985, -0.9319813344228017, -1.009953377507428},
    {0.30885287013926926, 0.0734884286483131, 0.07461182864172534, 0.5837476666839667, -0.1338979545165305, -0.5597282419769121, 0.6945455560718808, -0.10992434503333647, 0.5227763048149007, 0.7263714624541595, -0.11052154319673216, -0.296458414718959},
    {-0.4619322812636618, -0.09350125020899872, 0.20047516838558108, 0.017209518432507065, -0.6013831977272147, 0.17110535714893707, 0.21229043701211214, -0.11926114666211693, 0.2084262802833996, 0.014599130760962222, -0.09944568085762735, -0.2895853856797861}
};

static const float b4[12] = {-0.12531401327897332, -0.19612509735603198, -0.2670834768255838, -0.1924970404999004, -0.19907705275049248, -0.2366423900575863, -0.1840189585804236, -0.34485450327681605, -0.24901280702231046, -0.2632420014058877, -0.30632422756145566, -0.18513326252364262};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
