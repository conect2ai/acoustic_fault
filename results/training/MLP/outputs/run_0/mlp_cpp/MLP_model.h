#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-1.5127159434421413, -2.258419306711333, 0.81525584574854, -1.017859044834427, 0.4786745235871949, 0.3677120140072877, 1.0863316356891786, -0.5199106023405511, -1.6828624688265434, 1.5670310870309516, 1.4599153279093524, -0.14881901668911798, 1.5481157094679934, -0.1777745787842997, 0.7219150341228886, -0.8361325921988557},
    {1.3001094880299884, 0.43503702358380203, -1.4501378878927957, -0.13614715420866938, -0.6307513816816999, -1.3472402014272078, -0.3266498733687892, 0.3064082755440289, 1.412747326858502, -0.14682629914561043, -0.9586843943413991, -1.5052184354114653, -1.4645525372241022, -1.7284433557801973, 0.21034423708000943, 0.6828726699885375},
    {-0.4027710211433151, 1.1000937101244177, -1.1465327209090221, 1.066951897626468, -0.4013953145863595, -0.43603117641594796, -1.4133554721963169, 1.5771450360048247, 0.6517184913024221, 0.333716739366426, -0.8361678247148688, -1.7836949422871409, 0.5093110585093649, 0.7686026962055489, -0.37676402570844114, -2.0299014612577517},
    {0.7966082370818747, -1.8078070575101726, 0.20394802732157666, 0.7236039898346849, -0.980830188130872, -1.2433356265061057, -0.7808522598438045, -0.03823671271401976, 0.14972602160983914, -0.47634164246503646, -0.6639621685422785, -0.9544272198242069, -0.09115408902271746, -0.6975018960236649, -1.4379979685251485, -1.4393015216792482},
    {-0.8910326972153783, 0.40712554601390555, -0.5482976795874889, 0.289612677023482, -1.1304132684658887, -0.7873334749810802, -1.6299882422226513, 1.4670080884328607, -0.7835725237180599, -1.3809170361833158, 1.0539706390612489, -0.974243400795899, -0.8952267169201843, 1.0943614221435405, -0.9391808008750979, -0.9035248827527164},
    {1.4494546658300058, 1.5508815924168435, -0.8834969911997093, 0.5189166728324394, -1.5105331002527371, -0.523562567347724, -1.4129038728966516, 0.2000662113494611, -0.6237821832829816, -0.7765137686184684, 1.2782795890034255, -0.8177021561621758, -1.0836084679618299, 0.9729445658094382, -1.2006026418373505, -1.706823721005824},
    {1.995649855369431, 0.03805340059141637, -1.3072070863139997, 0.05370457420970129, -1.4282029634485505, -0.8814395049269249, -1.3154609045953993, 0.34937048005459825, -0.7628540544622492, -0.7987324837768345, 0.6031644480099232, -1.5031630178447033, -0.49516776840884885, 1.5700524039732595, -1.4955043441676903, -1.4840751101860892},
    {0.2514651215122673, 0.782807516534512, 0.2569964668200463, 0.7298748029326368, 0.01264742843909064, 0.5178932156582284, 0.3392314106442102, 1.114926164026682, 0.7364757342584193, -0.1715748583716087, 1.1119741951301934, -0.7746263589164132, 0.04399841692770436, -0.37177777026936215, 0.4462643692975616, 0.1380468317990382},
    {0.6271141158048056, -0.11956249173045834, -0.42475585386080056, 0.40250023629036213, 0.02294902124179173, -0.7695123005878118, -0.06568956223489807, 1.726176679954814, -1.181111239744033, 0.08749160669721923, 0.24146241479555625, -0.5688651052824154, -0.1775404346544868, -0.19468823638292562, 0.09575066395485507, -0.47609625911787057},
    {1.7995372059362587, 0.5717409378010943, -0.12003716207637713, -0.03434215834388928, 1.2052172200577946, 1.814694430802823, 0.5288006621556265, 0.061575816696318, 0.7915576180764692, 1.224316881964551, 0.3525740746039581, 0.05371453130580857, -0.1792535878938814, -0.41455483777863905, 1.633989505327906, 1.9132219308324985},
    {0.1693282295576982, -0.10061608782701505, -0.3746654321564408, -0.4208101030840168, -0.6689440976021662, 0.2749068664707392, -1.0077645208660846, -0.3159193269645086, -0.5651875587703262, -0.07994867287088998, 0.5927903345641575, -0.8983544883600715, -0.09213336844468645, 0.9260243951957102, -0.5471783649596932, 0.6639068371443204},
    {-0.4396258794787694, -0.662455855317481, -0.8540567836229578, -0.8798914504111107, 0.08477987427355005, -1.4748285907084806, 0.03433815378581547, -0.1649309152551623, -0.4372823799746531, 0.4646538180941454, -1.0125679382284407, -0.292050113528405, -0.31928563900540297, -0.8702296847257271, -0.2400675142235754, -0.8693267884460809},
    {0.6929867420631484, 1.6408278321565266, -1.4827443992684461, -0.038741068956374816, -0.42575070379421404, 0.5887639928035681, 0.3204895838603089, -0.24966919954379296, 0.09025112506111596, 0.2449117107424548, -0.1822045068668124, -1.157635269012827, 0.7410367380779417, 1.1705401970771634, 1.4410382236045427, 1.011362969658663},
    {1.0831994566880752, -1.2282109451182193, 0.9752269105837202, -0.8110007890125674, -1.1086337703400564, -0.6284273140936308, 0.4509592592737961, -0.47625705251070494, 0.34020969168140835, 0.22946844581586576, -0.23021000108548273, -0.3079021042285642, 0.04904781321936011, -1.1515767573911202, -1.5510712883979563, -0.16567009822590273},
    {0.30545860143987746, 0.5260502319929743, 0.615196484049982, 0.6579359863184397, -0.25857802247246076, -0.36026589422727257, 0.5084634457915436, -1.2562490672551108, -1.3218102127884348, 0.5185384034488261, 0.6133193226727817, 0.11259246342788971, 1.452596938005439, 0.3380090727144222, -1.1135924066414056, -1.8093318513895482},
    {1.4222397878219974, 1.301188484993793, 0.062211283168705216, 0.07277975889497407, -0.21875663293374079, -0.1832019455490846, 1.7575165634964904, -0.4729103703606004, -0.19106804878110484, -0.11225508942864659, -0.23745564254786014, 0.19045880326028244, 0.8160049587668203, 0.07442790113715964, -0.5597953899313494, 0.36986108604567697},
    {1.6200908053453535, 0.10621242217883074, 0.4278274045648643, 0.458914473882262, -0.7895198931481713, -0.2238666294897929, -0.19097605365319123, -0.03965046039744829, -0.08761053942118663, 0.10010299698305926, 0.6750224813405327, -0.13372772904259636, -0.2762135668698378, -0.38092522395043493, -1.6025121282870283, -0.9922784992800702},
    {1.0559871367118139, -0.23723910218934807, 0.2520445364859826, -0.7789771334000565, 0.12246448215002177, 0.25123104679466446, -0.06634698857669068, -0.023411047881559066, -0.04382185982131712, 0.15402172852670526, 0.41023257142588404, 0.5056333256662563, -0.3125849669062177, -0.1279564849623981, -0.8423083079515287, -0.8000301883730307},
    {-0.5403566213936747, -0.0580790117162357, -0.3953660860211535, -0.3483856965746707, -0.5672881278367334, -0.9299636289384917, -0.4028864048193116, 0.20429361915491295, -0.6933851894058393, -0.6357053901245405, -0.49354883900848723, -0.06019641531812339, -0.17181804246208576, -1.0937359539385505, -1.3686640719927803, -0.6322053435287751},
    {-0.20477209804434146, -0.81206620106908, 0.1524830540640442, 0.3113866927424421, -0.3302434206565592, 0.39218006656969695, 0.3569367556818515, -0.12315712376080047, 0.10412354286267617, 0.33267561968493164, 0.39963461409206624, -0.22428673678642425, -0.04826048937096173, -0.5469966256983494, -0.011211092152090528, -0.27984229468310073},
    {-0.6733525830745201, -1.0587654619401097, 1.0443489570227869, 0.0018987453308057266, 0.025608720314289433, -0.3179146310953471, 0.3830001218968988, -0.5530513963170027, 0.07705069538625693, -0.14686286584884872, -0.15026339944436318, 0.410931424166804, 0.24782870769297854, -1.207870261557039, -1.1714169221450956, -0.12883066186517378},
    {0.2507476255809402, -1.1055666997367914, 1.399292822347322, -1.0470932881333885, -0.6339855909132686, 0.4835322046404659, 0.639154755618561, -1.097092916162384, -0.39104236782460705, -0.10125547848753855, 0.5104133982082671, 0.8708559675924301, -0.005495316251482017, -0.9938778031061645, -1.316922019604696, 0.8638581386816153},
    {-0.3250855668740897, -0.15217049616404668, 2.005305460953638, 0.13476868115963955, 0.40568286689979427, 0.5628259291173309, 1.7856239794463564, -0.680378572679303, 1.4736581070519155, 0.4054526650389465, -0.7004903971391352, 1.5531759977517343, 1.422268372344008, -0.8111522883246527, -0.4991096389703862, 0.637638387706576},
    {-0.914595273653762, 0.040993095331597784, 1.7584561928662112, -0.03779062440592909, 0.03623512725516119, 0.4107562823866437, 0.6027076496819893, -0.29621069143795825, 0.7785558836908899, -0.05322958194783264, 0.04235241753441016, 1.445672789613152, -0.5173283538460793, -0.916838947049747, 0.27068042662119896, 1.7360967324031622},
    {-0.45873397593426485, -1.0112762468227847, 1.4998802942557623, -0.4292800274556207, 0.9223420143211503, 1.1991429566342904, 1.0600272288284638, 0.2902995880558422, 1.0595518233440993, 1.001562332241794, 0.48275082968204047, 1.1784377968859674, 0.5391200101717375, -0.2366627076242691, 0.06428757774358292, 0.8500946360775977},
    {-1.1796310325062385, -0.6658036229923844, 1.3897421177300127, -0.3414942533059944, 1.4167719572784934, 1.0915725730525496, 0.8985729737865181, -0.028020517803521088, 0.3463646099912209, 1.4163237007880758, -0.46127248423066775, 0.9617335290084935, 0.6319249044553829, -1.195122762445066, 0.7188298136032246, 1.0286246472986047},
    {-0.5503518228174455, -1.2940516121542518, 0.8626758276271074, -0.6433105785476882, 0.6629910282568603, 0.676496103106185, 0.29557130012646626, -1.6932082269320758, -0.27947841177648464, 0.3475478425687489, -0.5828030368009844, 1.042977224019527, 0.660312562853269, -0.5414626068193417, 0.2808002145339147, 1.4020298620664542},
    {-0.5246498369025486, 0.5023547876534289, 0.9904930727597236, 0.34999539156347803, 0.5055155421811665, 0.6742899087998231, 0.803654345358579, 0.49415145718924347, 0.480226696535418, 0.6200132195719391, -0.1286688157601766, 1.3381511712068537, 0.7468752797917165, 0.4984608877982408, 0.3968457308609417, 1.503822737663926},
    {-0.48193909538979046, -0.6759856787807713, 0.7920281279874447, -1.314374349460431, -0.5344642957633212, -0.1704415544905062, -0.6901693981382032, -1.4260648623965118, 0.07142220279137684, 0.5777668395897717, -0.883677774345714, 0.5037636096180812, -0.5536962972478757, -0.6883393012699826, -1.13540553830467, 0.08658594726635081},
    {-0.46331826683766264, -0.0421819964552329, 0.0886209830500645, -0.6925624176109083, -0.9739579975380618, -0.5274061940281218, -0.47962666484033206, -0.24431219806448384, -0.8160240122391986, -0.10661560862928877, -0.1538580437605969, 0.5807566895262304, -0.3124566782847723, 0.3652296711384226, -1.4451614849187708, -0.36824560931264266},
    {0.048617004152972806, -0.5998264521971698, 1.2466135754492695, -0.4132408839576289, 1.253541254135031, 1.3452969663606646, 1.3703408548112601, -0.16772063924907527, 0.7217149365616281, 0.9414149965355854, 0.7963794133982002, 1.5611802794142091, 0.7793257917392857, -0.9174244489379816, 0.7310382897733833, 0.9437366591921211},
    {-0.44268722448360265, -0.24245838220398364, 1.4224504331937708, 0.49530171906456333, 1.1201001621167077, 1.6767130520673896, 1.6649306252826748, 0.9543507069204701, 0.6689052310796745, 1.7765873245115982, 0.8790091540423152, 1.2548858208372284, 1.9268183664621574, -0.900326296862833, 1.3157985250352033, 1.2303970275534797},
    {-0.4219334499031897, 0.3816633648725274, 1.177667213649316, -1.1901075160804429, 1.2213266358825734, 1.7271410577358242, 1.168923486868059, 0.15302086126580156, 0.8912642035538816, 1.4261082666482248, 0.42414336687778353, 1.2994621521113572, 1.5051399073716782, -0.04274628383227583, 1.4292277626773067, 0.7446203105547536},
    {0.13632098962501987, 0.6533638554415395, 1.4353103774157487, -0.2842410350700565, 1.5721699254998363, 2.005116810809135, 1.2390331465934505, 0.6640998515990783, 0.6498255349775673, 1.6918645470201543, 0.27230776002571727, 1.4434460151724953, 1.4204887663616632, -0.14826253986146967, 1.1582016615284352, 0.6285097392223982},
    {-0.0044541897215269995, 0.39598213038762015, 0.5807283469952809, -0.5452288450803505, 1.0797974256774212, 1.4336354159147595, 0.44235706888542065, 0.20776785459913186, -0.056521606310789466, 1.0503121080898763, 0.3917547283417188, 0.7870595200643706, 0.9150184985328557, 0.054638818369331335, 0.845839868882079, 0.2582784043069884},
    {-0.13221547730816713, 0.23223642305083814, 0.5391457407580865, -0.5353324431919759, 1.0429715766805903, 1.4133566855072206, 0.9748146556384788, 0.050760657120605276, 0.1546454276097753, 0.8952666569712048, 0.5144002022966607, 1.271318781170727, 1.2944337295452226, 0.1554031800331597, 1.0313379586790377, 0.4246736818306785},
    {0.3858833797624106, 0.25989456581501447, 0.33182804682145656, -0.5515634769299425, 0.7693492916144952, 1.056433627609175, 0.4547559986470797, -0.20581991393309904, 0.32136984118502016, 1.0756148895900777, 0.24568357497578902, 0.5313043734844453, 0.8124328152465952, 0.37386376436227825, 0.5581835258147586, -0.11138078397141576},
    {-0.8054733990466084, -0.4410414503579205, -0.2687754793944523, -1.386837555273039, -0.5283932643465, -0.4806615010531762, -0.09344012687243121, -0.653830843382689, -0.6154129884151159, -0.3875161436470428, -0.45842529784545544, 0.2322041164729707, 0.022588344835369437, -0.15597990180048493, -0.7980256427886556, -0.8178529064120296},
    {-0.485081656437507, 0.08002295489905399, -0.030178394088842136, -0.7677955851701542, 0.36115831046499636, 0.4807112397779619, 0.21263578261217916, 0.15948124369605507, -0.5402990303897716, 0.655520298478364, 0.26307559425177285, 0.6290499261837839, 1.127181300745394, -0.2032380935894529, 0.6108621306250768, 0.009833939436561773},
    {-0.27728238067845584, 0.0588771157602302, -0.6664066129643895, -0.26893881402190234, 0.13646236715072746, 0.25667353610733773, -0.6418039404743912, 0.07297519729925946, -0.36620344795508697, 0.09928956164409956, -0.35542730097672937, -0.466390802065528, -0.31837502470180384, -0.28660420962096683, -0.20338819069623892, -0.5826944223132817},
    {-0.054852852529569784, -0.5763582847600993, -0.1530303569025633, -0.5216850652091587, -0.08031279283659423, -0.17813202305267942, 0.007696699959278062, -0.3584405770382456, -0.31133679814305937, -0.04995822819829678, -0.4697828584577875, -0.1485815342562748, -0.3958631669079841, -0.4476705762853722, 0.1242090300196922, -0.24110709210752754},
    {0.07719472753718598, 0.11729199769338429, 1.2115192488006445, 0.06479721596756778, 0.2268735436824889, 0.40066934265122883, 1.4059016650996032, -0.3188441005359157, 0.38253646213099873, 0.6628827257063146, -0.06871861278241442, 1.2290866199345454, 0.9262818971378449, -0.11258913793152746, 0.8413803930000302, 0.4819140785087},
    {0.06913755266704878, -0.30984766364041383, 0.25903195726177153, -0.42801663437844323, -0.6463315461582072, -0.556988581765946, -0.1263826920714079, -0.18179092776718056, -0.40858985479194077, 0.1021324030990877, -0.1737970176965332, -0.14597351479011023, -0.31031300607558077, -0.343437798059433, -0.6424247894553925, -0.37487418626786445},
    {0.11173299384936, -0.022787251046879627, -0.15689086027193241, -0.1800758516130284, -0.011299172840355058, 0.1200300452860944, -0.043836836737112556, -0.12186109690223783, -0.3572434998111196, 0.23796032405392697, -0.40472164500808283, 0.36243727658669767, 0.12147480637932799, -0.195829097794692, -0.267649571911985, -0.025578269634842856},
    {0.06543962137065558, 0.2280394064597762, 0.669351205553201, 0.22156144090085006, 0.8133303104362941, 0.943154510801263, 0.6075491231251074, 0.6150393619588956, 0.3284095427176812, 0.8362389828567516, 0.6722378538144675, 1.049287455230953, 0.9728557363087982, -0.2333332570401465, 0.9576834491822385, 0.41706388955513995},
    {-0.20192381253835118, 0.18990299730185606, 0.3812165720516597, -0.17447504799742242, 0.4850866565061891, 1.0106277542187088, 0.08603291794876067, 0.18374466062691372, 0.4466733767848182, 0.6045798931609918, -0.07819383189328284, 0.048879959553123235, 0.18124483179089343, -0.08666513720202973, 0.6089023075032166, -0.14401040676745952},
    {-0.26530756543662015, -0.32834710652951965, 0.08058283836867228, 0.17123095825018939, -0.565995710682872, -0.6946015384175, 0.09456142934052385, -0.05278690833173503, 0.5396811199722732, -0.4449414392987204, -0.5525679333588674, 0.19142825859667081, -0.49477095820386674, -0.6532471812323517, -0.6950923282749274, -0.4234481757575288},
    {-0.41099822047224543, 0.004621665894740894, -1.3636979084130991, -0.4721951050814032, 0.018981315170575604, 0.06450853379544991, -1.0829063151048688, -0.10779021367699636, -0.03973447074089682, -0.18744816094278846, -0.33538683893873783, -0.6520775500526482, -0.8483027976275043, 0.1027080729044821, -0.4285483898875304, -0.6201856266556154},
    {-0.03667514864297082, -0.12234581781969135, -0.13419287234885952, -0.24419678906150497, 0.18485609002796907, 0.18917898198253608, 0.1432271999778652, 0.36603429008619714, 0.6064865722749714, 0.3595776232645452, 0.2654528123781146, 0.4867226435821981, 0.08997976376677277, -0.4975616132545717, 0.36611875230008134, 0.2548840702798916},
    {-0.2171982770777791, 0.3763645001418176, 0.5208519581743495, 0.2106277490244077, 0.24956672043854292, 0.13989366677642498, 0.5873415128348314, 0.27087344283817916, 0.7379661158750644, 0.09005937132452947, 0.12225842147831395, 0.04055386791987615, 0.3966013541312639, 0.08859886419469563, 0.02471951114069446, -0.32047971874573},
    {-0.03878924267875448, 0.2511490196274107, -0.004964646998217962, 0.5205101261940768, 0.18645882357649277, 0.6940297815843359, 0.09201067113590805, 0.3491282339916241, 0.9362747441234293, 0.51433619305145, -0.1005511240430133, 0.011564106071445366, 0.6863988753357805, 0.12558244265474283, 0.5590008116860564, -0.16776028805765342},
    {0.4503102794834106, 0.5393109002303659, 0.5721539330919246, 0.9279867433380882, 0.915848509733573, 1.2536998021075612, 0.9075414146834865, 0.6780192137637818, 0.8689810149215791, 0.809531755307434, 0.5167465784061859, 0.6992892174705404, 1.132615440733253, 0.44552828950772416, 0.8484899349347341, 0.34249893806501014},
    {0.7584164966007478, 0.6401961241199221, 0.9892668188316268, 0.2775591583558409, 1.0501677980418174, 1.1913916557396806, 0.8564786712142088, 0.8237427220226505, 0.666781150761913, 0.7248930134600211, 0.5761381274436371, 0.9050110691607267, 1.3596741585987902, 0.4533323713724706, 0.788262359832121, 0.2739763744248818},
    {0.9945191698843797, 0.3087064183696681, 0.5531828767868443, 0.4200919424001149, 0.4206812838188886, 0.37748163138334245, 0.20442621691130256, 0.34044094731865465, 0.2145140307759243, 0.3022292277397987, -0.11440631550968303, 0.4566295598270459, 0.6495238607004428, 0.005218079666182807, 0.3354874035711063, 0.08366989862860728},
    {0.005826812138476769, -0.2998621595424206, -0.09593893455354735, 0.7452024566601886, 0.1706821930687381, -0.07250222013714612, 0.20642886911359645, -0.18685006241033078, 0.3814846670825863, 0.2604493241361782, -0.12735180486383768, 0.2086612836686226, 0.7201754920646485, -0.15484690410172552, -0.0714070985870154, -0.14188859944464635},
    {0.129099066298341, 0.14089321746943947, 0.37927299561499783, -0.6292111427032833, 0.21058932010638493, 0.7628747711826566, -0.06882664285334267, 0.35142637584989145, -0.08088373045253867, 0.6079784857412862, 0.1900784102135746, 0.2864386180616135, 0.4582806506459996, -0.05898510537008912, 0.23649471991822196, 0.22753053302818216},
    {0.12876722469501117, 0.29127525255321274, 0.2301522269447057, 0.04941904902513888, 0.6777971868573655, 0.5075434881099282, -0.05455831388685094, -0.0055965797310759185, -0.2429222334451854, 0.6435138345500937, 0.11219213948180407, 0.20440188095852213, 0.27050999581065654, 0.007002721294762274, 0.2493373067582593, -0.27072573360877644},
    {-0.3373340820632804, -0.47384377579478354, -0.4087554067345711, -0.13143026736248756, -0.08116527211954143, -0.13321096845161107, -0.004944816696224782, -0.34128013135814617, -0.11068728155318935, 0.28755694456294273, -0.48297984305457764, 0.5308192654057338, 0.2104706039541186, -0.09947920209153868, -0.5029850382196933, 0.2579401667937965},
    {0.344819609147027, 0.09664320954946669, 0.3120502255627265, 0.8939401555018752, 0.9848320242251966, 1.3901723663093297, 0.5795245985613418, 0.22830759770385975, 0.7248407237854629, 0.9162379152055528, 0.49818887795322236, 0.5062915521145118, 0.6609400723860537, -0.08378861165149065, 0.9524749613472254, 0.08188929391160032},
    {-0.2967942781318651, -0.14451157566313136, 0.3253444835498755, -0.5160904045875142, -0.24770234177598893, 0.0861178154664498, 0.15114332775726555, -0.3310052081028056, -0.18518792707134932, 0.0032847221828758645, 0.16408863153415734, 0.2445558182920091, 0.3072902482883311, -0.8510684285853798, -0.2356764294735315, -0.2413010666320317},
    {0.6106276605996602, 0.602138090492035, -0.10063653837828654, -0.0248650939108861, 0.44357404320664995, -0.0028685589828265877, 0.46240922724440836, 0.8075940841992304, 0.21579790179219707, 0.087166566729394, 0.4118423302310844, 0.4961682653101992, 0.1038709554435536, 0.6411349391117174, 0.08716644669329421, 0.6492658704948667},
    {-0.41261353097721704, 0.35946303497924, -1.0482867141798888, -0.5924554960819797, -0.5823317358953093, -0.7005591658656322, -0.9827756741080114, -0.13879418035826727, -1.2854490246477746, -0.5303598868972759, -0.2140168375015427, -0.8482818851065741, -0.7963915618884954, 0.033862926941092816, -1.0830896730606898, -0.5973561658570175},
    {0.24706291593564209, -0.2878413893089735, -0.18223967557216697, -0.2284431743540984, -0.06484577890213612, -0.047814269449167834, -0.10939869674103796, 0.028105235813624584, 0.019896499050709015, -0.06740939542234124, -0.4601365328286053, -0.0830220521131458, 0.08282601249522538, -0.2635089532361117, -0.02267406104278743, 0.0157020642825832},
    {-0.1432615880537013, 0.5168858555943712, 0.3427261916994469, 0.23879866002352512, 0.4400483121169586, 0.9132301656213153, 0.4367404172253872, 0.5044097321822008, 0.4070396756344463, 0.7188706986769887, 0.4705759908394711, 0.22580779069693915, 0.7487169890312638, 0.47281109695905615, 0.47021403562398867, 0.19273545823900576},
    {0.06042146403259545, -0.3669701476158685, -0.1252468120182631, -0.07169091876204876, -0.6026170534202452, -0.5408405883147479, -0.24575751229360224, -0.19181363288762726, 0.05793855846202465, -0.4106681054387431, -0.3111461138143487, -0.6604600270477863, -0.48729662075919233, -0.14479646440946792, -0.24329986556114694, -0.28243134933515895},
    {0.10550884194303994, 0.20265749558559007, 0.12254782492209043, 0.3403917939677572, 0.5552329355481612, 0.6291338004055584, 0.0047334313692874675, 0.6520651490342368, 0.6779955502934617, 0.23171899471119703, 0.3664427695537481, 0.08650495590606196, 0.4904030252970194, 0.27029901490401814, 0.8254678939137594, 0.21299409600186256},
    {0.13341390576964587, 0.1467492434423142, 0.12059584800733111, -0.17242782758059486, -0.1403948689164276, 0.15369329691069505, -0.09165913309205201, 0.09243979966478635, 0.03887009331183944, -0.08703579853452216, 0.01963982654333258, -0.15377432032450467, 0.18570038838417893, 0.16021678246315776, 0.0720459292890652, -0.06141038924160895},
    {-0.1461970343246392, -0.21599069822754502, -0.3200402528039597, 0.16811279511099372, 0.11451481885464111, 0.05926467625498875, -0.14264568570713243, -0.05568758203348897, 0.05034681217992982, -0.1696143966378662, 0.1223824618731945, -0.27730760740124816, -0.18644193259407382, 0.291753263081227, -0.2520219622918292, 0.07882144345661343},
    {-0.09631761412165309, 0.059452055135357534, -0.1597420231959426, 0.21024466441863224, 0.3204305778121714, 0.3451029750397259, -0.5191766543339118, 0.2675270296839722, -0.31739885187012656, 0.2346636971014489, -0.19442826888549922, -0.4488784579996435, 0.12827892975254807, 0.14155989456277387, 0.16043731509329578, -0.3570307802487223},
    {0.24482369099820858, 0.18840663171237476, 0.16578211208792357, 0.020715981684783773, 0.42616373232462085, 0.8979762519200573, -0.12012547630681651, 0.10034646487664847, -0.5907372126788186, 0.42759309000838414, 0.10686955944623733, -0.022429930573857768, 0.3324069778067811, -0.19980182081324369, 0.7244972239977231, 0.0576496441920583},
    {0.08167391554737698, -0.3353493975304568, 0.40764394386405706, -0.22182288604866202, 0.05974828197348333, 0.34537596203945253, 0.5292557682665416, -0.33351208088012857, -0.005198007905575914, 0.1851422078146154, -0.10543449426099416, 0.23518989122431516, -0.11771721316267887, -0.3075960650891147, -0.23057455879658936, 0.3857197227092199},
    {0.41162529547119403, -0.11656121993778495, 0.7497924957591223, 0.42254083836133643, 0.4434295979586302, 0.21760246278950715, 0.4097791697001098, 0.3899928375212697, 0.7658334258416741, 0.14317415183643087, 0.07184899129699815, 0.2534545411755942, 0.4476149414435164, 0.2928537702938467, 0.7290132652922359, 0.16633207686252466},
    {-0.04749770647249868, -0.48352027707246736, -0.31248099500723453, 0.45690298091317055, -0.1562846485237493, -0.2963300671179054, 0.17513724187913504, 0.207537667985832, -0.38344303616685704, -0.2541391000826617, -0.10123313098287441, -0.1539989829200225, -0.2179227097997218, -0.16613091043412748, -0.13643015464066463, 0.0038934422030878994},
    {-0.3069788685261718, 0.024800669614273744, -0.1261834877713555, -0.3818004265676312, 0.23514804768719672, -0.282779005868028, -0.0014138946410375873, -0.2610395051779696, -0.18042725900691486, -0.030346499436945534, -0.13369681009363477, 0.39576588319317896, -0.07916794649118028, -0.3945613791942139, -0.35357195119199225, -0.05398579981784458},
    {0.5618104927722993, -0.47476699430285113, 0.32240331529420474, 0.08044238008170332, -0.43529141721137493, -0.43702595446593584, 0.15422392643443264, 0.041181457875350276, 0.06279153668336808, -0.5065297676677827, -0.21741564866240695, 0.007696258351079369, -0.30863471524122554, -0.11285303442011076, -0.4795552093402578, -0.149985607298729},
    {0.4866174540792299, -0.09434944417287498, 0.06926559743502883, 0.45459887180399733, 0.24196296620561572, 0.28190353451208167, 0.2973062935360132, 0.2139352980936972, 0.27901552799679796, 0.11319746004783526, 0.3696951814874165, 0.38328987156999944, 0.6083120789507273, 0.2590406095930911, 0.5258953018505795, 0.06514421405241301},
    {-0.045828251880913703, -0.39870088348146865, -0.0830371655325788, -0.10076886541007836, -0.24493351184676687, 0.02719039633224346, -0.4030845061532889, -0.4065487192343343, -0.029740206315856325, -0.2715430493199646, -0.14543624711170913, 0.17571623793101135, -0.01245996837846669, -0.37907924664503273, 0.08308161877759981, -0.06504508994242487},
    {-0.0789476180209745, 0.07498071674210338, 0.5989773139840004, 0.4840559552347388, 0.49435478122648285, 1.0844118969497114, 0.9528825884159882, 0.5078811294542358, 0.24217861900775509, 0.8735779052458958, 0.12156254301704761, 0.645969276982918, 0.7924110051030859, 0.21021038598605854, 0.8136971074994502, 0.4545118619720381},
    {-0.028542685449193417, -0.2997699256783264, -0.08851919225469336, -0.3541133231314834, -0.10779892827915598, -0.17131955158023293, 0.11952597908958855, -0.055683772836977216, 0.05208138194339785, -0.05341521548177917, -0.003305217456404866, 0.014257408548887796, -0.3367363927890586, -0.2581494716965401, -0.2740520047419003, -0.408779061607405},
    {-0.12409526681480047, 0.05698268931344753, 0.4993712421338308, -0.09448734663053532, 0.37130172966239505, 0.09961794108652706, 0.7250180307141423, -0.09004567838543959, 0.32414440034314485, 0.21664569645717102, 0.18773820948676195, 0.5326512865990576, 0.48610538247482604, -0.11299751703373793, 0.1758355094308522, 0.3313817081089228},
    {0.19304197335293724, -0.13984052217488982, 0.09921304672013562, 0.47896492694050896, -0.3025150290962118, -0.10975188695027464, 0.008705755677992364, -0.07158621419366028, -0.07200409530508611, -0.14155022932436304, -0.22167850525523852, 0.09122554869961982, -0.19575943565419143, -0.21372174615440867, -0.12540149055221197, 0.3007354734476552},
    {-0.13868389061560532, -0.06016790401633383, 0.16973618210861793, 0.15607262222523682, -0.3993299889876282, -0.2034420880686898, -0.020578480916092358, -0.2671487573475151, 0.014192869984268537, -0.015691236968270038, -0.014269951014983295, 0.09341614041761478, -0.08483892902662545, 0.06270100328702971, -0.5262569613171882, 0.05243413252788631},
    {0.04448387465502295, 0.04553914763427768, 0.44003682644362263, 0.22502167133362352, 0.2218552660123908, 0.9952007447285159, 0.5425434815196205, 0.007026291357969912, 0.3189619807321771, 0.496617934090211, 0.15153528592073476, 0.3309366719658051, 0.8866234868278456, -0.1476012835025835, 0.25745813734187606, 0.36019078021146383},
    {0.2829598373817778, 0.06975393141094453, 0.11733041930759762, 0.6628592725782934, 0.7897121447598465, 0.5502119154470198, 0.018626289379780506, 0.30094512651914673, 0.9810552438825607, 0.33552025339358993, 0.2823270321671222, 0.5329775835635909, 0.1116722563430308, 0.5419053305551935, 0.4585161585745361, 0.566586173415746},
    {0.22654936221383024, 0.1567458383521496, 0.3725336712324038, 0.1933896349871245, 0.05348515447487263, 0.5656571610055541, -0.35617550147246785, 0.12794166911569296, -0.24322670336137459, 0.44355216996717667, -0.1309053577141871, -0.19903692927263994, -0.14365385397643812, -0.06142705636840809, 0.31108183428889924, 0.16594300546482174},
    {-0.16145892865034844, 0.2585466348026953, -0.350633400348903, -0.03615002126656929, 0.426001849860614, 0.8056804948260075, -0.019842874446460976, 0.1220454620341665, -0.2214462712147846, 0.4328919513083173, 0.3117431542258925, 0.09276357808534953, 0.3855792225093937, 0.2421306680942477, 0.5195559620082046, 0.2660952861621757},
    {-0.18623404856945663, -0.37100890697816796, 0.3484832548365031, -0.26020138701765577, 0.12192335727021161, 0.0708470771856767, 0.11513580264071188, -0.3977143586206759, -0.23757830231840496, -0.006829554062703072, -0.3336498681540857, -0.007672001916798678, 0.18254328248977242, -0.08759082474714568, 0.8715093836419431, 0.3695808033320682},
    {-0.11430558690955304, -0.05859515847333015, -0.0745066021378964, 0.14895626755507355, -0.37844197902169235, 0.3256880878390076, 0.3591798636540068, -0.10615471104851092, 0.16178683301805524, -0.27668474539114096, -0.3057841421586209, -0.37317951040731434, 0.0665154460188678, -0.2530658466545047, 0.04593135095353214, -0.6082186812295892},
    {0.00996445340365233, -0.1002032041260443, 0.03813995005107635, -0.39566548435278653, -0.17175286116218627, -0.1605848676708176, -0.4270423993613454, -0.0003535597832187377, -0.7240186013646804, -0.45698725014560454, -0.17375717131383595, -0.3262128492025255, -0.2236787052699808, -0.25825789965251167, -0.11867452106296006, -0.2217349215364596},
    {-0.23212226560454402, -0.19042188949207295, 0.5566010441951492, -0.24100345958543642, 0.07515721101960365, -0.17799521948918817, 0.09190235125772597, -0.19665960390958442, -0.1321470117023141, -0.34861420680652333, -0.26373568637672645, 0.32082946915648436, -0.08602131266748722, -0.14565505938539905, -0.46184393072811325, 0.1121369580115109},
    {0.8476944132343083, -0.021151076506776938, 1.0156919134217113, 0.7978357076986675, 1.3035699847233562, 1.5981915926001633, 1.482845218495862, -0.7570319475955771, 0.6272560350690753, 1.7382672305859388, 1.3384544943190617, 1.0663058125378486, 0.9194913082828409, -1.0394354332421403, 1.0198323036938475, 1.2402632928343258},
    {0.39751539310014955, -0.1035314179296717, 1.0723351114996804, 1.2402667358194583, 1.2237982127097693, 1.714100303549561, 1.7683640047921443, -0.03458624900888025, 1.0289152293831567, 2.1021673261130434, 0.9678467310788149, 1.2253063446296941, 1.3455816135365841, -1.0837486198728414, 1.1719772750585133, 1.733882992224627},
    {0.0229181757695096, -0.3049521711476918, 1.1611896676943312, -0.98295603181763, 1.1969490453155387, 1.2878824465500613, 1.3187699684988199, -0.3066580091401324, 0.18633656254345796, 1.1079010513715122, 0.168990266393381, 1.3573232937528965, 1.1581777651293481, -0.8847187271350151, 0.9975854515276561, 1.0749789837528119},
    {0.17824034288884152, 0.5145315892605418, 1.6109586772933129, -0.28824267162576717, 1.3046115870919588, 1.769038535785564, 1.457040046978873, 0.3528416167146749, 0.7800042100230082, 1.557874198934822, 0.751587124158427, 1.2552740547576131, 1.3591295548470759, 0.18863313541984927, 1.3275675962081557, 0.8787862429952381},
    {0.1402024943096223, -0.02441175255042969, 0.22401069056617456, -0.583995742700849, 0.3260624422998682, 0.6222746368562192, 0.3455270113782507, -0.22028188345192998, -0.3924017735579785, 0.518001397610001, -0.21398644398212394, 0.28517878297466237, 0.13620387228024447, -0.7427781379798831, 0.2539403855824736, 0.3573534120607553},
    {0.4003898414884721, 0.48260394363872755, 0.6904173320099106, -0.3584224597257498, 0.8543271399725252, 1.424911060196701, 1.0100328381192236, -0.07541396579736596, 0.4249756938504407, 0.5265671290741877, 0.5549389468157983, 1.0581141192141437, 1.1665373188649741, -0.39187362687143923, 1.1527562926432164, 0.4816432469374339},
    {0.3302130312582592, -0.15414479655067356, 0.6068812822976759, -0.1575859911718019, 0.12783529363336515, 0.5097986344550828, 0.8875937870154027, -0.1968880839095954, -0.22969937792536785, 0.08563159561069075, -0.09649955108179453, 0.884884706401427, 0.6224127361323606, -0.516602898827927, 0.5646619478207267, 0.18262403636820093},
    {-0.542962995270287, -0.573968345876562, -0.31776699846769296, -1.1584823419984354, -0.8054562019220677, -0.8158934304281525, -0.17080039143435624, -0.45984611080266863, -0.13188812748489315, -0.5011710710644541, -0.2246834549253394, -0.29949151658482664, -0.4473149841501066, -0.861784213563377, -1.2399648545438553, -0.6620243155041747},
    {-0.04583669210826404, 0.01601267105823656, -0.42344793008555004, -0.33379608337018646, 0.24973785047129385, 0.08853647738470748, 0.4286332900079915, -0.22622762767131024, -0.5762841970256188, 0.5982444462117688, 0.01824486286844285, 0.2960122901876395, 0.3387778600603861, -0.2610385334571296, -0.22228291985731274, 0.2253850171281695},
    {0.14598703908842145, 0.2778536997539658, 0.10287814225382129, 0.3820768689977868, 0.4370432880865682, 0.5449014546240969, 0.10527757768989077, 0.16432332934626237, -0.027872929797899768, 0.5118079367511857, 0.2729913944895869, -0.16112753690997525, 0.41895231934172145, 0.1561611198047682, 0.08346001066014758, 0.21190161926943826},
    {-0.683388721823123, -0.576849247475829, -0.31289666243679337, -0.2656679459130409, -0.12688289740458256, -0.10372367760922742, -0.2693773917482444, -0.751876627229036, -0.2788733372867201, -0.07188873353124371, -0.2517318661797844, -0.32994491207540944, -0.9971185738319454, -0.5102094137453885, -0.3562602544219237, -0.4683730207785584},
    {0.4488029598360782, -0.201554187503595, 0.9532867944356455, 0.6280778376679803, 0.5428115278895339, 0.5085063248432451, 0.9395410073927211, 0.00031936796614013207, 0.3067326261329977, 0.41503616186607123, 0.07547223716105744, 1.029605565068426, 0.8778338745833327, -0.08955929094883014, 0.4404219452738701, 0.5908074174387807},
    {-0.1292279317799613, -0.06470510830587355, 0.09477958756337096, -0.01987881505283788, 0.3270031860395635, 0.3070717067448961, 0.2231932162355979, -0.0006084572625048438, -0.2620949949182519, 0.15708821544761725, 0.330879525223759, 0.2285445413387113, -0.1581271118929456, 0.2602126333983366, -0.20247895971601493, 0.40194149307896526},
    {0.029103480484328974, -0.5129629871852944, 0.2936228783266347, -0.05370705883732852, -0.19226577135799086, 0.18158124429145586, 0.5105543457750047, -0.41650399339865135, -0.12326925784927731, -0.03376152720290145, -0.17018432242465945, 0.5836164992296111, 0.022606734384079282, -0.7816871635795009, -0.01985583291968158, 0.3242207662216791},
    {0.08575775471505706, -0.44906330933779826, -0.16363921464023734, -0.08717119364074655, -0.09038812429139009, 0.4591381405000321, 0.03058363679138914, -0.6584732045931108, -0.2344575998652732, -0.11036204431442717, -0.47738678525766004, 0.36283277951769094, 0.1920369701416573, -1.061836730856584, 0.11617260415034798, -0.12336143831427925},
    {-0.05450971772981339, -0.1337418436108412, 0.10388286539702046, 0.021437596928795988, 0.1341602946825903, 0.7388852134879761, 0.5765247782821591, -0.25185087580012266, -0.11088719385119515, 0.5401812082764232, 0.28087327448166033, -0.29341378309434457, 0.09597844620872073, 0.039698739409310554, 0.3300373927048827, 0.32843049552912995},
    {0.3275278181354287, -0.43608231072114967, -0.30765650153541846, 0.18685694096313746, -0.2987640926690169, -0.1499316021012674, 0.1607267068458672, -0.08080989822070034, -0.07396637661521119, 0.0844296505320813, -0.11386025951951287, 0.07969247435610398, -0.150061988243353, -0.0458797529500403, -0.15646134607325832, 0.32710454200812017},
    {-0.1693418480322753, -0.3950023296707278, -0.8181168479231316, -0.41569991476270063, -0.18863219423595665, -0.6004762432672737, -0.8462286633292178, -0.3385879439765168, -0.6947798912723282, -0.11042198207089259, -0.4272336628243752, -0.41117064267050213, -0.802406750769914, -0.45356759117028883, -0.8502778577389388, -0.35271403809330454},
    {0.0807581543878143, 0.3655546990634142, 0.07249172151859856, -0.1580179972196199, 0.4325180201896872, 0.9643080721473031, 0.1292229343015832, -0.06119393300345186, 0.08412560178043758, 0.7794257343812753, 0.5612518763415266, -0.14008722408455637, 0.41492322981271407, -0.03700132694588883, 0.7034619928003111, 0.28361508419300746},
    {-0.04378545605035913, 0.23255368675158744, 0.026520294101309887, -0.22985550626432086, 0.1751752786679367, 0.1507632029318057, -0.16836256934633329, -0.167560119562988, 0.34942668972333607, 0.010555863157513055, 0.026938122721921694, 0.02391823298049287, -0.00016201264011416513, -0.2985165414749082, 0.36942529769763616, 0.2807696688236331},
    {-0.20792072072332526, 0.29866763065005336, -0.20420842326943578, 0.6389154478649426, 1.0125786665252394, 1.2569390247866605, 0.4015603778554223, 0.5069777916936442, 1.0378096948831406, 0.7105687371363136, 0.7265126714413034, 0.4367647993524706, 0.8360722709178859, 0.4905473717407306, 0.9591802859388132, 0.6978675390091473},
    {0.08643788261102058, -0.4339897806359114, 0.41979776352853687, 0.6494125929435011, 0.21104775653268393, 0.3968357527495371, 1.219027553302958, -0.2321958153972118, 0.4085923845355283, 0.22252438725007917, 0.10795665695022502, 0.7339453930670345, 0.45358304394453575, 0.17713967026570535, 0.6249722468722567, 0.688844707362752},
    {-0.1738382461076464, -0.04068937547417141, 0.3571622890019921, 0.3180628438891903, 0.5856441182450864, 0.9311396757617307, 0.4840067050642905, 0.07858140219325511, 0.5545667435853574, 0.4732955325214443, 0.12424739777908546, -0.00913145405022103, 0.6381602958718652, 0.25720474970391766, 0.810998829194272, 0.0051539997146268154},
    {0.1478597730892814, 0.15030010192456944, 0.4935781167124377, 0.5442303199464763, 0.8423814343212603, 0.9116357974638254, 0.4994468649730875, 0.4278827136265521, 0.22174158678451772, 0.7084698982111937, 0.3541384412515717, 0.5464961033212049, 0.6787916919892063, 0.4797531218314741, 0.7208743790643225, 0.41927263376243773},
    {0.17650530627347802, 0.07443581144030567, -0.00019587277092855427, 0.1742037417055344, 0.6219224801781715, 0.7313164024141677, -0.024439277494278832, 0.15483450391244316, 0.1754288598301134, 0.34392550399218264, 0.34713707923344483, 0.7850377826824622, 0.8743441843310591, -0.33042543245446365, 0.7972408614458808, 0.34912127069815524},
    {0.03694878953704264, 0.15827552293676111, 0.29496890599201353, -0.36911823294015417, 0.45923733555415863, 0.8730610416956035, -0.2445221277649769, 0.2747073127758817, -0.4662041388638846, 0.5565189767673542, 0.36495277394236453, 0.14523786190711074, 0.5738209542003027, 0.22633804697122256, 0.05678145407358939, 0.3923555429696435},
    {0.16776275666074966, -0.07031507850587397, 0.7450983312989006, 0.16177144372985425, 0.7238562226635546, 0.6979268414272496, 0.6726058144667557, 0.13391441655785774, -0.2097873261291572, 0.7424241234872424, 0.2173356595926437, 0.28750943198859136, 0.292974433194802, 0.14298353165410965, 0.503215245374251, 0.479983105389842},
    {-0.6538281110403734, -0.6106175565392746, -0.33270203947930393, -0.3949753358112975, -0.04613400677273557, -0.18671845365918707, 0.04309302108453211, -0.42475511224047396, -0.05607390468021211, 0.3255161666932715, -0.48492215555241935, 0.8707252140485389, 0.0311897724688354, -0.5853858225948346, -0.42095026278801817, 0.18148607455172386},
    {0.040590984966731115, 0.016611742116347347, -0.21355405752560175, 0.7430706588692999, 0.22557428788660935, 0.8918506204827706, 0.1260869197667322, -0.12582684005146091, 0.411401124240928, 0.2901666561412272, 0.08889508471199263, 0.7123960318199587, 0.7011965022786978, 0.3537526003425793, 0.5920887429852185, 0.24712564333055664},
    {0.3035278243350417, 0.2941234942957014, -0.03455468014030092, -0.5354175092137222, -0.19739270587004862, 0.44460698656144554, 0.15206434195156185, 0.06420649520625206, -0.06945045833149688, 0.2350977268768098, -0.0076510750818456, -0.024615830787614576, 0.5654312125911357, -0.63241121074781, 0.2690942765085954, -0.20804828928003427}
};

static const float b1[16] = {1.879716229294356, 2.21065264307293, 2.5243703682930114, 2.160393159495708, 2.110684023536785, 2.1345344188063713, 2.3238749393308122, 2.3941520986973663, 2.746339480852878, 2.3385991839904183, 2.8801735898862812, 2.2587414881326926, 2.3466005346248733, 2.071762665262219, 2.056053012492274, 2.5162582268891196};

static const float w2[16][12] = {
    {0.030349970707884887, -0.4716696724892761, -1.2570844445994933, -1.9718342594214953, -1.4449387256899775, -0.5080308833779128, -1.5761156072769096, -1.7401480819923871, -1.8798371631717075, -1.271280641682186, -1.5775811722392754, -1.577599488620068},
    {-1.240265830335902, -2.3034674265540827, -2.018029174026485, -0.9256670483492281, 0.06871606193157341, -0.9279446330670115, -2.357390100937818, -0.39882463443158306, -1.4475481365185316, -1.6150653201203762, -1.8656419402724156, -1.6527701064813092},
    {-1.6469872966980201, -1.2118592170515634, -0.4621821373541401, -1.7355386091033977, -1.3783515970273097, -1.6928979620894624, -1.0952409637495197, -1.8676797400343361, -1.0200326565361584, -1.7410243817579067, -1.4000901785746074, -1.6056364394581466},
    {-1.5789413641426462, -1.4080102652830766, -1.0195507666547865, -1.4932983856633042, -0.9160665688130074, -0.7470642162801386, -0.977104785390148, -1.0207590203992016, -1.0845560055229657, -1.2723335307842032, -1.3368563247775493, -1.370864241102498},
    {-1.2929178425067798, -1.8763671518176406, -1.4125274027163564, -2.892169327047891, -1.6609566698104539, -1.3207258558250239, -0.611272676355469, -0.022237941755878975, -1.7365963067999217, -1.4608352930239499, -1.4558088465465402, -0.8214047127399436},
    {-0.7713260292165068, -1.2900855291320685, -1.568812473067368, -1.3582593924490862, -1.4953448440980595, -2.1853948917810393, -1.7326426991098953, -2.9279059336753277, -1.7890944808256735, -1.7019865321771368, -1.1373190336475538, -2.409198428660989},
    {-1.3792599406485628, -1.3059833403074323, -2.5856124963861222, -1.3094182755146107, -1.226388092059865, -0.9520696531818655, -1.321354827812848, -0.8812994511354271, -1.5710940738312855, -1.4104010313070507, -2.273167854790099, -1.4765178992800176},
    {-1.9444323215827353, -2.0966173256687655, -2.131962998535207, -0.3759595615220351, -1.2409840559951164, -0.8311981250232318, 0.11306473345823319, -1.8500104566970372, -2.0672855687802985, -2.334143201366558, -1.6885690691978144, -0.11598473552990486},
    {-0.8020770599551538, -1.5495339955686405, -1.3272838107685345, -1.3382068519461816, -0.8216889528953976, -1.8842273337249644, -1.9730124720574713, -2.4823819538903864, -0.5959293841625193, -1.3811469989272056, -1.3533875857153992, -0.39099979386010747},
    {-2.3895713311839337, -1.3616992074387544, -1.7019255912122766, -1.5594632897665315, -1.6873916089474763, -0.5087456523930461, -2.2842405558766816, -2.2955320790016827, -0.9740723219842964, -1.7935413135327585, -1.7320556530609037, -0.7093901045676976},
    {-2.066766583333443, 0.25523241324752904, -0.9754995053816582, -2.428555931083415, -2.0024830164961536, -0.8869298772063738, -0.5195545304878997, -2.055594613948337, -1.9298747067425928, -1.4130819177997809, -0.8450142996397962, -2.6145443811150084},
    {-1.7867051084605563, -1.8510628823149522, -0.6049965255406297, -1.8473468078400976, -0.8938003819348462, -1.679504078663503, -1.5497561143144014, -0.8781461262333607, -1.8032799518530416, -1.2746342849125911, -1.2092742646251742, -1.3429191393404736},
    {-1.159270411546712, -1.9312818446610671, -1.5712422676829298, -1.792460487040594, -1.952701534864149, -1.765660693230926, -1.1683025120532766, -1.6084613343426986, -1.151935002712083, -0.47860867575665744, -2.33744608601601, -1.9541700805716309},
    {-0.9900060443071745, -1.0790294037336725, -0.862904696077833, -1.043371396893457, -1.42876403463586, -2.092403800059911, -1.1454234549776572, -0.8167924431971046, -1.7230763316552893, 0.24669789873467296, -0.5410599885491528, -1.4377135548757756},
    {-2.1030196485024404, -1.9638541253748882, -1.5608087992285482, -0.7231047172148777, -1.5888704556799287, -1.7694581530513231, -2.306719495057038, -0.5056914516365898, -2.1360413350057543, -1.9386218306709508, -1.0841662341172444, -0.9234876489791342},
    {-1.0676835470472519, -0.9762903551072264, -2.1232359170065807, -0.2356397152970043, -1.6679841067207546, -1.8199549563770345, -1.5904085024883683, -1.7806485999908181, -1.0035995219130769, -1.5585386720336898, -0.5175675755804405, -2.3010756548552367}
};

static const float b2[12] = {-1.3677595168567431, -0.901588917256161, -0.6328515718687954, -1.1645148277439115, -0.735899454856413, -0.738615544530308, -0.7179661570990586, -1.1580542961895797, -0.8578328421281732, -0.4500152005215051, -0.6707949089621664, -0.7498557840000465};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
