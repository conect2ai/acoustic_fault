#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5591509634848734, 1.0113150993111348, -0.6774939815021355, -1.0092970807741695, -1.1906355550661998, 0.8332065522364562, -0.6650897345574744, -0.36559586164085955, 0.8391408516034707, -0.15552762391696287, -0.9428705498363487, -0.3053986834825228, 0.42039480425403, -0.0716288404964192, -0.24051039923067, -0.9377082087312946, 1.3914062489240393, -1.3016737224565444, 0.5401350775940132, 0.29079510581774465, -0.19750210875487276, 0.4225930984424292, -0.11097771501578818, 0.8675470189773203, -0.36359877641830446, 0.35864862094531164, 1.024701470155967, 0.9445673028286025, -0.10050756809961381, 1.3370784063340309, -0.9933163271364414, -0.3310635446672299, 0.8839232310484891, 0.46100939896122434, -0.39471645568281466, -0.6921712145939753, 1.1141294359271454, -0.23995843350972418, 0.40024053800332116, -0.608570062870261, -0.6346665173247759, 0.17139332443892016, 1.0724717187795438, 1.4039752449836664, 0.966434237338124, -0.9600998549231652, -0.41739515123831644, 0.22368994022401123, 1.2499789962688543, -0.3758121606468137, 1.2417103351985805, -0.756373645605874, 0.8080970764770252, -0.46389572401103196, -0.09105828516249186, 0.08823100584056986, -0.19978959895277892, -0.3808920466742469, -0.6593541720684519, -1.0314150446390211, -0.2080181528586478, 0.37357497096817777, -0.6646768155435979, -0.3208814039283669},
    {-0.6262008519947088, 0.5683511631665538, 0.5435814889939948, -0.3025292187040354, -0.22086103655310235, -0.4967503022132201, -0.22473542522863468, 0.07120488392017953, 0.901519687459428, 0.2736900793096727, 0.3153919647293391, 0.8170630483458335, -0.6134579734441171, -1.4262071956002391, -1.0136104823223382, 0.46000406914830694, 1.2339137290540616, -0.5052799750862267, 0.12095211624523984, -0.7229939984004502, -0.4407818855121315, 0.07290516571568036, 0.2506664696196012, -0.9721926476856011, -1.1243643821674694, -0.07814787066159071, -0.2772304942703489, 0.7776942305162041, 0.9034799343521257, -0.22151614751588916, 0.7410420305448295, 0.8779817533846137, 0.9333205617390004, -0.9783163073073672, -0.5018494329979674, -0.6906103983867001, 0.39638265356038865, -0.743019608372091, 0.8373091620895547, 0.21221555410080245, -0.10160090792657941, 0.6591248442804586, -0.15422556171373814, 0.2123953543416578, -0.3300285818465109, 0.3247249963371593, -1.0585734744580646, -0.7371011589393429, 0.4689181499330331, -0.14763497956464128, 0.6838341845715644, -1.1770841469024895, 0.15507727483918893, 0.513010977334901, 1.1641614647115914, 0.9265826218826267, 1.173003937327255, 1.3072993027240483, 1.178561765891714, 0.6529624842494347, 0.7734055281840363, 0.2104194102363875, 0.2532421562535643, 1.000290749059411},
    {0.015427381762651111, -0.04487771588002711, 0.6537056165284262, 0.7657055957080275, -0.04018345134798562, 0.03921990407289053, 1.0339083393854132, -0.3492928156547932, 1.3189374069943283, 0.797317459493603, -0.10808743521759215, 0.3760618058519465, -0.22420885777055294, -0.0803744043234783, -0.2261872495378491, 0.8265700805560481, 1.437720112188759, 0.5548548483010557, -0.3753125954098992, 0.022650110073917717, -0.13730309862955797, -1.074545816207059, 0.4707814486931589, -0.457123704378843, 0.219638977962565, -0.6809916685246278, 0.7197244415840768, -0.696348925312065, 0.23817281452772188, 0.36276113487038303, -0.773500123687125, -0.2775703182733663, -0.7497504619141906, -0.3856957083342234, 0.9884737684976936, -0.06506413310312324, -0.1665626660365756, -0.16534992545230584, 0.9718470276025041, -0.342532334533241, -0.16305302947034034, -0.9268543721306816, 0.9276032518710436, 0.8169383158204729, 0.36079835691228435, 0.7946177760784262, -1.0729053602057657, -0.6138231656191354, 0.7585183268621961, -0.7087030458055809, 1.2410136890188013, -1.2087033412671946, 0.039536550811597335, -0.5822238071792432, -0.2881761100914657, -0.5063870787934297, -0.09551895171200651, 0.17709956956141462, 0.5309235833357149, -1.0472952183647253, -0.5133633564757805, -0.3352052034569762, -1.2396778568016116, -0.1284839132324167},
    {-0.4890509436482686, 0.4408027829724209, 0.6328855522482905, 0.5843656682737666, 0.4455765799446742, 0.4111744869243203, -0.509835221569127, 0.2037340252624972, 0.7767848430724431, 0.898777987717554, 0.025325592798404153, -0.17092199629697133, 0.188558848462114, -0.9529127840317465, -0.33712455845461103, -0.9374400826150281, 1.5853308797335885, 0.21592289004075255, 0.05749955488595761, -0.47472399865100795, 0.41602478288502326, -0.9716722398897396, -0.3170598433322297, -0.736696646839951, -0.804686175553546, -0.757888052695448, -0.7953782531729092, -0.8931556593758253, -1.1398269946892776, 0.2359668046630908, -0.6965357176103548, -0.04752527985416296, -0.7142501616674, -1.1414080831426274, -0.16886898987610088, 0.15159103153765374, 0.3316101517168843, -0.9346820679516554, -0.11200077461117387, -0.030708524782020595, -1.4016464616532047, -1.3341820855907693, 0.09329621023968827, 0.2677259737743577, -0.9276508432677673, -0.25480184841803455, -0.9213016924006828, -0.593185346597753, 0.5216056344379347, -1.0181138586591905, 0.19408860265145794, -0.74961023780553, -0.8209756767969363, 0.5676765604118476, 0.16039106049062554, -0.930785113964748, 0.23894637321825465, 0.14768531918534888, -0.7215200169201217, -0.7326462417381103, -0.5637417012146676, 0.9463102492535715, -0.9434502805427467, 1.5657944734944156},
    {-0.6818664502004554, 0.9278399011917436, -0.8223890192350984, -0.9957509524123771, -0.5249363222611788, 0.5360816954229674, -0.7177515406994406, -1.1384144979534123, -0.5989185142773779, 0.8354579375916011, 0.39078171139979573, -0.1596704369424918, -0.27265315973330695, 0.21609538297849892, -0.02831093592519554, -1.4115165778587389, 0.8292123862467082, -1.4412333043678496, -1.0445407092942243, 0.43853377641454233, 0.2979512227471842, -0.7758695635865439, -0.07431316316962272, -0.5431769615083966, -1.5542942433985163, 0.7363618056147406, -0.8280182767527922, 0.6883850571657439, -0.2546223241857651, -0.18452449587969835, 0.5573375791016796, -1.4763716126534336, 0.1387897971482892, 0.18972572283071318, -0.09766208240493258, -0.7049240015467861, 0.020082208827702692, -1.5046979325682968, 0.2237676501411631, 0.5028353450981383, -1.194987636019571, -0.01759384768224405, -0.3710920630017733, -0.06148401604204391, -0.04678651581660992, 0.19851269964897297, 0.061336103910051724, 0.3178987982039587, -0.6056039033700165, 0.6858027106985944, 1.1977790414862832, -1.148443091784357, 0.7332766183344733, 0.693204561926587, 0.4666675313642916, -1.2597488143662254, 0.9946551195774471, -0.7376321629875481, 0.13804134124814968, -0.7564405228191575, -0.2749296244499821, -0.2002752303143555, -1.641599273027192, 0.10037350914928617},
    {-0.009954361283555686, -0.09369821492326691, 0.0648415072718721, 0.25683573131204335, -0.20424185897805863, 0.7914848396812623, -0.6600241696847456, -0.5550453788934723, 0.2611147738061091, 0.23633989360211122, -0.5012622912194751, -0.5961165687800845, -1.1084702325145468, -0.6525316182283335, -1.2379928047947204, -0.7325376876673807, 0.2332317288115115, -1.0101549286886893, 0.15509337886713276, 0.256864031534088, -1.0017800289621073, -0.7845008150806295, 0.4828626982090893, -0.8007513945390591, -1.1297534583931497, -0.4438319166542274, -0.45776795598701353, 0.39702337118842396, -0.6210341299312818, 1.098879694568195, 0.16734921897239688, -0.9216812735642989, -0.43330520206858203, -0.5485990822016441, -0.03318073105307245, -0.8236527644715343, 1.0695779699393848, -0.0008395224303372465, -0.8687801563427374, -0.5242542458069396, -1.5633670045547612, -0.775298576079172, -0.08018270450529488, -0.14093261145688676, -1.447432997277142, -0.3749862306891556, 0.04382808429396313, 0.2858526157500334, 0.7904105751681256, -0.4479461094538274, 0.6060050903992517, -0.1198693246446833, -0.08616700203111886, 0.48342286063287826, 0.7915805583006177, 0.11679031732553942, 0.4206653626637462, 0.3908926074800588, -0.1658597708569779, 0.11606980916686813, -0.7106574272419529, 0.665077230137514, -1.5628981321966011, 1.1634393296496697},
    {0.6358394317006613, 0.33879007689320445, -0.11884613427434838, -0.3069247477553621, -1.4357296940534758, 1.020091024183308, -0.6910742079400687, 0.3921484104721381, 1.0415186453358332, 0.8327027209152059, -0.9677770597628172, -0.2767342451000806, -0.36783400834173596, -1.1786114381382728, -1.3495500059844474, -0.8344316593481429, -0.05126328991331694, 0.010597727036536103, -1.3685291171190541, -0.3421383728522513, 0.41521842402181214, 0.07582497716943287, 0.8706562071410472, -1.097376150995606, -0.06146760897697525, -0.41752864147360014, 0.7151349539468768, -0.28363087096925327, 0.24616030397614905, -0.786281304629763, 0.16838028742983727, -1.3490515929015692, -0.066229733840666, -0.33119011778251667, 1.0332108219421512, 0.07862630328191124, 0.9451430567258484, -1.6861330722000474, -1.337117106043318, -1.241737026709791, 0.17066315856733016, 0.3808669710743096, -0.24775564633821365, -0.4075100739871839, -0.9837290924297487, 0.21773196644729348, -1.3973548370723035, 0.805902238970848, -0.23224432518112503, 0.43965594866627195, 0.5899376275372055, -0.8213943371638098, -0.1807389768488724, 0.8230715986562173, -0.6951375889111415, -0.36647278907310366, 0.8113760703498906, 0.5786438691431486, -0.3116305764429122, 0.3340888879130274, 0.01573974254585066, 0.7076311851262247, 0.05759454249349351, 1.216394736787043},
    {1.046084546019572, 0.6542497568919997, -0.7509005425830519, -0.0371034797024042, -1.443581979617415, -0.6755221517351078, 0.4299756379285373, -1.2105450900533063, -0.06028354810034899, -0.046596671045193536, 0.20142654870253282, 0.28390741876137454, -0.8596191304505405, -1.5291720847976777, -0.06345407873337398, 0.13835057115326463, 0.7196587083588222, -1.0030287418670083, 0.5580601599682967, 0.36848695505727963, -0.43286796359926033, 0.4553291997620391, -0.607489777558323, -0.5271311119367026, -0.840777582871982, -0.9178190069284043, -0.15194211269086702, 0.9731063377942003, -1.0844076179605657, 0.02781835479578171, -0.6685481058323531, -0.2619855614304663, 0.10884501505146282, -0.7471042837167742, -0.10719681353634362, 0.10415772751609716, 0.16456853799421242, -0.971190226254757, -1.0198324996723491, -0.25524545885525474, -1.3646800358925752, -1.323628195795574, -1.2573566307296664, -0.2573180026487266, -1.2461539839343876, 0.6066867082876848, -0.47529653094587543, 0.6474483425438333, 0.025569989691828023, 0.634463358641585, -0.7618905921040952, 0.24537211604951867, 0.19649874581118454, 0.6730852406831997, -1.1943307151661147, -0.9410945502547465, 0.35289056340182334, 0.017606067670530454, -0.838438077109631, 0.25167136506188825, -0.8912244827085023, -0.5569517975218988, -0.8920246304484843, 1.329798835350513},
    {0.3513676438066308, 0.22744360762308372, -0.02906762297854572, -0.6654692425367756, -0.9994579241644382, 1.1213653077844574, -0.8920725051652912, -0.22502735041389507, -0.36385213187182525, -0.5695924615373082, 0.18269130320441823, 0.5864855032794731, 0.6603727670268983, 0.190261774135692, -0.09569070857305287, -0.7465240704749756, 0.17855146594079527, -0.037650954239518065, 0.3241985153648965, -0.9130071459344957, -0.5803828923928955, -1.2057110521837107, 0.06999028480739343, 0.19481452733433793, -0.4755251911108336, -0.022613615562897635, -0.9972387736872292, -0.3804589846226162, -1.0332263129077006, -0.34660343884802686, -0.9496827325991603, -0.38462738203818797, -0.022756034253380745, 0.07067959018401279, 0.6457381175255513, 0.16182173943263167, 0.7232494068815596, -0.20755455879433193, 0.04958937395377237, -1.3804165177287842, -1.2021173893494943, -0.39366777828576377, -1.505330434785622, -0.06522249821062345, -1.4361727137613907, -0.20093460132961086, -0.46477379910628785, 0.8558924095188121, -0.5076547685390932, 0.6132719050125893, -0.1317849323946961, -1.3141627320583087, 0.36619412537602913, 0.32122034368261043, 0.24342331381001867, -0.9502321226768181, 0.19919080312171, 1.042138618753069, 0.2536572513881908, 0.8026518934085254, -0.1922345167264777, 0.4386712749128309, -0.04308403127268548, -0.0016823820366706256},
    {-0.029754519310735285, 1.24307091517862, -0.061522806743728814, 0.5325969063369157, -0.8558185739933972, 1.097331991878002, -0.015062055625642534, -0.008408957485260328, 1.0618729196753547, -0.8201541472783894, -1.0706863694164765, 0.16866856188260346, -1.1009925840730823, -1.6436163955263072, -0.7294345757730053, 0.28917480556687275, 1.3578924554960714, -1.3329310397330072, -0.6856157384341374, -0.4653440725916867, -0.020456956558314553, 0.10173536754985488, 0.3460102039274232, 0.38609303685000723, -1.0805655782068593, -0.2512347852658246, -1.0884181939834188, 0.8357708295643044, 0.09672029103919272, 1.0670273167936513, -0.2817988275855038, 0.460783845362898, -0.5848089079429389, -1.5971529746424713, 0.4365734481091777, -0.6884107646710426, 0.7629580959917125, 0.28659951834652775, -0.728473413737309, 0.445841637702278, 0.2852641071519991, -1.0649478586738454, -0.17801819816897002, -0.3772981233587693, -1.3247457100041702, 0.5875815284271567, -0.20225442842779068, -0.07145961813074662, 0.9584784757433494, -0.6085535676224253, 0.674011177749737, -1.0018123478423617, 0.5808652830431743, -0.3264330966892471, -0.2770574327900706, 0.012219946840683622, 0.4889890648428835, 1.1731324041523523, 0.18358092024729242, -0.19083686005118453, -0.8721871879901758, -0.5066968194074747, -0.724752792137901, 1.1075795299086286},
    {0.2902121427357531, 0.2937463540530211, 0.5656400730540765, -0.17463177639837119, 0.5085091559225602, -0.11084615989441621, -0.74614258887163, 0.4279133767140214, 1.0546679965197998, -1.2135981133404876, -1.1396732578038298, 0.31520770828605055, 0.24779815892018647, -1.4825639272946105, -0.289356713576209, -0.9252959383889047, 0.6403125844512007, -1.444946849236982, -0.23004294234579198, 0.724393863977879, -1.0500197953382557, 0.5173607575382208, 0.5949637049168369, -0.42883267889934146, -0.15095069911985592, -0.17084140082958943, -0.35325263721853856, 0.07599731321458962, -1.06625723843919, 0.8756884611971816, -1.1317118554130914, -0.06773094808034473, 0.8634830539854058, 0.2902275626927985, 0.7250983432500842, -0.2736671409972559, 1.1473984732060891, -0.569642184070865, -0.07437935780273854, -0.8577902670066663, -1.5070012214492696, -0.552653516441429, 0.15146357948598163, -0.7226735527908935, -0.6050521814173528, -0.7212388007014692, -1.3843736054341673, 0.6899473585065063, 0.41474102725310896, 0.4390073019078832, 0.04104569185969065, 0.32124607594023175, -0.7553209742224698, 0.5165718162029004, -0.7961846305059889, -0.11436375410148081, -0.8576118977844897, -0.11207817679003627, 1.03869481209434, 0.34701985225233223, 0.4217773504210904, 0.7664492424976966, -0.6283395957958289, 0.003229516935886611},
    {0.6729931424621459, -0.6721178709222257, -0.21475924658233933, 0.2541961153477268, -0.5787902910332164, 0.7168759299295921, -0.8960775048712094, -1.0355475018912645, 1.1226454161948356, -1.1593870362152792, -0.06818566460502366, 0.8279746960993574, -0.3326165498888634, -0.5907573859958656, 0.07733598785634059, 0.05222669759585061, -0.3305913093506261, -1.4564032055546596, -0.5514739717194136, -0.24980187277328045, -1.0944990908464725, 0.04971297358497751, 0.7388060462259693, -0.10276395265950272, -1.276116769093188, -0.40247983035649587, -0.046119314702421255, 0.6900939832118888, 0.23764789555397467, 0.9882479954667981, -0.7350101517680051, -0.1961606515174037, -0.6530499686931553, -1.6627822042928897, 0.7575969536366395, -1.3140045374831975, -0.5073562913027199, -1.496952430597138, 0.4366318342616415, -1.3045877914628041, 0.209783081345477, -1.2951710350944239, -1.3940675958712008, -0.12095434297129277, -0.29764539161849635, -0.019494366900615713, -1.5324321137311838, -0.6685590316755939, -0.7911592134904996, 0.1399431322110933, 0.15138889376415696, -0.7977486104775321, -1.060902579239043, 0.6743094079612191, -0.9200287507806728, 0.07239291433533304, 0.9895334317908178, -0.12446434671180878, 1.0030558757753745, 0.37389356972893806, 0.2679480767196226, -1.0486416993982803, -0.1385980301016946, -0.7255366646579169},
    {-0.3022318594375898, 0.556915479143401, -0.07708120680275213, 0.5082834269086436, -1.45053959492956, 0.37898367255673693, -0.4691822137117562, -0.35242749051511757, 1.1019518433003157, -0.1944318812182079, -0.8357552632724022, 0.317900216666925, -1.0127621638907245, -1.3951891423435039, 0.0577609625038944, -0.2202692552167235, 0.31423580698791237, -1.622146679927544, 0.284368630817892, 0.7782677182662695, 0.19677428488855708, -0.9003143332153664, 0.133616402964452, -0.1645593640265936, -0.6679147153508115, -0.8375943302160348, -0.8423798879366993, 0.40031605992249547, 0.5042776133308287, 0.7898540187780192, -1.371660164398628, 0.2663670252809311, 0.996431956398394, -1.1830275104210748, -0.6848529057226224, -0.2799395470329206, 0.11327357317792644, -0.9181472800332035, -1.3429433680792606, 0.1076692142507928, -0.8097515980533402, -0.011825494896098066, 0.14194401137522367, 0.5461832126367488, -1.0919377071616265, -0.4636417904091552, -0.33975475510925685, 0.10129006228734741, 0.45277673695591764, 0.549416345437039, -0.8624254028805448, -0.8871013395293065, 0.09677635023687262, 0.3025726218282333, -1.1977249342863039, -0.6814373689834059, 0.4702434866675698, -0.03556605517571354, 0.25165433629165, -0.3683694356824308, 0.24951231165180193, 0.44938691198630404, -1.5009390943990604, 0.8319417084127702},
    {-0.616613557169961, 0.5890159849735488, -0.02431410151359415, 0.3851779035575114, 0.3965803553348517, 0.06351228100063078, 0.5948234172580747, -0.17569924235135614, 1.24685754927284, -0.6795498227179114, -0.2832906382972516, 0.8315460823353579, 0.8859732811397412, -0.42371875340150555, -0.48720851978318797, -1.4321364360827056, 0.4833784953684638, -0.6738023990931803, -0.2514370896179719, -0.15281478712049135, -0.4681253950888437, 0.06287180912420424, 0.6793135959875294, 0.3471571245871811, -1.0086122222344307, -0.8173998399359287, 0.4164674694478949, 1.0389951246821083, -0.9236912776165856, -0.5496244162264231, 0.03917754350612756, 0.13920352596017063, -0.3424574699087084, -1.501199131546311, 0.3498954313331564, -0.06362509028588899, 0.996047219325883, -0.9113365821391761, -0.5572514787525772, -0.03780380338806554, -0.07576768634315233, -0.397726866737357, -1.0268048654479853, 0.3919619840292828, -0.6274308043859212, -1.2944465940232375, -0.11124567676811366, -0.7825943824673797, 0.798255325508765, 0.34431000508907705, 0.8933604049935534, -1.6522680102313871, -1.4523433568420023, -0.6712568061910292, 0.5903176292808785, -1.0051105082789524, 0.5132180596084619, 0.9154149682403313, 1.1887254988126126, -0.621916070066731, -0.21436644658116172, 0.46943712161864937, -0.10242786403836085, -0.13326717243496844},
    {0.7977793489629649, 0.4231442748863915, -0.519673355918205, 0.04982070964281498, -1.118357240823964, 0.07552000077442132, 1.075209744560361, 0.2156005839945039, 0.5517596775226359, 0.1929682566562841, -0.9939924921085604, 0.9469814605753444, -0.23154520399374678, -0.6324700189334209, -0.05447634326380932, -1.2702046285454711, 1.0494017398322948, -0.7424116958071865, -0.3769589015532693, 0.4141005991081055, 1.036256074708611, 0.7284700599193676, 0.0023222198246309416, 0.6131711426074284, -0.9044010358668818, -1.1926211908141438, 1.0222579026144374, 0.25252167567498535, -0.485045775005106, 0.1508011935460533, -0.8554092410743294, -0.23904474456445154, -0.7602875995813438, 0.10218606515110837, -0.5490163125261626, -1.1948051767796517, 0.7747158511170026, -1.5523811855188392, 0.018867339651908392, -0.17324413014031037, -1.167281402326626, -1.0941668510488682, -0.7827124807679162, 0.6933207106682298, 0.18767460697436789, -1.0186085873895072, 0.07794876558888297, -0.8727081879040907, -0.03340055197012086, 0.4885844922688999, -0.05008839144723603, -1.075210431077175, -0.6622442596990954, 0.10243515923045927, -0.8560403358042233, -1.0419602525013043, 0.48303251080970955, 0.5525838396427684, -0.26347229873176253, -0.064228007545326, 0.5565926597718154, -1.0629338287366756, -1.0904981335908794, -0.5434551632189225},
    {-0.674574967937585, 0.4050917067986446, 0.06436942176493046, 0.2886352912748165, -1.0021895439090562, 0.24443661431963457, 0.8000125263575647, 0.3792025882769877, 1.3426231918642826, -0.8143437466236184, 0.22200327613177898, -0.5980346235662266, 0.8565745477738042, -0.8937962664339673, 0.3050013610580625, -1.017543194295268, 0.09234567172536597, 0.21535388337081052, -0.6784796185898434, -0.8058930911069639, 0.5283272812808388, 0.33979634063134617, -0.10154385218077792, 0.02768425170625115, -0.5570307655119345, -0.23306622239189018, 0.9382810574673855, 0.029251694708240218, -0.8593532001818676, 0.9171025426039268, -0.20755065495480626, -0.790625456229666, 0.9927002345559676, -0.6891966238375237, -0.7099442306962613, -1.3372697435656242, -0.04322803618686668, -0.726472078649496, 0.10842601260314234, -1.1629671009182956, -1.0220017635432401, -1.518793900070891, -0.6436891355668312, 0.5803318031364366, 0.15987246554683984, 0.7619815954278766, -0.8721918063782204, 0.5321198182873492, -0.9583919154031338, -0.5658107934091505, 1.002109199494307, -0.3456679790439173, -1.1207346911217537, 0.186080197164613, 0.42228070461455436, -0.9850753522191471, 0.7568412410874785, 1.052245019299963, -0.18754774549035894, -0.02466328160916515, -1.1355107313377606, 0.14472722159505688, -1.3173327609198964, 1.3817115707465946},
    {-0.5783147494367067, 0.6520511396664646, 0.16050947375189953, -0.81473061273918, -0.5245181858980076, 1.1394327476622679, 0.21423812915271545, -0.16709377023751593, 0.11710736756123478, 0.04990152705836699, -0.5130727546680431, 0.08027051307391325, -0.024251162761766427, -1.0000250026316455, 0.2844975880834843, 0.5747291585090364, 1.5433263563412456, -0.9194440743310887, 0.3061925944094654, -0.1436638551698862, 0.5190996422724892, 0.571897817096267, 0.660156904757981, 0.5932267973482834, -0.1369759081558431, -1.0108521287054812, 0.9165298334239389, 0.4703299226228871, 0.5573858957860428, 0.2553691095620949, -0.6447128107692055, -0.5152258858710477, 0.8027213010775124, -0.7480178098734012, 1.1655213015190424, -0.6419162011250249, -0.23444380339263554, -0.9645429080877925, -1.0062512260404615, -0.7592947281114155, -0.0066560493658105275, -0.9263275154698007, 0.6159644547163963, 0.3097861144071072, -0.9756072268608457, 0.8216490600670422, 0.5415471988939657, -0.7431334575796129, -0.7138595175324343, -0.5274988925607376, 0.7193465569564418, -1.049744105846937, -0.3136303866188262, 0.9704325896661163, 0.6052136880300767, 0.4733961643472695, -0.2806863714224672, -0.4089557051960442, -0.1651138953531835, 0.7737540450641619, -0.23538064035489498, 0.850540259331033, -1.542356949877032, 1.0521146087795845},
    {0.6409002359164092, 0.8530913675994855, 0.4065312977372383, -0.601642570710391, -0.48427777301327585, -0.3290577798661435, -0.42735376580474305, -0.7900236411077494, 0.9907885194704702, -0.8191980236165325, 0.6026166360230533, 0.45239623435334114, 0.8876188807520374, -1.2740619914037787, -1.4481578354900575, -0.44987071600241746, 1.1707246783012808, -0.7042246715348344, -1.100933987104816, 0.7501391390183718, 0.8928685803613444, -1.0916499627249052, 1.0622964424156283, -0.5616253976701678, -1.2546234782210663, -0.4221285146766295, 0.2591045107689293, 1.0323206539869472, -0.4297799148344974, 1.4086693816758336, 0.10635594489325659, 0.40731050819599124, 1.0788782355088558, -0.767827745069425, 0.9217303960462092, -0.01512977677407276, 0.053336462864299536, -0.8572075192160007, 0.7899714583059885, 0.5393516947749394, -0.15519869611934647, 0.5051394372961739, 0.2805114864429249, -0.04451136624047825, -0.6760741281856987, -0.6360230226864496, -0.40803561214462014, 0.7022518109374716, -0.28155488260441597, -0.20792978529144343, 0.41538393601737056, -0.09082857850738159, -1.1861764912255608, 1.0806070275828887, 0.9277440782782036, -0.6325491446466821, -0.16095265777837583, 1.346433987100982, 1.0563184856618997, 0.3796096008559348, 0.2707628774367499, 1.1918997419695052, -0.20708819331994915, 1.2568132899737798},
    {1.179300234615083, 0.9995584036617823, 0.0840884346795095, -0.1968234864414181, -1.0789095526838886, 0.6796048558479789, -0.10456442167031134, -1.1281406347997833, -0.242895311822226, -0.41951255779256025, 0.33586739981887476, 1.0185475923199874, 0.5386947552713818, -0.907324837042614, -0.6738367882003686, -1.159292089067723, 0.9151109591463431, 0.3678378532993428, -1.010017478913761, -0.18006900493690292, 0.8412030090449277, -0.3564905323417346, -0.6053924508151743, -1.1690096838742117, -0.6937319836805422, 0.7658283010075088, 0.673709878044596, 0.9951830139889395, 0.6790842923391202, 0.35893283893934835, 0.08309397219864778, 0.09403850077896506, -0.22563294275696702, 0.1857902611310953, -0.19846457325235867, -0.79372678800264, -0.40248690851189056, -0.9068841392090344, 0.1542424514000372, 0.06942268267455338, -1.1751321958536032, -1.0571794889757264, -0.19690897764383825, -0.25162026551773425, -0.9464303450673999, -0.33203754831455956, -0.5627628868869985, -0.16725644001778053, -0.6759720610373801, 0.9469916259782671, -0.3486037610034393, 0.13825437674423302, -0.12779118167147938, 0.019589391788923317, -0.6107267724124339, 0.41274314195203404, 1.1565809729276602, 0.8244133958402678, 1.4708666090479943, -0.700313680616085, 0.2243261860271071, -0.03490792298412043, -1.126006486905295, 0.7052851794954474},
    {-0.34038963533604827, 1.3284690383072322, -0.21348055686082038, -0.7864452764936577, -1.0183552312313553, 0.14792028815628583, 0.9968581884088299, -0.7274300378012069, 0.3773224792567718, -0.4232264274490157, -0.56320508403598, -0.20588462087798887, -0.9578511271758062, -1.4270899307604177, -0.7141627988701661, -0.5686375448041167, 1.2335252564472394, -1.317852894253668, -0.6628256270516732, -0.8537670795993696, 0.7913856492480348, 0.1998378644909587, -0.7409486028319746, 0.000405943810213019, -1.452285902859912, -0.0006272211704741501, 0.1782708288994103, -0.08459577844459944, 0.6294416212837164, 0.7778094152108366, -1.007348429465621, 0.2589464115528153, 0.09092900015057716, 0.0558189107130558, -0.35999427911634785, -0.2214741268820386, 1.3004604149527152, -0.44925593285684634, 0.33010781998095207, -0.9471369975144196, -0.6851033962175866, -0.2554476049409635, 0.5404594394829152, -0.3389708948503895, -0.19186200124039177, -1.0288096175824526, -0.32233522960553135, -0.26090890142918033, 0.4229592863969437, -0.7456294477011972, 0.9126720078120326, -1.609136071870423, -0.2166346799195282, 0.5666768892903612, -0.8593045939958873, 0.8226598582376863, 0.3807113856624478, 0.4742044495608403, 1.0997802552966962, -1.0229112330907997, -1.1252508855297487, -0.7622288205519733, -0.3594389421731003, 1.3252691302442188},
    {0.8014541196892693, 0.174285270213279, 0.10328448665284116, -0.6398736659771894, -0.032390614792556685, 1.3009405091662423, 0.1919701527834867, -1.2101722833869057, -0.015301924464237688, -0.29001686923313114, -0.8724413895303452, 0.0023254694949033064, -0.11991894638218617, -0.2767747917551696, -1.2871766048127944, -0.4044866976971209, 0.9170596045332994, -0.26035581743963726, -0.6671192347910654, 0.8579902943350931, -0.5075502980921744, -0.9985737622388021, 0.2698795037864029, -0.5335926356671163, -0.2798572566128542, -1.1906944369306358, 0.9553847813631032, 0.10189251306030449, 0.09487876250373474, 1.4590309546916236, 0.567291124673437, -0.8261379896556084, 0.9241685501880992, -1.189048528362029, -0.8248080872064902, -0.6371372194611923, 0.8277751832503633, 0.38186060454202997, -1.042120333141461, -0.050302869321202065, -1.1631541746401433, -0.5355103325224982, -0.8811631158237899, 0.2940870028929214, -1.407565101207185, -1.0714508835215304, -0.8682708153171105, 0.15199960193805062, -0.8433219789712109, 0.32539297865782557, 0.5345561945030753, -1.28330717405175, -1.1240480883293793, 1.1581548044776362, -0.12191901727857908, 0.4649092037229789, 0.9547448461017105, 0.9196850666822766, 1.330799329867421, 0.1317061629664407, -0.3864367313452813, -0.03245688169601129, -0.9202629306866392, 1.530040288943611},
    {-0.13587870969464658, 0.569328588819143, -0.9312238138528355, -0.7422057562165976, 0.405835531949013, 0.8103873973365501, -0.42516959412172767, 0.4185054358961841, 0.4297053076289549, 0.8568018957413366, -0.5842729981466416, -0.0160357108532719, -0.5495775317568568, 0.2791294105399031, -0.8180687850520008, 0.6544222946758457, 1.466324296427203, -1.374608706550703, -0.16818672497772771, 0.041642169365094656, 1.0089034267607762, -0.01728783830510152, 0.22541624255954334, -0.021474288574913847, -0.24558651749323995, 0.34833558756239563, -0.04613638471922017, 1.1200342527777831, -1.0463469578690843, 1.3511063744710352, 0.8133827962780102, -0.7939294451534711, -0.12238388648549853, -0.16898811880533438, 0.6154483085870457, 0.6116930152208164, -0.49611616739656444, 0.4477708825252545, 0.14946262789005263, -0.5814980263358762, -1.0315565467538583, -0.8044680891129119, -0.10517390137131226, -0.6007126899380123, 0.06542179185193722, -0.015495248743412545, -0.576829479016908, -0.4639466903878414, -0.5944129393855675, -0.27364154157097476, 0.9712490671518483, -1.5423370336572788, 0.39478105162957394, -0.25319211531100305, -0.6223755443312536, 0.23345586740777027, 0.7730800350418527, 1.2108408211603356, 1.5274087099829552, -0.39062833512162093, -0.4441659078586136, 0.8916353480319977, 0.21863724671350332, 1.0533967097091426},
    {0.5925566140373618, 1.434663561307064, -0.30091456990334897, 0.7146419965495238, -0.9678349554541938, -0.10436974945717307, -0.6022164787493088, 0.9006169238258644, 1.3958622490274424, 0.8096789480721533, 0.2685541949063916, 0.3222381672636619, 0.14159635876192578, -0.6813853225368983, -1.1480421931199527, 0.1160654612709393, -0.09793005987095953, -1.4019120060668884, -0.29431573668891386, -0.5940412569341627, -0.6942406579861398, -0.477554636863093, 0.018231237136281074, -1.2143705517131491, -0.42195086201626975, 0.014737797228347619, 0.5322634277567876, -0.09716095818349155, 0.5449196796215272, 1.0434723241818713, 0.7720541308051698, -0.14219066134204836, 0.7391836892254474, 0.057117431681448005, -0.316997600646426, 0.19526424542231163, 0.03158141275463235, 0.730717458505015, -0.8959833821760248, 0.9686722729854813, -0.4337591194404226, -0.19385978165173534, -0.07856658019532678, 1.362428717616967, 0.2715722741641168, -0.5769534102028149, -0.3585786371015176, -0.6066415034047593, 0.06141472999158244, 0.30726953508446986, 0.1596138501280812, 0.1199186895277279, -0.059092251816068246, -0.03385349673223624, 0.32469362579774813, -0.33725176456560213, 0.9487661597414176, 1.553640010307841, -0.13301743989710166, -0.8350824596090679, 0.5465231469616486, 0.859513689033726, -0.8264977569758151, 0.9853470905311699},
    {-0.05847812887476199, 1.1119381469303933, -0.46989946276632705, 0.4048114938280666, -0.014514021321327529, 0.13360936731528825, 0.36679343326914093, -0.24116399101375408, 0.44024062249820844, 0.7450838644722282, -0.3999146423427953, 0.8928151378653505, -0.997621258332348, -0.08601707601080437, -1.4676028102845224, -0.9275133764511919, 0.3169299199382365, -0.4855638088105778, -0.5071253007055138, 0.9933332859685323, -0.29553150349785956, -0.541113493476299, 0.0830417750494356, -0.2564055363989949, -0.41340731227805083, 0.3957061550328271, 1.4015585245185376, 0.23496061496287723, -0.4701753462931705, 1.219654861097778, 0.41643888138091806, -0.6253705020880386, 0.35219541994612397, -1.0806476324511816, -0.6914980457190948, 0.4235554336845516, 1.1476902558776485, -0.9046341078654514, -0.2903652436087657, -0.4553967348612701, -0.8485876990127993, -0.13231923922031846, -1.2750937459697331, 1.3198129903854747, -0.4496959135466027, 0.05424673034666965, -0.9718028121441648, -0.12911542575926538, -0.6316890746450654, 1.0518925926968898, 1.431175908728205, -0.9205093495675761, -0.5971346950722014, 0.19698464176696914, 0.12528096891916038, -0.038292739255812815, 0.9974990750840896, 0.32420517594088694, 0.20523995499784772, -0.28706884312397374, -0.7900977977476862, 1.1406777301936537, 0.42463786184455643, 0.6695537578676},
    {1.09123923368294, -0.10325106270236369, -0.6513781722874354, 0.3728165644256141, 0.3071882381734936, -0.24827319209530946, -0.7703035156768947, -0.0905484766192632, 0.6356804194957766, 0.8075498995332174, -0.8870719486976331, 0.9814468499665726, -0.6821658664975169, -1.2007430097782905, -1.034069131229098, -0.017269909366409594, 0.8407374910029598, -1.542026563551002, -0.048103993132561834, 0.7820147014775635, 0.304321559524315, -0.6640628580154763, 0.25663615498652836, -1.312845434859361, -1.2779631296218534, -1.01061103549561, 0.022335949474787658, 0.40986150104375774, -0.9762921846535265, 0.7772686636375543, 0.11558933731755672, -0.41276319696289715, -0.19723411965793103, -1.03373013301011, 0.07264011921691062, -0.1475491026788874, -0.3408464288144456, 0.46722246732373407, -0.7060072273554456, -0.7482366115661228, 0.37378775128719105, 0.2867751734775155, -0.31898692904888776, 0.5765368266986898, -1.2231622863203986, -0.37027653861608334, -1.2968314322161665, -0.6755598389208177, 0.80120762541123, -0.3010445313524938, -0.20084817929302312, -0.03950890204749553, -0.33843177812378783, 0.05479744997866092, -0.5202256541448846, -0.3391475656744345, 0.052363383351222946, 1.406051742420607, 1.381494312151099, 0.44717426090253276, 0.7143369555670166, 1.0982376945535128, -0.36521793167185734, -0.010817362712251094},
    {0.42373589451269417, 1.1811071775816246, 0.061351556142056826, 0.5520643841721898, -1.2837781797764227, 0.14338196808691378, 0.9547998294992355, 0.02529703006867408, 1.1312210059066563, -0.11695563024863342, -0.01351676213271868, 0.9356275941150655, 0.27753282954636727, -0.06938877324645669, -0.4079873202883483, -0.9836537277188178, -0.024182757521968357, -1.2601522335888617, 0.5317465307696774, -0.3950348263162951, 0.25710645636895685, -1.291008197985541, 0.27649148769282367, -0.23198990804636435, -0.762391854083319, -0.7376068572870118, 0.4901178553092504, 0.5208100493425482, -1.0781829305010449, 1.093080012084116, 0.4704118803093896, -1.1074695876390863, 0.5034352022929357, -1.2316582745249383, 0.07612729540938618, -0.456412662466258, -0.1936902974547883, -0.050989556715690984, 0.4498802643698592, -0.5612558019280678, -0.6440605928877364, -0.8824329368962203, -1.0194504394867399, 0.14813622965634568, -0.028349376001531167, -1.2681000173613668, 0.05234918240563346, -0.9257900751999337, 0.9745119515406904, -0.510357871964084, 1.1439477845668942, -0.5081972477738241, -0.7356090826828122, -0.15801039577451584, -0.1419411608549214, 0.5561900649666373, -0.0013851147876630058, 0.3750350940270336, 1.4103923774072125, -0.16612134934904282, -0.6126127007544864, 0.9375123857802942, -1.0541600165215728, 0.13640775683966627},
    {0.7211966345574237, 0.7652570233707197, -0.17943209144602787, 0.8258886615058677, -0.20444884884233497, 0.9628261519668028, 0.5665952670979462, -0.7608149751101898, 1.2195095626338386, -0.26420957991563637, 0.40495671275715134, 0.6828554112400247, 0.15190000950949495, -0.8607473438112516, -0.8406467644049719, 0.7017022830916265, 0.18014119293092948, -0.3835329660070323, -1.0128212515656454, 0.17469501602577775, -0.07175488150922193, 0.45585948655470904, 1.1913373696551601, -0.4997953558386912, -1.292975796968345, 0.4934548559889967, 0.6807889704456883, 0.7012327914127945, 0.8233510510434636, -0.16591538007709852, -1.1698235461030777, -0.5651714506854282, 0.9414611227111632, -1.4550860632269949, 0.318009270590672, -1.222461813710456, 1.1842506211798611, 0.09739105160972499, -0.8441177868865712, 0.05245000255740824, -1.0350619888250374, -1.1454627276653933, -0.7283098764725764, -0.41348855197000145, -0.751079658139954, 0.49179924095855454, 0.4383198985866165, -0.3277836056098523, 0.09841412592960268, -0.08132753328718326, -0.43405472830306907, 0.24425206191440552, -0.5296682682471935, 0.9616739073665234, 0.6756095676584513, -0.18780164725533527, 0.11356563007678624, 1.0717862155346602, 0.9716372776008417, -0.4778651821951493, -0.5712180264385205, 0.798573131381573, -0.05372708171376109, 1.4643976889145705},
    {-0.0327336361933318, 1.062831280449533, -0.5898641227121935, -0.5940594846358689, 0.3436107880489796, 1.2363220734604339, 0.1566954158570403, 0.3319326826938246, 0.9557420029110869, -0.4292237680769093, -0.11994083868569136, -0.7774631487796135, 0.5373569064143163, -0.044762073334558464, -1.0459826935343268, -1.2092852105589427, 1.264416722005057, -0.13689826455385765, -0.7662067145960311, 1.0437880107738893, -0.4145939278961158, -0.7158432028524182, -0.20138806514929822, -1.2073208032696887, -1.3830764904211876, -0.9661085029200778, 0.8236237703382107, -0.6271511557559214, -0.01607365410434055, 0.02096917188367169, -0.7126229199001108, -0.19565301266385876, 0.29917756970904963, 0.3686326906300446, -0.5970875124930156, -0.7099261807658857, -0.472934405213516, 0.5651392334836807, -0.005362937468749444, -0.631626405393565, -0.20395757301805523, -1.5128762203374508, -0.5974038052243317, 0.06781288685692037, -0.5440869264415565, -0.27287634751167356, -1.2892242749057112, 0.5580949009396352, -0.03999700503447583, 0.05564536642733939, 1.3489978104517433, -0.9154857551962162, -0.8724885484226067, 0.6536856642991442, 0.1246971894418212, -0.8572928126920664, 0.6134121896400826, 1.5632444207028204, 1.4542425377406145, 0.6134905721948034, -0.023567244308057095, -0.7537306766772526, -0.58303235835963, 1.0523386825130763},
    {0.9799644217928013, 0.08107675639048462, -0.4081511004044443, 0.8815288772686282, -0.13083804417627926, -0.6923955301303222, 1.0509142873632156, 0.051653005045197715, 1.5419170406707692, 0.6028439809469935, 0.6778141621217217, -0.6293078696444385, -0.6664387600915945, -1.2402768359342917, -0.8625165872927583, -0.585907517185712, 1.1229433474089463, -0.7646078334192135, 0.40710343298712226, 0.8503813851534375, -0.766476489851132, -1.2743013131358818, 0.17038150794908927, -0.9876899673193986, 0.14753687255476267, -0.26261542205529625, -0.21000390325623342, -0.5672827001488739, -0.3227615925035414, 0.624025684121846, 0.2717201288013044, -0.6685962209164412, -0.6448674318609006, -0.7395171363397574, 0.30315957031202123, -0.24605657105744963, 0.10513221225968174, -1.0602397958981857, -0.25585552329045363, -0.04870140033981347, -0.004854942110117111, -1.4418184725896577, -0.46573598422933316, 0.4539538557530498, -0.28034736441184605, -0.6318547802118206, -0.27037002521153053, 0.7214578059273352, 0.5900198094712725, 0.48685275631591723, 0.9077214559683352, -1.1954468840721815, -1.1871007493807442, 0.05851567813721021, -0.15191348936378496, 0.6857418189497589, 0.05005386628070946, 1.0972547546859737, -0.09957502677832983, -0.2777866365368358, -0.011133669169738786, -0.6545685845978263, -0.2259297979405457, 1.6384940356672546},
    {-0.5824676146768129, 0.18631518478597658, -0.4411206082864322, -0.3804624531803656, -1.0711295638188714, -0.600929538834004, -0.8511221234723351, 0.03358471002329612, 0.5161748346384044, 0.7614918823508388, 0.8656418012657017, -0.38211952966904156, 0.7220890956222242, -0.7165660676107456, -0.8991028582358553, 0.47893342056714977, 1.4577204234889627, -0.023869675864001183, -0.18830755156847043, 0.03384495205937561, -0.7034411804633771, -0.17739334910562085, 0.5975554032834439, 0.09761457166112932, -1.5083019306385326, -1.1588443055037345, 1.3008826972498446, 1.065961049264793, 0.7886154825333916, 0.6535842173719904, -0.2166015294276812, -0.5426132863339063, -0.8528058428531816, -1.5279231099203348, 0.04339277549781279, 0.12080701464184597, 0.06211429554234867, 0.5914851449142978, 0.6581335912073452, -0.9261226611910282, 0.2339060112927765, -1.1527834047433014, -0.10568368282599683, -0.26354217269784, -1.4069546916235391, -0.3897271031180237, -1.3574621465050312, -0.6398756489258403, -0.2947353106107306, 0.9230275977246127, 1.1845424545069259, -1.4966131018023219, 0.19300543697114245, 0.42945327017240137, 0.21276620546575467, -0.39481737176960296, -0.538650023789468, 0.3722425366926522, -0.23867217586325495, -0.7190918449794824, -0.6825259535934226, -0.8322479171885621, -1.5548408169219892, -0.3528871017114735},
    {0.2971555124756036, -0.25558284393094505, -0.2288845825663968, -0.3838172103177757, -0.24911843873941222, 0.9337510785721931, 0.06205399950163889, 0.41490898491013484, -0.6697212726545375, 0.4158146209014174, -1.0789406569882183, 1.0179646670895062, 1.1866250136393952, 0.19505266208470795, 0.26778787666862225, 0.0895249444410635, 0.2917860704787167, 0.8937702303292402, 0.5839104029089263, -0.30734846524368853, 0.6319272401760121, -0.21888760343971655, -0.11922218387866322, 0.41743007190030457, -1.0318791601159911, 0.4694994922280512, 1.1486588356154863, -0.5276099411674581, 0.9725210731565489, 0.4000622637007312, 0.06708435898330556, -1.0359985194483368, -0.3876055096012402, 0.26597358681723715, -0.07822256939107546, -0.27719659608369085, 0.2811071535386421, 0.8748667711905201, -0.5416308972777734, 0.378408242899689, -0.07131781776471943, -0.5984345934867198, -0.632786920411731, -0.2814012670034512, 0.32140698762987385, 0.2415486691047402, 1.0869483688431245, 0.11311738759510268, -0.9729740318959182, 0.32057705995860286, 0.04615208619276725, -0.569737755107971, -0.6069315302619921, 1.0309298658176929, -0.00472285079827789, -0.6422431290261185, 0.9783700644904919, 0.9994682852881566, 0.16606657065443692, -0.9179222738237373, -1.2177143110549469, -0.308320346944505, 0.14683729367603335, -0.33866843807125196},
    {0.6029813384882743, -0.3305734425210547, 0.20665725081359332, -0.8754237251577843, 0.06354363674459018, 1.1032279824143854, 0.9832695899125737, -0.9689176108665957, -0.3611899243432345, 0.0847985439308289, -0.5045682414203866, -0.8255624908572897, -0.5141044266701164, -1.1971752520800456, -0.942538758241008, 0.22905630995873558, 0.3699963764794139, -0.07175209176318398, -0.39884334222794254, -0.700558378003102, 1.0686704836885847, -0.7449866816898155, 0.21636256373731638, -0.9591507082700457, -0.812626619541454, -0.626928731704676, -1.0277755818658207, 0.20040482106597146, 0.23840549221369012, -0.9174104877362459, -0.3141633921063565, -1.1696986460807153, 0.9845556879340958, 0.7429443150312145, -1.0530533820442818, 0.4456736713319369, -0.42022905292023865, -0.20696219764133852, -1.3121680334470465, 0.8403580224639118, -1.3050868618695721, 0.6620660851714004, -0.45673939130827407, 1.1541567276000477, 0.6279420211837802, 0.4138405671485793, 0.31988213865530224, 0.2625971025900798, -0.6985249801712642, -0.17299687258816784, 0.22215006774952015, 0.09592624646948016, -1.0606367095303775, 0.04653398855566595, -0.2811539725105346, 0.24517045996119408, 0.0227602373411523, 0.08863367399991474, 0.18801807322242634, -0.4726836757640094, -0.9587111917462503, 0.9297003845608288, -0.9745135104522281, 1.245882664284066},
    {-0.9791554987834633, 0.333932582209736, -0.20816897145573723, -0.48316922407979557, 0.3808989774270411, -0.3191858958691703, -0.7158014208832335, -0.7018621707107148, 0.4763053918259055, -1.2942792025613576, -0.7867607642052398, 0.8660594143404955, -0.5064879930693637, -1.090734965113323, 0.9818378643773683, 0.4881029086599885, 0.6260749490692533, -0.4291982387343195, -0.5345439898092369, -1.0061831234465493, 0.25881496766031614, -1.3188876531071316, -0.9005696634147012, -0.856480526740125, -0.4252393971021023, -1.034277193347425, -0.055253263840126264, -0.42652829859044167, -0.4096410232080716, 0.36527839790869465, -0.5461734392937102, -0.7779398262544435, -0.31150885698519837, -0.9766043517080861, -0.7934692129168351, 0.07745421810494428, 0.33793082627156634, -0.4512835020055887, -1.065936648822178, -0.1838932708402389, 0.6013987124417276, -0.37417271037894684, -0.30728146227494463, -0.8615569007164836, -0.039261042382895316, -0.08237644287621991, 0.9110101649043151, 0.6832021739227518, -0.7171187236916751, -0.9445911551369236, -0.18628500445053536, -0.07495711009993267, 0.299612966799481, -0.19131000156065214, -0.8452069191991722, 0.8763343426303161, -0.7452471820255051, 0.4637033322132066, 0.4386765866607833, -1.1050433366191612, -0.002786619666729946, -0.5995953955357861, 0.6309041216777085, 0.5003216717435702},
    {-0.8389429404890707, 0.8010435471865262, -1.3245138208847453, -0.31391055595546596, -0.27707127696776906, 0.11504781505246889, 0.39623647392306116, -1.318543492765526, 0.04256377942617175, 0.3950419660497104, -0.2773894289876034, 0.5465809739316098, -0.34527623130596813, -0.7896443033513414, 0.6316208652152486, -0.8443163317378115, -0.2541816142945271, -0.8529598625531982, -0.14754830611881323, 0.6033800202473107, 0.9149049770372142, 0.17537351275488014, 0.48644832918740305, 0.034148121059319185, -1.1794037437426828, -0.9191850585518635, -1.123771282171232, -0.8583473104535946, 0.7856312547184305, 0.8714141404299668, -1.3040462066139678, -0.7558880969092088, 0.8281751527014011, 0.2839064907316684, -0.8533005666874163, -0.5952646860470258, -0.7167324114614917, -0.4022755011547185, -0.5147885398300398, 0.3898333117621528, -1.2477293275650494, -0.0626073499401414, -0.9894394117986486, -0.30049086827258575, 0.38526910537052583, 0.600165835889876, 0.5982572899885181, -0.9392531961386218, -0.04854811124035575, -0.4162046870646561, 0.23512769718305362, -0.021808491146725697, -0.8354743921073513, -1.0155766505496429, 0.572501772479613, 0.4786267950799184, 0.2953904345036307, 0.6335823099613644, 0.8839296406973385, -0.7236632125683122, -0.21177312437217868, 0.6957659994564014, -0.8129041105663043, 0.7184028762122717},
    {0.013512560431315091, 0.03422810054499417, -1.303192535426812, -0.9715621383028892, 0.3256181757276884, 0.18656462358144554, -0.7612858015009162, -0.7615707199655236, -0.45838349512866805, -1.1993986900345461, 0.2964041753973606, 0.9562309271545694, -0.8735661258483758, 0.13950595173515115, -1.2832604637459681, 0.7191592017960572, 0.8740343547896515, -0.7101892179673122, -0.46413903249775806, -0.2707637563525221, -0.6624567726108122, -0.2127059921101339, 0.3293900088353021, -0.2960695591562123, -0.8420076066589939, -0.9005506337723644, 0.2595817212034941, 0.4299215053973337, 0.5188013173221431, 0.1717747837468988, 0.5869127941776716, -0.744104399468552, -0.11090816691388493, -0.04969298936680514, -0.8231382956157464, -1.17544909227448, -0.5403849323651971, -1.0836386995121206, -0.8321112024801276, -0.16592686059733053, 0.021786445156363958, -1.0145976030443526, -0.7785656649444189, -0.4757865429995167, -1.1892765952840534, -0.8461902455269348, -0.46174053395937265, 0.842094060214835, -1.0776604568788104, -0.9540732903316237, -0.9000123699526554, -1.3203699220219332, -0.3170247983768268, -0.5920557234153767, -0.2193918203331396, -0.9229134725303156, -0.48867376188528155, -0.11068348911294133, 0.3600736945789719, -0.8808070557498499, -0.697762604409479, 0.9262691064964488, 0.6322658387242094, 0.34489199168085866},
    {0.32638915026947435, -0.026029847643511916, 0.3521723512364433, -0.4100854813542703, -0.18067400852177185, -1.0117480090432616, -0.6618317528092195, 0.635361463838786, -0.589116858681356, -0.31676991955346034, 0.22773460326483647, -0.37768555972546214, 0.8197694564077249, 0.1349165061339, 0.1714245492282023, 0.4212104693047565, 0.7958616137696908, -1.2669360961421101, -1.3478265438175157, 0.7735450998358278, -0.16737050268482198, -0.48673395099714717, -0.11376931174742555, 0.2613577069977278, -0.5996019016486261, -1.0486684224258025, 0.5397101497510467, -1.2842896317715444, -0.5655178316520054, 0.07931964092966198, 0.5569235920365122, -0.6874186450982518, 0.5807982487284203, -0.6233098461326406, -0.6843647187951476, -1.3752759274521187, -0.011219344174773774, -0.43894630295482434, -1.4863709214365939, 0.41739013298737787, 0.5787205021178634, -0.3564137128323573, -0.47978761605197284, -0.15023956106865338, -1.5040755094670089, -0.06362306531594554, -0.59916303347289, 0.5133313600643018, 0.5768155379183179, 0.2045327868708827, 0.7768131753453824, -0.7540589903731011, 0.1753494054358313, 0.8714799335463437, 0.6784112065508725, 0.34507036409072533, -0.5758149222312309, 0.405733155676975, -1.060130437574982, -0.7620437984368567, -0.8245552067011467, 0.5637167455366616, -1.2885757459960978, 0.0920537416566154},
    {0.035007892013680875, 0.5251378328944062, 0.2565984940095526, -0.8513956121062479, 0.46817775468563777, -0.9626770921323381, 0.3419610585469524, -0.4750677458913116, 0.7547712002197466, -0.8199356272094446, -1.1088534877643978, -0.8964644723278056, 1.0522921962882958, -1.2203944870981833, 0.8423928117393508, 0.679037222885281, -0.8042336206588899, 0.08877063267415235, -1.2398520027450546, 0.8548673370938098, -0.5264690391975576, -0.8209399386942104, 0.871479634572831, -0.26767200577372435, 0.04564733275331637, 0.010550611795658032, -1.346677921735948, -0.32747924186933003, -0.6365252363373612, -0.9244439072398363, -0.30293310724457456, 0.4450956043379453, 0.19505166157970483, -0.5058107163207705, 0.03258851091429806, -0.3272810967650801, -0.5217582888209747, -0.6022109419361807, -1.1254639185328095, -0.35491074496478964, -0.9419114706378366, -1.2798319408975503, -0.12006192265183722, -0.8984399477189362, -1.2518847764836054, 0.9292727839862621, -0.5697371063805526, 0.2661358535275934, 0.6762249589818333, -0.722224083175568, -0.43334622086765495, -1.2989062041700687, -0.1273986172258129, -0.7024836266069756, -0.8670557834554338, -1.0424367498218263, 0.4675928746901631, 0.07811428189503235, -0.22677275761664328, -0.06646961511991256, 0.2633030600961768, -0.8535249632425108, 0.6403116239793034, 0.5583109226056354},
    {0.3255787473557175, 0.008510293150207808, -0.08132296761286764, -1.2774538814077676, -1.0297525800581542, -0.8991258109418722, 0.21812982767511985, 0.6071641008620662, 0.787259819437505, 5.3952869580674504e-05, -1.0348165852026376, 0.6000651915059084, 1.1341469250955813, -1.309064477693817, -0.6878157094362095, 0.08579502927414333, 0.4447985208417016, -1.188713575528125, -0.03548219490746058, -0.14846581371046208, -0.37814231964281503, 0.4980796583782593, -0.860367800510098, -0.32841938155074996, 0.015106772286711376, -1.0497112596159333, 0.18194327338114616, -0.9882235699958638, -0.2590178957265189, -0.11487510937078349, -0.17151217845085076, 0.05166866436977104, 0.5181589407037765, -0.46716062717924256, 0.3061735244661389, 0.15376337340992122, -0.6433795410745158, -0.13171195898976124, 0.454078245715485, 0.3108199025311656, 0.0612971534718457, 0.6287685324774762, -0.3942147011942284, -0.47598151997350047, 0.6181399682667282, 1.0110444320183871, 0.4332564088575923, -0.9351309930751802, 0.11023836378950419, -1.167192997498893, -0.4447140786168074, 0.35405646134971525, -0.8331594800122826, 0.17589199299223596, 0.7003481321815854, 0.891642640804818, 0.371250934238734, 0.19120281280879892, -0.712871998988625, -0.23899241475083827, 0.7713854592889476, -0.436547491621367, 0.8740892964444236, -0.5916363985638401},
    {0.09431156428835721, -0.6414465277868218, -1.4639564724832992, -0.6089884158138192, -0.5801967536403222, 0.2680294048948116, -0.8546055403043936, 0.42333795237937594, -0.023312544278008274, -0.3855815399394029, -0.994093416872822, -0.5907596313163094, -0.19047291897521684, -0.8628079082436799, -0.6763206366091581, -0.3587985663432019, 0.6407291427927836, -0.7762997982803831, -1.1985753140970525, -0.8000399896666582, -0.46536162910914747, -0.18199639662154807, 0.07504653070877129, -0.8794539124815971, -0.4235385285344477, 0.7930218114947633, 0.1040532718030772, -0.5818296858526233, 0.6393648608823073, -1.0319582658720385, -1.3012762664253736, -0.771464074828504, -0.8657734578185398, -1.0295517572715915, 0.29790721225916805, 0.19740295351362455, 0.6518640438953728, -0.7459448481497447, -0.5300111448246504, -0.8396415321446116, -0.8299671788559764, -1.2330189507542366, -0.4943000793555446, 0.42139847260641533, -0.1255475703238595, 0.7910238173606585, 0.6106703703891325, 0.8958421714266567, 0.4525722986249033, -1.035744407771663, 0.11760476069824216, 0.011935491765886336, 0.6258795854223675, 1.0772993692694557, 0.8250176236804845, 0.8945627858535782, -0.3336976224568648, 0.5081005026868529, 0.41003059479741943, 0.3631445914552904, -0.37851121325811277, -0.9850609254158703, -0.6931620855966475, -1.0613917996171793},
    {0.914625384454569, 0.4706462363084885, 0.2559716664075293, -0.2124998767561883, 0.16964520609830344, -0.4774793560876897, 0.36742901345326895, -1.1384331109999895, -0.7018188285065202, -0.2678644482178539, -0.5420076237658464, -0.996380245400531, 0.5205698472138178, -0.12529030232278637, 0.02485944546036644, -0.16211753725945516, 0.9844390779243762, 0.08694112519174256, 0.09377642429261654, -0.5739581460654066, -0.11559287330847853, -1.0072664712056425, 0.8351681780814584, -0.9838266682561382, -0.06257116122468206, -0.1765459130178584, 0.012368987368107742, -0.493238705411159, -0.5311108884440289, -0.9003589485506119, -1.2898632278117899, 0.49227905669694094, 0.8648085445586197, -1.3022458007775293, -0.19533745959540438, -1.2255622585453374, 0.7653415368882556, -1.1501310858495437, -0.7841858989715891, -1.3202967572577717, -0.44278187920292683, -0.09427126584589504, 0.7051500946631708, 0.3659665129132217, -0.5893361424811756, -1.1064614374440154, -0.6683909613033405, -0.9785679224409485, -1.0626706617666744, -1.3065707222214171, -0.6036813541991173, -1.1937148507006503, -0.712655717304246, 0.2091624761371616, 0.34192094553902336, -0.13854763293366998, 0.48297612063388157, -0.7600401145616467, 0.7723751012763742, 0.2995014240989271, -1.190783317522592, 0.8586478808651014, 0.8111935263535821, -0.8370392361291203},
    {-0.05019241895579728, 0.2825118479490893, -1.249350769035083, 0.241802548674729, 0.52417467070872, 0.2966552486473833, -0.6182286397455785, -0.2728890095901928, 0.8496748497315839, -1.2482149100011772, -1.0405812116077109, 0.5734627489926423, 0.19506730450707818, 0.06397888134182639, -1.1371776321106568, 0.8027409397238445, -0.07845021619496928, -0.8402181870344657, -1.0607645448596008, 0.6636606577408053, -0.9976933351231279, -0.6002469317234174, -0.3118653673541521, 0.2568965245441832, -0.21057883842618527, -1.0022367084961652, -0.1696766092279363, -1.1996455684605454, -0.8296585215896235, -1.0610474877060598, -0.4892127533668895, -0.08625300441505268, 0.6517777039703916, 0.09991715840181915, 0.8248124246104044, -0.2982763296643512, 0.9461024000993915, -0.533647856909585, -0.578361753565055, -0.8584854289549216, -0.26575250103359377, -0.7696879788409414, -0.633976371638451, -0.7470526488913888, -0.5629508905318122, 0.9357263887151805, -0.10980870952506969, 0.7008208753660073, -0.15107719563809532, -0.566527788648212, -1.0749633573618935, -0.02574901623698586, -0.6168842439416581, -0.48242398065108183, 0.6495673726943451, 0.8634638915567056, -0.03300516493017806, 0.19581939706733203, 0.38264905331214066, -0.2240023513093259, -0.3653601102218864, -1.0564105992459656, 0.44587681292894454, -0.02234989427049355},
    {-0.3036279750816377, 0.6830765802863443, 0.389305294455682, 0.29636287482626333, -0.9082646163935875, 0.5360154971493839, 0.5891874867438938, 0.25779975878682887, 0.02245593063808487, -0.39668007914011394, -0.030555780529008442, 0.8051478581423172, 0.6112612952813801, -1.0438593757422623, 0.369742984848627, -0.9276451958837096, -0.9180917174778991, -1.22300849970844, -1.3078995962955182, -0.932863670188226, 0.7967367893693102, -1.146343858121958, 0.6019521510383216, -0.4034009278343776, 0.16972567704818498, 0.5563102711121679, -0.44160474148136875, -0.3906813623235524, 0.10651947230990498, 0.26018965175497166, -1.5518525018387455, -0.13191206708714046, -0.11935546807313831, -0.26640997163274444, 0.35714571765238406, -1.2795929496319944, -0.11936324688778825, 0.24480888552598146, -0.24891820534932663, -1.0298480972254052, -0.2904647064024057, -0.7976867765195288, 0.4411180149351227, -1.0458209684119437, 0.42885305683117814, 0.15016967943236978, -0.7131628831494567, -0.3532232530985019, 0.39380540307215445, -0.07377415519852819, 0.018136714580936002, -1.296702607021465, 0.22507675920092937, -0.24248788449222192, 0.04984821117411029, -1.0332483292917878, 0.13092208134303107, -0.22804941598534048, -0.1621705467681843, 0.8885503275694517, -0.7758738651512191, 0.7056328187798967, 0.5300467931649336, -1.0177904007245056},
    {0.9362229748864728, 0.7466812489164782, -0.22764153211043492, 0.4595172459818902, -0.3172804660184908, 0.3835900491188326, 0.16833241895837883, 0.25833719568669394, -0.8302199760120724, -0.3548311205417643, 0.413566448220006, 0.753173595862645, 0.5677525469878045, -0.2266039612206935, 0.5208145771708496, -1.3355213044426848, -0.6645716083200343, -0.7052428736463124, -0.7426697615571592, -1.119535259991848, 0.49159748473877374, 0.22961707185108082, 0.39940702679093915, -0.43925110927824446, -0.1318152375310865, -1.0139498178812312, 0.01275845672571925, -0.3338736022797356, -1.13015376527374, -1.1020469395339898, -0.5770243626744157, -0.6314777824742628, -0.41058421350841406, -0.4519029418042928, 0.7509315407370261, -1.02718690348341, 1.0417337900437862, -1.0248109671936954, -0.17226033383629855, -0.9659568272817137, 0.3178622663532212, -0.7971175717647125, 0.46023724529774424, 1.0317924397259681, 0.5106047383354393, 0.5327509256941523, -0.5910744106671891, -0.9939746860813229, 0.03615421126747038, -1.3745013795158998, 0.07588612647178758, -0.14901442444937138, 0.805599757628041, 0.9886628545376855, -0.10345061548860442, 0.6795793874321098, 0.9714753165487542, -0.216628628173621, -0.1360743867578443, 0.943086114472483, -0.19583358582405014, -0.6308902683358577, -0.928087202685871, -0.5473257675483102},
    {-0.4739719464860326, -0.23283443967362755, -0.706296197143366, -0.752307045242016, -1.0218676177985568, -0.15685519452496768, 0.5511675423947924, -1.281299495365294, 0.7166009196271256, -1.2305784590495552, -0.300991634265715, -0.43034850802816005, 0.8104790239266916, -0.4383899619681119, -0.3391088689416791, -0.331845109181917, 0.15196460804890666, -0.3625969440971829, 0.5012343016710088, -0.6212870984336665, 0.3297568336916358, 0.48202138477841744, 0.8788115438706374, 0.40384209275001526, -0.5955680508956729, -0.5284639987825931, -0.2896526567858099, 0.020063971281810443, 0.10421747914727396, 0.5506784707518163, -0.9493166029182897, -1.1317577458282326, -0.42412575233003613, -0.9962100956400812, 0.707837863928764, -0.16931632613231823, 0.7970989391995205, -0.08870883901989705, -1.1295162576381363, -1.2013841861289318, 0.45884868172874566, -1.4945219607047167, 0.3040907968900501, 0.9051175200395143, 0.23898477838888627, 0.03201239285828947, -0.49668678501620933, -0.4348921229719192, 0.011918424719778144, -1.2010886265226357, -0.3526148431024213, -0.11522058741399019, -0.5928313365574899, 0.6268253947456919, -0.5162245445542496, 0.09715806739033972, -0.24352220209058847, 0.08827311220005252, -1.1418963681941374, -0.0836019030482289, -1.2621538118287043, -0.3043325895496152, -0.3991339553867769, 0.797499196187263},
    {-0.7124746047911568, -0.11339344526609564, -0.026920559903632842, 0.08615672112252713, -0.0483289555570786, -1.2939029417251666, 0.2710579069520132, 0.3582574014967595, -0.8376048980341364, 0.5741561340952311, -0.7773261204782776, 0.16607061015563146, -0.47497153650964397, 0.6938288193838041, -0.057102835317216036, -0.5393056730228145, 0.5002653515112684, -0.3219389443848052, -1.3341774812551888, -0.5237398671135133, 0.003354519179682171, -1.145173548995643, -0.6765750878349469, 0.7480162237057627, -0.07461751370213102, -0.8810561330098985, -0.78849850410311, 0.13949145151875322, -1.1445523057270515, 0.7906539002072507, -0.1351489643678257, -0.7217607662195811, -0.6406686549451562, -0.6130520478262461, 0.042207833342110236, -0.35451387260734607, 0.8629637881659797, -0.15167236091433603, 0.0009245005803636451, -0.8146069796823928, 0.267331911050165, -1.4642524234961585, 0.8067530497397568, -0.9568355657418218, -0.3667790892843789, 0.7505725876418589, 0.491334562969113, -0.9327918508532317, 0.7890031480419955, -1.1667610072223564, -0.3551738674854547, -0.637364147426915, -0.2922178211716127, 0.08899148965762704, -0.6259880657139102, -0.09724922692559682, 0.18742725483631895, -0.05561835260643282, -0.9683050927464426, 0.6730457643796737, 0.17505846454632382, -0.7181963411275706, 0.6830569009736411, 0.08614922710977503},
    {0.9038496044539381, 0.0533608858985367, -0.18980912194229593, 0.5551603510068861, -0.2531695243557483, -0.29541533862013825, -0.6082478736669485, -0.13418550955057795, -0.03066847112821261, 0.5439385371770401, -0.38347920755560366, 0.8723325371837924, -0.3447512947058058, -0.8491831780769004, 0.10683080433084989, -1.1412172720604281, 0.6989500296126645, -0.20292214689537041, -1.3697262982974097, -0.4542471858769688, 0.43483381053507253, -0.027790036866142995, -0.008723815331606922, -0.9466445605713455, 0.586507018981882, -0.0914703433924088, -0.36563214005150096, 0.4808534829180846, -0.2484512968972129, -0.02146306257643728, 0.45214192992064556, -1.0200323447376116, 0.26428435349243046, -0.39251210015907134, 0.07974300068107781, 0.3806469950933509, -0.5606365516060465, -0.012966514544831104, -0.7292486771581351, -1.1856401197000668, 0.3054714728339923, -0.5233097726033221, 0.5559192981317265, -0.8947925890053383, 0.6357519299051262, 0.06671565597787103, -1.3430698282827929, 0.08943611918002131, 0.7024023062024107, -1.1024315050213505, -0.2707378201529851, -0.8393482135154886, -0.14876578954989272, 0.16324880458683252, -0.03839058734057841, -0.9978567702321164, 0.9273143722999818, 0.5819695826907959, 0.34587466819207074, -0.9899844913930815, -0.41088722580999126, 0.13062043852876892, 0.7501981489132229, -0.9597708934292422},
    {-0.828339083438683, 0.4422124531115235, -0.904684832066464, -1.1464113371867577, -1.2338062235209388, 0.45074228974366515, 0.8466352065591078, -1.0601302051949735, 0.12768863608988548, -0.5425227112779668, -1.1178611565390466, -0.3930484026746492, 0.6771226855997456, 0.49590449655501295, -0.6945180808680966, 0.6762542997848424, 0.7635247002549255, 0.024219469788165828, -1.195998240358981, 0.46908392774509095, 0.3442285956360248, -1.0341168904666609, -1.0227228824118175, 0.6119736098179267, -0.0454874241668536, 0.6567342971894993, -0.8510390272849551, -0.44249782730756426, 0.7009016122789381, 0.6164888429798291, -1.3271290417077801, 0.5785125487393489, 0.9952249314024582, -0.32992610640442677, 0.6456090586834171, 0.20477996916884914, -0.9671188155671347, -0.552982551111547, -1.0393326202011026, -0.5246305957363422, -1.121618522097187, 0.06798632302486785, -0.6542765387049579, -0.41972790457072423, -0.8204147226165965, -0.5656303584621757, -0.7747904530631087, -0.8029056227652065, 0.5883354845068112, 0.124045669438407, -0.591665492220756, -1.4404082733069024, -0.8425922984940589, -0.7914930118640037, -1.1123828300794028, 0.21567768311332408, 0.19762829970959453, -0.7135425203521043, -1.1233036734191169, -1.09883812853601, -1.157698702855165, -0.12507015790312848, -0.5762585288065944, 0.8629068627325871},
    {-0.7108342777878259, 0.6541300451061681, 0.2575214132499094, -0.18051184774615192, 0.009828295306748515, 0.6276050833457354, -0.03250258445242116, 0.5060885198453593, 0.5039594564636913, 0.07602267126098691, -0.5518873140396975, -0.5944204724370648, 0.3451889626658588, 0.13879368788675353, -0.5938010438653514, -1.256457284588556, -0.4892733430991598, -0.5243212012935923, -1.3156898300157418, 0.6519192178331268, 0.15202923603266333, -0.09070714341450418, -0.5606707702306393, 0.4069142250276583, -1.1699392935385171, 0.4274420470681514, -0.6033082372267788, -0.33686877244132274, 0.20453114339510173, 1.118770569659496, -0.15221414016417836, -0.17583140712327333, -0.9308451717914997, -0.6343198517787862, 0.8722297682211367, -0.9521571239743576, -0.02847091844108915, -0.5961502917532209, -0.9391440293672848, 0.6476851926020933, -0.06835702031384043, 0.19573550515856306, -0.9174333454513806, 0.6091767545210064, -0.12573203969524435, 0.6788265551855941, 0.43223148527871375, 0.2926779734901074, 0.21723101090036676, -1.0146070942133794, 0.7903797248482697, -0.6744260763535154, 0.43887875782918717, -0.3109495087150891, -0.4256722429892801, 0.713022452803834, 0.13659790350982798, -0.4285276915984939, 0.7431419010602858, -0.38585151378266563, -1.2917533812555606, 0.4478443127983067, -1.1683073053943258, -0.06906913486286827},
    {-0.010936194453484708, -0.9305827101224627, -0.9165633810463064, -0.6837023038265632, -0.5764479595628842, 0.15848132095370016, 0.06607605351858468, 0.5139242853602591, -0.7239158808542822, -0.5325104186009895, -1.2628912465888549, -0.5187471097619875, 0.9525853639166804, 0.011078061513638455, 0.4032106348761663, -0.575610719467668, 0.3163591529932263, 0.33660180109969057, 0.11643535707054789, 0.06291922255532276, -0.5175144989890945, -0.35404037747920764, -0.4233764843725653, 0.01712287835260024, -1.155792501590932, 0.8979940985270614, -0.1651879488334619, -0.5584255253535089, -1.1595344545261006, -0.36980600680449094, -0.349603246472201, 0.4908503540115072, -0.8286722459524638, -0.017869388341113724, 0.5141880505648314, 0.3138782993239436, 0.7628088782470172, -0.14702661594788755, -1.1078158367357953, -0.021999832714759034, 0.5257018275412937, -0.5258118212221503, 0.036603315945982845, -0.7222004822420632, 0.07978080894879383, 0.21100862739942142, -0.9413999495639782, -0.30493083321821757, -0.8681426007143245, -1.3154471074349836, 0.04374116106316695, -0.10418012542483228, -0.7270956878426648, 0.36815136617101474, -0.3375308093728565, -0.8866249600709104, -0.6077607578506982, 0.7475223593030225, 0.08634705085605891, -0.8054116699714382, -1.2381344064488538, -0.7548374020131453, -0.3380717238722341, -0.1767019242176811},
    {0.8955461220336399, 0.0020155591822205244, 0.47018338161078205, -0.07815238931225267, -0.8757276047485226, -0.49882736182312243, -0.10887529164188847, -0.3279130919100431, 0.11804869709767991, -0.960944823866061, -0.7215924548100684, -0.35806030917867226, 0.06637286706084769, -0.3769645273062867, -1.281059729453506, -0.9081073387371799, 0.09296618868170958, -1.4008610080338726, -0.6460348745095009, 0.21658511884618226, 0.3362494101186163, -1.493662097876166, 0.03240872048985224, 0.043208489750416836, -0.8875683087937283, -1.0999459818679709, -1.437699526841773, 0.3641891648970874, -0.5579791400127794, -0.40127321197039284, -1.598125517306799, -0.8209112321645583, 0.23725191296733975, -1.065873155859499, -0.6401503065039205, -0.6002843054002694, 0.6248021200666871, -0.9332779087078753, -1.4153718855853101, -1.0333212311251339, 0.2149993167709394, -0.6280126658251135, 0.6341983867062279, -0.5186598295296057, 0.13551556602311032, -0.058443340274361155, -1.434856430383966, 0.8730353249202911, 0.8455421611710063, -0.5590179095362721, -0.6444724184505966, -0.3778570652680575, -0.37403122765055125, 0.41859777266763515, -0.3243564727096683, -0.15756222763372962, -0.6553140364724973, -0.7541311827783045, -0.7773524233894415, 0.8039617551901111, -0.4071313548035522, -0.05607228605797523, -0.4408666820097777, -1.2388021178566089},
    {0.9305917062450687, -0.7226757390190468, -1.0748363858878136, -1.487632770232881, 0.5685737962574395, 0.15039693194988446, -0.8473235507818505, -1.0466430515152343, -0.19539260147983267, -1.5390806124777974, -0.3564125208568517, -0.6281739464396139, -0.31991046818789654, -1.2596866470725305, -0.6116947565248513, -0.44772990716819344, 0.7721234230754578, -0.2608561784095467, 0.00929969033653166, 0.8047791794201239, 0.8029680854415394, -1.0374442439524862, 0.6647635085443008, 0.7266657175172238, -1.31778132092761, -0.5070951475023798, -1.104398001827106, 0.6680359474557959, -1.129037997359943, -0.9146297886384953, -0.6485379382012348, 0.47395076324867325, 0.8195985930251559, -0.5663344428106822, -0.31183669755240456, -0.962185447570169, -0.15676534565235786, -1.56137395528299, -1.7265597461431896, -0.6668385162337352, -0.45886338380311953, -0.8811744172936631, -0.9724014531536571, 0.48872270568442217, 0.5256170826660113, -0.9476061443006092, -0.7027467022822693, -0.9351422006052338, -0.1947980500244881, -1.4936331851223676, 0.6061244266831849, 0.11761134567990675, -0.944581371086338, 0.44748031298490865, -0.4448905355333024, -0.16418206157763643, -0.7999087762989247, 0.07948751216723392, -0.4001419644164496, -0.24445181166580915, 0.13290273368141037, 0.6367248029336776, 0.6238862706385121, -0.48824401429221603},
    {-0.44130228766642143, 1.0871350015830226, -0.837744244793427, -1.371979247237982, -0.6902654232959866, 0.5956982783520955, 0.2091281389762039, -0.7395852518360713, -0.5772114127102373, -0.40135368375697006, -0.08526195626643332, -0.28480201042278835, -0.7421040613606792, -0.9022131449647713, -0.912616586467915, 0.2748179930691054, 0.5343486179112684, -0.14245708384658376, -0.2045674858498531, -0.4270068984711242, 0.07505636537265682, -0.9164358262379281, 0.800884130456473, -0.29897812016104197, -0.24943901263447513, 0.36798906112249824, -0.2656129345221589, -0.7506590719233315, 0.41054226154333906, 0.9574005677544134, -1.3199335031462043, -0.9766245203681464, -0.5324924822729268, 0.16793747238138157, -0.20776217573925163, -0.8016166583808793, -0.8144585411015068, 0.3572391807209255, -0.8845330497406877, -0.2849106446932071, -0.7899582446159079, -0.9600658354508991, -0.17038535672141383, 0.7303852753998816, -0.7053878083476132, 0.07605502803791946, 0.6441291367551141, 0.22930395557582314, -0.015446690444425844, -1.2936642090221653, 0.4061470610367249, -0.26503551578017387, 0.38470697320883124, -0.15001411674096765, -0.520337452356833, 0.6287653292485492, -0.1368482802946322, 0.8448007421831328, 0.08444516614117142, 0.7412501043766393, 0.1858584616705471, -0.3250301155514544, -0.7480427098547154, 0.8142590220265771},
    {-0.3073596456646582, 0.5306034831149832, -0.9035849133872266, -0.7361667180331216, -0.8056158255119752, -0.517296204007567, 0.8689733053292876, -0.7607053486495899, 0.4487785687543891, -0.45451612243309414, 0.5824286955939382, 0.25968442339588127, -0.5381611236561494, -0.644360819575431, 0.2707073247597691, 0.5326168450801474, -0.9127353338487784, -0.6430235811874656, 0.12985364668083724, 1.1670266679847316, -0.7215756401689505, 0.25774671086562934, -0.8096644313146378, 0.7297415630623844, 0.021002969966627354, -0.2803442443426267, -0.8498638658854314, -0.7360102454951396, 0.15511385658742813, -0.8210512410502704, -0.4863794296994209, 0.3985119621551983, 0.46727599457904606, 0.8209708048378626, -0.510643582705899, -1.0108280086620738, 0.9504946929178811, -0.20844615850701873, -0.6885340764900878, -1.033096876708422, 0.7269862359512744, 0.20332624030286953, -0.5054039625632581, -0.03597092886942841, 0.583291312657083, -0.3564127458972023, -0.5281803940539362, -0.8610844045622635, -0.660815544093324, -0.19740724703833046, 0.08319629666342174, -0.23545416004954997, 0.5262072472195137, -0.7255176600693656, 0.056888714095277695, -0.07338764085492164, -0.2544962171325459, -1.043845978889325, -1.2357053502055548, 0.6743214338625909, -0.48636347024472276, -0.45756603969485204, -0.36705587873054546, -0.1757801287698068},
    {-0.388847255123293, 0.019180188218255255, -1.5486353687516454, -0.7035874690389544, -1.3255102095875992, -1.1336937077813083, -0.8268133832164092, -1.052235717412478, 0.34645476363392247, 0.35479093392266764, -0.029403344276806784, 0.4738955301805294, 0.5317098299362234, 0.7060833082971596, -1.1806979065556427, -0.28139309281158037, -1.0916053985165648, 0.12764840739780636, -0.06817547483393616, 0.36858190877376745, -1.0548456752291326, -0.10717076949093404, -0.6679915542010946, 0.6684840129311119, -0.8496269057482236, 0.19161345145593703, -0.0929908672871065, -0.9662472851533901, -0.6398178808110064, 0.12871563687107496, -1.0256273755937912, 0.4468147682096133, -0.12382976218434187, 0.7128845601590654, -0.07045411768650241, 0.38250797702555706, -0.12733812262455116, -0.6042567171510022, -1.610561591966391, -1.1046948032098711, 0.34720310572567215, -1.498788090755095, -0.8997183471163983, -0.23398540220772093, 0.7795926711004535, 0.6378827286250056, -1.077703203983825, 0.5014006431738167, 0.26851274084963467, -1.002902754453463, -0.32183856167137415, -0.2697097033542631, 0.22389658650865327, 0.2912194145966126, -1.2445920023049868, -0.23775325853343593, -0.4992964568191914, -0.2338281627079437, 0.1492104262356128, 0.18697900946221735, -0.8959194003722755, 0.6151489254492383, -0.8023105940221124, -0.8531128525441108},
    {0.772033411593438, 0.548051448755662, -0.7062820624247951, -0.8434090795301667, -0.3825587158313967, 0.5923455769072304, 0.20902680892908262, -1.3280342048093965, 0.6744553000694927, -0.18863554019665107, 0.37461661544099434, -0.860550343680767, 0.22552979798201142, -0.9428055363394381, 0.09004188416794894, 0.3907039483485757, -1.0457848920329937, 0.10772637725951814, -0.7600790615521297, -0.13196509665510225, -0.5567098155154327, -0.9735612278296233, -0.6643349326853428, 0.1408414429582463, 0.4861651571736946, -0.10341477620807964, -0.9979021769855744, 0.24119443425655737, 0.4918891517090471, -0.7031818962563838, 0.15318920348736062, -1.09221610092612, 0.060259837515407824, 0.3293817278204216, -0.5298623247362689, 0.23217167423116114, -0.5831321287239469, 0.2519482388059336, -0.5108508923333108, 0.5270304158423802, -0.22200541744998356, -0.3705123058568025, 0.3930896493330152, 0.8100272775596924, 0.29790250567756466, -0.2779900447090017, -0.12543554008850133, 0.07318013768932438, 0.11151160023037494, -1.4830515891078122, -0.8067596617869913, -0.14575334126055536, -1.041623050383867, 0.9612294334256642, -0.5025166212916298, 0.2236975562488316, -0.8987930872911658, 0.10818866778684132, 0.4799855737316655, 0.37610926664902966, -0.6612905128767028, -0.1762151396881047, -0.18669824198856289, -0.31737644093805767},
    {-0.1981251542570236, 0.40274967233147546, -1.4184811940718356, -0.01642626109372465, -1.1360316748950425, -0.6060780048998667, -0.31886674564952266, -1.261383410459519, 0.10962981160592054, -1.1208411654404664, -0.1307954926141931, 0.8534563432629507, 0.641273526166026, 0.7848361622814235, -0.2538923628387543, 0.2366866839799119, -0.43217527292424784, -0.3867390089809088, -1.2196003149206966, 0.3960355155237385, -0.012651881347922302, -0.9628122533027859, -0.3825626525293953, 0.77497635713803, -0.7693428448734578, 0.5282946795468744, -1.4286431837294031, 0.19931846928766445, 0.6481579015809168, -0.10627623641379141, -0.0821030196936081, -0.44648730534516523, 0.3160783728848613, -1.2067494791936473, 0.9826041723519778, -0.8000177686888805, -0.16068267058188912, 0.2666040355941552, -0.07583360517203268, -0.5449937789351215, 0.18333107603983936, -0.7092046474078333, -0.7937119012131946, 0.655239592053848, -0.990481593025578, 0.10801367838381769, -0.32159005719365197, -0.5643290229788721, 0.043025961507495984, -1.3031846047821027, 0.4286872127659629, 0.34201087356350457, -0.18483524113010635, -0.20576021091882687, 0.5938776176236296, 0.15724325109374623, 0.6367523818498412, 0.5387980762195542, 0.2484780916108999, -0.4847482277263078, -0.702037514695494, 0.9518403637326046, 0.2056390859463559, -1.0336250669774456},
    {-0.3150380235948662, 0.6651639983213713, 0.3944159550088881, -1.1756050617902654, -0.7335974545628486, 0.29318596615669945, 0.31381951770075467, -0.18355103386381352, 0.5014397284754442, -1.4089534681888236, -0.5618884676585207, -0.42958975998927396, 0.45333402451539495, 0.24163635367988792, -1.3079489962685105, -0.9918518589555011, -0.0521728884132643, 0.149507503541726, -1.4271612085657714, 0.45443619996898926, -0.05528407466576363, 0.27700583275376445, 0.9144042148903673, 0.7478308265002206, -0.6381910381878723, -0.4452299546718211, -1.30305961172195, 0.477243716041674, -0.9314036419462544, 0.2556285149247853, -1.2562487253743322, -0.9056177544758265, -0.7762395851639471, 0.44863553071822526, 0.040310795128388026, -0.2147420504820062, -0.4583379241013477, -1.2218606727859294, -1.0691686257565989, -1.378656774061523, 0.4309277998593116, 0.08734627782800435, 0.9071019302143445, -0.8906947986301542, -0.16256159864657818, 0.6945719160194067, -0.9727937562771, 0.4589796787279359, 0.024931230254679117, -1.6841070191084377, -0.5021336829793182, -1.2085519996424268, -0.12087696114377272, 0.3645908937759691, 0.3691866457288335, 0.3349789335658066, -0.24275876006666963, 0.7094791409554164, -0.25759683254645377, -0.36899116663231596, -0.8279797127583615, 0.702680388595104, -1.0110145055387847, -0.9001272820949436},
    {0.8295032726375549, -0.10870361455585029, -0.9730112549620411, -0.3281847392902948, -1.2434673641831593, 0.7926283288981643, -0.37561062610811, -0.4433417028202402, 0.4650659633103711, 0.45720795373407075, 0.015951157780451423, -0.28298069368462503, 0.3631420692970777, -0.5824793079206584, -0.9853686653876393, 0.05503549094606144, -0.07306593688075254, -0.489746572377685, 0.32515386130494617, -0.7016443481475697, -0.024423061152907998, 0.1321878699412192, -0.7373631158208187, 0.12255513254423031, -1.3608978999892813, 0.7873350241372702, -0.24604396460300634, -0.3643794474288793, 0.2583378564663466, -0.8343599810713067, 0.38561630956843806, -1.4596178531383805, -0.33526824277954703, 0.3030050036437214, 0.41527093267666176, -1.370656631164999, 0.03719197479789334, 0.04517454729501375, -1.6705703186732233, 0.003490668701083576, -1.0260699937852824, -1.486073433278162, 0.8530231683342695, 0.9815343625040653, -1.0326068709135041, 0.21228527575035636, -1.384354838674395, -0.9957470660145302, -1.0181773969410177, -1.4348163256784299, -0.07177531697064209, 0.5115587547210259, -0.256007577506481, -0.1313500231223219, 0.21577311431851662, -0.5448242616744782, -0.7133151822899191, -0.5095658926522111, -0.689405285319103, 0.7484538875138239, -0.9544064351132029, 0.9298451887079775, -0.7024968198721756, 0.040978333201910445},
    {0.5650702668970145, -0.7316732877444021, -0.428566584867107, -0.6371446589386142, -1.2045153474801369, -0.4876460904463644, 0.6859976823502525, -0.7524121785565051, -0.40261639623806694, -0.07631029658192938, -0.9674279223553562, 0.5718908781346511, -0.08010451324525325, -1.1244678776506665, -1.1941089751150291, 0.41066196421230977, -0.2930638207015691, -1.1086046516667023, -1.1023443921486664, -0.9342582705721637, -0.22065494013218614, -0.44733286381145426, -0.19255845448363387, 1.046959719586066, -1.2802624167605525, -0.7542486139668835, -1.2776116267701303, 0.2799389341483769, -0.9768161486666118, 0.13145622807222349, -0.7726023146321902, -0.7102555841613989, -0.0960622047819341, 0.16615662961228894, 0.3093274991635221, -0.9976682162415443, 0.5910216994688846, -0.4844179435118266, -1.1055637210956233, -0.89204166451098, -1.3480249601357728, -0.6023211129810353, 0.9671533352332896, 1.0015402811754976, 0.25073458381677, 0.23328690770942032, 0.476306541822154, 0.708583566791531, -0.9489317126992114, -1.7675035623483684, 0.49255685734583665, 0.6225258526210251, 0.33623928144953347, -0.14856893515777014, -0.06365759355916244, -0.9051692125438857, -0.2951875070590467, 0.41137325924961055, 0.5419036727875611, -0.23124191283742, -1.5439474799415582, 0.8737888868880687, -0.1667645389384958, -1.0014645644004374},
    {0.5248393172069022, 0.20848475020979984, 0.10014390660879682, -0.6619318884602247, -0.7643187409785375, 0.6035681253596823, 0.06821470908317896, -0.4430026154525442, -0.4059522037064124, -0.10554724433719287, 0.13468512271722155, 0.2530439271568276, -0.0006023247747743199, -0.8920872174175286, -0.6293342064118437, -0.6102360549656511, 0.8397341036412734, -0.8236974604428678, -0.7729747634793007, 1.0120195319890841, 0.8165799837723328, -0.8168227089612387, 0.23853315465432792, 0.11776881772165597, 0.029345491381610387, -0.5241884656273229, 0.5574013141374234, 0.2063401191512796, -0.6493999658041715, -0.994086730796758, -0.9405081493517621, 0.47812822613095274, -0.16189439872941047, 0.6295838620516659, 0.3069035409133715, 0.29724073250594385, 0.32543042573458214, 0.05567808689564203, 0.14469465912123913, -1.064741032947732, 0.08271275254135847, -1.4082582916242203, -0.4087491667405417, -0.25115444676829723, -0.36967795378307483, -1.0930196350469563, 0.5699701743044299, 0.12556477824550322, -0.8065771589687366, -0.44041072089849537, 0.2889573245229895, -0.5065294516027198, 0.6080721775023613, 0.34051472377941044, 0.17093019201083398, 0.6409496773382984, 0.532964766192414, -0.4745392845009295, -0.13391890177561475, -0.7083867319353314, 0.07010825327266815, 0.6446404111534566, -0.28701446198222014, 0.6274567543989649},
    {-0.11710973842762853, 0.3201429003844917, -0.4332805649656208, -0.9485327195853616, -0.6467805193272841, -0.45410633786426846, -0.872440620111493, -0.16535124656111946, 0.12540973203642417, -0.38520767155675767, -0.8270665150345969, 0.13444672083534712, 0.04750175664409817, -0.44743739600920046, -0.5744823445853752, 0.5306527932182044, -0.9678458642299308, -0.44437658402921254, 0.3001724737457601, -0.4640520205265811, -0.2573532598536902, 0.7831025434308818, 0.33907143681124147, 0.9178932975780405, -0.8731304988953633, -0.5381389648507672, -0.9221413233015567, 0.7240346689526266, 0.5694022788656863, -0.7040924279528131, -0.2857669387792909, 0.764787139831547, 0.6280267182049417, -0.4847356667051999, -0.14932785804012913, -0.03978380799339073, 1.0057109322333697, 0.06237081745612903, -0.7220402227281071, -1.112526989866705, -1.3791175764139467, 0.1409836198414802, 0.534874266145251, -0.16093403242888757, 0.6758916431267367, -0.843454756088045, 0.9893615235863127, 0.15417085658314716, -0.8900262736934126, -0.6440343677143591, -0.42032005413597623, 0.25185236363582963, -0.6654092814016178, -0.753921898600483, 0.7155273198042514, 0.26428856760284025, -0.37921662624911867, -0.3187932458263116, -0.33379121921398425, -0.9932186142684118, -1.0836603679629777, -1.227740197199796, 0.4462156920337702, -0.7648023606326354},
    {0.6989802591128125, 0.03920256838471604, 0.7528690973112777, 0.0902800606918101, -0.5154817135853985, 0.8446077390218505, -0.0578677180382203, -1.14121832308715, 0.16235811194828326, 0.852702179680601, 0.5925947854149355, 0.3988590856680015, -0.6059770047537488, -0.6505193535911691, 0.9294095858928634, -0.07405143728206168, 0.09046337618261614, -0.16241029035282492, -0.016703490798556344, -0.05118607842228579, 1.3504595121085805, -0.6367861443346096, -0.28705104573205026, -0.5118778184370711, 0.23027981759301255, 0.6601042365914999, -0.19898889050396837, 1.387251099482022, 0.8785737877436314, 0.43294034783905844, -0.3326966752063852, 0.6626121132386853, 0.6106506429312198, 0.3869873096436212, -1.1007451368786576, -1.0975339848803458, 0.9278332391358147, 1.1508813179805268, 0.5051952179028907, 0.6504391152300056, -0.5431110146542802, -0.6526700554229407, -0.5916408941803154, 0.6622375983841475, 0.9831305913901672, 0.4320142219283002, -0.7938250816771102, 0.7744960896904655, -0.9077984520109258, -0.6322108486231149, -0.06261776599902848, -1.0293198141091173, -0.157675956083505, 0.9956839142798514, 0.44269995790167055, -0.5625488204244644, -0.8606607162876541, -0.6787232702257034, 0.8685659081478861, -0.924441349075541, -1.0006022555310643, -0.4443299485570758, -0.7046334239735822, 0.5078230945907357},
    {0.036598708365397234, -0.8004684533236099, -0.7862378230123, 0.47547630813732106, 0.6487215044146328, 1.2842928665577662, -0.4221786513392649, -0.9214295056240225, 0.13612470344999056, -0.6413654599040723, -1.18542240708503, 0.3970260614551456, 0.6075533992803798, -0.7340381236991643, 1.141849346920285, 1.1371145175940225, -0.6720255012745797, 0.2654270427376005, -0.6400033174645682, -0.1543147926644683, 0.8045380402207148, -0.406526242528491, 0.5609205910028044, 0.7833853096162448, 0.31791439820403344, -0.4547831346333278, -0.44607893506936425, 0.027864169096461503, 0.5600597182555928, 0.7659688749851623, -0.2916419194684808, 0.23322835563446334, 0.5163728349393968, 0.4810730282555949, 0.5910914213463296, 0.7908990410695089, 1.0195364419948387, 1.2978169523897953, -0.5891642448486678, -0.965796786347607, 0.2638997837855052, 0.7936993831049123, -0.5340417227255029, -0.9065127814877114, -0.7576000444144061, -1.112265749384035, 0.6542705867801913, -0.3391408147882665, -0.670635580539229, -0.6072245053289473, 0.7032809116184157, 0.10016858863349276, -0.037193934840019, -0.0006453704023240141, 0.40349270602325904, -0.7026330713895124, -0.2820120173804909, -0.0722544497525312, -0.2563327534462082, 0.32182395959739507, -0.5724452516433212, 0.016774844199857978, -0.18858219745743046, 0.18425261910712895},
    {-0.23224901698576347, 0.5215595895972901, -0.7636531128631847, -0.05810894078307989, 1.02011567367018, 1.2979183126683773, 0.594337582799554, 0.3401083374173528, 0.06856188410066148, -0.5904108454592893, -0.028043087593857378, 0.7312622449767875, -0.382388188746392, -0.29978078672930936, 0.1801304846224791, 1.1492598096990356, 0.9873341936874913, -0.19890410737142106, -1.1346959196488349, -1.1165500550048122, -0.4791976056507711, 0.16651698042645455, 0.8793792873566153, -0.9473587426535451, -0.8404749985114464, 0.21407545767187544, -0.1033207452730498, 0.6338165759864117, -0.6426387316287849, -0.8887651456033675, 1.3808640753951602, 0.6227099899099194, -0.9490605190286528, -0.40465433121438904, -0.24715133083431606, -0.00637400735795782, 1.0646747727061008, -0.1376236981946556, 0.7476895888294889, 0.7744201507293585, -0.8295440102541092, 0.9892406574084038, -0.5066280968189708, 0.04577953809348476, 0.2802296734635755, -1.335267738794831, -0.0988712924634416, -0.39428376002288257, -0.05223725547568185, 0.7114713803303022, -0.9626582379408937, 0.5291165131890392, -0.0244786023093489, 0.016130433466263232, 0.8930723085174579, -1.0128156227732048, 0.06017006656980854, 1.0100815513646495, 0.47314544012408244, -0.7794307824609332, -0.13903333652402644, -0.019154379329885302, -0.30467482227526343, 1.172989106000744},
    {-0.38421865602146005, -0.6080065697480177, -0.3750886950827049, -0.19654484434568012, 0.12150966385706474, 1.1805610551684556, 0.44378124850912765, -1.1549677005521362, -1.056960707286446, 0.8127683449493761, -1.2991064558559708, -0.030884075382112276, -0.48297603850063786, -0.543002422455796, 0.2461659913979084, 0.1903230410906588, 0.7215672424339973, 0.6980584780084808, -0.8750036818262995, -0.8342698200746935, 0.2333736586853041, -0.6343700158267878, -0.9002210997604421, -0.13647970014342858, 0.45129823331443075, -0.8004223565864936, -0.7262571941231868, 0.12696804339455323, 0.7739216264120004, 0.7936201937928663, -0.47251754858055667, 0.18624542337943387, -1.0653667973364764, -0.36756383687693717, -0.11201078615269985, -0.3443154237592977, -0.6732730787092509, 0.03821425017679818, 1.0015334450032425, -0.12808897739488204, -0.7146217599977728, 1.167041201920233, 1.2111341573574654, 0.045028450514881524, -1.0011770400157909, -0.6658786930513789, -0.45244038440315276, 0.6693891973658136, -0.7463993719661969, 0.7354072634442306, -0.3196140450661651, -0.2400445808690128, 0.4353595465256366, -0.7233291653132508, 1.1633441202036992, -1.1550008539058756, -0.8554401804980175, 0.740784275087012, 1.222542137790551, -0.47712950587426, 0.023808999491194482, 0.5400067154302494, -0.8930152458284369, 0.6453154998957805},
    {0.505814206879673, 0.18921114347530105, -1.2676487051959209, 0.3898715411955921, 0.6127837358076197, 0.14315380271375172, -0.3434986256174664, 0.27163645653144186, -0.7077833478526206, -0.3419429685877871, 0.3985314618985818, 0.8769928844952776, -0.9079070383334008, 0.4244919182850371, 0.7089007112566946, -0.5088160411802112, -0.6370361720956057, 0.1438248382799829, 0.25472895485937724, -0.2194939104086966, 1.2182111664437294, -0.4808463906743216, -1.0761497531767823, -0.4658669021281529, -0.05077753042657038, -1.055825300199041, -1.0258675603052463, 0.7139684074024986, 0.8421063431959684, 0.6854537215599886, 0.46537240331850727, -0.6245031852285782, 0.47925209702535887, -0.03779222329589265, -1.0323616044683845, 0.0424135309736572, -0.060644592532708465, -0.13489532900257872, -0.9446026903637136, -0.9591741691842279, -0.3252825704514035, 0.6704309245876593, 0.5888758145619951, -0.4066891113827323, 0.6056351289807552, -1.1378998125708515, 0.9796883664946319, 0.5243728783423373, 0.131949111121124, 0.21231858074234483, -0.5532493952157056, -0.5876776308615013, -0.6667428876644844, 0.9453119029047682, -0.5265745913701173, -0.8579143380193516, 0.659157275218742, -0.19613627864406613, 0.1640155564494323, -0.5396454575365138, -1.0179521520889854, -0.3323131751463255, 0.5765459700154204, 0.7122571724034396},
    {-0.7326632636622723, 0.11968647218045403, -0.8775672716715378, -0.2824929963916159, -0.6192079314392577, -0.5874329088739486, 0.9210543046543979, -1.2622995737324842, 0.15245325521570688, 0.003552155438110446, -1.0153831421543535, 0.34286051143690555, -0.7834629675659726, 0.9034630808769013, 1.2726460266384079, -0.19153336244454014, 0.9999696066746235, -0.5067169836886197, 0.5374667232522208, -0.9985449131590575, 0.17927883809026188, 0.43765590071533395, 0.622548936140286, 0.12341211318423462, -0.46438438427409306, 0.7373532300183063, -0.4340960136800685, 1.100512965171775, -0.004343835829190188, -0.5511299222536152, 1.1781367102157365, -1.1142404599792899, 0.4866294117376128, 0.5503026834386282, -0.8153582480679081, -0.9569111271547753, -0.4562208093172014, 0.8854908720393881, 0.5615331238856506, -0.5597602173021387, -0.5043170500130678, 0.1191493527985627, 1.1236294385397543, -0.653036400250299, 0.718140699629289, -1.5359979267914432, 1.160839492237553, -0.30911979475573903, 0.19282360290178907, 0.49879784425650203, -0.6586276479533448, -0.6012309077326049, -0.04630713462541188, -0.09748556041507953, 1.19958448384358, -1.1686542602788892, -0.6923039870834701, 0.19280698937613094, 0.4297519633784877, 0.3331405897743127, 0.7941371284114004, -0.07021929647986519, 0.02453519801450119, -0.08488064870065086},
    {0.5691368135568861, -0.29355844629635025, 1.0271299882816876, 0.5016162036866244, -0.1706108313755298, 0.8924198563956884, 0.4716210166464258, 0.8665400448347019, 0.7797860379133296, 1.1449026834520846, -0.05290016065951782, -0.35717275255314657, -0.021421723278666344, 1.0150601876511747, 0.15568623466567877, 1.1099749835114692, 0.730495855164083, 0.8584298682619798, -0.8616448959619474, -1.184382716137615, -0.21038918399027987, -0.6287452133903836, 0.28445031235035956, 0.3665879997395143, -0.48839985974939176, 1.0591799706290121, -1.3187225071112505, -0.45322578607043207, 0.7984031656052654, -0.30289903381850475, 0.9690788488228317, -0.492787009278601, -0.9024261704796497, -0.8095005859323705, 0.19595052193264634, 0.3763576735594229, -0.09761609978288138, -0.6365090672901367, 0.016903223824458854, 0.7105181213122544, -1.1223813614744023, 0.11688336698497352, 0.703043821790011, -0.1471552255864369, -0.5585146258432235, 0.5125150243376706, 0.5831299493081911, -0.23513442604000137, -0.5356359549307613, 0.04143962740124219, 0.150776649102802, 0.41644524766892504, 0.6133593027100729, 0.6849155380930683, -0.5662900972227115, 0.4415007648695386, -0.7297558499970813, 0.0647282580659073, -0.6266988706259885, -0.5430020084718018, 0.5184849964119645, 0.19346872065920637, -1.0225139558550127, 0.40148755170623},
    {-0.36137449738508187, -0.5115819377377976, 1.0426428079836774, 0.6487860793533896, 0.15658966045542055, 0.12335333710638771, 0.33012268846538056, -0.792610498680328, -0.316012212923228, 0.7897743345609262, 0.2232103770008612, 0.3833003336424764, -0.17309178456711435, -0.025275264524654412, 1.2944785605193985, 1.0292740885698042, 0.6471582040246341, 0.7963404693419577, -0.14774480260488618, 0.02317961276503644, -0.3213066208789229, 0.4573545485849842, 0.2993938702029974, -0.656109309986037, -0.27487196711414275, -0.18711285741069877, -1.0363605977734418, 1.1661902738112637, 0.255037535583737, 0.29346323241232664, 1.0045371906655092, -0.2981185102662428, 0.18079207037482217, 0.8022648043428442, -1.3034611640004072, -0.43175698581937577, -0.08653939441204772, 1.14846241077074, -0.544151433178836, -0.3970578649130976, -0.6019584200068716, 1.20225107585374, -0.006078230721722125, 0.021387774007015366, 0.6292581819916482, -0.20356777458770917, -0.7557451338017824, 0.7821138351591552, -0.47904593397828343, 0.0916336125049246, -0.777492857925802, 0.046274443435301967, 0.04992079259027197, -0.9391153481057298, 0.05789745827384244, -1.1959522988784357, -0.7933319332341722, -1.018837562057825, -0.49720827127627815, -0.3597130046616274, -0.5217745293131464, -0.6638742444098903, 0.4716847075846215, 0.5432531182975245},
    {-0.8872819763449151, 0.4069059007739915, -0.10237813295893641, 0.2635765432031924, 0.5488271659141618, 1.056731465965071, -0.5738176890503114, -0.6712244704964284, 0.5590102390813737, 0.5621539763724895, -1.2696950265684708, -0.23832615523926612, 0.10963322836154082, -1.1304216198232155, 0.08933803988259222, 0.9587803294956113, -0.18209412673738895, -0.05911516380948738, 0.1319352160405634, -1.0841147640396578, 0.954208132094486, 0.21470610115298183, 0.8679483647896443, -0.2202750646212208, 0.19765533047391667, -0.8258422107163443, 0.45777768344067044, -0.3916331046101637, 0.841616219102221, 0.39267161661213934, 0.3506521586658434, -0.5456373433827638, -0.7273951321157544, -0.3873246256088658, -0.650846238113358, -0.42735058309653134, 0.4194075944464998, -0.5043755364653555, 0.3143606317002725, 0.4451991457499458, -1.0526719888015703, 0.9613764822660128, 1.1635290134956413, -0.08832433460848277, -0.27354048267450526, 0.7852355729321795, -0.04223034208305768, 0.4721963893294095, -0.6233327996677189, -0.6603685175179173, 0.3851656122372723, -0.7752800091836458, 0.9888343925638119, -0.3167593036391919, 0.22641895845312998, -0.6568405731446442, -0.5326453205550571, -0.841640550226821, 0.10237716379776916, 0.7719811506645295, -0.19240935035000198, -0.857813079006981, 0.7123987922654428, -0.40293552945514566},
    {-0.7164290560061538, 0.12100871293007547, 0.544827016099404, 1.042377196534097, 0.04915443538794536, 1.380181600132832, -0.15053013636025767, 0.27382113551407117, -0.644090430082717, 0.7517583484134837, 0.24297639597593418, 0.7321931454990782, -0.39865597779954826, -0.733280712116614, -0.7011035220281607, 0.3018544516301951, -0.6406031750333154, -0.08453766158493291, -0.8834092574053717, -1.1153373989710822, 1.4641068976281642, 0.18688978860898545, -0.5166962464138929, -0.8449979359929787, 0.8325530215090485, 0.20749051138616917, 0.23881239754958267, 0.3595594118928324, 1.0032299716770203, -0.18519348493601542, 1.4542732683825397, -0.6034512460271133, -0.8639765295514479, 0.881046962502832, -1.1631697874352622, -0.14046441766945195, 0.14836154026576726, 0.4704381243398618, -0.6443136795178495, 0.3687328302903388, -0.42729211419720986, 0.8297207388772412, -0.18819955012260053, -0.44235585135420136, -0.2328459528360216, 0.1351045262887902, -0.7599427979656079, -0.34553690611275734, -0.9892555675313509, 0.6413744231473861, 0.5398614727227072, -0.03197021637600144, 0.2574965947092082, 0.6693222637769405, 0.9674103403263907, -0.4942820525479513, -0.03308940697702216, 0.768766851805241, -0.32050184037149065, -0.009776562910702065, 0.7613082028557806, -1.0816325728346359, -1.0506292020866639, -0.5162455534060936},
    {-0.14820677581779673, 0.936764351619905, -0.2594688189841827, -0.4416226387327107, 0.8523169907879868, 1.0467773746211746, 0.23522579148276404, 0.5883855263059868, -0.7546821796500643, -0.5354784354691529, -0.027867230703094006, -0.8895684903899318, -0.6059512492887581, 0.5406199722556069, 1.083609368122184, -0.06643933636548155, -0.4850642029462203, 0.6309897871108278, 0.8387172466861207, 0.3003404210828549, 0.6352003859326334, -0.707984033781348, -0.5083505862481914, 0.2228455419726251, -0.23027013948303948, 0.755273490385316, -1.2469100466290823, 0.6393016049102824, 0.9353994816593714, -1.0327305068273362, 0.15668657150985546, -0.688667092355643, -0.1767221828774281, -0.1395096108059886, -0.6462635371280177, -0.744666640972828, 0.8847509001056689, 0.9980439732262764, 0.3480733199039398, -0.89173240655419, -0.8375637841577989, 0.2422012199414051, 1.0623674256316111, 0.8016345767774862, 0.6920395654915512, -0.44210980385734355, -0.5492271378038386, -0.40710580746189184, -1.0427728611519995, 0.4876270132640544, -1.0787811964883673, -0.8736676528890569, 0.09407663888602849, -1.0871229187977876, 1.1581822926736596, -1.2087658551345506, -1.3221513385315895, 0.9883632080699271, 1.0544405086606503, -0.489548778309091, 0.2920971911913638, -0.8531848285437988, -0.3748185949466035, 0.4056361665076855},
    {-0.9418854998213283, 0.30482670953113583, -0.5746226689573767, 1.0707540553885981, 0.9976802434686823, 1.3154695449186689, 0.6426698214330094, -0.1538385208495907, -0.07637301522278986, -0.053282577928435125, 0.08830374975832146, -0.10483326893167279, 0.04803401950414646, 0.7736526462133768, -0.0372358991263106, 1.2417767897719043, -1.1113217782125593, 0.34585702770220783, -0.038914797933839805, 0.03474269132517552, 1.116251555465648, 0.9836666510138814, 0.5760047809832888, -0.20537025212009588, 0.6610658597650763, -0.9120037641868911, -0.9920991240385819, 1.0704173767190128, 0.09781678441682995, -1.0781461980972715, -0.37042279631198616, -0.24865701208664703, -0.03246885675263674, 0.09642427486237073, -1.1055370467256824, 0.6740495164247501, 0.8474108419242877, -0.785077698740781, 0.7778480071403032, -0.7288476215674315, -0.7831759346788043, -0.7850935903326304, -0.15182766402639802, -0.46211731982748167, -0.018295984576970462, -1.1708191870931328, 0.8876643283482448, 1.1131892469273106, -0.1901163006536069, -0.795980149027213, -0.36830944390371817, -1.3409960099700586, -0.7150153123347377, -0.5306541730183763, 0.7849374441431534, -0.4336555138535301, -0.7714216936935989, -0.7203120644208623, -0.6828081199111709, -1.2330866700996954, -1.0206952936699667, -0.9258356026752543, -0.46735669033439353, -0.549310127398938},
    {0.8604870969642465, 0.6577910946292528, 0.40721868212542034, -0.485683486484288, -0.8480725456937569, 0.7701347891596864, 0.48950291125571477, -0.595788375366126, -0.8322676839846124, 0.9852475474853913, -0.8720211747361503, -0.4483868491718441, 0.27837178449668293, 0.6400159508159361, 0.7728636760264782, -0.5057749413610899, -0.41989196074517604, 1.0719884309890029, -0.0939966129412707, 0.3036918261255435, 0.7339568550158568, -0.22956275663916417, -0.41199934004256605, 0.8410164742618678, 0.8435342176978536, -0.009432208677052153, -0.38065841574811915, 1.6316684832028199, 1.2718384686102595, -0.5557334212464946, 1.428830529148889, -0.23301496208916647, -0.5929515618560246, -0.22131777292765437, 0.3682509418367201, 0.16549197246014666, -0.4133599390462729, 1.0257244686843163, -0.2571986886636244, -0.2537787315954329, -1.3534891895069705, 0.7420457947650859, 1.3209993994303681, -0.3663924357771108, -0.2791397176860938, -1.0319020141559305, -0.7669124495522469, 0.9009180392394804, -0.4835858463306219, -1.0934266076300565, -0.6186563099948971, -0.06318075068429453, -1.0964052838438945, 0.5522067433225887, -0.16622488267285382, -0.8288916268812943, -0.6018709753015467, 0.9630318629409033, 0.8757482840725884, -0.8150465586645466, -1.0557203134532662, -0.7872806480755229, 0.1436711680700803, -0.07296347903446973},
    {0.9944890235005923, 0.15431253059043223, 0.08975451734291788, -0.050774347078364424, 0.010483663075123146, -0.10199212295886795, 0.7312362535334854, 0.9980284378626936, 0.39898285089767005, 0.4751436931992945, -1.3687358964358272, 0.33242191099733565, 0.27520622894076296, 0.6977204914430039, -0.6433040060722001, -0.6518594584608072, -0.8019715312388067, -0.8409326552567151, 0.12786589158479927, 0.10506428265754571, -0.7874659813037729, 0.8084007659132043, -0.29441168804384765, 0.32050314132224667, -0.2211489429904172, 0.4789720262222942, 0.8944521195266941, 1.0618481649545688, 1.3894916981945695, 0.5797110525776157, 0.9048557123871784, -0.04666096390117371, -0.23391902027017528, -0.5342613806997055, -0.016883921232476243, -0.9252901055531884, -0.9685740654626541, 0.412255859911406, 1.0755785596099814, 0.8454468168171401, -0.5386130239659711, -0.21001392986911402, 1.5778180410083316, 0.1972855219099927, 1.1523344374439792, -0.03651296099961616, -0.36831304956943695, 0.6245612390918608, -0.08510202394849338, -0.6192941275474889, -1.1149908345854134, -0.2298741631650625, -0.16083114795742182, -0.8778202553598768, -0.4413407604209558, -0.47163302843593075, -0.4648458426086869, -0.9420010613228083, 0.009475327748617757, -1.047745904958677, -1.0586663672838716, -0.766299293738999, 0.44717058225649425, 0.4777891454909302},
    {0.6220049873295288, 0.9480886255076895, -0.02039560147818297, -0.5908738006574983, -0.7841788742524431, -0.36457085177447657, 1.0243631721256554, -0.41930551097491103, -1.0887943434103124, 0.3985900068849363, -0.9995333400274983, -0.2803026981990107, 0.44329594624767615, -0.3306902425609759, 0.9427226524918049, 1.0089262044307938, -0.5345887148417092, 0.8873307539481158, 0.43089193069560194, 0.6604639541483399, -0.4235985619725279, -0.7600590989087516, -1.006701402898891, -1.069393822208511, 0.5367427268163827, 0.42202361859811094, -0.2751435602122046, 0.727426797973557, 1.1839929098027082, 0.9486765818635192, -0.473706010301371, 0.2900928216496724, -0.8234260167434333, 0.9417788589416746, 0.8214887824714501, -1.224356343823113, 0.6453469368483917, 0.559565752664401, 0.039014426901454444, -0.40049534777395285, -1.0160047149737925, -0.22691847761193495, 0.7224276423849477, -0.14924241761239027, -0.8599023457670448, -1.106512883073008, -0.45943903787214435, 1.1935356912072894, -0.10807664513244154, 0.7278554168315613, 0.21361966668162816, -1.099874031082878, 1.0679680172147923, 0.8857360657184997, 0.5677613002070188, -0.001250905220243729, -1.3087092606532131, 0.47685071202246, -0.33786506067295596, -1.1093295632425426, -0.6437959759606079, 0.4403179642889407, -0.7783126410087531, 0.16848439751888536},
    {-0.7898293447360354, 0.7866203554593756, -0.3327221404946262, -0.7923127804830379, 0.1313101875002996, 0.35657192543416105, 0.20554910398831772, -0.7627325168038255, -1.024259994893607, 0.4065981023876367, -0.762720875258168, -0.263159466188416, -1.138502021109974, -0.0026990286426857107, 0.6786821135215796, 1.2276906680970645, 0.8019741376890996, 0.7852428104029069, 0.9315541220669119, -0.2913287754324239, 0.19774774488373884, -0.6151191037561126, 0.05397175756283841, 0.029353185764472624, 0.1068761167805121, -0.6072188240333812, -0.5574896784006591, 0.6055830506754587, -0.2341355629897569, -0.11260029960736437, -0.24612061375726732, -0.8170888347776182, -0.25000341903663986, 0.8467569314703332, 0.5005351439430136, -0.34336444686139145, 0.6592666984960973, -0.37102211795794215, -0.8917592146719402, -0.2096233733736531, -1.49144709162286, 0.6578155206462203, 0.31378292071265945, 0.3690916799224809, -0.2850896746921065, -0.22056024262568516, 0.1765006896354917, 0.24988842652472232, 0.2464489111090814, 0.48188654672726167, 0.8104840774707921, -0.7331585011811033, 1.1306960695402766, 0.19034518748215287, -0.08808446880687111, -0.0818091440831403, -0.5122927731876268, 0.0820067365039673, 0.6729807533105822, 0.4214436427129368, -1.084343124338619, -1.3327334267561852, 1.0115853895844718, 0.8038080294100513},
    {-0.26771824238394937, 0.6769527385088739, -0.36012812164102664, 0.9032949649307557, 0.15574304718226029, 1.3039943632994437, -0.43192150038085353, 0.20191368657336137, -0.028733414154199274, -0.330085935404788, -1.408503484582308, -0.402596205675289, 0.012926405273840457, 0.20278649173302926, 0.42982732646860294, 0.4455486449539138, -0.21342884098267445, 0.8089118649218121, 0.5553287810980424, -0.191755505202276, 1.4278762854925577, 0.7959153509325204, -0.4700332735528962, 0.45044883726159346, 0.9317937987193256, -0.3258126110460016, -0.4795803423357452, 0.12221299094768857, 0.2788026445016992, 0.17460436723747375, 0.7187417865165768, 0.831338640881252, -0.11420577360571317, -0.06242283877293443, -0.17262213624802877, -1.086400580067766, 0.06941907429344586, 0.821260057222468, 0.7991702029108534, -0.7120386457992263, -0.6373735777847039, 1.1495476061646852, 1.241480220269971, 0.8795922663734138, 0.9368870796384517, -0.36681497149527276, 0.865804343616409, 0.6772822016075755, -1.175487234979654, 0.5017958361820773, 0.3213994902531377, -0.549820800309681, 0.6245518980942891, 1.0488447921370483, 1.2983866576286958, -0.7464781951099394, 0.43537986123276695, 0.5949511106528509, 1.2225218712555457, -1.1867143983081707, -0.43478458227724515, 0.6324956974074254, 0.515015859408296, 0.13986197873906006},
    {-0.3413018252501482, -0.48959235948818836, 0.20922835886586844, -0.0803894985933532, 0.1171257956236297, -0.18543453070307064, -0.7113226330143214, 0.8942121338179848, -0.6456228128293361, 0.22357136965928284, -1.182691542099448, -0.3785196695462504, 0.6555821585007481, 0.26097715691934464, 1.0628959443843542, 0.37043512791492644, 0.7853047834784188, -0.8736291221811769, -0.4953766326015737, -1.175093316120616, -0.22317346993203463, 0.5525418801444488, -0.6214107318079546, -0.044812401118172966, -0.3233473452585818, -0.7970858107406374, -1.083616063804623, 1.0268204022659575, 0.5365928506049107, -0.8606743828102722, 0.919158842192397, -0.930767142646332, -0.028316736255671618, -0.1860721060397332, 0.7405367860138689, -0.7786106914304521, -0.7160979498538278, -0.5020794082734384, -0.6608462544814783, 0.2964042443973625, -0.5065542875227584, 0.1428010489676799, 0.3823970476305562, -0.7225927740635126, -0.2773876924468864, -0.4087854080385389, 1.3375803890430964, -0.0209685762428051, -0.7366464401275349, -1.0072411013796956, 0.6208211554654507, -0.008205857956614483, 0.8604291026219014, 0.11077912206650381, 0.19756346229128507, -0.9923413435727535, -0.5633561819041467, -0.3978804056523541, 0.633865823763422, 0.6087744135074254, -0.5879422613063768, -0.4286473721276114, -0.601237394728167, -0.5829199175916265},
    {-0.14235945132046035, 0.5186696586468009, -0.9124862415422595, 1.0544234270238293, 1.3186085013341458, -0.4862305857943929, -0.6097292198501264, 0.8924877920744589, 0.26544336378210814, -0.49921914719913557, -0.23270353098718866, 0.37457224840632863, -1.106396456753894, -0.9144614924647388, -0.051024413941876984, 0.2356442242107395, 0.48496099882701504, -0.955437770695328, 0.0805783010602207, 0.659430185313998, -0.6870083715305998, -1.068536460878978, -0.5650529195980369, -1.1281330441407205, -0.7981644379317351, -0.023263497211677794, 0.5484744844464088, 0.40158912121865026, 0.9305528606267408, 0.9516001412128029, -0.26494539894163105, 0.7468563341113126, 0.12963632581671392, 1.0935359760057632, 0.07729652525127453, -0.06258419265561738, -0.7152546009546602, 0.42244879978201066, -0.20042203933274047, -0.9562578838120563, 0.41039649237356224, 0.4063939735661337, 0.7353773876377493, 0.7273092003118592, 0.2534715830654075, -0.12802382755611172, -0.17017863508474798, -0.20695310155417634, -0.755574267227682, -0.3946139445460544, -0.19696361884624386, -0.4707263402224579, 0.7928131579972856, -0.01707212290224083, 0.31236947350760813, 0.14341948168033772, -1.399026289206965, 0.16276039161773534, 1.1364093440922012, -0.7786702697146489, -0.442992246252602, -0.6199385659949347, 0.5762501882194968, -0.4828590245792996},
    {0.8485169603429239, 0.21199408970666533, -0.5054951131912788, 1.2478438744579967, -0.18544556180451932, 0.23771238633398373, -0.19606303327100277, -0.03752546748190791, -1.1396108446818163, 0.17521135181106656, -1.438962739778581, 0.6517711511696027, -1.0270808741995037, -0.9783435243896129, 1.0571334544500204, -0.7226695296944358, -0.16046592560971376, -0.12531565141748657, -0.46649664551962955, 0.5468836341786585, 1.0460063354928686, -0.8405334674842139, -0.5373238844457741, 0.3049353333012975, 1.08738107425533, 0.9298794863602258, -0.8175635454509289, 0.8823608909628848, 0.1622467703812298, -0.3714085492396867, -0.38469468737980594, -0.8245965507464328, -0.9754650325030615, -0.5493473662471753, -0.5099523405612061, -0.7920434542234659, -0.5858568155856867, 0.553721481699929, -0.9715586191248194, -0.8592314568938876, -1.478813012949623, 1.003667775096133, 1.4451574656526616, -0.41202064555929113, 0.8523730743728849, 0.7039812413357669, 0.12447439918288276, 0.6057616430360291, -1.3003597340698534, 0.6882053823500879, -0.7432503516065213, -0.4561347909370517, 0.1380767028413495, 0.017577005169689304, 1.0770633923822401, -0.901508435818859, -1.1938492823437674, 0.9687912441211233, 0.5175040898405883, -0.9602966938554377, 0.1956875898507044, -0.9773701633524077, -0.3028607495527365, 0.6536526788992323},
    {0.17857112864617475, -0.5499573785743023, 0.6490892023615785, 0.7243246990737491, -0.7302771626737544, 0.6010690819991455, -0.6651564043854802, 0.8079422370245851, -0.6332862080337112, -0.6329430361998356, 0.07158299227395015, 0.7227574643009266, -0.6187703482456605, -0.9900140593295295, 0.897252237317044, 0.0479985314537985, -1.1635734121202677, 0.16626427527443868, -0.4854299287644648, -1.2009758280812886, 0.08969419715964135, -1.0894342469246239, 0.41128086657710516, -1.0687945467906053, 0.8002803773593746, -0.4895781575727922, 0.30114860143163064, 0.11914788061197913, 0.24627291087295186, 0.9402986184570659, 0.7538740296119562, -1.2197249139730837, -0.5039753389370621, -0.3570642418190072, 0.7312365522208871, -0.47258022607528405, 0.8802620933756619, 0.6697259128485752, -0.19470564820281552, 0.41806004419075043, -0.9662888535937303, 0.6661431738554819, 0.8026187830471531, 0.26620716241741244, 0.36927516785105396, 0.02437065803136308, 0.9572061139063379, 1.1066840122503891, -1.4402605457406892, -1.1358279387019974, 0.0056200352042160145, -0.6913308570830704, -0.7992772619148047, 0.09878393002435697, 1.3904944253256055, -0.43427430273057177, 0.43461808781201383, 0.2691635896433103, 1.1162069757595696, -0.844041903512314, 0.5908469323052472, -1.2846547092847753, -0.20662373561106429, -0.5263188697415083},
    {-0.8725024017498259, 0.6287060756256267, -0.24512711627750827, 0.46919314625481673, 1.1446068231207436, -0.6389524395708288, 0.5806978378363922, -0.7947009485770133, -0.7085935898553829, 0.9571125485496329, -1.4193809115725604, 0.8971964522586247, 0.7867524795544325, -0.29861975046379446, 0.3222394500188858, 1.0438891166483624, -0.1951611980337224, 0.15143774227197074, 0.28795639963730396, -0.5831169143614056, 0.49108595126683063, 0.41838473831171663, -0.7624511923917492, 0.9361877918414166, 1.1369084575040274, 0.5556360461973634, 0.856760389781175, 1.242270473905389, -0.014116418308627428, 0.43931932709595617, 0.4445006014875974, -1.0198836967673208, -0.6964780249069412, -0.8033019453997844, 0.6050826734573598, -0.3603283388352072, -0.4153000577970515, 0.35123789308773395, 0.6729756333744716, 0.5935051677987693, -1.117464722793535, 1.1408016199846225, 0.6423586620097603, -0.8844488721951422, 0.44532550151606304, 0.34172937267054404, 0.8869337179526275, 1.0194643890998099, -1.258655625380351, 0.21493797615937357, -0.1430133638309106, -1.168024684693839, 0.1739242139031585, -0.16898704359545325, 0.654972466539587, 0.2292923748693688, -0.47566624212653347, 0.4799100827727342, 1.1987112108189781, -0.44064732175511556, 0.013130257510860147, 0.537068737274826, 1.115179544040048, 0.5821973758466452},
    {-0.7468710395921772, -0.2880490733019845, 0.5973459145546227, 0.03691392783757327, 0.7392891223216198, 0.007807691678906745, 0.35604179330278585, -0.7815628267733852, -0.180477044198122, -0.09652168143621119, -0.6686034253068027, 0.8392238825030656, -0.654554749826043, 0.6482302420589597, 0.7166073955517186, 0.15718545462499312, 0.5611515064161732, -0.18591688590266303, 0.18076179417545346, -0.021586315334284553, 0.9110423919327395, 0.7951292009266779, -0.45468082084629463, 0.47892982155152825, -0.05457064456751731, -0.8776184807152234, 0.46650505852335544, -0.45430040294983026, -0.19241246898899247, 0.26858820916307763, 0.9084750418151187, 0.8141470913632044, 0.35710015326426886, -0.8101519218584354, -0.717575401154436, -1.1716954078888586, -0.1246651514106724, 0.6687404247112325, -0.3851609001298757, 0.8017522665791145, -1.517856831539362, 0.016564238227829545, 0.09775034358681507, -0.7932132959231669, 0.5505068941360846, -1.3576894258360732, 1.2630516302858832, 0.46584950203957715, -0.34433695847970724, -0.7107220010397115, 0.5415734592254049, 0.1375271573297771, 0.0829126154080769, -0.9159640839024036, 0.1857659011867366, -0.020582850379954984, -1.4030184089528484, 0.03255295929803186, -0.24769713010677624, -1.1008078574341706, -0.45511960333376683, -1.4820364125525658, 0.4508910113485065, 0.8785165603888591},
    {-0.7455639394429977, 0.16029746540070675, 0.24074625738771377, 0.5038883297374557, 0.2601656931571743, 0.34180286433079327, -0.7952598806988063, -0.12035019928429748, -0.5634655786782692, -0.7967387286607418, 0.23784768152116548, -0.5951175284065029, 0.24211769549199477, 1.0301041638632027, -0.7146998949845907, 1.0197392084708146, 0.053583808539668466, -0.8915282256490833, 0.5402602314824947, -0.8234978160997475, 1.2663887933570261, 0.45308387897110824, 0.2726760776152155, -1.0536594010294842, 0.8568547443504567, -0.7245808059809689, 0.9803797870285412, 1.329147035483112, 0.749208594472236, 0.42487135909068763, 0.9288728080534081, -0.9837712400359943, -0.7679461426741427, -0.11250881209201072, -1.0843353174889692, -0.2871544233831996, -0.17682897153046695, 0.09962704800464355, 0.18919865803950814, -1.0523482879098867, -1.3461711847223965, 0.6767967915265866, 0.8678397388812045, -0.4178749920224503, 0.7899174451596402, -0.7252457033993572, 0.84398149720198, 0.6016323591005655, 0.5719698037570128, -0.746709730262034, -0.24227237336244808, -1.2802900073710703, 1.0706535911367887, -0.4039314715930638, -0.2628303753350863, -0.6205649222220069, -0.7746049966942958, 0.28286302307931305, 1.2298180956852038, -0.3165085400697373, 0.7579833313825123, -1.5040708376453147, 0.0946182965937126, 0.3888821656338199},
    {0.13757889410432683, 0.2538152727205032, 0.04758844168286248, -0.5443269620986882, -0.5456381207037997, 0.6298865066582496, 0.975927908358987, -1.1472016251410786, 0.3793733996547013, -0.5618240987509974, -0.8032719360777468, -0.7403637546711298, 0.1816456356270091, 0.007486959652447427, -0.42462201746023676, -0.10668398127203244, -1.052687002710733, -1.1514887945740107, -0.004186075624552028, -0.5668700191058162, 0.11350743009090487, -0.3373553441461095, -0.8876670699554622, -1.1487645712694807, 0.4051872966418763, 0.09296930235271296, -0.08265156538697024, 1.5278742842997395, 0.3880541499389677, -0.707358681588198, -0.2957112718896307, -0.4242362798130476, -0.1672047060011465, 0.7988558023561434, -1.0009023178221699, -0.8678906225075886, 0.9624596032413659, 1.3392114247415707, -0.5804696353353741, 0.5151401478564802, -1.2533718437030223, -0.27277197002851544, 0.7091979028542083, 0.07620862305135812, 1.2906705306400914, -0.9755675833796742, 0.9695805958011506, 1.134027556563531, -1.173200293147551, -0.6598845639466233, 0.34552919866070986, -0.276266297650668, 0.194723468101067, -0.6327897531110006, 1.2392852748418943, 0.6016989609529533, -1.0749398648612662, -0.08564828409063928, 0.6732933399069404, 0.6314529129089752, -0.5117657308142318, -1.0493357030999737, 1.0802467076235096, -0.48954764148457874},
    {-0.34706762719136247, 1.19033692904684, -0.48714565126535475, -0.0060752165406874, 1.0030837746526664, 0.38289998863564007, -0.20954452965519121, -0.73843453168729, -1.1753611487643483, 1.1312225530881863, -0.22607408299878423, 0.7796033406301647, 0.7847381092582582, 0.6496188025191134, 1.1699943432882358, -0.020142918548539678, -0.23305261763427998, -0.5987756155261187, 0.12112614386564725, -0.5148101047601595, 0.4794469994940447, -1.0890007324638817, 0.08055212756528696, -0.7332726576499594, -0.961966428114684, 0.32870758748745565, -0.39313286615456217, 0.3594748660713204, 1.1928726296381025, -0.7440835205041323, -0.34783668471259377, -0.09172650351541829, -0.21228978345372992, -0.0184016358074902, -0.24996901740792943, -0.021612959013692885, -0.5316304476708308, 0.7150544018663335, -0.8874740121776579, 0.0012109420991499853, -0.4571915690687305, 1.1065470066436691, 0.742461795718049, 0.13031180922233226, -0.30642125210856347, 0.0521331099707474, 0.5677261729328155, 0.3122160416914715, -1.2575384050113978, -0.17406563975622175, -0.6408862540865948, -0.45540157062547404, 0.9302819809797139, 0.6050775591449541, 1.5455062918344078, 0.2301736731784515, -0.9527927688051445, -0.3016621352402999, 0.9455564887115879, 0.39306476710862254, -1.0240526036407371, -1.1556224680411933, -0.2855144278024406, -0.6857489805416674},
    {-0.9414376184658273, 1.1391463487801692, 0.5432997600804139, 0.9722454741637249, 0.15140657651787004, -0.3120347431671947, 0.3516658838064089, -0.4352427601540982, 0.5022118391922464, -0.5914949226764112, -0.07804339418387041, 0.6004770805625346, -0.2710668710262513, -0.872723911631979, 0.10670905868051989, 0.7301579752923023, 0.39778268905070874, -0.39154944585605966, 0.8568427110073731, -0.9675338478276216, 1.0959905737825306, -0.6701514202620581, -0.8878725471000966, 0.2319095166955448, -0.6414681605651247, 0.756502272135128, -0.6854184597489982, 0.9824527947082339, 0.8113817331415555, -0.28236368599148615, 1.4336916164337954, 0.3809956201000896, 0.8432019285822018, 0.8914612178115939, -0.7931418239289466, -0.30283523970170056, -0.10207499022444053, 0.872912694004115, -0.24477762749499626, 0.8506559844613926, -0.4941610220229398, 0.3951472178798994, -0.06726653897766541, -0.8085241342666089, 0.5573737326922945, -0.3387152175450532, -0.06130800350458981, 1.0717337354106558, -0.7021623515222242, 0.4761216707497185, -0.9382916604427525, -0.7034469935583805, -0.4186327176579367, -0.1930386638065671, 0.9901268059802024, -0.7503141064827923, -0.8519851789940636, 0.44414416333498297, 1.1202742174963307, -0.7776905652087559, 0.3081709898885658, 0.5128020568756765, -0.45453238297899645, 0.9003101604036028},
    {-0.04066940649005181, -0.6266792817368853, 0.6297082379278357, 1.0233361789345305, 0.3839197954010566, 0.7782128106338982, 0.613961958095858, 0.011929822822843175, -0.9572594583241135, -0.6634479422340693, -0.5817681477393483, -0.7054075027382977, 0.6416270817560434, 0.30644743062183716, -0.739057576426885, -0.4994893223059059, -0.34654460975001655, 0.24316597192742326, -0.7135523911749937, -0.8752224560823996, -0.020441679643505933, 0.4481771401354865, 0.6219319577530139, 0.11825116297204433, -0.31308727150310006, 0.2993747996721989, 0.3927329227341785, 0.6175422295003231, 0.8346741441060851, 1.018777371161431, 1.206599629200881, 0.6136025249819386, -0.41272332459661426, -0.8179132926100969, -1.2655180086162783, -0.791408137074725, 0.23729721384727434, 0.038718403733847516, -0.742308089368518, -0.24043576507486272, -0.48195767150355623, 0.9586361895276619, -0.42586271890679583, -1.0876665367479676, 0.24455270707533083, -1.0972179209101607, 1.2003542938827274, -0.6470217545198866, -0.10211427096035947, -0.40416993948324953, 0.8099158319768606, -0.5399789499132842, 1.0559459254793562, 0.8003641843512773, 1.1748393279266833, -0.3467687307528379, 0.08296257489738791, 0.17467185500843022, 0.010049035271714071, 0.5211351996900057, -0.40539651461829107, -0.10801752944493159, -0.5268616394716695, 0.3330387253773592},
    {0.5171258305486129, 1.2987251957910835, -0.49984289593616726, -0.30983869815783366, -0.3649519886138248, -0.5195022327889797, 0.21637254065581812, 0.018417379640126425, -1.0538944945467466, 0.46856738668634484, -0.9521227926257233, 0.9685640125576539, 0.6255413942472122, -0.685560388223773, 0.9357888655834358, 1.136749756638824, 0.11207549863108933, -0.6336100600642234, 0.5715089196863045, 0.37424737523020674, 0.15230222917653502, 0.2907497921664265, -0.5345604716155731, -0.6031613401724344, -0.33443046958501893, 0.8272312841698454, -0.05383271370885201, 1.544043380030728, 0.43636679194438577, -0.23298730818081456, 1.4921491423110818, -0.7633118695568598, -0.4106279477634558, -0.9116228718647986, -0.9002387950567544, 0.025033520882795573, 0.8250622151432324, -0.1492748584247491, 0.707864334888187, 0.7551750586758034, 0.37680993515869676, -0.6564233729776711, 0.4580155484387513, -0.8768831285278209, -0.5845615534586278, -1.2975617475900807, -0.20468315617948846, -0.09223730390887493, -1.0981435323103788, -0.5464549752952046, -0.4116300431995378, -0.7418538064526842, 0.9165232520219142, 0.898221899186971, 1.066619044039947, -0.4902615339422785, -0.634208275094663, -0.8682815797890412, 0.4012100273029925, 0.4768398194133196, -0.4885565926780763, 0.5743975869428485, 0.8213037496386415, -0.4709619866331355},
    {-0.267983572276937, 0.4225779365044812, 0.5463554062691649, 0.18821037287153733, -0.08445507084136958, 0.718995175576075, 0.5059733909082464, -0.7106872169341513, 0.30550563766674893, -0.7301443222198043, -0.26082497863385, -0.4885134343924685, 0.8929138015854484, 1.053557225982081, 0.23281053780146477, -0.7528723050047769, -1.194400783345577, -0.8829249797618302, -1.0413557936809297, 0.6391312774414291, -0.03624361129941378, -1.216341103854913, 0.2684541232087111, 0.5394560998518202, -0.7991252297933881, 0.5381421929419613, 0.36404344592223753, -0.3534135129060243, -0.10157530535855708, -0.7596328929996017, -1.1244405461771245, 0.3455522700973967, -0.03623430680307016, 0.3507945250461153, -0.6793549027346815, -0.9749199330870906, 0.7632616892778169, 0.3980500497111558, 0.022415936895102444, -1.1883037903309253, 0.1818381353300821, -1.1765224566905634, 0.855750289776931, -0.007223666491350924, 1.042527311650492, -0.483225827465782, 1.004053673026637, -0.5869571775971292, -0.44029371900160985, -0.5139132217378967, -0.27878615310293914, -0.32185216447011733, -0.3269220053725544, 0.31721861311588534, 0.6065639263810475, 1.1846654724444166, -0.47122541696423687, -0.46030756438591935, 0.2874086498816866, 0.8530017743668231, -0.7851692234789142, 1.1714465182254479, -0.1687004249231103, -1.21908255275006},
    {-0.874255100021958, -0.15994939780516043, -0.3038820919768757, 0.5594390926163427, 0.50414394971465, -0.013599966107587149, -0.5092049812013342, -0.9197821760778444, 0.5333863964624402, 0.38886407007671064, -0.4209968965809987, -0.28268177530746186, -0.9720151025251704, -0.7844622274296005, 0.5984879351820875, 0.08076141058043408, -1.1196086483141072, 0.13506606642514263, -0.3373470284280025, -0.8097969624422475, 0.21373832784313587, -0.6772374226178947, 0.9452243586431978, -0.7369356271179763, 0.9663222728995139, 0.3839043955869616, -1.1499549617128986, 0.3910282778461887, 0.2398789023696916, -0.015388495387503323, 0.8481488375537718, -0.40630499424821676, 0.725200120414028, 0.5347412877521585, -1.0084385954480306, -1.09768962897294, -0.6514994919445469, -0.7448163191859174, -1.2235613298147927, 0.651976813822887, 0.2076884812868766, 0.8704425887874482, 0.673545181742151, 0.3869605999148854, -1.182297409737601, -0.8627987210473341, -0.7016706116568011, 0.7222600306794567, 0.23193160329158108, -0.6226137755461713, 0.32186974565095744, -0.5879936695408765, -0.8056710910426527, 0.6509617226766214, 0.15863859832535268, -0.9690154509982007, 0.6811364744148061, -1.0098179152733653, -1.145025683503279, -0.8275328476805468, 0.2878621714189025, -0.5555499689151824, 0.41067281283661944, 0.38344500055677994},
    {-0.39302123447585957, 0.05027549860908454, -1.35869918020998, 0.16060729838390808, 0.9368419610895049, 0.7331068046599778, 0.169502835781553, 0.45100277941913564, -0.8588211599308403, -1.4510348436977973, -0.7362790222823781, 0.9290981285051614, 0.8639320581904502, -1.2493036642611728, 0.08409929738563164, 0.711951059384007, 0.39265296740279837, -0.12273658825925662, -0.2779627751582381, -0.1833430602281067, -0.04947584220343161, 0.24261310337736902, -0.5832326849462138, 0.294310248977596, -1.055040547038117, 0.47114348377611404, 0.026050515918617758, 0.731284390017793, -0.7432444888220626, 0.22560057300718098, 0.5002737014783398, 0.5343223342838401, -0.7017861522020593, -0.847943370423922, -0.16536729406308484, -0.44654082191646155, 0.6088664067522187, -0.7134027704506787, -0.6650325098812228, -1.0207776752301498, 0.3044322490005245, 0.25822058904392536, -0.07934975252081064, 0.046401544900176867, -0.6533020924040208, 0.5719883183989396, -0.40236124356825204, 0.060535083489838305, 0.7180655243332614, -0.09483830886563993, 0.5436509832903356, 0.10387514956635459, 0.5325955432297886, 0.10815025657989329, -1.2891091765374938, 0.6854423497287653, -0.45924054595079283, -0.608343200110816, 0.4603662635444889, -0.6815502964487731, -0.8187853146883826, 0.9732858026871799, -0.36373819054744977, -0.720472718610067},
    {0.8152759656544821, -1.195021622117924, -0.36937454425569854, -0.9390818320990584, 0.8543782430301733, 0.29917895473095807, 0.35446775624172555, 0.8114999656120673, 0.793672883501274, -0.5052114419502285, 0.6712671743159395, 0.13835299578919566, 0.6898946296253725, -0.4664374521138356, -0.7500766248163133, -1.0815461739818815, -0.6471104853736128, -1.0968117799781012, -0.8055561309489675, 0.3776235121949342, 1.1457830390455872, 0.42718155436761435, 0.36332708213024445, 0.7242115555986544, -1.097179512460858, 0.7940047661005087, -0.8744419489539439, -0.4690363519012653, 0.6330751988003633, -0.3639769754990889, -0.24841821715242862, -0.08420133711501661, -0.33867168885159915, 0.2126221130123635, -0.26556060617708727, -0.5420615871118127, -1.057937780754738, 0.15341484102329647, -0.13337270717661165, 0.780924500337356, -0.356844775419755, 0.45045193770014985, -1.1101465341026138, -0.29418281856189576, -0.41328086032772765, -0.12497410224626904, -0.580768305630808, -0.6690920175820082, 0.6097472743701702, -1.242030885520957, -1.250248705975293, 0.9840545162067053, -0.2547700844543925, 0.34432452415320713, -0.03646723658056219, 0.23526218862013842, -0.9411714872209991, 0.8393753093514733, 0.1060962397464804, 0.47663333677952535, 0.1395611667487539, -0.2091099793733964, -0.5883163150123174, -0.6071081218826218},
    {-0.559277068691954, -0.8770492555819809, -0.4613119869086515, -1.212728396030816, 0.6840694582260114, -0.9225219619426381, 0.36373972929588766, 0.20542884720394727, -0.7320846016158165, 0.3106671103063143, 0.8471426122609047, 0.8460863202727547, 0.5260573078404033, -0.2533887375521998, 0.6711264147534355, 0.23288676441590547, -0.8250475984464205, -1.2684910045640627, 0.5253474350589357, -0.5887838178474885, -0.6577750706751588, -0.9111751119205937, 0.3202383927137478, 0.47663506197442934, 0.013982273675129567, 0.009671565482570177, 0.13554776270346353, 0.8368428694988983, -0.1849674462905405, -0.52371793360243, -0.8580776088611293, -1.0857436577090422, 0.7110673369829111, -0.4775049816656114, 0.3487618263217997, -1.081798997438746, 0.8192025826547934, -0.09412838033923605, -0.7581791943928141, 0.11889204432482806, -0.07272355582326646, -0.4844864143830893, 0.27003580788889436, -0.43001677685539724, -0.5706928086534107, -0.09219957753163587, -0.9454488033408872, 0.209060544803851, -0.6217033899767477, -0.34855731683939445, -0.7129123711140187, 0.6349574366421047, -0.8573672273305227, 0.8037947675476047, 0.46963621973880154, -0.30719003959053753, 0.9842614641789681, -0.41744034312557277, -0.9712856466800568, 0.2008484168436754, -0.6798459581560924, 0.6643284279478758, -1.0202132336966074, 0.16090915292784694},
    {0.8457535694851253, 0.22337283184511417, -0.20952369466233284, 0.832947245206281, -0.7048068113108944, 0.13663926727821774, 0.9870515974798475, -0.017326332540168056, 0.2202530336071829, 0.24120040811584337, -0.23124617522836052, 0.9914110745884542, -1.0019515446477307, -0.9102556613133096, 0.842637853329493, -0.7967995983533604, 0.7823061008031108, 0.8108854202408464, 0.7493149747214356, 0.8162650160993391, 0.6798869818286426, -1.3094019355917108, -0.27403555230896187, -0.8700928318957207, -0.501321499689874, -0.8473012256343869, 0.0808420939012699, -1.0853962974297442, -0.5141604524447513, 0.6923632268063924, 0.0347863220617654, -0.5831238616389952, 0.29155333158516117, 0.23535783556876866, 0.5434856614420955, -1.305181179746507, 0.6215889254380368, -1.4105104058699494, -0.9746350612943144, -0.4601028956724724, 0.7504934473747311, -0.0693005547086053, 0.817566765512875, 0.6663476186958878, -0.6751438123832942, -0.9194771004003249, -0.7175408817844924, 0.07766873483493791, 0.25547130595072454, 0.5288094522706525, 0.13980603114259063, -0.6573048071434796, -0.8919997238518202, 0.36985559732157397, -0.09808060644704712, 0.6254507370414165, 0.21522034101098916, 1.0508713333843622, -0.6766136785672813, -0.04178573518014318, -0.24065932112227845, 0.11660633287035489, -0.6581314826699193, 0.9931963235597665},
    {-0.4137951801840065, -0.06362178146553782, -0.607352041118427, -0.6351085821041873, -1.2073263149930265, 0.7920250551433641, -0.14520434708526894, 0.15867602991221894, 0.4151458876450105, -1.1613002566348025, -0.846915450089249, -0.9829598106734937, 0.9606900087570941, -0.4077238894321408, 0.6036052175398303, -0.6045290441208162, 0.25935455098101073, -0.4063684724422055, 0.06132733173996862, -0.08476525311370206, 0.30506406463043734, 0.5225855066292272, -0.3335569954062283, 0.045011882982360064, 0.09518884348031821, -0.19600409278455685, -0.26038303908975047, 0.03215361217368556, -0.9564195751663177, 0.43732239750169444, -0.37703499799874174, 0.5259846138872479, -0.37374800093079114, 0.4917060782410353, -0.614970709910697, -0.1383541038214492, -0.13919148728297798, -0.43844216698219396, -0.11758728511895261, -0.04932059410979761, -0.32422876332997635, 0.05025018470678109, 0.419527904123873, -0.08311493804253664, -1.307269839442062, -0.7690814874152073, -0.8004734946765113, 0.15704025496143334, -0.8337986296486635, 0.2274153679651645, -0.9205695215238172, -0.9188802228859364, -0.22508663729663225, -0.38401820122533636, -0.8640044495341324, -1.0314188094080716, 0.06993920768557894, 0.2658411023982806, -0.9788609925048646, -1.1508895739362304, -0.37827988583613553, 0.803736845329516, -0.12167731657607295, 0.9384153252481028},
    {0.4345928438032025, 0.18221026390929762, -0.7882752654761276, -1.00885330099253, -1.2009741169591768, 0.17586409360746916, -0.06485957234558977, 0.899108229987404, -0.5452285649901323, 0.8538679806583861, -0.2119748801617151, 0.05229606656071596, 0.9573142814615186, -0.6233694545092066, -1.1445086393325914, -0.7214912970237186, 0.48262622540021105, -0.3552888773337544, -0.07415233855981097, 0.17419079127420814, 1.1636677188837725, -0.6396493231645074, -0.6379812624443925, -0.4904609663428084, 0.9152972366887885, -0.777311427611235, -0.2748769302398148, 0.22183422248214185, 0.5552861286973156, 0.7656271966152637, -0.8477396397212059, -0.5015572588562843, 0.8477557638751159, -0.2268569923418903, -0.3263283433983952, 0.05350373925776814, -0.7000611462423305, 0.29246509718717734, -1.0205121683345895, -0.6582946672467924, 0.8002824185114785, 0.7121256148941736, -0.9006653021050228, 0.8767165991997411, -0.24204547718933192, 0.6392246296294903, -0.5971016886796879, -0.20579572736865015, 0.28791570429500707, -0.6219101844749011, 0.14061393215534274, 0.8491587677309163, -0.8316352825693935, 0.33297596575603855, -0.7441903405094398, 0.10922694476436004, 0.599044500145059, -0.8692063340496144, 0.3049167584803445, -0.8595885643583916, -0.30227780425907785, -0.060780549648525986, 0.5987657014172754, -0.9681874149488063},
    {0.951541492303109, -0.41214557861625695, -0.9483075323845784, -0.7459778683014451, 0.37024954996325327, 0.5879281084214646, -0.8434268542515005, -1.072215465179748, -0.9831262135853752, 0.2574636922577225, -0.2224184926774646, -0.5890046484037135, 0.006016995825860082, 0.4396936833668117, 0.05819420023713086, 0.3451399974398687, 0.4215419960837594, 0.7352989919168889, -0.6548901390892345, -1.1277812234670106, 0.4540641906314909, 0.20380197565608854, 0.232149085509702, -0.8594790413425608, -1.0692811679338692, 0.7991783505424315, -0.3021259280516355, 0.5927396840763464, 0.6624997865909588, 0.8065967528650493, 0.4071420532722625, -1.371133762766527, -0.0983629361456295, 0.7686061686160935, 0.2412731892582977, -1.3729920683196297, -0.24789806114138757, -0.3964630212937704, -1.0723796333507476, -0.10102898942341772, -0.5303508917443753, 0.6893352611553303, 0.8140685477813001, -0.897166818812643, 0.4681657387792444, 0.5993767002938563, -0.6011845115414001, -0.23471102075947634, 0.40417594833935266, 0.6767357797033143, -0.4971915291127499, -0.1685770713860696, -0.8909920114293031, 0.9447314517382998, -0.4464350474711882, -0.11603569046807401, 0.8481714199680341, -0.4053863356189683, 0.43343119537951547, -0.6157400983180628, -0.8034780888450316, 0.7087212354314065, 0.4631288365289928, -0.5018838728230676},
    {1.0165848257625707, 1.1299771256964724, 0.8101960895654788, -0.746307384834152, -0.8369134185154922, 0.7634298343629901, 0.8119829977812935, 0.41841093340058183, 0.9587272981754674, 0.7652191287554939, -0.25835590804363084, 0.11704554189343652, -0.5145268503959374, -0.7737723250521965, -0.4021036796435039, -0.8919494706839729, -0.29753298458359134, -0.29763548828214037, 0.09069505252117945, 0.5433707152463048, -0.05185500332205587, -0.3361915997777431, -0.04827145909504865, 0.36046206680680115, -1.2244003898020106, -0.7803223774589407, -0.890849569814453, 0.9208081708332112, 0.8157757507310646, 0.9478139212708445, 0.36352765495848893, -1.263519947264414, 1.0205771615926151, 0.2919452347283502, -1.003348960214403, -0.3623081763124802, 0.6815284554625622, -0.370340495648926, 0.6375335921996139, -0.016133903136558245, -0.24267852758138672, 0.6799583400734446, -0.8417963959424163, 0.7367717651163698, -0.08683437525660301, -0.5505650639312311, 0.35684999492372393, -0.39345407725788606, -1.0443023442241546, 0.5706410581552227, 0.4087541322042886, -1.0507623642384414, -0.11993737100498014, -0.5799306614962081, 0.41272216695778224, -0.4696368076648804, 0.5754704053054913, 0.7563865026311166, -0.9499808178503992, -0.9096134510020888, -0.026852530482551613, -0.7839478459141768, 0.7651089995449625, -0.16950698841594664},
    {0.8108676957793562, 0.745799313470798, 0.5631469044250411, -0.12270139476685457, -0.8616437735860905, -0.9689059019537761, 0.16782308210623298, -0.6250866123693616, -0.31150910075605087, 0.7225954858260275, -0.07070800737653557, 0.4485818506864302, 0.4755038662009731, -0.5252554125591619, -0.31534448623808525, 0.20959518260175078, 0.5891855356264771, 0.3505200322676091, -1.0036195483628283, -1.1098044634386233, 1.0603209257229704, -1.0947513166906595, -0.8268586280506534, -0.28379847602450253, 0.43710414996078856, 0.7609640388198108, 0.4521130901418335, 0.07794446095508699, -0.3993302530873762, -0.4511131871391531, 0.023005799124470646, -0.09392689051068645, -0.08416523284598718, 1.043850594626999, -0.7902109330890034, -0.41055607196610894, -0.052619201951961465, 0.40696039678296114, -1.1170221929195572, 0.30720669242599735, -1.0818018775648792, -0.06536926716299646, -0.6751702775485359, -0.1764434003847922, -1.123233633108416, 1.0206707987670536, 0.5263081570669236, -0.049930080121505856, -1.1095408309651473, -0.1431212466978659, -0.7317332063389209, -0.3928529045304575, 0.4860184119895089, -0.14763350440725875, 0.7971195858759791, 0.22233805086678268, 0.26518052812773885, -0.4557560654166645, -0.29983862884208234, -0.5320076794514085, 0.959738339777246, -1.0519512633485992, 0.2709557894152875, -0.969321672064673},
    {0.9064948407253526, 0.18593325384064763, 0.6384318748679014, 0.4078666005906111, 0.5784088720033673, -0.10209133703068297, -0.7035019678744441, 0.6157167691925534, -0.5798786141614489, -1.0882984307196852, 0.2540508800464148, 0.9119529459571319, -0.44882067014363575, -0.30312817191185326, 0.4453500068487511, -0.8166089482662497, -0.10095050996149592, 0.315687894398676, 0.49721279387747097, -0.6538166049386276, -0.8100221507710034, -0.6934097207074595, 0.8562403127234711, 0.48455932205074814, -0.5039879760660371, -0.6706482996830309, -1.3971022380518108, -0.9023135909743704, -1.1767015234689955, -0.5695659441391846, -1.1688322340134378, 0.5731647198375359, 0.9980068469698357, 0.262851041349395, -0.5514084365163254, -0.47626503358634736, -0.41162432961993767, 0.49412906370471366, -0.5343408507818773, -0.8296740641330648, 0.19195933916462476, 0.11442137487798626, 0.36229712098884953, 0.12977454600996843, -0.571919290050621, -0.14757885787293848, 0.26491517872082493, -0.28354470927863484, -0.43447845404165153, -0.3695230826969798, -0.08292966643587724, -0.5929343809309355, 0.7295196896161575, -1.0098762336835128, -1.227826982973094, -0.49314576268127763, -0.20063726267513657, 0.4544645510329334, -0.15978783543423677, 0.01291006202888239, 0.49747409092374195, 0.7596946593493753, -0.5549890425634226, -1.233548166901325},
    {0.45491265992924473, 0.7888054117059404, 0.08836730321388328, -1.127723940651769, -0.9303447155991472, -0.4569992036231396, -0.5426719238912786, -1.0726597834288722, 1.0112721042796122, -1.3525092183683545, -0.8491173676334027, 0.42874205837532964, 0.5951114274146307, 0.798790713140084, -0.5061083398360876, 0.5509847278582443, 0.08785225133887174, 0.08324131539206651, -1.2115141511732472, 0.6960549852541787, -0.5289389638725464, -0.7167152430155478, 0.7434229061509943, 0.5306793038741916, -0.226207841691879, 0.023637064335543603, -0.6117666045408906, -0.5416256901243679, -0.22832843033115044, -0.343680280687812, 0.1996647154947191, 0.5811343665433453, 1.0717864735635523, 0.0006602581960331692, -0.8428275646055692, -0.23526900915397517, -0.2046570888923054, -0.7870632413148032, -0.25817542014104805, -0.5028913040666042, -0.57353644269349, -0.3447221195981863, 0.10992705301891241, 0.7132302012866685, 0.8042069876719253, 0.35662171666113957, -0.5515294062007982, 0.39170142163483956, 0.4550544152002314, -1.3556793333934434, -0.009421663772866367, -0.9634731977299273, 0.8551767501602175, -0.898360201293776, 0.8036618600992214, 0.7396125398825335, 0.6749520813674557, 0.09961706833426152, -1.1919071852064869, 0.06794569935299573, -0.4142484001135142, -0.9017529465075311, -0.309251956412588, -0.8355246733236249},
    {-1.0424054538917362, -0.9395880162179789, -0.7862501624933792, -0.11891537361392718, -0.6260741149605247, 0.12616017565882845, 0.38343162263244085, -0.3669738274567426, -0.27150807656666487, 0.3516265792159512, 0.7504465190178446, -0.30496311339316884, -0.763675878091966, -0.282827965641654, -1.199051321661872, -0.48173995280889687, -0.4679762169040383, 0.7748860579962298, 0.6285754946219759, -0.23489275958843853, 0.1904269609345079, 0.042549289250546615, 0.5608938117135599, -0.03519571664181255, -1.34140536775873, 0.8422800005877261, -0.48890032378432463, -0.8683723077869564, -0.38266892418707144, 0.12667017237610523, -1.3220579048876653, -0.9886619837294732, 0.6196150745540588, 0.622519723007319, 0.36728734808472785, -1.3936370906605664, 0.7575994741315051, 0.16565724060729647, -0.6016308778406547, 0.2885964833936622, -0.5236641693123397, -1.0883030239291145, 0.8958842547162663, 0.23860530684149006, -0.32595036472305206, -1.0262233789620308, -1.0696752750146277, -0.42646962248397763, -0.20767645440780025, -1.395463140100532, -1.2125756616026475, -1.1859329705910775, 0.8075491643826959, 0.8048215924865028, -1.0657243460703436, -0.97792889866795, 0.6981745524768589, 0.49731722921502547, -0.8006058348204783, -0.17250357172826344, -0.6379628585218684, 0.7144464833292062, -0.8977746523420562, -0.5418424871067726},
    {-0.470088782826778, -0.16607985224339966, -0.7516979779857023, -1.0232264035016125, -0.3028046207184344, -0.7416285078846719, 0.2682870356861223, 0.1812799320516329, 0.9332759653082662, 0.7074836173114037, 0.659000207231336, 0.5078966004120302, 0.47982342169119435, 0.06823439239914693, -0.12572384809273301, -0.8846692733933769, -0.7332210261307931, 0.1571398905418441, 0.02969563436466181, -0.6623452615468642, 0.9344404709091518, -0.6097757585715413, 0.9982169478600614, 0.513898383571669, 0.2324206801927049, -0.9571158148119809, 0.30167641695080055, 1.008727914842383, -0.7393425045741663, 0.1316679527479123, 0.20310557832512838, -1.1051950925137761, -0.15624873689267238, 0.7206373876837839, 0.7677670097433468, -1.2550186710566704, -0.8860300055681577, 0.6183757966028913, -0.31692069583087795, -0.09858594352993377, 0.12103125882486437, -0.08059417432325064, 0.7326147654113295, 0.7953301170523612, 0.7594325059032688, -0.14679796672002599, 1.078636083803181, 0.04461791048836337, -0.2206175116694721, 0.04430253432309202, -0.8521903026756078, -0.07217817256875941, 0.23982734299322853, -0.8976710929420002, 0.05313495573477899, 1.1788607564237537, -0.15189200255088023, 0.14979944404829687, -0.2719609903219098, 0.8990544357243724, 0.36868313702824823, 0.13508207028785546, -0.0697540801109963, 0.16221243992142526},
    {0.751657723880626, -0.5212379326471727, -1.194532434131819, 0.4520682836849773, 0.5116234025975729, -0.8474241527927528, 0.34115593352230855, -0.3688267031855063, 0.12778511933374104, -0.812269870370943, 0.029930391380327413, 0.16857723751775877, -0.17315838123665292, 0.784850857064206, -1.0020388178749113, -1.28529383193274, -0.47353408226620103, 0.00870052957292855, -0.2889983875826818, -0.21176090861332947, -0.9750709290795672, -1.144918381334531, -0.4409242529473124, -0.6684459160074866, 0.03318990321438064, 0.5361763398749495, -0.0726362027549575, 0.8301817100104175, 0.2819718341194424, 0.5372054956493628, -0.6851527387647475, -0.08761613766705326, -0.6309191542722565, -0.2160988835368836, -0.21750962140839133, -1.3349079430871793, -0.035102204266969465, -0.2755079287968328, -0.17449065570318284, 0.4588830402220749, -0.7216492674226108, 0.3372687043118268, 0.7593648383043171, -0.48723586748909725, 0.8118282241708473, -0.9370173343138948, 0.5441247511016527, -0.6315624247096412, -0.5941713109208626, -1.1793599484519326, -0.006024573257828565, 0.42710995958418, -0.5163961180780635, 0.23301016801648017, 0.2056062053738463, 1.061139421933237, -0.802516165523544, 0.3382858091456472, -1.3960342463508524, 0.3960691223485865, -0.9907749754548911, 0.43690298289068924, 0.8395344374979724, 0.6933130286301377},
    {-0.03044848599760748, 0.07792751078130263, -0.00012085795949571434, 0.5133528961659043, 0.43357537333107277, -0.4059286186996837, -0.7687501212635566, -0.5212060756957798, -0.7007002042484173, 0.40517920008047786, -1.242692572646741, 0.07435545398452502, -0.23266544121747065, -0.7425034517854293, 0.15451546749349587, 0.6424449033668911, -0.10827607386874785, 0.5930735937934559, -1.2439202727855978, -0.22567564510702692, 0.8270153013631678, -1.022244593528593, 0.44057047294496804, 0.7232211534895189, -0.5089161967082345, -0.7294852066121832, -0.1820567444617652, 1.0545791444866628, 0.04499997823302723, 1.1234901308412075, -0.735894087461552, -0.5161447104996649, -0.11412953545167105, 0.46816077929344324, -0.20976168730003772, -0.43494675398679006, -0.3624078671254006, -1.0018508393316274, -0.9723867870430417, -0.2451804474678819, -0.03511659352476467, -0.8798822996655365, -0.6941691605349032, 0.07844497583755333, -0.5792138109159027, 0.09103788859408488, 0.24856795472004944, -0.008970020088784933, -0.9808589693027975, -1.0819489444907686, -0.9131042859691356, -1.2273382954776826, -0.88725998375554, -0.46675887506833197, 0.13361401954227473, 0.622008325067825, 0.042346786444434494, 0.6292932332453832, -0.9663003503770476, 0.6539615105226103, -0.855878137941884, -0.93250484999042, 0.9729139012317883, -0.9479801096471319},
    {0.526899787126296, -0.6030707946637506, -0.8249003851444273, -1.2280524575255958, 0.5675137338325499, 0.5053615921312862, 0.06678306402545142, -0.5000185543118165, -0.32846924850759335, -1.3026835666648993, -1.4239666147916314, 0.6141920488795413, 0.8351494679737255, 0.36330546449165296, -0.577815324513349, -0.3994203013624502, 0.35453420562248206, -0.5301252237893894, -0.8416642275977216, 0.6104212630777269, -0.6477255197702217, 0.23308511929574205, -0.08863488443156065, 0.6733703673944996, -0.7762065694264777, -0.36378591165128904, 0.4725636870033579, 0.4135168545042607, 0.842713410184606, 1.0803057471366722, 0.5976365596962733, -0.7478181150179839, 0.9004314235027581, 0.4638170324075815, -0.3457489223949936, 0.18837811059748227, -0.1688730874851317, -1.0184605621000644, -0.25462351262759325, 0.5680226968778526, 0.6293682216625607, 0.5293602625286925, -0.33804011985027854, -0.868733569975398, 0.7251733281842235, -0.007401149861188785, 0.5470697039249213, 0.531056333087759, 0.5467310084382057, -1.2251675813903091, 0.7193523514534335, 0.686169021647586, -0.9887399429930952, -0.5203656678095008, -0.10405466400020619, 0.4336422831426716, -0.4001064935481033, -0.7229126043576682, -0.24149816612856773, 0.3611437533394457, -1.0694668272726158, -0.3184901413985566, -1.1043992118953931, 0.928745391735594},
    {-0.9022169873016014, -0.8236248024170842, -1.4290600270334755, 0.10908349942103904, -0.15115338730399985, -0.01087192455897621, 0.5297835938460665, -0.5295632603897438, -0.40046490025300685, -1.031822382983101, -1.164749847033492, 0.3919208003763453, -0.46476883290474824, 0.8370693975396348, -0.8540430590761182, 0.23433040055595256, -0.0065587093930567445, 0.4635959799199294, -0.4593839343928951, 0.875090808087569, 0.4862862342679595, -0.11383711320710242, 0.01180548367617475, 0.5348290979790767, 0.8985943624617458, -0.06764482426258257, -0.06644729653269912, -0.5594723877764366, -0.10541401674369036, 0.3460078458572317, 0.21372353511079686, -1.053794413565015, -0.7543742017866558, -0.7243039049542435, 0.5516276700444147, -0.45709581172060815, -0.9472321473008255, -0.9741557642994847, -0.4668844782569439, -1.1348925289602187, -0.24120369283456355, 0.4788491519669783, -0.9054151560404409, -0.7962148683624637, 0.23275693434230574, -0.25228947586575146, 0.7955798842872424, 0.23335579070662982, 0.270845368486979, -1.169790593331137, 0.864323504079062, -0.6236000617425005, 0.20578531642215642, -0.5759152670781212, 0.281460211264364, 0.07072147298614877, 0.24936761533781268, 0.5026424336612946, -1.2059639723327116, 0.595326980360309, 0.37861212537779837, -0.13292509277151315, -0.17562364723949864, -0.8758345872720716},
    {-0.7265146339564421, -0.38055273195223605, 0.4398239391135052, 0.5616559951350678, -1.2308302839211098, -0.9736662198506152, -0.8279265731308167, -0.04901095652646835, -1.1745872829683386, -0.11691521396496592, -1.39997837219571, -0.14473380207859365, -0.8314760287108001, 0.23213999740882463, -0.49930353716583054, -0.05261468704601094, -0.9742966152467044, 0.3718147268396685, -1.1956840860485423, -0.6387174045309434, 0.2212878873906676, 0.42147067114057934, 0.09965373056120466, 0.7217261659592797, 0.27657616413260755, 0.4106154039789973, -0.2752344198075435, 0.032698007181717226, -0.7528354021687915, -0.389703081774878, -0.8695693683609285, -1.0815555420303975, 0.5615321786284003, -0.5484189953622204, 0.23391088372209887, 0.4928620473948986, -0.9468638422968321, -0.20750205908272143, 0.05550916647531903, -0.90830279173068, -1.1621956806618075, 0.06899621349314015, -0.7941494592275362, 0.29934079747468956, 0.6024765509719411, 0.4044450531726278, -0.819139636007834, 0.01791195313329286, 0.7772734247967816, -1.290152931841744, -0.09975206067128986, 0.7813852787643419, -0.9635169012779956, -0.14095298904401737, -1.0603816320461437, 0.4423439561026755, -0.5538280202233257, -0.7560433826178187, -0.9269375463424131, -0.7462352007953326, -0.995026793673472, 0.8032578260959208, -0.6091244348843737, 0.4852597368731812},
    {-0.6397138466412744, 0.3992616599324494, -0.5755726442299443, -1.4149263765792814, 0.7161717951826115, -0.7619489856825756, 0.2737239257195908, -1.0670741008724507, 0.4782080369502068, -0.6850817215014097, 0.2818397304900848, 0.5541485892131355, 0.562706652013489, 0.5923501500145518, -0.6529548370330488, -0.15074095178498056, 0.5744383299894934, -0.6948592919348577, -0.33355852316822415, -0.576049709574665, -0.3070861796387059, -0.8941172964786973, -0.5820548661591932, 1.204413798324084, 0.18361254178968173, -0.9930374882522693, -1.410012884788923, 0.5394539305892883, 0.24121057460854878, 0.08087090189400725, 0.02530227052730793, -0.7412940379307974, -0.49512509736188914, 0.6177869345634518, 0.9329668044154655, -1.2593115591938626, 0.9507236807872701, -1.2016879795099416, -1.7736174716743731, -1.3072122287958434, -0.10126316196484728, -0.6892343045300331, -1.223994423666416, -0.7558063662093321, 0.8305093446713689, -0.8062384804092703, 0.4329755942308489, 0.5055105969719473, -0.16902762596185708, -1.1491241030973316, -0.9965426919064484, 0.04692335058305076, 0.6324828667011703, 0.5578009797840602, -0.022053779034758494, 0.6454672294804947, 0.9923410856351982, -0.884933143248491, 0.07480826526237383, -0.08263401717865189, -1.5323323288144908, 0.8947774773313484, 0.7866334395123386, -0.8605224735260228},
    {-0.5627968110227718, 0.4939471900380477, -0.6629324263051747, -0.9814631395912374, 0.01618437669198562, 0.5385184389569669, 0.768492474980235, -0.06570971010435309, -0.4100041323528838, -0.8082533877087523, 0.484339397217074, -0.8595992177426539, 1.0519023873767674, 0.2771592594251907, 0.05478583207477169, 0.2147020837750807, -1.2825268404788535, -0.8246846745675432, -0.9937349302957308, 0.8727168281356373, -0.4282047398115228, -0.5734485692718934, -0.08821569814134357, 0.05592813118961464, -0.655746542458342, -0.5025972041859674, -0.8358288677476859, 0.359930800508319, 1.0495635154564276, -0.024499570338233655, -0.2684973418131732, 0.05075938975609389, -0.6484515391308966, -0.5856378200961274, 1.0218648891897697, -0.4190900973457034, 0.7575270192127309, -0.8131068042248578, -1.1653725153066536, -0.7869033720043532, -0.28477649077542483, -1.4751002850646484, 0.8255536339952806, 0.8304926113595335, 0.4922045586915958, 0.21635640078510796, 0.9051472235262927, 0.08455382837117402, -0.1995000985438845, -1.7498083456675686, -0.09919134827850042, 0.09668935978700353, -0.6509492812022881, 0.9900340481751386, -0.8175378207871126, 0.3937946378311737, 0.6164658401015034, -0.3618509025727906, -0.9027186120657441, -0.9135277711380347, -1.2085067885548026, -0.43499400881629935, 0.9078568099905449, -0.024137272997894456},
    {0.15387142432266404, -0.34580832669272465, -1.6904459120563597, -1.2831149582595929, 0.5935050911978318, -1.1710611773236794, 1.1507659406500124, -0.7628298176939322, 0.652254095101078, -0.6325143438565787, -0.2389543743079656, 0.3923107800682334, -0.7499090486374597, -0.8954884916241049, 0.045190422094188706, -0.43542580087728977, -1.237696002968713, -0.5498264568461544, 0.5573102637576509, 0.22120867164237554, 1.0663452494968395, -0.03422603384858208, -0.05375428475483553, 0.09192900208990358, 0.27169342538759467, 1.0963071493564884, -0.5385847634994825, 0.999886122324882, 0.910377914810456, -0.851830155669047, -1.369584704671752, 0.4597462564026965, -0.7144909065826117, -0.16521671284789904, 0.6996079002342662, -1.50958517434098, 0.39861222201698415, 0.6222216614168716, -1.5401278085672099, 0.6411557937932472, -0.5500711917002196, -1.0214093889512308, 0.9784800047247986, -0.12902755089959114, -0.8248494861005436, -0.7934078157237905, 0.4890852966398797, 0.845501653102519, 0.8888677025336882, -0.9722311829095779, 0.9901568226494377, 0.626914253311336, -0.7040775735921175, -0.5367408832165165, 0.025016824368365723, 0.8886131494170826, -0.27206325959688055, -0.32247289307894295, -0.9996759776263583, -0.9802309018497202, 0.5890733483944428, 1.3229598070540978, -0.09254784051674486, -0.7479399418789993},
    {0.1644679468837193, 0.7950332749253033, -0.9951891212353887, 0.10028701994544438, -0.5573096403371997, -1.1697087619459214, 0.6752788213439426, -1.608884001865887, 0.5490456994320508, -0.6053356341633643, -0.14269978578712772, -0.5207672529848381, -0.6797393357328474, -0.55088841493064, -0.16015957516893964, -0.3556799633021757, -0.1392426849386508, 0.13335562889751693, -0.8304366193875953, -0.8084271306270993, 0.07836678130371494, 0.2944513553804147, 0.2702518469843394, 0.5097854997071647, -0.5153457978387863, -0.4155031670795788, -0.8793459457853624, 0.7896863653916464, -0.5256848848012954, -0.5544897687017641, -0.35086108402845495, -0.29069907535829914, 0.6043491002987933, 0.45014005007907437, 0.9472933004387806, -0.7889101933322586, 0.5922273731840787, -0.4144850432810637, -1.1180230648158533, -1.2347250443895048, -1.1534176542562102, -0.7396924843134973, 0.48737803103979754, -0.7744360023039303, -1.0241877248841005, -0.4077853361744857, -0.9844144061830662, -0.03260319162278066, 0.11464790843157247, -0.7616476257665052, -0.23898993795211676, 0.5602170465908362, -0.3927923590069115, 0.9672292702187915, 0.10094057084220112, 1.0610275836693495, 5.134850428617922e-06, -0.5856512438242886, -0.17118914136821647, -0.5511567996814855, -1.187056836021638, -0.4187086790849929, -0.03717325715745323, 0.6382393017564668},
    {-0.025296176523933792, -0.6524372901089034, -1.1436519658937307, -0.8551303314747761, -0.12535944720009906, -1.168641415446967, 0.4011657914529193, -1.004995079282985, 0.34483072474312054, 0.559921803536722, -1.4083013089145342, 0.10301481614167031, 0.3274879654419182, 0.005637681115160074, 0.26944076250892174, -0.733735099448239, -0.8382367099230967, -0.45447565073882, -0.533291292265606, -0.9104787804904796, -0.11336436544825654, 0.20091672152390794, -0.6160759512366568, 0.5901278155425635, -0.5827148172917157, 0.1006947810036975, -1.322226683165222, 0.615814374486851, -0.4207092311308763, 0.1102251906992357, -0.8672896413509065, -0.8515390749064139, -0.5895779459384182, 0.4100239662027768, -0.8091034092923824, -0.2436673791047127, 0.16884798617112254, 0.40350806611020484, -0.721973925504529, 0.06999281290526534, -1.1100545751329718, -1.1583524018654414, 0.8276935411176537, 0.4789808488287552, -0.6149031979620094, -0.6111985049228742, 0.034131801014054164, -0.7502473700652285, -0.9403348489507768, -0.9833625407036759, -0.45198892560376697, -0.22352090045953096, -0.39540259547237144, -0.6531880415188738, 0.40158640122367223, 0.07584817191311549, 0.6299676771142795, -0.4339542769017641, -0.6765831429567821, -0.96033785626323, -0.23935984845202593, 0.8509851442040629, -0.4710827440865978, 0.5131162330571981},
    {-0.48962605306420515, 0.760640821120614, -1.2358801270078124, 0.550057809867232, -0.2103956693367413, -0.1391048659676139, 0.13144714232630747, 0.40158829110191097, -0.6052334685449089, -1.0627768669279818, 0.06464323855493727, -0.587539993069054, 0.7552560709116345, 0.975781357866176, 0.8714690734587563, 0.41475723989217644, -0.7007999196898936, 0.12475477746404802, -0.9569257720976496, 1.086891942843391, 0.030720021461523656, -0.3136965850471197, 0.30157797278137777, 1.1537068845669822, -0.10771142766197639, 0.6553669478914113, 0.2950690171374318, -1.0775097438899368, -0.11290287414352729, -0.038675267291938424, -0.5801946882174895, -1.4688205676681465, -0.7509005567049478, 0.7180138772786939, -0.14206478235158976, -0.6846283594892013, 0.02187339080191266, -1.3823514878027807, 0.05617582621072659, -0.3505868007956284, 0.15244332087257123, -0.8325765181386177, -0.5106017248780886, -0.5663961479464404, 0.301912935144729, -1.321660788608693, 0.9596076704473999, -0.1358857788897464, -0.1924479275544316, 0.050219596725692844, 0.803981304444955, 0.6642587664306888, -0.3801990098415474, 0.8596050620753536, -0.3797571661251311, 0.3761869058236819, 0.05110276761774091, 0.5574913531440762, -0.31589300495715533, -0.7765590487376335, -0.8748290229576176, 0.03291402646823215, 0.9355431543193943, 0.552082560269413},
    {-1.1289218041161508, -0.3636493110365289, -0.6571861872912381, -0.39552299382178946, 0.19930557614252423, -0.0870781840664646, -0.1128619544329051, -0.18521768662076252, -1.1426388029816699, -0.613851476601753, -1.3841093246084566, 0.06097328043137594, 0.5682735548192819, 0.7778700251194709, 0.8088999171333934, -1.3431395265600357, 0.005738766336372179, -0.07541160773224996, -0.6415632108436111, 1.0387841775460387, 0.06344334188207551, -0.5600070233969494, -1.0569910032631564, 0.5462865227412909, 0.5019714210970604, 0.8128904885609167, -0.8368841034155567, 0.19922053973357493, -0.07931722657409443, 0.780443507565801, 0.3796729161672915, -0.983981859130784, -0.25482398897528413, 0.505837510421111, 0.16990530785138838, -1.62252713436799, -0.12029085092173153, -0.5751073131954371, -0.19749432138008485, 0.4786972883398513, 0.24918259847403815, -0.043377373328906746, 0.8803680740487783, 0.5452655717220555, 0.5374446314736794, 0.20611551960764005, -0.8261139213125225, -0.5783813746188423, -0.3849522315909377, -1.0443549355975519, 0.11648864055787181, -0.27020816571061235, -0.1403496742058997, 0.6384728239673209, -0.11028493940947043, 0.7043026163307087, 0.390583443415351, -0.41388644686481085, 0.12350603064045901, 0.6856138864259134, -0.20943450769470526, 0.21298681341369896, 0.4096259115642941, -0.5461855605212036},
    {-0.12730053483888637, -0.5129637566780322, -1.2820595106000017, -0.04458364426580257, 0.050050092940150795, 0.6640499737763959, -0.6711284910383516, -0.7237377411262932, -0.37925411330571923, 0.17524771448728002, -0.9916004889354424, 0.013569869544466555, 0.5356873394444771, -0.5345451988844292, -0.02588397702954715, -0.9926298501211576, -0.12815790500343516, 0.46308121343212605, -1.5139617722419583, 0.959996002318058, 0.03491248195039879, -0.26033484425582526, 0.5969950492089973, -0.04505557511984021, -1.285161244259501, 0.33371437238427704, -1.3005117937116315, -0.5100226188417377, 0.48299215676157736, 0.5048881196280113, 0.3493716897821176, -1.4620636380728647, 0.7492190370484134, -0.5533965580209318, -0.0708748780406474, -1.1559311330118545, 0.20038625636158927, -0.3305841488527386, -0.7569276172912379, -1.170381688749185, 0.3185606107886289, 0.09015768549273129, 1.0655096745830173, 0.9391336846705988, -0.45160252187019256, -0.4243497561328239, -0.8691331094604141, -0.2149948058669352, -1.2809604033440452, -1.7980733236033344, 0.30351306334080297, -0.8325619765979656, 0.710099412603185, 0.7067203024780906, 0.5587070680080524, 0.6217373093349171, -0.31180743262634125, 0.21016283589191087, -0.13628070175986343, -0.35748622081922216, -0.8490007899811454, 1.0541959343728506, -0.632487749206862, -0.9578759261472565},
    {0.3178912943588063, -0.9116415527424616, -0.7990532729183001, -0.6899875102228349, 0.4001863940940644, -0.3025080070402888, 0.10784782956066889, -0.40934684334353216, 0.0834183108728572, 0.485055316701002, -0.7683422592048187, 0.8556603915603014, 0.6579393514395246, -0.16999141759869835, -0.6868517408516517, -0.9487965882492314, -0.13897294499037613, 0.41065683909543543, -1.482402117233248, 0.4663559396201189, 0.1486583184173411, -1.0384673778000895, -0.9796040216782824, -0.4051265658399123, 0.3625434344639421, 0.9620931937734211, -0.6446199147906645, -1.0490328421522073, 0.6176592562649673, -0.14851606445629142, -0.6769424732099343, -0.44643581938090116, 0.772822550554204, -0.6839693724576983, -0.5865559624193922, -0.555594423642373, 0.47159674375799265, -0.9793639153328799, -1.4462810396728014, -1.218117622098813, -1.0256680262740834, 0.22972840376689568, 1.1682603953314932, 0.24014624574735424, 0.4375721503774221, 0.046733261457765275, -0.22290918726455172, -0.8280185965872874, -0.8262421081419381, -1.3387545628313384, 0.27286287398864645, 0.31974809695729134, -0.5160113531394799, -0.5397797906020131, 0.905157600769859, 0.06198972466837201, 0.8309512094137088, -1.0064682731752077, -1.2170031198525049, 0.24095551118925482, -0.8480030417887223, 0.5677341683047827, -0.2715521185029173, 0.6280249175502144},
    {0.7665858492484062, -1.0592888140102834, -1.1788585731808887, 0.26484047405263483, 0.6455357527847596, 0.2573718081548893, 0.6769073383570293, -1.1738452884935906, -0.9162600844767441, 0.18925778481629457, -0.7324950028487514, -0.892153557379275, 1.0833020667361, -0.7507777769751203, 0.8652021947078665, -0.2245788094740148, 0.6161696421395809, 0.017810841831362726, -1.1004004390201154, 0.4790898653477109, 0.5791923749939779, -0.5006062481279074, -0.5009052870240891, 1.4239132636863947, -0.39823333880546674, 0.7041969720560941, 0.3835958738078087, 0.06126832799451349, 1.0378539586539337, -0.24560804072460318, -0.2889608916782567, -1.1638626389099842, -0.473980866390327, 0.6427084082568373, -0.20740795650779342, 0.2116211449624837, -0.4855893142823687, -1.0129140264252585, -1.4327278371427776, -0.3528788135999142, -0.5941839566714543, -0.3171910387231301, 0.5264828566064378, -0.17932341059046603, -0.12833881471753547, -0.818696989781042, 0.35402316240023135, 0.39576244674900085, -1.2389855880356586, -0.9639365049818621, -0.18038904114119764, -0.9516474132574063, 0.5435715054701327, -0.09313345016061533, -0.1851956509473227, 0.956282953087795, 0.703631678919978, 0.14373417277723582, 0.07954444209463193, 0.07950949593191343, -0.4481161171496436, 0.747327817944686, 0.8767959284736285, 0.36222406152744685}
};

static const float b1[64] = {0.7325036875663347, 0.9482215541304968, 1.0487422087758445, 0.9377680197323262, 0.9386671244006873, 1.096220564200266, 0.1152350270708838, 1.0123734266003706, 1.073302641603084, 1.0628782798099186, 1.0595081752963431, 0.11637217993225897, 0.7559024847292403, 0.9307418732799734, 0.9096493173604641, 0.9326717532173141, 1.0828509896643683, 0.9839828320969769, 0.9376431470499781, 0.8706015228253023, 0.8880979956670249, 1.0263560178454119, 0.28549706703613886, 1.0356723777923746, 0.9500610901773989, 0.46859755701251055, 1.1451275871569433, 1.2005983729947316, 0.899580101864155, 0.9839352089793816, 1.1904180185949658, 0.8962941432798395, 0.22379219210859072, 1.0038498804862388, 0.6840895384673026, 1.0566188585944343, 0.373957127986093, 1.188158668899933, 1.1866230867163914, 0.9609571375849247, 1.0926263639765739, 1.0630198386060377, 1.1023859366219364, 0.5088132438955926, 1.069625079741042, 1.0772870590427577, 1.0237377479084109, 0.4424426088277774, 0.8685745824688988, 1.1141037822240887, 0.9100917097297024, 1.0491062409839544, 0.790186731420885, 0.6162125213384182, 1.132322433193148, 1.0787541920088053, 0.8369660133504759, 0.9015030665108559, 1.0314103890925697, 0.6947808202303203, 1.004189386090316, 1.0174687410059746, 0.9474246280788534, 1.0665198802285065};

static const float w2[64][32] = {
    {0.833268582733816, 0.9210557019067566, 0.3798968024056242, -0.1111921789761038, 0.768172306730374, 0.5767105837638097, 0.375514352420139, 0.30193014076143165, 0.07076871478569595, -0.9180397045326233, 0.7895867642179333, 0.022724305404724254, -0.35511961110254525, 0.3311107741479888, 1.4876067890924278, 0.8693587980661205, -0.6515963832837781, 0.10232958916769339, 1.1075766499796411, -0.9932551691770007, 0.3165195385601608, 1.4473658635742612, 0.4285147018084154, 0.23219154400893474, -0.41976842313104606, -0.19739007077310336, 0.38966555541084363, 1.0733929529895359, 0.2301487974658094, 0.9509141570771781, 0.7338383720124098, 0.00038086750473662127},
    {-0.505532265379906, 0.9188279587873222, 0.46756138866677477, 0.8228944457808438, 1.0500024634345626, 0.49835312671467374, -0.2914806933978354, 1.4771933080715114, 0.1621797582705729, -1.0288072730578568, 1.026814724001339, 0.5262307699938453, 0.15077184527011755, 0.2540747167042782, 0.7652316420716895, -0.5822930877122741, 0.04030904443816647, 0.543657601551627, 0.9696891165944858, -0.38838489141710536, 1.470427484660664, 0.4917038195377859, 1.6392071984006154, 1.5937188294479898, 1.505720138538537, 1.7189520669381797, 1.254061291317524, -0.3307990470597422, -0.0330617573106304, 1.0889369621410767, 0.9879171224395424, 0.6874427586016005},
    {0.4834731805860424, 1.135428911155155, -0.6144739475864115, 0.43739482780372985, 1.5332382412320178, -0.2969843769096069, 0.42180456366899394, 0.035134434450747674, 0.6586137468278641, 0.02502437634619741, 0.0957285426174963, 1.704171029974541, 0.3904492233884346, 0.9861992507698185, 0.9756968554177388, 0.5275971931076872, 0.5257562608341076, 1.4620684247452245, 0.1344804713287158, 0.022746487139116058, 0.523353238534561, 0.03043537842577901, 0.7496167515254307, 1.04140165467668, -0.2558595682967725, 0.3664539791155307, -0.5200034739232959, 1.0662184449341092, 0.5936029413562042, -0.24400765696929758, 1.5916167530699237, 0.9804826066981936},
    {-0.7628767837595679, 1.235748773109384, -0.8170634408725126, 1.4029143478825956, 0.02657423249616506, 1.4983090835627233, -0.9186489841297788, 0.9953051079803652, -0.37900988805469477, -0.43628813943507955, 0.7142345325812589, 1.3305980095664958, -1.0666436094640546, 1.17880922877865, 0.5800770699460818, -0.49510987623611924, 0.7672287673202537, 0.33371242753434127, 1.273211730355989, 0.21887493697412902, 0.355976906119094, 0.7703492002932514, 0.8815660382396892, 1.493428946036651, 0.36577783356806065, 1.2292565077651512, 0.935485278756776, -0.16040180598279827, 0.4453146576671933, 0.19680832361475045, -0.14052283826800716, 0.8533307844783462},
    {-0.4391872118497044, 1.5571578232894587, 0.4127712767504956, 0.7519435924243577, 0.9371136507227841, -0.14994339020180966, 0.3985183879740472, 1.5844965628240788, -0.3532509336564866, -0.4835634182941182, -0.021999659856914888, 0.20412005049999893, 0.41376417880682553, 0.6474333766916186, 1.383089432128102, -0.5412747884374173, 1.3914511702992478, 0.2819428525756517, 1.2443421255008509, -0.9628938693545945, 0.08734137219137968, 0.04196715085969048, 0.28258818524494406, -0.16811144495601854, 1.0119009135302048, 0.8206975225041164, 0.8282152659587878, 0.4969400934332076, 1.3711844256248689, 0.5532289374237183, 0.20894838084897852, 0.1263409143793853},
    {-0.2644926330817918, 1.504762482093585, 0.6332192780866652, 0.5421676280410865, 0.5880724302908245, 0.07016293074298831, -0.5651784181009629, 1.16996787947118, 0.14947788093947684, 0.5025053623614559, 1.2128374995593465, 0.2231809447530191, -0.03800375860388222, 1.1174200502673468, 1.6554130108464855, 0.042683889814447436, 0.06068106335556955, 1.411995016626888, 0.5847830773656411, -0.8587906657169185, 0.9042181866817451, 1.2300878199511556, 0.6943248391188547, 0.27242251145933605, 0.41049680112879294, 1.455765296235899, 0.1378858547319551, 0.7895481804080594, 0.42957514587582213, 0.7410208695002727, 1.0310978781406415, 0.5415706857339704},
    {-0.6095028678152904, 0.139175635930154, -0.4700111502167561, 1.1562465052805004, -0.04384993126148686, 0.4244976938936677, -0.9176189382829709, 0.4521766085382964, 0.17604972230271837, 0.8063272473943685, -0.08402070478549661, 0.6917698589093563, 0.5374214293465457, 0.8943020675247291, 0.11119460281312776, -0.5358619407073828, 0.16779250810899535, -0.08125772690451037, -0.44654646713106544, 0.6132386137158305, 0.4416395176432988, -0.12272535519078427, 0.9510302777621285, -0.06623724762331122, 0.11409097563747923, -0.032614251364347015, 0.24078668620571225, 0.7724420346718475, 1.330279137878728, 0.5394557784850476, 0.6294104392052903, 1.4770520281729886},
    {-1.1244630122015828, 0.7732959926436472, 0.5295583713412251, 0.15941171258188447, 1.360610986338567, 1.5568151357090707, -0.7019481948538925, 0.030988913469688403, -0.7134347145101074, 0.7761659325887956, 0.6055638949771571, 1.0329722626884925, 0.762191229047333, 0.8903600523080203, 0.1944825564576988, 0.27748702837288475, 0.37849413130459464, 1.1821687809611374, 0.06333433265730971, 0.48322774897678283, 0.2595707318283386, -0.13585234352759595, 1.3395681793531522, 0.7632992784324218, 1.10981132179494, 1.4105014137259142, 0.6983749285853633, -0.1815315646254193, 0.48866828124857786, 0.7793781080760882, 0.6776540297747055, 0.9405707160504999},
    {-1.0453838320342654, 1.281700715052696, 0.6763408191290992, -0.04477570470762081, 1.1364935355884673, 0.8296916510627061, 0.8035735981974051, 1.3518571018023424, -0.7901943631569464, 0.6556171456980928, -0.3767536961917325, 0.6326092476999515, 0.6903283857561424, 1.4386599564013938, 0.8841619894314365, -0.8630171480755251, 0.8736050846383306, 0.5878180637365783, 1.2345202975925338, -0.7550739529912962, 0.4356247215708659, 0.8260222200709489, 1.1735028763315716, 1.3583704920766848, 1.3990005139533677, -0.19800778104105646, 0.025445341672313323, -0.35501398926502337, 1.4754752119564496, 1.3174346126085075, 0.6233691830296175, 1.1700742893892178},
    {-0.24042067173423692, 1.202821017153335, -0.7813255381412875, 1.0054732690075803, 1.54579647532528, -0.15218897700626155, -0.06231076032949965, -0.025036900730033593, -0.5223894240881971, -0.8078213080455932, -0.19116209151834115, 0.9262781847931599, 0.1731185267396255, 0.46237339275287276, 0.1647637631011054, -0.482347559717295, -0.21338656599937175, 0.6714567190210119, 0.05756027863668897, 0.05670827260271637, 1.2026910731824574, 1.5111065900999048, 1.700298811781828, 1.0322809107566953, 1.0654670136466498, 0.6733946998345709, 0.7088904150591336, 0.4856921983779406, -0.013485768140473926, -0.294459521155476, 1.605003903689054, 0.892780596905585},
    {-1.019926409069443, 0.06176017279128775, -0.33178553210484146, -0.040099083853389256, 1.7672976517764825, 0.5349191504243044, -0.7279584521623936, 1.03942124764828, -0.2610864163390806, 0.4314128786256566, -0.28711540664120233, 1.3778381612332238, 0.5661726094846691, 0.5881493989844874, 0.7020013112372062, 0.8162641078381351, -0.3614949965703013, 0.3956090683510084, 0.20387731814430057, -0.48751701902689965, 0.083507431497725, 1.4414575246466916, 1.3340652448991406, 0.9366328847692422, 0.7925391644895804, 1.4115186066780137, -0.10036549798857629, 0.3938260464832245, -0.30275921177403736, -0.0034892032205807765, 1.6468364663328796, 1.562015344691452},
    {0.28479790645503, 1.046699112231485, -0.2060869245760991, 0.39709634303936625, -0.19429751113183777, 0.25259615385750234, -0.2986201646316482, 0.4846660676267679, -0.2835395761037174, -0.20318626880684929, 0.9806717127444221, 0.5513752270256824, -0.5327447989840653, -0.06291801361840693, 1.2278863077820676, 0.017770447370954914, 0.0532206998955059, 0.26560112147531745, 0.06350647714305335, 0.7818056622975897, 0.8768868076963905, 0.13258524612522954, 1.0500101079928699, 0.30028650541134927, -0.33798904976352934, -0.06092790439810895, 0.8901286340700892, 0.8746894590300492, -0.09696501856692796, -0.24174234866828248, -0.156375943602374, -0.1995640082678178},
    {-1.054732639598546, 0.4077736500563487, -0.705873992678804, -0.15361016952822037, 0.49586487265156226, 0.3164078773288659, -1.0511074014704203, -0.3623168115310141, 0.5965860226411167, -0.19493365786889388, 1.09292279577777, 1.2532124441173214, -0.35470195293735496, -0.07129071879397471, 1.0537185182794462, -0.47040864607013705, 0.6062764289232719, 1.2790010026370078, -0.27454400508878957, 0.6880728154702721, -0.29663577072600944, 0.9922709947805869, -0.025330033362945734, 0.8621748192592589, -0.09807694924356293, 0.6734432554509028, 1.0745054175699698, -0.18768846025925862, 0.048887806011256196, -0.41344623870053143, 1.291097464442491, 0.42313353431148004},
    {-0.6485283416092421, 1.525516920931898, -0.9661812364028544, -0.11132671326440337, 1.2575114140954686, 0.8987831802318884, 0.5909904691504608, -0.1454536767846087, -0.5701263896626921, 0.4119048041883124, 0.5053094259464205, 1.1943361850479863, 0.838068738726812, 0.4596348083183202, 0.3049971940247864, -0.4706553777845799, 0.02924473079935985, 1.6981743446882243, 0.01362284012859191, -0.11929005610806685, 0.28586264391173133, 0.004951882073039167, 1.141234065995137, 0.7854014128121591, -0.16692941611766723, 0.9746637501613089, 1.342682477768632, -0.10616613600302541, 1.437838886984322, -0.0449238583183712, 0.6347411708868441, 0.3752021921698505},
    {0.15048842794390965, 1.2793276919689685, 0.7320169985269682, 1.513628469782446, 0.8305122255714268, 1.4840269068984433, 0.9320669198832896, 1.4912346946896347, -0.3612128378492311, -0.19686106967687877, 0.510498136079593, 1.2187365492938405, -0.7716090943274109, 0.4177591030786096, 0.02466826052954197, -0.07903691399747918, -0.04973663672343386, 0.5266597927232437, -0.14615339538344674, -0.9227443249423931, -0.29391923949061627, 0.9808992950167178, 0.4921180914862757, 0.19104505095654425, -0.3261574797003885, 1.4427818631101463, 1.3656976607523559, -0.6689794803390886, 0.5271935930593222, 0.6620460874624685, 0.7619193242212284, 1.2945100529748939},
    {-0.36556043772023245, 0.5495148167818424, 0.7264134104655726, 0.3974020512299143, 1.0935814231008745, 1.1204972254820145, -0.6926007755194318, 1.7776197845966992, 0.17587864017023438, 0.14818290875853898, 1.1847394516006, -0.18594154059605517, -0.179286605335367, -0.08597116913877473, 1.7575230797537955, 0.3065558220877304, -0.2868686936553703, -0.07440865196942556, 1.5276373837134092, 0.6841628691654178, 0.5009602033419398, 1.603673004326232, 1.6925905590683838, 0.29841107572782605, 1.5104854556853753, 1.021288384693554, 0.9684675408754937, 0.48071228627242635, 0.8400604536903586, 0.46461762516993105, 0.004564607301439148, 1.6797631052867152},
    {0.7743059897827184, 1.507197353260398, -0.9910135242000376, -0.03725336652795117, 1.8228558191971789, 1.231999056405925, 0.171879718098303, 0.15658880505525655, -0.4901042644935512, 0.6267978458276632, 1.4691144512944523, 0.5707739843240192, -0.27559462344018054, 1.1471450614429062, 1.3540585938127783, -0.5361613495591744, 1.0415093733940832, -0.0832470623919977, 0.09252969197632345, 0.8575596586541038, 1.3907769246204982, 0.4781592221311293, 1.3104086992344577, 0.5025340409970112, 0.16320794998399094, 1.5736514667797865, -0.506304579060384, -0.3302807389893433, 0.6985906244303772, 1.3315802406858808, -0.06258613488227589, -0.1590279193445391},
    {0.5431159804640807, 0.48167596609684504, 0.6977764784391124, 1.5354637935676345, 1.3716512753450378, 1.2911528588318038, -0.2929702149867531, 0.1018024730463642, -0.9083304398974072, 0.042455768810452266, 0.2665107494527677, 0.28289164619618606, -0.8526034567491801, 0.2264040600870045, 0.43490001299523884, -0.3569468015778519, 1.0887700604075896, 1.3600712789265301, 1.179976468240647, 0.05791006831086356, 0.8299362346082464, 0.9009761514481273, 0.5918864525522642, 1.4259018063936992, 0.7255929918072506, 1.7755565440354295, 1.1071655373541176, -0.4556175013612692, -0.14324988508207542, 1.3851465652061612, 1.3272276327372126, -0.07355496491639575},
    {-0.927095881935983, 0.028423296255846123, -0.6300481406602996, 1.4939498740319515, 1.2144454987311957, 1.1418044080349299, 0.7452637931923702, -0.05919040061119797, -0.30144107401602016, 0.237840027394417, 0.38930964679902047, 0.7139244595090687, 0.5715149237272558, 1.5894702475262443, 0.5060202740926603, -0.057928398552657474, -0.01700419304011207, 0.8264394650182504, 0.38984242984390033, 0.03564213879802066, -0.03474407519426719, 0.6320541514475404, 1.6316812995366798, -0.04137203746129559, -0.2801689358443676, 1.1726033547910977, 1.2324699231036038, 0.9416329482740907, 1.4427790613876448, 0.10037380160292947, 1.0297611332416636, 1.1157224980888263},
    {0.8340950401888948, 0.6892237968553911, 0.6736433868981874, 0.721625408380402, 1.2798578103777354, 1.1313275148816968, -0.26081509472816705, 1.4744904173463547, 0.5654409676510752, -0.6587142948493538, 0.7074400055832004, 1.1976938739460596, -0.2978177274537628, 0.09568623412356166, 0.2384866517024564, -0.10709627549844186, -0.006693307447013433, 0.33020137752573303, -0.15714085904244657, -0.5642608250630922, 1.0625627833164144, -0.13434206572453325, 0.6161371729932766, 1.0929204530426395, 0.10131966754748573, 0.00122609828729354, 0.4934320350212291, -0.3775255302739458, 1.0553865871354189, 1.1862864908487913, 0.6769728387310021, 0.33162542369527076},
    {0.7222968495810249, 0.7521303284008466, -0.008275259317344139, 0.4482203711215518, 1.5710052222480477, 0.4143736957251488, -0.07636559492599901, 0.352737670467971, -0.14203558958055365, -0.41310829227548757, -0.16670622426099735, -0.19158430281190703, 0.44068390697557397, -0.15059783144159847, -0.0740580390675437, 0.31754324122266575, 0.9612091427931942, 0.4466064977570729, 0.6027767980498303, -0.36587854960717725, 0.008512315078068987, 0.8549382311018618, 0.8981064873863143, 0.5995202255438016, -0.246605309768049, -0.14051642902491754, 0.7766610866788793, 0.7737178659302876, 1.2665877973818356, 0.5761773078329463, 0.14321274258806516, 1.7598592039519791},
    {-0.8386006051100612, 0.4881250684055094, 0.037932102701034566, 1.391856556269715, 0.300212955718782, 1.0453720219751648, -0.9182872159019407, 1.590622273108217, 0.24196631639151536, -0.34451598525159377, 0.31235317440517385, 1.4785569477989293, -0.7219164198057243, 1.5583741536695621, 1.8831896770283028, -0.023507487383360146, 0.9794580311042629, 0.06553554946970246, 0.8118872274860396, 0.38945951118633143, 1.1605724608590964, 0.8626304649539522, 0.4249856563512521, 1.4846857397072895, 0.434510272329382, 1.0405274590127065, 0.1085058296908612, -0.5539754725553669, -0.12071617005658496, -0.06970097500331048, 0.7223277835750227, 0.8559213868492258},
    {-0.7193970972945735, 0.08273829053218504, 0.2440197068376741, 0.3057296796470573, -0.18373753974315138, -0.30293812527882374, 0.7234420451505515, -0.10812967301131095, 0.1428421872003382, 0.13997824239120846, -0.1648408101127745, 1.2006596289550029, -0.6462417873125078, 0.5023545648362614, 1.114320200636164, 0.7537134452150129, -0.043822125461437746, 0.5431074703925314, 0.5795707476426947, 0.4493567633794901, 0.09722986665601917, 0.5374308729379924, -0.30112270954752407, 1.1153280036949755, 0.45236730681200393, 0.92133035850865, 0.779608961274431, -0.16510014068063572, 1.3304273999729452, -0.17207930145481018, 1.2772425932058065, 0.27849384986218473},
    {0.4806855836803266, 0.24471002694285074, -0.14897530099503448, 1.3694897173730314, 1.4589828397099838, -0.13514438677702614, 0.6388503263200622, 0.5675624357632874, -0.8655233237557636, -0.5138272612392042, 0.23850083880907347, 0.6566369823460801, -0.3995132639288908, 0.23784239660592393, 0.7558938965411163, -0.4092126168115953, 1.0615411689455339, 1.4826365330944344, 1.5548637741594737, 0.23599747703602397, 1.4774190563144767, 0.8330914739887979, 0.010697852324827409, 0.494039272405461, 0.48477302634615627, -0.05466574771576187, -0.5308332549938184, 0.14807728212691904, 0.39996628795760253, 1.0008399283213807, 1.0762986565708392, 0.9613472245347268},
    {-0.4752603568158471, 1.547964571145668, -0.4944027700167171, 1.3491395430336592, 0.5664728240201726, 0.4787254248558746, -0.884734203241798, 0.08123439947915571, 0.2255428913094479, 0.8721450995881737, -0.31248152050683126, 1.5837627469131943, -0.031105534847981398, 1.396195558812225, 1.5687105861374848, 0.33100089617675554, 1.3642519479756645, 0.31438558774332803, 0.9258910992834984, 0.03403585122599412, 1.2458635462536947, 1.5171457581832197, 1.6504011811636503, 1.5994118118005753, -0.09136933175577826, -0.13134959271475616, 1.0347289226999268, -0.21903913802001915, 1.480961694120662, -0.266092728645056, 1.4441919563301255, 0.817623588566474},
    {-0.9897566304017414, 0.08013951101127063, -0.6156424376522686, 0.3526333355389042, 0.8640101108101567, 0.38538138301512026, 0.736549519578076, -0.023614598288228913, 0.1833717580218501, -0.960012752037371, 0.8378865996841146, -0.24538029494566607, -0.08428703070325802, 0.8393690357872631, 0.29180477158820994, 0.12529197992648816, 0.031419456249235804, 0.44669309783682326, 0.6451984063989296, 0.7414923458258679, 0.2932504650983559, 1.4420313445638269, 0.9517374444902321, 1.4602160084247444, 1.0665007114274219, 0.4105208945320099, -0.6212154302359221, 0.9346108464486703, 0.8044611749754896, -0.13000035698280024, 0.3020631505542163, 0.19012991444486949},
    {-0.07738613442846677, 1.4409054710266198, -0.24420086581883016, 0.2718989493217779, 1.9156626655018372, -0.11542983088427956, 0.9792927107974245, 1.055016630965798, -0.0129936419878444, 0.4320476915896493, 1.3325358463910781, 1.123367462521519, -0.44466587718251727, 0.7942151473861074, 1.5664723647782681, -0.49777603031525147, -0.09089794520967158, 1.1111952485438632, 0.41713472214788444, -0.6777664279541578, 1.2341339394119089, 0.9117002598561372, 0.7467246768373632, 1.611196352289147, 1.3446009656209355, 0.3889172338967041, 1.231233474394641, -0.22638422869267172, 1.512469159428984, 1.1139900239078926, 0.9019676681890278, 0.8196690108786768},
    {-0.3075211486654896, 1.3549452817803966, -0.022795506081234748, 1.7637404073174279, 1.5199702945816052, 0.5178619583140224, -1.050728685328648, 1.713776057621585, -0.812062385328134, 0.30200337972144603, 1.3316310798490711, -0.16226669522910742, 0.38488427505222805, 0.4699729003255101, 1.692540656420549, 0.19010716518619655, 0.571537223821162, 0.28392547806835733, 0.08527137534814799, 0.07527967499470602, -0.2960861580367745, 1.2772446645483948, 0.48561491335115986, 1.287437876960088, 1.162345830980601, 0.8722704574505449, -0.15204835833768307, 0.7015658669219337, 0.1152696939313184, 1.2453534753213449, 0.6550330135272691, 1.595236362159937},
    {0.3590395555171868, 0.8541329271546653, -0.8226849103776344, 0.19462460001955997, 0.9796609705738127, 0.11028679369738155, 0.7735047901874058, 1.7578002845712688, 0.13530237634602763, -0.7473174112729929, 0.058100530836868086, 1.3108859501672803, -0.9376178479894763, 0.11428097698545428, 0.6801160052715685, -0.8427125103294684, 1.430292000735153, 1.093493081929898, -0.10915005789869237, -0.27030515090598795, 0.6777320718714039, 0.7479469940922245, 0.026142727500514332, 1.0310461384280794, -0.04178192486522889, -0.08769004993377053, 1.2519560507353127, 1.03076473761896, -0.24871010105954047, 1.2592448404129024, -0.08187224826744613, 1.9128586407331984},
    {0.3243172300781797, 1.4135678546732158, 0.35703347463095925, 1.1390056281877017, 1.7633747299374252, -0.3071107750170762, 0.9338572109507138, 0.2869038679500078, -0.24107728602098027, 0.583841218469581, 1.6260503546481844, 1.5103396652097005, 0.4899954839559864, 0.055202157754669204, 0.6292630440017849, 1.0607324600482468, 1.1662714648087134, 0.008859203638009306, 1.0758369155818417, 0.028770677997110243, 1.22645727340372, 1.495665211388509, 0.08870521537245181, 0.9767239534151131, 0.3919624332656314, 1.0810080740561885, 0.6388642917222576, 0.637245072695746, 0.19468147431736138, -0.006544106266164209, 0.12332592297836446, 1.227681380968337},
    {0.45635873076159533, 1.7102960580160278, -0.3964341956072896, 0.5262110991865422, 1.9386442032263973, 1.3430429989607529, -0.7964757264616762, 0.7787321447936169, -0.5991238909070971, -0.663285315749227, 0.4720836218310976, 0.35701753672305636, -0.6082230606481539, 1.5187370741059232, 1.765645215393214, -0.7795314075988876, 0.20821523593108762, 0.05425014175873889, -0.11121729004245663, 0.28435196456363543, 0.13882961319029982, 1.5040052588042532, 0.8573792600785349, 0.7502947503429969, 1.193344220039603, 1.0857301168399587, 1.2191903453906678, -0.6343129446917473, 0.8428883873354451, 0.5348284275246836, 1.5293453119320355, 0.21123223397077853},
    {0.8483811133234459, -0.04580914485942948, 0.1614695008941222, 1.4000191127729649, 1.5668413512863193, -0.24222411319999845, 0.46968292599357486, 0.6333852408682746, 0.019622934100564014, -0.31267347947733615, -0.28202629379385635, 1.0220012841180077, -0.8864926544011762, 0.19978663494831087, 0.5970855660318597, 0.06919588239557765, -0.3089367808793297, -0.056604557966883566, 0.49276506662679653, -1.0151265948030825, 0.7234556139923086, 0.15054335769637728, 0.2926654228746222, 0.4849736644853392, 1.499796731640023, 1.0084430561792246, 0.000953717741451634, 0.45162737532188557, -0.11281938007986558, 1.2746467007444273, 0.6304253687181407, 0.4779870052298255},
    {-1.061321501023212, -0.09217901306881189, -0.7528371132384323, 0.5599741634701767, 0.4912325883993644, 1.0479883203959488, -0.3753588156049885, 0.33588409845277073, -0.9326828169341653, -0.47222712402282735, 0.16197023309822126, 0.3263980695364562, -0.36376012760403553, 0.5763434939361677, -0.18325166401393064, -0.04384140541616867, 0.962490608557259, -0.02841512801675668, -0.4654428750023483, -0.20283803048454985, 1.2812728652384568, 0.3340161692857824, 1.0223958513233058, 0.6455012091519187, -0.2177948797604372, 0.11355511084497655, 0.6336787628044797, 0.18085172392151444, -0.40797007838099275, 0.3324625616043239, 0.3600221484868831, 0.30330179890187664},
    {-0.7005140516854103, 1.4145959201759652, 0.15531317089064653, 1.6281418876073865, 0.65735772476588, 0.4986199322946695, 0.2748595122902525, 0.48969516491509435, 0.5766208301884552, -0.8511077631920221, 1.2485122051898303, 0.3702014879798529, -0.5731410180539044, 1.0348597206939012, 1.5698942668150224, 0.5312581811711268, 0.0559507205790894, 1.0511625613827364, 0.31072257649785323, -0.6224449592275156, -0.3358215968959394, 0.8666215135559842, 0.07693550894352014, 0.07417472008619737, 0.03431747278539451, 0.8099858796806633, 0.48126157293382693, 0.5835365825088057, 0.5397924356767575, 1.469366963918534, 1.0249874806701929, -0.01583833627571818},
    {-0.3345882304440239, 1.6709078509817128, -0.8692406246113813, 0.7368703066894097, 0.28479088173145545, 0.4219263293009377, 0.5061667138178263, 1.5503819670081702, 0.4028307885051069, -0.663973019010824, 1.0618592262263364, 1.3747240059192953, -0.9316970172319385, 0.5744760212518313, 0.1262503575980461, 0.290983422461752, 0.46250647966394176, -0.011590010305672192, 1.4008681391209483, -0.24618707998371325, 0.8598389175498972, 0.14948005068718725, 0.36810084286859585, 0.3342417137011685, 0.632100074602552, 0.6804912497115368, 0.37603678201180846, -0.6161768839091831, 0.32511404410389966, -0.014285647467534473, 0.4851557231310682, 0.10363987414715042},
    {0.04273235973693298, 0.25588491608506836, -0.40632712092834905, 1.735680512921079, 1.5596247442368356, 1.2604759181278784, 1.016836117251088, 0.08869943350731913, -0.6271626613322865, -0.9170628799312168, 1.435127252410369, 0.8295027940638511, -0.8262006048135806, 1.6740836256074514, 0.776539491743064, 0.008890563250052845, 0.5401340858507169, 0.46987362631922225, 1.0764798146871464, -0.7167961625887977, 0.2359854179308681, 0.5991663140018278, 1.4935723656900564, 0.42535582468124594, 1.3030520093753533, 1.3245313743116063, 1.224990851393976, -0.5384689006440316, 0.23408452181130457, -0.3973101941267019, 1.0665832829154918, 1.4288703775348754},
    {-0.7564921463857583, 0.17561350019666103, -0.4776041289504323, 1.1480551169212878, 1.1030970651548155, 0.21252265756623012, -0.7710590942578538, -0.21390638450325353, 0.43303337042549706, 0.06543763181101989, 0.9663378629973552, -0.03748226881024854, 0.49985411068901636, -0.1532559449675103, 0.006232124844929275, 0.504439328057513, 0.4017941194765648, 0.44761563963902373, 0.10408532319327093, 0.3121821043560232, 1.4479923194064643, 0.8032212303775869, 0.7190302637369959, -0.23792030031363237, -0.3755994294370656, -0.2900014301296917, 1.2036878885227948, 0.047784880516183605, 0.056017180597053316, 0.25429541651421844, 1.078493545177102, 0.6659248758285777},
    {0.3940042897358041, 1.5297059220297944, -0.8519373077125684, 0.5640897060339936, 1.7794713725374454, 1.206324402998923, -0.9098202937186615, 1.3885068701174121, -0.8728827196560384, 0.1818724754533656, -0.1269221995094046, 0.16179319316793608, 0.8275235256466118, 0.24020599235668547, 1.745412836616834, -0.0650234822021474, 0.29302030846968974, 0.2100559196137501, 0.530957725739863, 0.18257685058517442, 0.0703749545646453, 1.3176808506634061, 1.6964113842042565, 0.06588998728587891, 1.5710350755732412, 1.5410853779842701, 0.40159205194066516, 0.8363661066365377, 0.05685909306400254, 0.7876330820334517, 0.42269308248566617, 1.0537056875621649},
    {-0.7096401796928373, 0.8358774106302436, -0.09124981285603001, 0.13088056212213187, 1.3632473901035518, -0.2626092282244229, 0.7707772845051051, 1.545442157170304, 0.07020951300379158, -1.119322853468483, 0.8564003410440871, 0.8193269458887593, 0.24238216388100262, 1.6293403746822868, 1.802117188274499, -0.5109913478329189, 0.5486262085651021, 0.034111145893505966, 0.04242938835971499, -0.10019610920069467, -0.11366968677127214, 0.12892196638026399, 1.6315977449055952, 0.9310627595011315, 1.616531495076262, 1.5205121406151518, -0.1334419809448836, 0.7295952236023355, -0.331648834989655, 0.14251896135757333, 0.4876680162530663, 1.5910847974315478},
    {-0.5744738699280848, 0.38782752386108377, -1.0516856642419488, 1.4967395164744257, 1.0864340568866642, 0.5129380365774142, 0.6678118045099499, 0.03412146605370111, -0.23176086973881843, -0.6495071046217736, 1.310856671516543, 0.2872847743179385, -0.4283473222458955, 1.5833696579186005, 1.8938318175401692, -0.09637527345809448, 0.37661528498308244, 1.568108558355902, 1.5829951556596862, -0.88722137215213, 0.8733107250003441, -0.041386400874389516, 0.747909487868062, 0.5374826931420511, 1.2640997692847538, 0.5598313708187336, -0.35365662217430605, -0.20845559727061932, 0.060569678426909815, 1.2554741168640344, 0.0555195646051473, 0.1811573555763496},
    {0.5123914044404592, 0.23364462157454802, -0.8129513512121049, 0.41183227675156026, 0.6657628851575297, 1.3027027954802544, -0.7135813721642523, 1.6789782046475732, -0.4122937713154313, 0.34830378236002985, 0.9918223420034288, 0.5637695848346016, -0.03666409855018391, 0.6876046439960889, 1.486279741386618, -0.6297587337698626, 0.3097263709917782, 0.9131681300435027, 0.5038768460944918, -0.17309317508315006, 0.80145559777742, 1.4794022267541191, 1.5566850697225034, 0.7545180092275673, 1.4872099122619076, 0.7180481522947756, -0.4791667705230449, 0.061952389807641124, 0.2559829664145577, 0.29179428390562684, -0.0020837662023301118, 1.4166205293095044},
    {0.47990666829092565, 0.5523278659295393, -0.22410058952596862, -0.012373024144855393, 1.3272844270584752, 0.5386718564305027, -0.49921808911510074, 1.4175846837410477, -0.010569064573782863, -0.24719083556212978, 0.849840078456175, 0.608835704409315, -0.11266379572702466, -0.21369022719502395, 1.695699397497913, -0.4622712966622177, -0.4608316870261269, 0.4082529108458271, 0.7104392429168273, -0.15070048435857475, -0.3650662310989033, 0.6786625370115478, 1.7862905156612645, 1.0903437730567462, 0.456485791032461, 1.5466129604651278, 0.4363453515848229, 1.0662794664085964, 0.7583937914161695, 0.6935434210841568, 0.6867776192764885, 1.7108211806340865},
    {-0.7796436028137366, 1.3087211293954106, -0.47021483811232223, 1.586787738905802, 1.5486647805655376, 1.2530992681042536, -0.4792872637325797, 0.5362895552434171, -1.1262404366372882, 0.8353421160124624, 0.1420437694361804, 0.8169363429676507, -0.8170928255524665, 1.3273274179282943, 0.010100516343945567, -0.9057965977884437, 0.6399788398367956, 0.8536606037023258, 1.3095371236539841, -0.8543594170224802, 1.378513874150298, 1.489367691560091, 1.7046542251073256, 0.8076764093804482, -0.08110471197812943, 1.5947570978504595, 1.2275041436551481, 0.20490590701532774, 1.0065596316136234, 1.5214160538736354, 1.1792356770580557, 1.7992146648239489},
    {0.718784089886756, 0.10293051293591436, -0.36289976393863077, 0.3266694634139573, -0.07794966906288696, 1.3795734326569544, 0.8249440501828492, 1.4904096786584111, -1.054087280095219, -0.8285405366381823, 0.7381191631982122, 0.08327673505582084, -0.29945429812951474, -0.11467781589160253, 0.5397151379945766, 0.8650437681643831, 1.0716376978356528, -0.23048573472705755, 0.5547421494274523, 0.533844539302238, 0.11411899597360513, 0.5813463259992604, 1.0198910142353141, 1.29977231397863, 1.3353775617805559, 0.5828235294356001, 1.1770600790275727, 0.9526278545167246, 0.35666332740393786, 0.15293875782145536, 1.4210577429333595, 1.319297598958292},
    {0.5511643437038185, 1.4541331001767273, 0.13652103466937757, 1.4034008136967502, 1.5158890228515034, 0.18103087623500105, -0.7576315400423794, 1.6203848354134052, 0.3047680699753838, -0.2708319627305055, 0.37341301998129356, 0.36989949900547964, -0.15771869492107662, 1.3049656621764931, 1.4514702832976936, -0.9622905524038812, 0.20235752431616208, 0.6279246900726806, 0.7695365946322893, 0.5805706329499838, 1.2560495800066231, 0.0058136859699523605, 1.5760329243510252, 0.210475894482766, 0.1209547014940091, 1.1544183281263558, -0.4163565169742434, 0.5607975866233937, 0.3228420533394637, -0.248784553067442, 0.46017103991508407, 0.22559173448773734},
    {-0.08867420295736196, 1.0406449154728827, -0.26985546622976087, 0.5436923286935109, 0.8570611265701569, -0.3278335311135033, 0.24150548490785656, 0.14516915339210582, 0.6179905832348129, -0.47881390266677465, 1.133378596514307, 1.1969981742279736, -0.4895010119374117, 1.5310382234979392, 1.297913870186862, -0.531799569895675, -0.10716893702488199, -0.13494975421360167, 1.5331628716803318, -0.2041679268898727, 0.7926545485125395, 1.0485440154156098, 1.5092648091555187, 1.027895663100474, -0.3162978392851619, 0.6378021430914428, -0.2897273262592045, 0.821657184316306, 0.5828730033480413, 0.709184810728887, 1.3567432746855328, 1.4021669640257985},
    {0.8194910339853319, 0.8611525202575696, 0.3497256186452537, 0.4769669780779114, 1.7190043085082536, 1.0627985321854914, 0.0019621342891985908, 1.079499033985493, 0.5326882520662953, -0.7069386079040363, -0.24968270108968363, 1.2629628893131108, -0.6065435403263073, -0.12943957910074178, 0.6297435850371108, 0.4903558475516144, 0.26846020504612417, 0.9568941201248489, 1.4093490689793926, 0.8292568960129317, -0.08958659927238714, 1.0670668510682857, 1.3081143472740577, 1.675244563982896, 0.6283082140003751, 1.5953082950334516, 0.7791588437760503, 0.2993125025525396, 0.7547564973712887, 1.1242276527495931, 0.44290306730156803, 0.8525479672502969},
    {0.520412148068478, -0.005672398927223823, -0.8554617635417128, -0.25498880492518927, 0.9529521624253667, 0.28669330888706696, 0.7557032087029814, -0.10233874916373906, -0.2714690942779107, -0.05592771104299467, -0.2124412197562513, 0.12346124504485348, -0.23562857245473878, 0.7239267471094223, 0.687879578405758, -0.5931593825249233, 0.35914905451533163, 1.0982654061163153, 1.2228043375623259, -0.8432258814441334, -0.06117028663010408, -0.12522873745638824, 0.46774990076403766, 0.7355324588940269, 0.259067266330659, 0.9311633197083734, -0.7187021045338604, -0.40894873664636927, -0.35007514393064065, 1.1854738790726391, -0.16077039506176016, 0.2978440684467957},
    {0.12104470492340044, 0.6985856542925428, -0.15009363046614993, 0.7563573559556471, 0.6037152795779274, 0.7944221608304564, 0.015000533152209327, 1.1824504417993633, -0.6377883755335513, -0.021655665817423318, 1.3040025860828555, 0.5748701760770124, -0.7636877694278025, 0.40943024123139576, 0.6211234631603741, 0.49642024417875263, 1.0982913125779015, 1.4225829277323743, 1.3740554655933424, 0.6687823533765724, 1.4568035367001892, 0.99527807630123, 0.1119335546323855, 0.2314310722479717, 1.0965721284590053, 1.4614813192668008, -0.25904294557718893, 0.005231681143901513, 0.373311489124477, 0.3021609149697797, 0.650998612053228, 0.9126825140245199},
    {0.2006079779097336, 1.8847218472513538, -0.4201369536634446, 0.9518375087633654, 1.4586789646634308, -0.055614440555236566, -0.11930615059017351, 0.7484687127184191, 0.4188610341053338, -1.1212265362142648, 0.8639528758566106, 1.7415080075221718, 0.5357870064262436, 0.3938851025118986, 1.796795503936579, 0.7776453362374506, 0.9327170803334066, 0.6505819472642725, 0.7525771249710238, -0.15836492066850275, 1.579711965726292, 1.3934291372694723, 1.3019887801508974, 1.1249402709233454, 1.4798543088468539, 0.6506354651805437, -0.05193671616760984, 0.8163769656230784, 1.1644339739747744, 0.507359794311628, 1.6168499046889269, 0.9552528521713756},
    {-1.0473593318348287, 0.0493229647316509, 0.3621631353148716, 0.36961251900772474, 0.19495871379222304, 0.6024562999730161, -0.7354709596984063, 1.808441962560306, 0.21895364600735978, 0.09695679747988914, 1.4582664193733401, 0.35548475823382547, -1.0002518802081428, 1.6128272728973287, 1.2810715218677708, 0.5713594174013599, -0.39694716943634184, 0.3811877144436523, -0.2441065835266862, 0.11909074447240448, 0.6572014048805984, 0.6461769879365181, 1.114814542664569, 1.483568779385858, 1.2659302379767983, 0.9901195026750365, -0.3624898182787109, -0.04152147993404007, 0.7922828013721618, 0.7786926598195931, 0.3329837267001059, 1.6443877485018583},
    {0.0020445604472676656, 1.3416882124817149, 0.21938339154872488, 0.47566120068159157, 1.5630567280265977, -0.02887524762342681, -0.8263504640181487, 1.3815061985593913, 0.12036572276676012, -0.7802732251313612, 0.04658252254822364, 0.03490264115666602, -0.9880303501120807, -0.18773476118548052, 1.11516836474872, -0.3016911589587178, 0.6822278386596474, 1.7277440823633936, -0.1403447769215126, -1.022703472923378, -0.08193823138524392, 1.1119313539882665, 1.3813208009260227, 1.4026338031965584, 0.4918104463660527, 1.5108756037376037, 0.8156048772288139, -0.5774979032982455, 0.35126530536493067, -0.06184479915778574, 0.10652172460056564, 1.0534368369361133},
    {-0.4653446166842577, -0.012972940295916955, 0.2304039225514929, 0.8670430662070288, 0.6625448834031024, 0.09007249501953411, 0.2644597301483806, 0.5818338481542131, -1.0647600082555182, -0.34388291036226104, 0.2878638290764775, 1.3709979286609473, 0.04498999674423451, 1.4584893086642992, 0.5693510120181748, -0.0006871201381065628, 1.2168905660636151, 1.712768779780165, -0.10279417927294325, 0.7579015595262972, 1.2097293061758954, 0.1983149797876429, 1.5554790366807107, 0.14200167616913023, 1.2067561522747225, 1.1391777209697769, 1.050099505184665, -0.0876793632132771, 0.39024923723680455, 0.6401974209766039, 0.465779331390774, 0.641881644797583},
    {0.23658544181433017, 0.6026026874868813, -0.06849274089777947, 0.013107284630666913, -0.03408648488315593, -0.44770744907203686, -0.03388878448861914, 0.0679093531613351, -1.0529673216774733, -0.7889199288607989, 1.0536904555005944, 0.35218168608420997, -0.32415456991731106, 0.6492260230858122, -0.08395154627824632, 0.8319748147045325, 1.3128601744996848, 1.3457307755003136, 1.1300202257471987, -0.05701179880404106, 1.4469185270296019, 0.19727343828878566, 1.2242561871536561, 0.32710153616840343, 0.2194184882924151, 1.161412652786375, -0.4833482284759659, -0.31865495710314495, 0.4632772652957778, 0.8076460787548048, -0.14892750594275433, 1.4114144872952754},
    {-0.8046593331420249, 1.6743544704356679, -0.4194234157204519, 1.68734113342938, 1.3605102655300003, 1.2727532477937542, -0.3108717700741869, 0.9597244505500777, 0.648316244293528, 0.6617076029175407, 0.22396682713840393, 0.21022245234843553, -0.8953541922477776, 0.42234453247317094, 0.795255828480022, -0.5433504659516388, 1.3509258131352544, 1.2486591401499185, 0.9407291491145771, -0.6760281656741378, 0.04505548134841369, 0.8762002618876353, 1.1417465990948812, 0.35195293567371605, 1.5811931475344454, 0.010894282605874972, -0.3687351736823662, 1.103353748852049, 0.7881549784681091, 0.4136112564300486, -0.019741139039232546, 1.7661927695139785},
    {-0.2818397132025836, 0.5121830089247218, 0.6362311875729552, 1.0904087347559521, 1.4176410847377157, 0.7987870022357312, 0.294056462361, 1.6015948611435058, 0.6151629225866044, -0.2641495201561487, -0.08375275807410895, 0.4180094774069531, 0.9108450679341671, 0.4694411227378608, 1.43078663700164, -0.6390640589114354, 1.3469571673612175, 1.250210478790045, 0.9581558800697518, -0.959414496023646, 0.6570365527180645, 1.1999707144834841, 0.21180262104011863, -0.15005013582128196, 0.2967873487969245, 0.5890268699391513, -0.6418926169774442, 0.4018019600473927, 1.1021685073319016, -0.43309894622293504, 1.399578180229236, 1.1792742471570468},
    {0.11495900639826398, 0.026679213920255025, -0.660348480046606, 1.2205606156662552, 0.5539496057095705, 0.6238123712824316, -0.22778405441550162, 0.8158109338691347, -0.41640652434706404, 0.3258275562295696, 1.2339629278891833, -0.2853413261070115, -0.6626928340323929, 0.4781893971127644, 1.005024967583479, -0.4426794883173541, 1.1025329823167502, 0.2641662510316191, -0.4973568764978445, -0.17398440244395677, 0.762413722930269, -0.0076248298919449654, 1.0064461883916722, -0.19609668253230841, 1.299926600854878, 0.7795433863588508, 0.8095767228515854, 0.03942237152152486, 1.257776520813092, 0.5388258705035139, 0.9114112494684669, 0.5147329816309516},
    {-0.9798794669281086, 1.399535443837317, -0.1272789620021762, 1.1637412002418315, 0.2209451002399113, 0.7318445428044589, 0.09345071263281406, -0.07728389742777915, 0.4996138879722388, 0.6699099963662748, 1.581193272475548, 1.3528179442786565, -0.5357558091643599, 0.9191270412773772, 1.5364276179801633, 0.5144943815463104, 0.13723066034689427, 1.5634656620418694, 0.7312168363408476, -0.5852291135881433, 0.9046351135744509, 1.5721067229616332, 0.5461009891202108, 0.27671065212440554, -0.17882134192713445, -0.10453237516340703, 0.27961662673986976, 0.8792918961456451, 0.0598380723411564, 0.6769644210834604, 1.6400452951164495, 0.8141327773055301},
    {-0.8185798611496848, 0.6838742158503041, 0.10295338708353362, 0.2613984523795464, 1.737901468988733, 0.955616019707856, -0.8324473292315835, 1.693237947037865, -1.0936125647042083, -0.12931467870560678, 1.5073612194742882, 1.3074120809855052, -0.34477613943222984, 0.036346411022710474, 1.3289840135642839, 0.3329327867256061, 1.513745809581887, -0.11619112185102792, 1.3047453889714467, 0.025311582697630116, 0.583407155576815, 1.482509579655858, 0.01610226114106923, 0.03852171538620031, 0.2144879975875573, 0.8298400837348352, 1.3260862365754322, 0.04760568276365937, 1.050123906855093, -0.3264228766864332, 0.8751656435616582, 1.1197181002722651},
    {0.15944598711052752, -0.19554543795031112, -0.682040249869856, 0.08496482739035661, 0.1409028860803146, 1.3064322391352245, 0.07097559033485112, 1.1707565918691316, -0.9391976600398554, 0.1527991262791311, -0.36296007682143216, 0.34167965824276536, 0.5682342804996401, 1.4989381106243298, 0.5830953540090713, 0.09159171400897928, 1.4132221693806697, 1.485782531887836, 1.0063085931693097, -0.17762592083985732, 0.548607465650657, 1.5772701731385925, 0.19557220361639424, 1.6403271908220498, -0.05773371019608685, 1.5386509005239106, -0.3383874454222543, 0.8116430658189295, -0.21743986805321788, 0.881057709127297, -0.16851306387390613, 0.5705822706787705},
    {0.2507023224202685, 0.3495429171195748, 0.7243640459638481, 0.9540914450104743, 1.310152269699223, -0.15699712824898043, -0.25199561727957215, 0.08228857113335612, -0.04643624902534972, -0.7333128809539323, -0.0650167737803257, 0.6585052775297884, 0.5825664966528914, 1.2999243385948962, 0.12499071231230871, 0.25491773430004744, 0.009960897570960931, -0.019961357700146745, 0.20968209292578757, -0.6281445501018121, 1.5057956546030669, 0.18673143610415266, 0.7377916085036155, 1.2136940627289035, 0.2014149157422296, 1.3063174938375246, 0.05319463961162383, -0.21938565149727224, 0.8863184774974218, 0.0573364084424909, -0.18562334424387872, 1.3479640350780013},
    {-0.1465160008736824, 1.0972728418818853, 0.3284728931987977, 0.6273890005816899, 1.635656417751442, 0.9897892380609818, -0.3459651195577819, 0.21602976138291216, 0.8458793388547396, -0.7090321221020617, 1.2435480503526972, 0.16695978620535995, -0.05436015754735555, 0.3992405627700207, 1.0047573397493796, 0.2785550158089233, 0.5490423268528781, 1.0823521614691431, 0.3380855660539112, -0.8030629859053326, 1.4127264742687342, 0.842179723224033, 0.3998624999380509, 0.5445788012283367, 0.6743824762607743, 0.3195329276592347, -0.38021300306492667, 0.9973300336870279, 0.3635224896985696, 0.7544068113463335, 0.8819159644464096, -0.30894190709718033},
    {0.3506316272686694, 0.008571207067604196, -0.973380554730893, 0.24905734593252762, 1.3558949897687915, -0.08611440353734248, -0.40655180661038914, 0.026221090178695818, -0.8000330632086471, -0.20549512250976132, 1.3703336827195796, 0.020255625101460704, -0.16032641711168955, 0.2605422755656103, 0.20675567351194413, 0.5822411737960385, 1.0728775415409009, 0.801726170345275, 0.6291887910707404, 0.18640726675840902, 1.0544946844002026, 1.5331086006691266, 0.2501526252022936, 1.2305129860828516, -0.2659035977854055, 1.5907658964036948, 0.527876939384929, 0.5507532359185643, 1.3042626160950306, 1.0787583346937522, 0.30040864435018744, 1.3672947503698996},
    {-0.8537444733080506, 0.6755754548266512, -0.24493994413133624, 1.1654746643784617, 1.4966095257026466, 0.6429513569198475, -0.5968815273373232, 0.6187112650297092, -0.4369834688566303, -0.7781959803813756, 0.5958622424847625, -0.09223677723880953, -0.9097662038363108, 0.4208454285571179, 1.853888236339277, 0.6265624976276088, 0.48985179828060554, 1.490241309604965, 1.5129137463042885, -0.48310986895471686, 1.386376177223586, 1.2723045303861356, 1.0631643088209666, -0.05979763110675048, 0.07584778102592905, 0.46393435009017253, 0.048304528244440474, 0.5400346051195872, 1.3540074683254233, -0.30690546257358897, 0.4933517331159305, 0.9744726937748148}
};

static const float b2[32] = {-0.15849072557518107, 1.0356696647338435, -0.231073258984719, 0.9742920338393541, 1.0432921030764015, 0.5905879660569116, -0.04091057185291686, 0.971368808806109, -0.20625492354588176, -0.18117864649035476, 0.8163496671258778, 0.8285900583313341, -0.14625962897627798, 0.8182690595784212, 1.0794084225971332, -0.04748581440777789, 0.6437312891623878, 1.0282559366027686, 0.7309176493697338, -0.04167808315737897, 0.6990785664857708, 0.8244674271898964, 0.9246444898477018, 0.9878640504171319, 0.7592824073645874, 0.934098510615473, 0.35075333060671265, 0.3045400011852462, 0.711739868352965, 0.7475112638054062, 0.8738445996980337, 1.0757002879751842};

static const float w3[32][16] = {
    {-0.34341408053508204, -0.7095089068222641, -0.13517487130970537, 0.4514558079345151, 0.1714138162052796, 0.8165975857382632, 0.23201818125434115, -0.058526433331034994, -0.595290243316584, 0.9570338130489714, -0.3800029913567629, -0.3317236205317867, 0.18385720266324357, -0.7927896085277745, -0.07754927944935545, 0.8211756704158746},
    {-0.9308931349510462, 1.6824137367984904, -0.5091519735992431, 0.21588517837147608, 1.8702130026028365, 1.3897368986890686, 1.7998727480730043, 1.909103730538135, 0.6882129100077897, 0.7255815481154696, 0.2950409956330008, -0.044922591922015816, 0.513268606727212, 1.9468692627928081, 0.5662392505951314, -0.7193934926389548},
    {0.7702437636808741, -0.35415543844193226, -0.9417577191036262, 0.20466166779266134, -0.7764688945139745, -0.7863420073256442, -0.5947577640426391, -0.7518886028060654, -0.8201279764996061, 0.9421303423461929, 0.1922230558172155, -0.5256917779143704, -0.18554406140435117, -0.2240485544510834, -0.035016643636634134, 0.12678716014073982},
    {-0.6781529556542225, 1.5142771177145598, -0.44195093669252417, 1.7258096075009213, 1.1921402939112336, 0.7028134748672508, 0.0803932493490899, 1.3070248061184675, 1.4701482240032577, 0.9187199134622634, -0.5308484052480998, 0.9085970111566817, 0.25708240369770063, 1.8555537395714103, 0.8956651090072021, -0.8568095251270865},
    {-0.5371917677761098, 1.1220575792043492, 0.5228889477892102, 1.8834554485987425, 1.8089222031338485, 1.2087106200167976, 1.3565770371416825, 1.7214527897460643, 1.3268110020648243, -0.9204976632190561, -0.7691680002639822, 0.6683844795132888, 0.8674386577022727, 1.1215497104280443, 1.8746224144138621, 0.5981440068065358},
    {-0.6210580799423965, 1.4975450134453197, 0.35377031534922837, 1.4683961320672376, 1.448610481667815, 0.004488655369464728, -0.06879541936209342, 0.3651260751528574, -0.037184655079818676, 0.08330721367849193, -0.6210237807657438, 0.3035238171236742, 0.6406538499931191, 1.1029100195647576, 0.7772730164436729, 0.4304269132461379},
    {0.06894453941045033, 0.25325383599000834, 0.5845009608625371, 0.5028211276173301, 0.4486346550339493, -0.7656042670927489, 1.063090842115156, -0.3005987093829101, -0.5331610933934151, -0.6869554429753055, -1.0149686092578323, 0.8753184595287238, 0.6107414602995103, 0.8796887656516237, -0.4373697447684696, 0.8466458824004452},
    {0.3722523126765204, 1.5737539546196493, -0.7294700642005113, 0.2649434085709268, 0.9147457987907811, 0.7679118741583972, 0.9706947890057485, 1.7624237025504181, -0.12260003667459257, -0.8293890419941311, 0.9722567280066148, 1.3750348040251918, 1.4874950840992605, 0.7352361454281204, 1.675940916186713, 0.16904309649848295},
    {0.11318197990673969, 0.07501228955516165, -0.06535728044749985, -0.13785155607656607, -0.7138131009001529, 0.04175148115906168, 0.5271682857133607, -0.3601288230943285, -0.2487293915986534, 0.06746108746250246, 0.7852574657789871, 0.3356754637636697, -0.855862358620992, -0.41089915132641547, -0.12314284564558076, 0.7355359989797814},
    {0.7087673415200447, -0.21428961662165377, -0.9021497104844813, -0.09087601579627955, 0.012146395397256067, -0.8617144003209484, -0.10546495009356394, 0.6028495664364959, 0.09831414358946604, -0.8643831089727979, -0.5206602122005757, 0.6107643741525391, -0.2757504694663872, 0.4731815326348807, -0.5251697514302558, 0.7175889174615704},
    {-0.6933496230623715, 0.7499540272480605, 0.13225638577670887, 1.2988082960942344, 1.2783616500327437, 0.442277458661909, 0.5823969712581948, 0.24673284871525428, -0.10621374857033287, -0.8598295654008012, -0.5952207474033424, 0.8654252699203319, 0.7844717899587214, 0.11785657291125076, 1.700397694479088, 0.38724097375090133},
    {-0.5851136940145406, 0.525412824352469, -0.4262205829274723, 0.10406289452474862, 0.5646811140946987, 1.3592404831496885, 1.433215035270589, 2.087277061503254, 1.4841117324633755, 0.23150528749777324, 0.5573815638964547, 1.3667357429741938, 1.413965424622726, 0.8287939090813554, 0.726880558467597, -1.0651930572261419},
    {-0.05080089161112965, -0.7134475729995415, -0.12672773452043268, 0.12391403247238895, 0.7334709412216457, -0.39331481157003295, 0.0013290017475508188, -0.4732753060332456, 0.7706082642443591, -0.9974997729013272, 0.48466325733513066, 0.6370924394348262, -0.20471814376168904, -0.3703149387975873, -0.33308451028204, -0.3092747930764357},
    {-0.2873823959304506, 0.7538711927131531, 0.7195878550425265, 1.651920691886868, 1.9195875536891431, 1.334672544620653, 1.1313654012760117, 0.20192521181095704, 0.06698688759135, 0.10237602107675356, -0.6143349885741253, 0.3881252966577798, -0.09876311258337432, 0.5699939305615285, 0.46735457211253645, -0.5688106648306098},
    {-0.37589928850592097, 0.9754902516868625, -0.3294089585938644, 1.8918949766759472, 1.5961312824283793, 0.6272550684033782, 0.8243450971030188, 0.20262531792420277, 1.5147795587145414, 0.5758235936982918, -1.0395284232909519, 0.5644653559431608, 1.0237291577073915, 0.8388058266912606, 1.809012655705526, -0.5831576183810899},
    {0.7651000894690122, 0.21459438461284056, -0.08399620406627702, 0.13609365709009166, 0.3153501357603702, 1.0953248101148767, -0.4962263652843125, 0.1174494487094989, -0.09591969517215071, 0.6193014366948753, 0.600002966062066, 1.0341342138686558, 0.8933535023684712, 0.8556614775176656, -0.4767776449853636, 0.5055891772531153},
    {-0.8070301050924596, 1.5520024541601576, 0.19792109491344903, 0.040630527305765045, 0.27582735672428915, 0.42007515317960636, 1.3973203277595778, 0.7835340494770171, 0.8030542532557617, 0.9323847149467592, -0.25160555305151433, 1.3710887035677393, 1.0994165318931273, 1.0824181959245096, 0.4344368682998847, -0.2735723494025663},
    {-0.17207218334082441, 0.5064818150779022, -0.09342859928391326, 1.6207410550050971, 1.298034502904068, 1.529327686953017, 1.0092461578709073, 1.1767225835651987, 0.42295568814690276, 0.657452128393035, -0.8386151888415603, -0.2907246951079923, 0.30482332311104504, 1.483649219218478, 1.8131381842789351, -0.7526927742643228},
    {0.15770372262001317, 1.3212995358367268, 0.9928157996911634, 0.7130844440856661, 0.1740598035399742, 0.9972313225496149, 1.133487780637921, 0.8185558099991256, 1.0517867794556812, -0.7020386069818263, 0.059171059578667015, 1.4460479398163968, 1.025206272849358, 1.3162058863144945, 1.5517694859774627, 0.37663621361674426},
    {0.5967149659734016, 0.8317738091924111, -0.5567050130906469, -0.5402011668863609, -0.6797070072987037, 1.0384318511389565, 0.8467662081144238, -0.7657839303114359, 0.557080659647528, 0.7287753292472843, 0.7225289217874287, -0.22209447119702636, 0.5718586915152143, 0.0760522444558411, 0.47167452256702186, -0.9608693375527789},
    {0.7131984263986423, 1.3966090329863718, -0.4845645306050932, 0.6835399356470919, 0.5873863277227184, 0.20907529652104456, 1.048118249473382, 0.5020328867705326, 1.340669346123665, -0.08758133747962957, -0.14584573586803415, 1.2078769831338587, 0.047829925481912276, 0.644011783467325, 1.5446418501824364, -0.6975810243387635},
    {0.38298139589683744, 0.25220595671368357, -0.21668296355609326, 1.1325580665306896, 0.4528199345338417, 1.09712595770791, 1.2318048793746306, 1.60873134363383, 0.7486386644601657, -0.4146553325063993, -0.3669974560982513, 0.3964708262260369, 1.437719413310303, 0.6759123742682838, 0.4299162262763543, -1.0567602245410614},
    {0.8909100467213846, 0.8088413384851884, -0.008053739741019583, 0.3009278284146941, 1.1564182809817418, 1.103164001033012, 0.7865809110808286, 0.5237961443398982, 1.2788685628444338, 0.028844432242841743, 0.19363104094866884, 0.8501847198102302, 1.8002848563635991, 1.5546302491321498, 1.2585275147865573, -0.22187001210825374},
    {0.7143465985573187, 1.4701039246328096, 0.0705473211108356, 0.687206049577808, 1.6926868556986971, 0.7694835486259965, 1.5934087996627104, 0.5952715978253644, 0.14476503702453072, 0.35342433266947226, -0.23510370781265497, 0.06285919345116406, 0.3620669413017854, 0.13813413419138887, 1.5683151908092448, 0.26316349322385435},
    {-0.7716744995043168, 0.9885371661391039, -0.6556396289053985, 1.0683326474307013, 0.8053438491733533, 0.3460372770400828, 0.6802547837697743, 1.531430027182754, 1.5766926256457594, 0.3858946635920893, -0.20554919469173588, 0.5052414789580612, 0.7475463319122178, 1.1265087415825854, 0.6076825525985744, 0.8011525659641094},
    {-0.5378390394332713, 0.7850159902389189, -0.9327669697211318, 0.16075423142184547, 1.7976156401093868, 0.8222516437534, 1.0421659350385468, 0.7498661746824182, 0.7233278000347514, -0.6920913110127898, 0.7107725755775111, -0.060332490297280265, 1.8197364971337702, 0.0641440075489599, 1.7911206570872087, 0.64283250386022},
    {-0.6883701530569478, 0.2847000393962074, 0.47530897716896775, 1.478436256903643, 0.0916998255709448, 0.45350099018427575, 1.4216513897827832, 0.17632251559136916, -0.2184358101452246, -0.3771796823121715, 0.6480150430462136, 0.2596330253188518, 0.7333991099477013, 0.4225192936942835, 1.13322859468927, 0.8157906945381088},
    {-0.16252191043997075, 0.06928760606639024, -0.9683214552029247, 0.5034931408807543, 1.425817830837878, 1.1189480412583164, 0.005141237559103397, -0.05524434141542857, 0.23299705582959848, 0.0280895775846072, 0.20666736473277306, 0.9561699679221853, 0.08871295053102628, 0.8965803042059012, 0.21257717526536915, 0.2790588080878615},
    {-0.9605202124650021, 0.3640301608693422, 1.0121663691474652, 1.5197496310778569, 1.3471757272369467, 0.25628969214282, -0.08129378318849442, 1.3967880800294237, 0.7515290844798598, 0.7632671057976569, 0.17595457062107825, 0.9795553677374774, 0.42688519357232607, 0.634086026826404, 1.0853524225101185, 0.6647549860463905},
    {-0.9740233725075054, 0.27833174506822306, -0.6147367009488446, 0.7094178701540462, 0.9005890171677671, 0.39921834921477806, 1.2041940175918664, 1.191289604845963, 0.7572991917033117, -0.40558087219014444, -0.6167630452889307, 0.4879896429446454, 0.016944614853863546, 1.2270702022116855, 1.706557671786888, -0.2685783956651528},
    {-0.19692286278987528, 1.0722139918634819, 0.8558873722200879, 0.2595303989499878, 1.5632016103497384, 1.3362692459684642, 1.5950343385431918, 1.2333150257546113, 0.8631205239572759, -0.04064960073507545, 0.705981172656831, 0.23607443632896738, 0.6341248000312012, 0.3800024703108336, 0.6087558881637373, -0.2182377196779899},
    {0.5242068848676059, 0.634556719061212, 0.24991231554531043, 0.6259161146411091, 0.9917819333921126, 1.3406999162407398, 1.3582140380959988, 2.0035675184725092, -0.026582933569786533, -0.954808810579404, -0.3197748082660655, 0.3756164898673013, 1.340450875862605, 0.4949042551514772, 1.6443784775373547, -0.45323777412797955}
};

static const float b3[16] = {-0.09360148077158054, 0.6797544240150712, -0.020765370150695166, 0.6160825294994716, 0.7692282752839523, 0.5673115948412959, 0.5606808928211909, 0.8601624051659299, 0.37259979485413836, -0.05824421447658833, -0.09296832215170252, 0.2643011493778148, 0.5376840035077844, 0.7272088195626037, 0.6168796470079693, -0.17283439457694513};

static const float w4[16][12] = {
    {-0.9951371335550644, 0.17315364553463686, -0.7833180384814562, 0.6504209696583222, 0.8031537803576966, -0.7940388251682187, -0.8450896998831919, -0.21914972157646875, -0.16559791475864996, -0.17442150722169358, 0.8107760144021031, 0.7338809696278347},
    {-1.3129622118260638, -0.8948439131816516, -1.3121167341331028, -1.585488050032653, -0.8879278997774859, 0.3714791000308117, -1.2624344327017671, -0.8106774597426937, -0.3697169298046929, -1.2770116547864994, -0.04054255804958817, -0.2796601333457497},
    {0.37119867202562834, 0.31233285915075387, -0.2617640160290532, -1.0328137414923741, 0.7378469338306296, 0.7627475079477629, 0.09575398121350327, -0.9405868588533984, -0.7464845051165709, 0.7410110524153212, -0.926922562792057, -0.1515189216226001},
    {-1.252645530071635, -0.4371599604655246, 0.059306870158822585, -1.5602133581069635, -0.016218742533701713, -0.8808208920286695, -1.0393395511512868, -0.5355574033292232, -0.8145104475692855, -0.9981189323668096, -1.1245024246964455, -1.3698128350178118},
    {-0.5059332557228104, -0.6252146291802995, -0.43729500198446125, -1.4727202725734674, -1.3062996528671964, -1.5196020937935188, -1.4499972173922733, -1.674710463442718, -1.2395687342443593, -0.8527594816828096, -1.5346478544172408, 0.16430164139089465},
    {-1.271605070085722, -1.5065896748007792, -1.697696864258869, -1.5420169912105364, -0.5095189013293914, -0.152147667944649, 0.0008868861456977461, -0.7962370125738866, -0.06388628450642324, -0.2829674767248554, -0.9745990672776024, -0.6080387593264204},
    {0.08228126493047065, -1.454791514108866, -0.17133157716451863, -0.30405882700759473, -1.0867756109306372, -1.5437793231758943, -0.7583999372953407, -0.027382206063926842, -1.5325929892244952, -0.5573687640894404, -0.6300731368371166, -1.4590981709499713},
    {-0.9277286777703428, -1.4208691399526938, -1.244819976847441, -0.9820573578360353, -1.158925320814976, -1.384897361689284, -1.4303745129967946, -1.3465431788345859, -1.7385217530779868, -1.1087921272828687, -0.05738672937368307, -0.16886858386139353},
    {-1.4710097835210258, -0.8423946607609163, -1.36612585220473, 0.17440500999214908, -0.7816472868165703, -0.7171176501011288, -0.356685802217564, -0.5614019024884709, -0.8049125755531007, -0.2265131826256003, 0.05884630598936087, -0.8226640013262639},
    {-0.48223614187891384, -0.14265399886937127, 0.2637313544304721, 0.45458631166642705, -0.036488544055480764, -0.9448287048927491, -0.46961033343751113, 0.3846044745959031, -0.9819480166180021, 0.8497872113665996, 0.7725841258577001, 0.8030926708794766},
    {-0.5974540320480061, -0.4474587000563797, 0.6137058491574023, 0.9293929685573742, -0.028001370547556626, -0.4613092515113079, 0.3369999711503235, 0.6228916600266785, -0.5260171163629929, 0.6478674623685864, -0.4806165191453755, 0.4995672492259742},
    {-0.4026793234802509, -1.175367278209044, -0.04679520454631306, -0.7608588287361142, -0.4941911416086622, -0.33252620052679005, 0.23010891698252695, -0.22884796696264945, -0.5018240698065622, -0.2623579309361418, -1.4103581881643747, -0.5324698141596503},
    {0.029895848818253773, -0.6560664879636867, -1.1929453006267652, -0.9422976815519024, 0.07284377181226805, -0.8310976906818909, -0.22202649856783024, -0.517728348570978, -1.5957874260094318, -1.0625355197054995, -0.043332957125068294, -1.3313527516203916},
    {-1.4997548485468544, -0.9349990038797387, -0.3649491251922827, -0.09523505494325, -0.9399026122984033, -0.11339761507863062, -0.5325578999526523, -0.9374860406441401, -0.6548977671509063, -0.544920342889835, -1.7261983071677003, -1.2198254531342991},
    {-0.870896145378723, 0.2602051162007431, -1.3834318746343408, -0.06649150305375853, -1.59997904111807, -1.4864227085338226, -1.428346117586909, -1.2320621214295286, 0.10139054397371598, -1.55919535856986, -1.5697099145710842, -1.5270799553742425},
    {0.1904110041957356, 0.552713222947147, 0.44388890691803695, 0.3232212463250333, 0.5994758294468879, 0.4087490482708054, -0.7427671215723735, -0.6172256828795715, 0.6032231351801, -0.44198223013513765, -0.7935539467402981, 0.4326290352018733}
};

static const float b4[12] = {-0.3333455822092501, -0.2903351343767319, -0.393261437664674, -0.3827575687304156, -0.40661765789530235, -0.4042154380264739, -0.3340111070862129, -0.46046114070830774, -0.41269749994879074, -0.39444901441485086, -0.43495000121390964, -0.4061291956848317};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
