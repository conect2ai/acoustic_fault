#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {1.2141114143908238, -0.5166361757218471, -0.6443366240573306, 1.2810791929713436, 1.067694107786272, 1.2181940143023573, -1.751794401257316, 1.4112206424966205, 0.9535799701671845, 1.3033041326512853, 0.8248104053311569, 0.02690680762331109, 1.2533090472887465, 2.035817237466335, 0.5293839081249981, 1.3561191348022572},
    {-0.7714933374151765, -0.1823080140822009, -0.8648684810847963, -0.899896918479039, -0.702146229444001, -1.104073154302046, 1.129175850563198, -0.5099811004293031, -1.8618894534838486, -1.245893353291865, 0.44292594551745434, -0.2851523917915971, 0.4100864356452125, 0.18301787187582547, -0.21799092824602234, -0.4476233783951204},
    {-0.8483255572615314, -1.0905062106118824, 0.32850522008859584, -0.5287691638982451, -1.2777044101908366, -1.259370248640673, 0.8540788191080871, -1.2938461545597153, -0.32163256931135403, -0.02322024627970372, 0.030165833371747268, 0.8396532854154513, 0.2625678707701768, 0.1258460520426528, -0.677633728098674, -0.40384872995590204},
    {-0.6514561234799107, -1.234908818607996, -0.5054079000605063, -0.702150987331889, -1.1418099431128863, -0.21440198310158717, -0.6716956175081902, -1.196945140351147, 0.8923829473508542, 1.397177114830439, 0.9257512576224017, -0.7602627514313586, 0.628808357470165, 0.03863073733784569, 0.1384714643057359, -0.41439949835727047},
    {-0.6356767954555186, -0.5154962037480599, 0.6616022243783035, -0.5716725649631432, -1.5642161989612877, 0.421713265874591, 0.047498042784689214, -1.0981842429776612, 0.15842239505456177, -0.054367626369159, -1.1473547348382196, 0.6908457490029857, 0.3894782998266292, -0.6511355126765371, -1.1538841724969784, 0.18506957845482402},
    {-0.8587906544718814, 1.0510855867751345, -0.7285902506290186, 0.44129628960556105, -0.6410320517490732, 0.3685802226398625, 0.6486153235078151, 0.2825419290380172, 0.4436589306818878, 0.7215744731512818, 0.4441958756649691, 1.0197539148536294, -0.021468451732287376, 0.45337461045984956, -0.30560513826811075, 1.153203197051532},
    {-0.929636283984054, 0.644684038053836, 0.4126822100110991, -0.08055252239849375, -0.559015720522887, -0.18529499543658226, 0.34156152080693863, -0.28247788676723545, 0.5556453592100525, 1.4572659029190895, 0.8098778481817331, -0.22668044750701155, 0.11118785067182362, -0.1473150365417035, -0.7985771745603955, 1.5927272633186016},
    {-0.13505651509918845, -0.5754974283870637, -0.7702001756572221, -0.7460665167253531, -1.4376010438341043, -0.07902697414141123, -0.13724749012180762, -0.65262569523263, -0.8060470607986175, -0.050517487366442085, -0.22561534568761887, 0.6341548926088838, 0.5409606152366241, -0.49533491679338054, -1.1189275245210681, 0.11782029062194734},
    {0.6876444315067627, -0.8260064722926391, -0.3175851000822051, -1.2995552652495745, -0.753771321724518, -0.599035588273317, 0.5292935488416823, -0.6394294017191862, -0.3681683217858218, 1.3248329531790664, 0.8404806421707811, -0.38154985147102166, 0.6695656166120962, 0.09414686133846195, -1.1204393277290254, -0.16832499292418682},
    {0.45406239631693035, 1.5633051207493562, -0.2815855377496479, -0.049766157516762034, -0.22578437205520382, 0.1260714985466261, 1.086332219691635, 0.08542961411236226, -1.5336239909378986, -0.12631202989418866, 0.5244235996387113, -1.217758187904777, -0.44921786947867287, 0.46512537901479567, 0.442844290922757, -0.5608987658736027},
    {-0.6467689859770601, 1.2217668945920621, 0.7040744779766198, -0.41991697626112956, -0.33041334375736536, 0.551408174952576, -0.3359912779678473, -0.38723770210220937, -0.1333563855082727, -0.3127857297819521, -0.24921669892975776, -0.10696196662081765, -0.2734257862142949, -0.2295693734663163, -0.09647732196634932, -0.08544371799555313},
    {-0.6354658884573413, -1.3241909167678771, 0.19590096841758162, -0.5488390284962112, -0.15815057761395035, -0.5961377147367914, 0.3419614147992877, -0.5262357963977912, -0.6507403586742833, 0.26981253512999537, -0.5033418130385191, -1.151755023906736, -0.027945163159490423, 0.9598037841772371, -0.18974274695624838, -0.3453162805925734},
    {0.4113278967219583, 0.42834342321414265, 0.8682636346737882, -0.12881568063611198, 0.7305562121947599, -1.1542861987352615, 1.0011557508911537, 0.26336377432452523, -0.8050135669846707, -0.8673334382113985, 0.6096666291603893, 0.28951735551478436, -0.937299232430001, -0.43890054360190506, -0.7582988000680433, 0.4781982768235902},
    {-1.2798076423627383, 0.5067325323450574, -0.755188587775019, -0.8831016544161207, 0.02731603588813543, 0.6661965995962468, 0.45670004847384166, 0.36772939407214184, -0.04390052266424015, 0.5102467155710462, 1.0943915331333904, -0.5454873826618329, -0.21865822920100125, 0.9521719390732974, 0.458231966010807, -0.09217178169906232},
    {-0.6468139690999263, -0.666572994268885, -0.9073479366456015, 0.20799393341526579, 1.3329649573595428, 0.4502183705561209, -0.6243463544338423, 1.1313808925090834, 1.1446872901633451, 1.3112547261668273, 1.0332533746456303, 1.127603088790119, -1.0402916909180044, -0.009187390224458967, 0.6510146712629249, 1.205285528731647},
    {0.07216492345343059, 0.34160072561245275, -0.7750955059149546, 0.2593287662231888, 1.4664218736855616, -0.7048487505144853, 0.659164064329151, 1.4981286886978211, -0.29096971326929477, 0.25493449760076903, 1.207103863404653, 0.5058908343552729, -1.5262720163448422, -0.39475165038817406, 0.16002453689006937, 0.2319134576095528},
    {-1.5139268536433461, 0.49090652633365206, -1.1428550202335626, -0.44807092782795066, -0.29391624807575834, 0.7618075925142171, -0.3431365384816032, 0.3640609904496861, -0.1050622117139172, 0.872106539811154, 1.1223359470298062, 0.20006204426955806, 0.010559614146386285, -0.1582705506827369, 0.5361347126742398, 0.28479677452722113},
    {-0.8552557510689179, 0.4073587247695009, -0.5955451799780777, -0.15120276487192585, 0.2761678120503626, 0.1120348745645496, -0.09602364243067292, 0.5337003750257518, -0.33075727539196614, 0.49645480528185626, 0.4315003125047451, -0.31327620214398216, -0.23065326238892075, 0.4900289325793504, 0.36778201954706286, 0.025504168954818093},
    {-0.446944137066845, -0.8369525343514211, -0.2794232666238836, -1.023689893199664, -0.31016899070888004, -0.5826745795806821, -0.5232768919727896, -0.13485742305589654, -0.44097803139279335, -0.11103312552698899, 0.09060518186583154, 0.27694428621547956, 0.3165178316104982, -0.7737963918834924, -0.4599317208037916, -0.2584566339322102},
    {-0.0642398945005974, 0.3942266500430604, 0.012727568306312846, -0.1095569847192929, -0.414166246181852, 0.846579346519206, -0.5155473973816411, 0.5510676599682914, 0.14703635455629277, 0.07556768867707671, 0.2863190480967883, 0.023190097568970877, 0.23454414631896695, 0.6970737741803689, 1.0664628698966603, -0.3883452264101981},
    {-0.7510922276261113, -0.4537111223678696, -0.9483563112237877, -1.0666531472737415, -0.31632474780873643, 0.1369345616484841, -0.699418171737191, -0.1057404070642303, 0.5209566196398028, 0.17744315224489796, 0.017122095548078302, 0.32362944415125483, -0.16694567423616472, -0.3011032977245275, 0.12489806480258674, -0.2641155164715206},
    {-0.025680822800383266, 0.6771779947233649, -0.40388736928562685, -0.5547410877956503, -0.13635146716728985, 1.1911368679768064, -0.4592675780757529, 0.5185441567730472, 0.669339907678409, 0.376399170169668, -0.04478921895944201, -0.6743822515548313, -0.9171829780591392, -0.44868314374692503, 0.926320032462511, 0.15062980284953975},
    {-0.0964451886004572, 0.010789857911011391, -0.6756091381309811, 0.06455251141217966, 0.33833120817643664, -0.058634175077004684, 0.2178512275256488, 0.6608116690931115, 0.539273921798077, -0.17724360905948178, -0.21381724159635337, 0.8510150102156414, -0.4632280494326787, 0.05248179355542193, 0.8406485123749295, -0.48948996075292245},
    {0.08379697817380694, 0.09002142257512412, 0.17143128272973832, -0.8951289287923858, -0.8130046950117493, 0.636379006496484, 0.2852832867757333, -0.39977023204515777, -0.3395244065530442, -0.46286063602433125, -0.8167048242912885, 0.13501230980078824, -0.4508413286948138, -0.6729735216611609, 0.9655584788902185, -0.8292219342474845},
    {-0.5187737403825188, 0.13897357378618172, 0.11305668990733653, -0.5095695831275, -1.1684655999887785, 0.3076533194752108, -0.5578107386392529, -0.3918048555091876, 0.014010047421459478, -0.17210263832536618, -0.6989284274187412, -0.16195805925173093, 0.5167773170050135, 0.4600028439665172, 0.4815851364022671, 0.19484057141942507},
    {-0.11714599274859527, -0.6425043886932414, 0.09021828074866758, -0.4735323050668617, -1.3679364716929747, -0.3677123506736575, -0.7232508089882684, -1.1089892572235258, -0.15725274755755336, -0.8797671226672202, -0.42726456928554346, -0.4363341027323994, 0.8395611577721723, 0.17025821276941777, 0.7792489829821105, -0.9245185751354678},
    {0.10118308684140774, 0.7234077392047102, 0.09254214823894556, -0.44046634578710836, 0.31695091933373876, 0.4361319612803545, -0.8527047721221369, -0.3193229881870115, -0.1997322536938866, -0.42386028043586366, -0.8802805468824191, -1.3912333673314068, -1.0896215707926964, -0.7365931475454508, 1.2258902761105221, -1.0461150649735687},
    {-0.12666863426339559, -0.516448090832803, 1.4414614580836678, -0.38875616604674873, -0.9136470475311897, -0.66898351551935, 0.3834720144278836, -0.9542758458457934, -0.25696995811240464, -0.6630334027013121, -0.7698549269344435, 0.3715616947351116, -0.36467937613437934, -1.0133798597411623, 0.30203806837398733, -0.18932314636855713},
    {-0.8956409176670669, 0.2684821012858449, -0.5402475895749378, -0.5073871132762532, -0.7135143075629309, 0.7367626920790955, -0.5360199310828665, -0.6416852405667707, 0.17467150740214596, -0.4050304944939212, -0.2777422872661273, -0.9455563102574538, -0.5039609386928634, 0.6834290241387293, 1.2819628655901427, -0.7518349821216391},
    {-1.6643779342584553, -0.5969662278575251, 0.3159916501921704, -1.2006532901247038, -1.2522298937125844, 0.0020301273079944082, -0.7227058872942527, -1.149809816658548, -0.045979806664526536, -0.3624399130419132, -0.8667843568560117, -0.0613712374321452, -0.881397674774957, -0.6505204322640397, -0.3973645922268186, -0.0929793044921686},
    {1.1401953121521637, 0.7843190024080461, -0.8390055095368578, 1.571038807396299, 1.3079115183513572, 0.46362018361648355, -1.3433158872385877, 1.5182221441013302, 0.8576488043820807, 0.042470301551832124, 0.6147643630383819, 0.8253477080092964, 1.209301563195543, 1.099451289883276, 1.3743098547330204, 1.5220578476348605},
    {1.15258181243155, 0.39809409818899955, -0.05999311307156449, 1.2560283266159484, 0.29205469391495587, 0.2518567907461484, -0.4334168199273994, 1.0420688900859478, 0.659190934828667, -0.47439318698285365, 1.262518806639023, 0.4306881757064194, 1.0205640109900638, 1.1619408088413203, 1.378289884502051, 1.2728124779095793},
    {1.0415370043195664, 0.6200461017015243, 0.18418565583587623, 1.2339056822538308, 0.5366471671523495, 0.42691761143719964, -0.31320770318138, 1.7107047530792778, 0.8434453631273144, 0.0722168017462465, 0.6863740474898677, 0.5045188824399139, 0.584957846122457, 1.002225075848861, 1.211940371918786, 0.633217878445381},
    {1.2736859963632214, 0.685494876381787, -0.2227038192840923, 1.2354665996207423, 0.6432832650411391, 0.10567992969390182, 0.0023980677228627205, 1.7906201603045095, 0.4832374965599347, -0.3481182205337412, 0.9454858937414518, 0.5327360616728913, 0.6359092091720381, 1.0105814928333867, 1.0676806828235585, 0.835878813107201},
    {0.9251899841157833, 1.0242506751332918, 0.07759342237135992, 1.5783491703149444, 0.49734972206085676, 0.43914421857072794, 0.07168279880757111, 1.6778248540767375, 0.7106620634944697, -0.030202818661162856, 0.8526202862713451, 0.7170689859140984, 0.8006416767594744, 0.6408660102302904, 1.278603275930613, 0.5465463899890718},
    {0.7862516637015531, 0.5569673093285264, 0.15996184304283606, 1.0847697232560891, 0.708365026826336, 0.3394135180840171, -0.18013006860645905, 1.3503585384899817, 0.5000904527796011, 0.11228905148341847, 0.5989077507958178, 0.2623711880849256, 0.38714309505441935, 1.1632193334458798, 0.9547912072115129, 0.3363409204536834},
    {0.2763879810945872, 0.34997536379615596, 0.13736415150966233, 0.7879485921602297, 0.6330868895175958, 0.14175255579798338, 0.02780790983106357, 0.883194802406865, 0.38393893527639406, 0.08919686233420886, 0.2918057074175516, 0.0143349705442327, 0.4210505897590766, 0.33792932627074757, 0.9475603769445888, 0.44356852321942447},
    {-0.21695196033884578, -0.03945420597691876, 0.5466583876093501, 0.24934990153547623, 0.24212299244304386, -0.03534657287265571, -0.02414892535965145, 0.5222684911238054, 0.5964305782013799, 0.021906898181409944, -0.0857205680460892, 0.029592260097402005, -0.21595529604610428, -0.19803031373420393, 0.0077067287974653875, 0.23006761346317306},
    {0.42484657203288473, 0.041172969275562854, 0.023114953968106994, 0.81391338588293, 0.21277621239988673, 0.04141398794250323, -0.42990676706676323, 0.7388873212416174, 0.6888553029155854, -0.13164316145838106, 0.3238565878457491, 0.4218661209392264, 0.3075268286514284, 0.060794064394422094, 0.7468829195613511, 0.28637888708094017},
    {0.218064992793252, -0.09230185643938366, -0.2534382046728145, -0.1355320581522118, -0.4544587919510658, -0.2971354274094455, 0.040410961945987485, 0.0551543252589679, -0.005124975745251474, 0.08836974187979585, 0.025779970774474047, 0.20452992874340048, 0.028099394731624525, 0.018347350173134123, 0.1964520946564846, -0.08126074311449447},
    {0.24089285099038008, -0.009068622016773529, 0.1611936890492159, 0.696170486030764, 0.273688459169364, -0.06352676735684701, -0.14805729462558745, 0.003970030187668505, -0.05115054876726115, 0.016417788815555105, 0.18731830176527817, -0.2561152487485948, 0.2049721134113784, 0.8189953588283463, 0.33651981782366786, 0.041301352500939435},
    {0.7357784065081553, 0.2758291561916031, 0.012932392448757272, 0.9432495622579867, 0.5318953776687032, -0.13437284217498105, 0.599133051933443, 1.0427108137485896, 0.4563592636319944, 0.4142856770643122, 0.35697681641551926, 0.21238848510936967, -0.06975176658094576, 1.002429007146061, 1.0271058515832188, 0.18933949540750694},
    {-0.7447534902534002, -0.473052002300113, -0.15200951617194647, -0.9625970443506097, -0.6852911812991043, -0.0630066768682937, -0.030363334409495502, -0.7727240713740245, -0.04712609661722377, 0.38345983998029537, -0.10895504307095877, -0.25876830851418614, -0.44121779050756754, -0.2464927619584225, -0.36415283461045755, -0.3458346240490385},
    {0.35030278613657145, -0.3989775682766636, -0.06543887704025325, -0.5692493499237758, -0.44437790675707656, -0.1258700907207564, 0.16691061383118455, -0.032527062437756625, -0.14172476593379457, 0.10633027295919534, -0.1114208038012656, -0.23405104117078962, -0.636963855237044, -0.0745717309510905, -0.3189081826400039, -0.07573601338019688},
    {0.7917240473292819, 0.07538616519206598, -0.0053858622901354755, 0.5970347261056493, -0.5260310593127003, -0.03687396624081068, 0.18957522389852624, 0.4581333695886066, 0.09584810889494548, 0.42899851880277307, 0.2578562107479646, 0.32525682319096244, 0.4469896575850224, 0.4074132165608138, 0.1293300957206262, 0.019522871672247533},
    {0.706832003045391, 0.07132998102092916, 0.06209494078885261, 0.449033639748424, 0.037158964809055964, -0.008556116281620361, 0.5816532295792589, 0.025159492888962586, 0.212216431402299, 0.2567811539102878, 0.3359727244724764, 0.22852744005883327, -0.04409729938652337, 0.551075466986898, 0.5895611075497779, 0.16605760646393014},
    {0.024581705901410445, -0.0040302376655926425, -0.19496177035285936, -0.033633160836483454, -0.4443328620126098, -0.02531761828804642, 0.06966215326307708, -0.11351648941131391, 0.10515326260337708, 0.0586876954622446, 0.0923810786216659, 0.2508615822527798, -0.24761666997755055, 0.2898584500077166, -0.28237160122448884, -0.3228477903988875},
    {-0.15238179245333072, -0.020904836716593815, 0.06387387136472597, 0.13070119136381353, -0.5243231583984156, -0.13688599371709115, -0.22607655250533595, -0.46200029885191307, -0.314951344651082, -0.13954823473820294, -0.18524909123922617, 0.5647538338675585, 0.08737399113959216, -0.0372298814195575, -0.47105747327165953, -0.2769933615243271},
    {0.250113173249081, -0.02501157709769522, 0.30388766646775284, 0.34276660633962475, -0.3843026009959986, -0.15433885667748184, 0.4590524920488537, 0.04005944937593708, -0.031069862587006027, -0.00911319658658248, 0.27819481229589976, -0.052937295718481554, 0.2787845256496098, 0.4843334522267385, 0.012084075983106481, -0.06847020950123425},
    {-0.6980231867343963, -0.7013120911195472, 0.08684350463444693, -0.4085524722000955, -0.645528292166595, -0.3321388086629936, 0.05866818223229788, -0.6459480532596993, -0.600053502430176, -0.17489307043459384, -0.40725004586518354, 0.1451624741857215, -0.38100750505363234, 0.17583613070746948, -0.44628197652412616, -0.41516452236829593},
    {-0.16529859748089418, -0.09579977495404945, -0.02043811248297473, 0.0823117674474789, -0.3098361228650987, -0.08377319196533561, 0.6337891704235322, -0.16670366427449812, -0.21111418863159834, 0.4951443413570185, 0.09210760093967761, 0.10496915040376023, -0.3584830173960277, 0.2922943007400733, -0.2142488276299105, -0.5604133585930755},
    {0.27307877969486444, 0.23858462467702404, -0.038340907539955366, 0.9363091366798545, 0.3463878985936629, 0.02547577657011935, 0.4832902944532505, 0.49250882862466755, 0.11825804268882129, 0.17246549867605165, 0.4411179168997146, 0.4034261941871135, -0.05540277950960153, 0.7381351982440116, 0.06674251832374904, 0.0147738668600126},
    {-0.42886771148595615, 0.38547116023960215, -0.05143903668504078, 0.2153582438238666, -0.2398601776499137, 0.012779382477644107, 0.041167340427405434, 0.12776581562138187, 0.01197253581254111, 0.22894890176067748, 0.0702594784415136, 0.05423303813740061, 0.1899855042330461, 0.29735761805942307, 0.08704954791731123, -0.39229334941801625},
    {-0.7197745640333858, -0.01728046108832636, -0.11770340500053339, -0.43930698570299664, -0.009299468168269626, -0.3766662064473888, -0.5281242809544827, -0.2835246314073817, -0.31313966227125933, -0.43735162069616923, -0.19150194953969557, -0.2325663339417787, -0.16346134533128182, -0.36558298752939267, -0.33107726644957886, -0.2545644741579943},
    {-0.42226657690866376, -0.1849484844297187, 0.24767241273147775, -0.2791312023411172, -0.3581674040477132, -0.26892455640075635, -0.2142103010766598, 0.40284952675083835, -0.20562490703202374, -0.13981480377342598, 0.1180629792059235, 0.3325026882943225, -0.17599781701795258, -0.20802170849006285, -0.2439963019781107, -0.3073641517072232},
    {-0.23207598335743973, -0.16648057868372307, -0.07649822584610283, -0.3506060126517445, -0.7014081122683951, -0.08062890541431286, 0.09683627496543759, -0.631275543776758, -0.18180852908275014, -0.028346074517359317, -0.29661046091384347, -0.2622987333680929, -0.1748863141468172, 0.2666955479211566, -0.058258581923022704, -0.28804857614960333},
    {-0.08320940927334576, -0.21150474998720645, -0.27164151101017253, 0.0560043409937879, -0.10925606330835115, -0.41345722652536765, 0.2213867545392974, 0.017355323674732852, -0.09623827888561191, 0.2816516120113239, -0.16941463661031125, -0.37365736955294915, -0.42828221934776084, -0.1791575199735488, -0.01679558023164983, -0.33171350484189066},
    {-1.1002079164675889, -0.18721869450513093, 0.269021742033982, -0.45470896691811985, -0.523991976297612, -0.3890612761803389, -0.1255414399331896, -0.2611494333261183, -0.43184640079222736, -0.2791504312092386, -0.1586812582610963, 0.04427474259994913, -0.8471625682953554, 0.04928122842575013, -0.2758839446409627, -0.5722790691080896},
    {0.054936792868652634, 0.33079195935750794, -0.09866550548981723, -0.03253770099019583, 0.024388352101560096, 0.14849619930410343, 0.04521660922793253, -0.1372489056060311, 0.07647133451139178, 0.15221582621737506, 0.258013628637108, 0.2769846263402475, -0.07318674823786318, 0.552758608291184, 0.3575306020963374, 0.18710362853476079},
    {0.17123531550226734, -0.18570910062337007, -0.07426491475328177, -0.24602824561305056, 0.11610971796661554, -0.07141627540132522, 0.2829834890821768, -0.03664956559567977, -0.042768762244001134, 0.4686798025880659, 0.2907065728996116, -0.08920439353926693, -0.0429333627482868, 0.6494370295008793, 0.2473411016421239, -0.019817583838617564},
    {-1.0980578834352903, -0.6284588227138433, 0.049111179058796764, -1.1054672639526104, -1.4783355651571093, -0.24163926558740118, -0.11290969804140402, -1.2749161431474039, -1.0538608512758756, 0.05979207278481969, -0.7105403540410719, -0.8051439019836456, -0.9583396014371093, -0.6608294175604023, -1.4298371720488716, -0.8399098918848044},
    {0.5074729426923338, 0.37227575196527357, -0.009412762031625338, 0.4728114336177437, 1.254374656768493, 0.03609510856350676, -0.531335455104909, 0.886262708059242, 0.5851750805735499, -0.11670238272586937, 0.39285907967143546, 0.5484371153931731, 0.8998109389733958, -0.20920614865364867, 0.689799868519693, 0.2890570945786474},
    {0.8103677573126679, 0.4568918068940962, 0.42201154654104894, 0.9307626493622668, 1.1859974122036845, 0.13628179251954922, 0.08797610773192896, 0.8034857858826643, 0.585445295766995, -0.17255224886905235, 0.6109200223662664, 0.369809319522072, 0.35177213507891275, 0.4998872798495847, 0.8810898298247386, 0.3602855429785905},
    {1.0834461426915623, 0.3737941502861601, 0.4649727799789219, 0.8235793275494387, 0.7718736478411834, 0.36915789935752197, 0.5173163799298119, 0.5002098882566751, 0.9509854092875323, 0.07104858058287575, 0.6065415791790129, 0.3577710434060814, 0.6590864529547065, 1.0747011931139239, 0.7359820713981081, 0.704027731042815},
    {0.40053994740103444, 0.2514922745705127, -0.17583277300415823, 0.34115596103353396, 0.2337132736339419, -0.17149331359597383, -0.021854819770478873, 0.26592644498600126, 0.23783441150532106, 0.19358951331845922, 0.04731595028309392, 0.3917034752986693, 0.24328512207324515, 0.22179491514051508, 0.6605510169796524, 0.30686321970607267},
    {0.22906196819780972, 0.34672758007006804, 0.07056550321078359, 0.03439011786818088, 0.083960913035181, -0.02393321330118666, -0.20071999689703982, 0.3186328755281277, 0.3484760976205804, -0.20427461608210026, 0.22550264738322473, 0.36240016987116713, 0.30508395377088465, 0.11449884187426405, 0.472679165008499, 0.467717376716089},
    {0.8166253072934547, 0.53853141394668, 0.11532857895075445, 0.7776464362429109, 0.4076110253727639, 0.31064099551894114, 0.5061496438058242, 0.7982945269588894, 0.5179631978137931, 0.13065406383619288, 0.4422955026457052, 0.21201215455921193, 0.2850902264164142, 0.35621017833654, 0.5870820826485328, 0.25576128601656667},
    {0.758356272006502, 0.3474788659989433, -0.3339063160100614, 0.4864730876018346, 0.6733967006872431, 0.19585236546276166, -0.03950295196092804, 0.5008467850415497, 0.4325990686856406, -0.04047008722018704, -0.13029260282930785, 0.11640838473763945, 0.5505575123818873, 0.24568742382952646, 0.6978348409499726, 0.6195624753609882},
    {-0.003849732275682086, -0.0726450235146874, 0.05353810791236546, -0.26033123605762, 0.3566904109635852, -0.21752215944612527, -0.11855640096884594, 0.10645532273926266, 0.14371186771335773, -0.018251182935014203, 0.04029101748092357, -0.009074227814372943, 0.23038256359701395, -0.11193695916019937, 0.14491748585986983, -0.13793943976715906},
    {1.025027171142836, 0.5409788723762046, -0.1677525952058977, 0.996665005969241, 1.0661099682856778, 0.5799596598867025, 0.2169743610857609, 1.3461759204562365, 0.7102010327332163, -0.1042342465480855, 0.4246658305022008, 0.18410194899686957, 0.5977277366791628, 0.48501096201186517, 0.6700925871958633, 0.4538481962011631},
    {0.9465543395564583, 0.4168143554402045, 0.1579194969425496, 0.6441497377690604, 0.6587058958384112, 0.2746951048632079, 0.21085829840064155, 0.7602907056959608, 0.629806267992538, 0.38956606678370476, 0.46901712897199493, 0.24586590493779126, 0.5793023575228835, 0.5461239906212756, 1.0224287273161388, 0.6379369362832555},
    {0.46773657361090615, 0.3326777571529356, -0.016376628052819326, 0.4772958942979366, 0.2770408142541453, 0.1441991232564952, -0.015035439358923501, 0.28103717343547147, 0.6245480275248781, -0.343271560659087, 0.4345153721057608, 0.1539324529366412, 0.4971480200349657, 0.9004853175665548, 0.47035639214318853, 0.44346331145908807},
    {0.2749922514934042, 0.20807913353504148, -0.04182200865204482, -0.07363150324324177, 0.15934998998891353, 0.23662906165342876, -0.412826966777403, 0.57263767885802, 0.1748903294710319, -0.1560802212043481, 0.08038588715254041, 0.18085346978840375, 0.19811157427711823, 0.08812950660633344, 0.01955651331245332, 0.2952127320494887},
    {0.581307990517178, 0.625940304027683, -0.37610586738024204, 0.5805042822823507, 0.6211573230231234, -0.01705811268889563, -0.08318027932737317, 0.6929655063756092, 0.4011536854535131, 0.35051408954354735, 0.42697003519281945, 0.10020707141862893, -0.09892512772899896, 0.22949203334316626, 0.4329340215207069, 0.10909288958051233},
    {-0.03821617523699159, 0.022947544196532034, -0.1810870365367482, 0.21205907854879288, 0.11177375117415073, 0.308016449164033, -0.030725016299695714, 0.03329060796588027, 0.18143081056370644, -0.1597927244055884, 0.3031190546683066, -0.11038672405167647, 0.32324473983724933, 0.05536410487856932, -0.03248518860591659, 0.23541887222429325},
    {0.7125297984932387, 0.17895604057181577, -0.19477709652132036, 0.2834617373624331, 0.37254628253709726, -0.19502468071188422, 0.00615395078092606, 0.4493651592660085, 0.24522902776485572, 0.3931456194959388, -0.026820257932559658, -0.06511002451204925, 0.2629401263537476, 0.16626532644930964, 0.15330185326689438, -0.0065752988652316635},
    {-0.383728533609199, 0.17070225713544954, 0.06050034900106014, -0.30998453444956847, -0.19409404608972675, -0.14952842205760272, -0.22671924597717275, -0.3696877410621526, 0.20422272115342135, -0.20938445748417464, -0.17793494128914125, 0.05952239387010002, 0.12467214261027126, -0.15639568175604038, -0.18774118864779185, -0.1260048419496601},
    {0.21900267504138732, 0.14235913829980837, 0.014097474638771932, 0.37468082413660003, 0.008094589983315865, 0.2675336420078737, -0.10774760517985597, 0.19088756398981493, 0.1673519022765634, -0.12117860778258233, 0.5574937364674231, 0.2092203818227593, 0.15976702602223514, 0.16451273953260523, 0.44355018122021406, 0.31397941593655193},
    {-0.14577699303172734, -0.12924477263006093, 0.11729426880447313, 0.217186040632266, 0.04419485353370436, -0.049754124169389895, -0.12395719067499207, 0.21001960716497126, -0.013616611681280116, -0.1942638378112602, 0.4250242681882463, 0.23759864457052052, 0.23563714690837226, -0.004347189851396716, -0.1450342693391523, -0.14283287041403048},
    {0.6825636411128071, 0.536145189581802, 0.10530043279814605, 0.6488728716644024, 0.5396210097355935, 0.02781170237628557, 0.23049966328464724, 0.91980251260395, 0.6121217655828508, 0.4649603119118395, 0.37131272846999436, 0.7842583918814995, 0.4312117395196451, 0.5871061646305732, 0.4955574966086795, -0.2689166828324814},
    {0.04411263951739147, 0.11444223009794773, 0.03666943427717476, 0.015280767209793563, 0.2174849131631031, -0.321521704820517, -0.1281883441502483, 0.44834063343120345, -0.0356686210104078, -0.4148523787902235, 0.26995184133628863, 0.24300465807995358, 0.13296436070243156, -0.3286368641878813, -0.14490792723064946, 0.41442875068485335},
    {-0.07968866766934961, 0.13362053664512166, 0.10781149053404154, -0.10703227119027062, -0.43359062861690884, 0.3614577352066807, -0.33311522714168235, -0.0609906416352658, 0.1927470411200966, 0.09568348354327845, 0.19596617030280483, 0.16505218968264826, 0.0004545842748591321, 0.052360777194090026, -0.2836871546274813, 0.1245253724738249},
    {0.7885633816756281, 0.03172353616220429, 0.09163520523182345, 0.5188449462613342, 0.3771814189245991, 0.4650938003857623, 0.5244153490317606, 0.3543519491456461, 0.34440056794948554, 0.3118219674921455, 0.49532002447675283, 0.07765831522222923, 0.22223009872595847, 0.6041961703926673, 0.5881056207450289, 0.36803304460400216},
    {-0.018197464965116487, 0.5132119688631268, -0.20989551402678383, -0.07017257522971879, 0.0872392959800129, -0.09792670815253919, -0.3149769349810604, 0.14248628625131102, 0.20935646407520583, -0.06922468602732171, -0.13783501330497805, 0.08007166973914824, 0.029244530018481926, -0.13726341301880352, 0.058631081348647966, -0.20814448543199854},
    {0.2406583480619925, 0.006343589568705755, 0.10891379624314426, 0.31173734104995315, 0.08187769099020938, 0.2563265890174394, 0.20271034747726308, 0.1779363999784975, 0.25012645639803915, -0.13305150410989758, 0.31960231691586033, 0.30402632123196266, 0.0014175697064178424, 0.183767189848563, 0.31155304616777535, 0.32247758554912076},
    {0.09070884627526189, -0.2510159267344655, 0.0317880864168084, -0.25277638530821295, -0.2936981980227113, -0.1669719908088573, -0.32789286652954835, -0.3482712479370566, -0.1478859844713747, -0.08718885233725171, -0.3430674654904922, 0.0881575520989682, -0.7022094520249076, -0.13937390962499557, -0.3898878562254288, -0.48900896932530435},
    {0.2751338021511792, 0.22600995798672377, 0.16854312546942452, 0.5147189382714668, -0.304322704815692, -0.11955977998209776, 0.004067483458271991, 0.34175550108158154, -0.013490469803660574, -0.0965372529756154, 0.08003288910776603, 0.0567833580222925, -0.0982748390260977, 0.018014366517303235, 0.42554302386987464, 0.33667364726921106},
    {-0.11182259214959239, 0.08588883446600476, -0.26554588598743173, -0.4934645034237565, 0.44997339307650513, -0.1169471547881504, -0.09533567482459632, -0.377353660251968, -0.1133294408309787, -0.027826012727570487, -0.16928104466573646, 0.15655930728458806, -0.033801937848187275, 0.08986326334734078, 0.06427566530607925, 0.005511708968008031},
    {0.4119770478359576, 0.26289921599396754, -0.09675020146341132, 0.12929323871237247, 0.10028416326329445, 0.046326489738469236, 0.12334257997419941, 0.3351139434025211, 0.1493511389989204, 0.30794314462777983, -0.019655536412129516, 0.1243044659542662, 0.13104662474653175, -0.029268907532440158, 0.12138396064800873, -0.47600710990034023},
    {-0.5139338123745082, -0.044381429861658814, -0.055962163673865334, -0.06269375526228997, -0.3868061729292202, -0.11445957596425592, -0.38578579379992134, -0.3159453097376301, -0.21856504825253242, -0.16742046314720557, -0.4694736294397942, -0.23655217283411895, 0.02664375583486183, -0.4768762016873242, -0.6629800285140405, -0.05997491054608103},
    {0.9658914026596426, 1.433321315017994, -0.9678226829528288, 1.767569249958572, 1.071572095003082, 0.345658123523223, -1.3365676757430551, 1.571225321797534, 0.4421947030039692, -0.5661835934464361, 1.0016213724846275, 0.3597041611292707, 0.9937923862137338, 0.5642410026182306, 2.141952944291261, 1.6989407830314678},
    {0.6172360715008505, 0.31578553998681685, -0.7022968949541245, 1.1410480048506784, -0.04996137443154764, 0.29841234415296874, -0.9993871509986029, 0.7650627999108783, -0.3072924865117601, -1.0666373547553738, 1.4193818127796507, -0.2583318845896141, 0.44747079195570244, 0.09520041596965798, 1.9144896650523096, 1.1984414247304858},
    {1.0546418827523243, 0.9429704905273749, -0.15867938563380016, 1.1995658454085751, 0.8318815968162708, 0.2263353609079556, 0.04186401549261294, 1.5317545936781733, 0.6124985071239207, -0.6035710006831685, 0.7426652757472783, 0.3649949749724851, 0.6334491719837507, 0.6844446575542542, 1.203241317317853, 0.4885237907997649},
    {1.1822247608298468, 0.5415528731934688, 0.3484445375430247, 1.3212348931372737, 0.5794631271824522, 0.2999768587646803, 0.13756730239639853, 1.5591562566459207, 0.7288003315431435, -0.39787674511824056, 0.695653208324388, 0.4336073155549881, 0.6996158094949297, 0.948660999290066, 1.1070095982690942, 0.9058356521657908},
    {1.1255291002085772, 0.531953354446047, -0.19194891488459664, 1.2579457293785132, 0.7090538584855175, 0.33058284232674995, 0.14808863799472294, 1.6673406200826346, 0.523275124844446, -0.1572100566524378, 0.8215859997940705, 0.33336299507131856, 0.49114870800712607, 0.34790302035216664, 1.1974891433920432, 0.2927463896247084},
    {0.30323072751652524, 0.23024499067613466, 0.010338005465090023, 0.8308896574848283, 0.22675633548764834, 0.4835889825948755, -0.06431715935096158, 0.8101601857547782, -0.05948526168636542, -0.31941618807517963, 0.6007478881225469, 0.10765241645208842, -0.14814762386553826, 0.4865521632298432, 0.4717854603348309, 0.015630683266333337},
    {-0.5896901804860883, -0.10004500032005888, -0.2174512268361395, -0.07757229160620423, 0.2520235673712963, -0.06328951011399675, -0.22554829942543606, 0.12446157386913154, -0.12716052821125273, -0.07892534446829995, -0.05179674038127344, -0.0220325809892723, 0.0121265146358761, -0.07282189285924401, 0.22215805448821654, 0.2907104777307398},
    {-0.4938386196532029, -0.35605321367655024, -0.14345453168669023, -0.6690086772590256, -0.6766440958205165, -0.03440689395031097, -0.2472191459700656, -0.24393534292734162, -0.14468103009136296, -0.1671482083863721, -0.2613978348333199, -0.08784846689575768, -0.3015277303297412, -0.3547977578234079, -0.26119115557943695, -0.05418428689942209},
    {0.18694760415230158, 0.21407399090196014, -0.46685573686015946, 0.4232451337240615, 0.06988329422493436, 0.09407464251010592, -0.33334849789750276, 0.5477447292907975, 0.1864461147478577, -0.3837486331055541, 0.49356783759882095, 0.3426864204012381, 0.48190123170710014, 0.1966405585534764, 0.8827954792075042, 0.6012234957107457},
    {-0.04522479603095417, 0.21487354678158466, -0.15867907519040417, -0.35072517065289516, -0.144417515699625, 0.1297328200992798, 0.12269676799869146, -0.17557530827764864, -0.40086837479364235, 0.3394132957909231, 0.12174071146664092, -0.1565532820309155, -0.21141279895913231, -0.16014034379468264, 0.07630835159584504, 0.19208142563662697},
    {-0.09671637680241209, -0.1693406101808532, -0.05084650114613196, 0.5583737924514565, -0.2178475916835867, 0.21941193992677624, -0.5987660868542231, 0.03026748252966309, -0.10515222457849378, -0.4830836531406269, 0.01759386752132863, 0.07698202244846292, 0.04367642554202792, -0.07809527259580953, -0.23998008859997436, 0.04122983512425896},
    {0.3774425643450654, 0.291309109474947, -0.009113966273298772, 0.4934884829599338, 0.4678230403162955, -0.1388224000999401, -0.09250495363464174, 0.590663482088959, 0.4447562210739881, 0.2677371714392608, 0.16138107155249987, 0.17761691225259438, 0.2493329705844758, 0.08128659976189463, 0.724464684107453, 0.20983319187106148},
    {0.4676548903841886, 0.37936523488713947, -0.051775122082093915, 0.2924746826964307, 0.09314672381688795, 0.1382754014152263, -0.025303371307900165, 0.23799297584446288, 0.06351857175713466, 0.0287151065437162, -0.08518310422102411, -0.009461471353862782, 0.11916400396884541, 0.4441502522185507, 0.4112681110896535, 0.22829017152035228},
    {0.35635125193906914, -0.09514734069529629, -0.2781895307300394, -0.4529422753883315, -0.3827079135453492, -0.03387177725788176, -0.07587288134211777, 0.3810272265898678, 0.12694362441845103, -0.31011025477602266, -0.2033594668144395, -0.20479038129870347, -0.46983161864687584, 0.23643568512828345, -0.08456285461151407, -0.2505347501456235},
    {0.5700745106283109, -0.08652436695245026, -0.15496609769265648, 0.46604862910395745, 0.287317995439445, -0.08096080013561295, 0.16102256436174836, 0.817806759830241, 0.49081675120685514, -0.07719066417689573, 0.2761556657733067, -0.17087856116339933, -0.08847732470229488, 0.45640396713097836, 0.6086136620053548, 0.030779736988184044},
    {-0.02830628907898241, -0.06337756559082089, -0.37243647626907617, -0.07772650861070322, -0.7465905704733395, 0.20959988645879832, 0.054521518374507104, 0.27951790497930823, -0.5491414887651043, 0.2702035111862696, -0.1399405147848172, -0.32273691097950247, -0.326905880525124, -0.19832403565921808, -0.07275285467119723, -0.1410976718296039},
    {0.29227305834237166, 0.40247628532247043, 0.16917279501905014, 0.15054551142744296, -0.11092450772129203, 0.06599096699393783, -0.32880041717863095, 0.016487438191111932, -0.0772771339254416, 0.018552890113514707, 0.4506687574971364, -0.19741742722744646, -0.10579401223257319, 0.2515852540837539, 0.4606256375150938, 0.10755923785186257},
    {0.04723455309318496, -0.02002374246548343, -0.1223766246318835, 0.4257892256292592, 0.12673820173362846, -0.032274860629882836, -0.5165470357332619, 0.10867593011837622, 0.12302491407554551, -0.7856192753013763, 0.13919527016833144, -0.22195453767287013, 0.2961660489763661, -0.5154851003479405, 0.1989810942657611, 0.29882541977516675},
    {0.0027220243833960094, 0.26481960513042424, 0.10748777113055562, 0.3168358686363601, 0.08381971438624812, 0.3270528457665797, -0.03975799643700523, -0.009215230996119147, 0.08547057011666864, 0.11668378580944594, 0.6002889695851263, 0.12358649350837797, 0.13431311906536045, -0.1005099158660387, 0.49098187478440436, 0.25915431928166077},
    {0.19352546075834282, 0.32543555880268243, -0.2545736048488808, 0.127152315560491, -0.15021487263425756, 0.027356455164644883, 0.022332110558058785, -0.1083452869789549, -0.07450471971860025, -0.31841993941361185, 0.024063165260377356, 0.12842467950060352, -0.1985395326834861, 0.1369479924103007, 0.41885438095933447, -0.06803839797353352},
    {0.9297000733925878, 0.20033839796157688, 0.312246978026296, 0.8374233241492378, 0.06705956154696241, 0.15922877364383756, 0.42191682470013236, 0.28530924373958233, 0.10152615517701466, 0.14917844016539822, 0.2801609617930487, -0.1914978697346006, 0.13989826368131195, 0.4898106821034033, 0.2927120696631867, 0.1639979228666152},
    {0.37208321356330226, 0.19032988442218582, 0.25932225351168764, 0.49096948944853913, 0.009659807439535368, 0.17363842048029338, 0.010422725271228128, 0.8665692574226549, 0.15209332278268622, -0.1829548684511797, 0.4644468795824066, 0.01358103064058304, 0.13270945664081432, 0.24808854207773212, 0.019813092584234426, 0.38295415358789786},
    {0.2936008729468866, 0.03636215553076837, 0.22881353527101256, -0.039756154004564496, 0.5889720210659135, 0.08726614308375814, 0.04176469916348394, -0.06570372059351824, 0.2054749084143399, -0.10356239172950805, -0.0005194389300988397, -0.04470638469911031, 0.2827621446907522, 0.3375808343366034, 0.1292884703014334, 0.07317686504791186},
    {0.4339690311726626, 0.0583985919503019, -0.07251722044178743, 0.019973997738729387, 0.05579412828114791, -0.27484338685759857, -0.41632539726996765, -0.34379685489863354, -0.15982826902014752, -0.2108171536133327, -0.2834938168526805, -0.18547246548427135, 0.21464460783787365, -0.08043131521424088, -0.09552689789319956, -0.2336447492011371},
    {-0.11605261081758077, 0.20052721804406992, -0.14321912507694762, 0.39164186210253643, -0.265042074751441, -0.06044735954322316, -0.4219746928401198, 0.08470215300532787, 0.030121948755712967, -0.42254222200494385, 0.13990780656249774, -0.08806536121807838, 0.23315539856264458, 0.03354984952506952, 0.020306270402216827, -0.08519108151577778},
    {0.018495072714082936, 0.19856733246848055, 0.1621659705769528, 0.02604388518523788, -0.4315419664631157, -0.023724729289024728, 0.06598283965188569, -0.17267701474033592, -0.23305303597824736, 0.15072069738218277, -0.020162345811748132, -0.3222651606904442, -0.22745248196034729, 0.061185519434813436, 0.009083860333576395, -0.19827239312281797},
    {0.1746647230798284, 0.07330034123291956, -0.08408872372932365, 0.3915102533551763, -0.09985296437634837, -0.07155816700526943, -0.4710618673533989, 0.6803664834959406, 0.09324584176025548, -0.1481212645235437, -0.2659786966915373, 0.030479294134352842, -0.08119819020075658, -0.007960670127363503, 0.548478453082539, 0.02597659430765392},
    {-0.8444578258956519, -0.3853518044431981, -0.03208694514164473, -0.4042514766127545, -0.7939276178392924, -0.14266108548696507, -0.34429459963919284, -0.9380254388991099, -0.10405397334378812, -0.48783552749450265, -0.4356638313619857, -0.33085969773402524, 0.038237510553984104, -0.2999071119669078, -0.6087601328542864, -0.5251497392821464},
    {-0.5742280194319486, -0.09546460308407699, -0.23919475100711526, -0.08598822513122038, -0.33838212718196214, -0.10884649956858249, -0.7935686340331913, -0.37604637234890165, -0.20151454237940938, -0.4164247424648356, -0.08272074129879227, -0.10655281954846373, -0.2930921022937656, -0.30976754344375934, -0.24656359963391467, -0.08915817360647928},
    {0.10183170774300145, -0.21917601426780478, -0.09090188978629793, 0.26553936351248925, 0.08528268776441408, -0.10231216093829629, 0.09115587193074776, -0.15718700573734154, -0.19436340754759185, 0.23169101913659634, 0.23462365381003664, -0.026915264106547224, -0.11781726580196399, 0.01906418602635208, 0.03398161860765642, -0.09535914116048298}
};

static const float b1[16] = {2.111328837787776, 2.2950566720095145, 1.2695981498525946, 1.8966835974673466, 1.9091724837599982, 0.65803941961643, 1.350592025141265, 1.6971042054365932, 1.3789758818556188, 1.3901193466286716, 1.9829944438324172, 1.9514789605933212, 2.148717427337637, 2.0094324771110723, 2.5746645532015138, 2.229775368582583};

static const float w2[16][12] = {
    {-2.093034240947934, -1.708347553299847, -1.3048753006148273, -0.552829522732522, -1.7282343152793909, -1.504019880327782, -0.7563962927886735, -0.5465798522756099, -0.9365817045307456, -1.8279168053983585, -0.936499143501234, -1.5009525472391583},
    {0.3933211446402596, -0.31881203939161057, -1.9282463289023277, -1.0462019846594253, -1.016721830664304, -1.293776966062841, -1.5127533252352137, -1.8111008602246357, -2.12343295970837, -1.359392752738206, 0.033401141737541475, -1.910767610581979},
    {-1.9219774667277711, -1.756063672913487, -0.6075362366152549, 0.12055118386531319, -1.028839114490403, -1.86556328340371, -1.2169468325274342, -0.5376217610835089, -1.3820347736707979, 0.17872435891365493, -0.09597453598143386, -0.7573589963382013},
    {-1.2789191380176783, -1.4421993465256886, -1.382272825062789, -1.8915984067060725, -1.3119396252278537, -1.6611172037728859, -1.639361228111641, -1.0830058076360773, -1.9826574284069787, -0.6891074409659369, -0.845151787220082, -1.1827919826609872},
    {-0.795576484252531, -1.137943897651539, -1.4450314931721655, -1.3645991632342913, -1.2094990502682654, -1.2562510175528137, -1.4864609697908415, -0.1864237724767772, -1.3802764224645376, -0.8652147419614664, -1.5316484411415385, -1.376732384418397},
    {-1.3763302740604524, 0.9835189257424478, 0.8154710850420114, -1.1249658854328253, -0.6733264892780486, -1.9211841324756673, -0.5180260809644701, -1.3404799056894101, -0.048056169652182776, -1.1859602992135123, -0.1716955276314712, -1.607898394817338},
    {-0.2744040704531564, -2.0364088052270035, -2.018072061334581, -0.3882558801653615, 0.0435175748076192, -0.6750906293431886, -1.870155627401086, -1.2805401775060705, -1.050934683453764, -1.5055286521351061, -1.7747472201505243, -0.8105528576964909},
    {-1.5934408075455249, -1.4915722858618834, -1.5040387355650917, -0.6465449681818367, -1.2460125881582178, -1.4985740460437165, -1.5854672678020616, -1.5863591686537721, -1.6673312966777858, -1.370303798256493, -1.9873112771361243, -1.5003612106964856},
    {-0.8000519811333825, -1.8877942329884696, 0.2917159621775819, -0.8643383916732281, -0.9380012437077747, -1.4179724754561156, -0.16822482184586993, -1.8157739388840228, -1.2604605020070603, 0.18396710420184356, -1.6158520407517045, -1.5456907384975382},
    {-0.8259998356458862, -0.4321363695902356, -0.609852156491546, -2.0510094195912636, -1.6704873454482916, -0.35328041812849525, -0.03975517477438948, -1.32462842096699, -1.654328275517784, -0.41741161998249154, -0.8923325085667098, -1.2884518121335005},
    {-0.38756004341868416, -1.4785118671540058, -1.4422233786389145, -1.6505893489190342, -1.8600596129296583, 0.04083293837886408, -0.8423308152670116, -1.0964453884136418, -0.3391181875859461, -1.4912218342462868, -1.3848462285113199, -1.356260525263029},
    {-1.9030842113721655, -1.491667495452706, -0.9995236426813272, -1.655397396475837, 0.3556687010473562, -1.4881265350388284, -0.5505833974965461, -0.717476872848422, -0.8633197080888368, -0.6507785067022458, -1.646223979135663, -1.065705789961386},
    {-1.2929669662890333, -1.5980492424304487, -1.4452485987285524, -0.9230485423768647, -1.256610245590106, -0.5633970901825875, -0.3296315104842906, -1.7310833554975218, -1.2898002307539076, -2.496042419452431, -0.7095204946642412, 0.34949825561389114},
    {-1.8540257355760341, -0.6920020964011648, -1.1667325982161116, -1.490759495473093, -0.9983460892088895, -1.1411461432315133, -0.8385903377076134, -1.0210088839808464, -1.4564845193768938, -1.1514414147914218, -1.6790852849481115, 0.2268576929708065},
    {-1.481247382403071, -1.3737397649507976, -1.0596266205921698, -1.4662292083093371, -1.3354343320760302, -1.1601929506558395, -2.2447438765267607, -1.6786135262320943, 0.05833054520236506, -1.90440497168667, -0.8728449030637574, -1.2811670706079454},
    {-1.8452367782722205, -0.2700856688966346, -2.1364689810916735, -1.2494141274277444, -1.0063094777609163, -0.566628126437594, -1.1581567667422656, -1.0817172604353993, -1.5611999782135944, -0.3760543921868184, -1.614585721313833, -1.908701895811223}
};

static const float b2[12] = {-0.7092503458760074, -0.8998052062688806, -0.6947708827802482, -0.8029594153229141, -0.6361297177311508, -0.2656072691985413, -1.0211215673823868, -0.6853047211871275, -0.7264422953477222, -0.8443589299826837, -0.42842366991296404, -0.4725324657314124};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
