#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.40303274365730574, -0.9847355226262205, 0.4030417372969812, -0.34023644076615894, -1.000750474091839, 0.30997564672719485, 0.4794651290869578, -0.45005304888911507, 0.1167380320984698, 0.18113057002172925, -0.5080125989127253, 0.4442976913759318, -0.3384783235484697, -0.5378249235235277, -0.36644877012039534, 0.15484030482585096, -0.9108227961167813, 0.4168358022122509, 0.3316865039811117, -0.053133731220931055, -0.9144432831997543, -0.5428674253312191, 0.38285031904204536, 0.5187405067493689, -0.673248781503846, -0.09277516736264341, 0.23109004655701212, 0.3176570491420578, 0.3224815870191276, 0.43393645260898267, 0.7032658962380771, -0.5171896619755806, -0.3777906258453439, -0.3633397539924969, -0.46590455182791046, -0.6634396860806465, -0.6134799643912775, 0.3056123551544736, -0.7653332324241978, -0.7470274333706592, -0.2592767557469816, 0.25464411721344643, 0.1439503680089606, 0.0907749735342531, -0.6043239252151507, -0.7895524322032991, 0.23829023833284804, -0.11824373725714821, -0.4344458747363298, -0.14022667182172932, 0.5589890111267418, 0.5507495122159871, 0.3636184921325907, 0.4460271175330365, -0.45271525211639885, 0.5332213720858284, 0.09885986388233621, 0.321850599484965, 0.6476357962818085, 0.17837738593879376, -0.7437036345348293, -0.5823670854148428, -0.2839779011971817, 0.06604518453081064},
    {0.6121509293997931, -0.030332426674188246, -0.7962045566053769, 0.394390131990823, -0.15451050887167633, -0.6718671503462819, -0.4590980140470219, 0.6102441666846133, 0.32326705093275426, -0.46825852084105235, 0.0006780075621600343, 0.2546953929732299, 0.02647833154000121, 0.11415371994060289, 0.4278188965853241, -0.42950437330026714, 0.390126580280858, -0.5416137276696442, -0.4160538518162864, 0.24525904066377507, -0.0405258081673207, -0.15957379607215566, -0.15677312319014197, -0.49261918899562623, -0.660411960278375, -0.47112669495304077, 0.0883886890601912, -0.4583398342270408, 0.3990040532846013, -0.5745353720297655, -0.7617704131499208, -0.06868663016730356, 0.30531981727110286, 0.007755118760810797, 0.22481953585721284, 0.2627799336660815, -0.46183179849348055, -0.32485248882499135, 0.9004581008180293, -0.4820174489237993, 0.12384234103726817, 0.28402039256602896, 0.1566422355036592, -0.12632428906522286, -0.06657460012990148, 0.18687993051098672, -0.20191474425193487, 0.19295293845450068, 0.24671503495876157, 0.3620761574763047, -0.26335127538284153, -0.5689520251623675, -0.5896250705027767, -0.5492397441144192, 0.3591880706463458, 0.2879141962413709, -0.4539813911850539, -0.20222423184882118, -0.7420338499759606, -0.4381577645028445, -0.027294184710732434, -0.45991431510650044, 0.1348190283730488, 0.04384757743544724},
    {0.8434582226433623, 0.7616572531545782, 0.10869387285799625, 0.2991595961770683, 0.5331530941028806, 0.5297693955200763, 0.3425927196285674, 0.7967158778426661, 0.18261073297147162, 0.21582174343094757, 0.35010589772597456, -0.5281820825253, 0.3214024504679441, 0.582357660965042, -0.12141688165401006, -0.6521068646082294, 0.2538747614830521, -0.0546556875084156, 0.2618898531363145, -0.5652431374713529, 0.8438249158183921, 0.5781801964848822, 0.14818565209039342, -0.09907723864835803, 0.6682998518196228, 0.2778161276628086, -0.44700785726949066, 0.42894913155661346, -0.254615689639837, 0.6076294485548902, -0.045555478474847776, 0.40922987658975885, 0.565865843390784, -0.674202792034779, 0.2988824730077997, 0.026738746008647597, -0.5178115991022011, 0.11969516530378871, 0.743840554530627, 0.472000238810742, 0.10691524521923937, -0.24055343837396945, -0.028701687295280283, 0.5060704058277742, -0.35659941753840707, 0.6215785398615526, -0.057721081034910304, 0.6909240305999003, -0.1007940106336753, 0.1605210032034381, -0.08913182865471365, 0.4665792743195458, -0.09103554422665346, 0.478103853514004, 0.722617493769311, 0.2048262705791016, 0.5768481641855886, 0.09540474935164267, 0.8490515896564392, -0.6660057118515522, 0.5961289484518365, -0.06334663571849643, 0.4029194604566118, 0.690531597697344},
    {-0.08141201380771004, 0.5955359084247832, 0.14173965247749876, -0.4158119301324429, 0.7476698838232222, 0.833647991502649, 0.2142333423676296, 0.1152274689019424, 0.1994892313797721, 0.09427730183623767, 0.13502827045136087, -1.0782263972753268, -0.29627212906352374, 0.4783776925677861, -0.26649175317757023, -0.7763510281670916, 0.16918613623011897, -0.06830792299911444, -0.7619622387157146, -0.8401067953730942, 0.5325034747151676, 0.395558842938079, -0.22092489806303064, 0.08255733852429492, 0.8997681971461058, -0.17757575274063658, 0.03768739534647002, 0.7540647097118085, -0.613235957823201, 0.26296470696484786, 0.25407745940850535, 0.16961115212398795, -0.16288208479202135, -0.428647087449465, -0.0789544055414892, 0.22103430803680127, 0.49467764035730444, 0.7474586855698305, -0.224830802614218, 0.48088451042346975, -0.04538057835965043, -0.9019389833522086, 0.3132914880063229, 0.15158431289073537, 0.10500792895581439, 0.58930836977756, -0.6377427495663027, 0.5333892243770897, -0.5169101806579879, -0.4889406149877306, -0.6112604629061744, 0.42785996755777234, 0.36657809832962956, 0.32826297548544536, 0.19591661444877143, -0.2205132690686657, 0.9372535802567671, 0.09757826834161513, 1.0898846972842813, -0.3054493026015191, 0.16988014962501632, 0.2946764892647963, 0.33777156802035263, -0.023781702941007104},
    {0.24789834497366214, 0.8983896267233796, 0.35797496337107226, 0.15421006426612127, 0.6018592107186008, 0.27010278437755, 0.25369242974366657, 0.6794674924629052, -0.35045722239404986, 0.7310692371494543, 0.556823753731709, -0.8050014000976033, 0.5475739838154173, 0.5453560565064552, 0.5655484310536157, -0.17396001993376897, 0.7220659772637384, -0.4761067290617009, 0.13221245282079802, 0.3978317179393618, 0.24786685449777432, 0.6401945761947139, -0.16004453261439064, -0.7821459837313018, 0.5306825611776008, 0.4395403495280289, 0.0995148476154054, -0.024263688744034145, -0.8596724107636753, 0.5791197760029679, 0.49423484964795017, 0.752167588249828, 0.7018989760611336, 0.40589806415721186, 0.3072847544585333, 0.5355689532288167, 0.657356843254837, -0.23992835086699799, 0.24785404129860197, 0.9830315178104126, -0.30604535221589574, -0.8046558018926601, -0.24581474029922826, 0.6159577779563493, 0.5111694035293471, 0.6007756968396774, -0.011973026443124764, 0.20647838476057734, 0.18438991053148532, -0.17851450514015746, -0.5179886652620143, 0.45898292478878444, 0.1834188786137988, 0.39054487217901457, 0.8341442617245933, -0.38933254828303815, 0.5805048948015321, -0.19761138015848095, 0.4775483694091831, -0.8104862012335314, 0.6030191508705225, 0.25787420517946114, 0.08424474629320176, 0.5539508229829639},
    {0.795053005754357, 0.653090854375282, 0.5948030645026455, 0.33006999785367674, 0.8444650729715711, -0.16125730678797165, -0.15744252525673652, 0.7682800830236884, -0.45579980365402517, 0.6482815445373499, 0.34032981387040945, -0.714091960386719, 0.05472941477076683, 0.7884469747926547, 0.8623652904703304, -0.5472491812802813, 0.9098978923486857, 0.31483559451694076, 0.07037753420821255, -0.32290518048884315, 0.6616099601233684, 0.7164108229045231, -0.418916569554203, -0.3035618428706089, 0.5854576373759204, 0.6866432322000058, 0.4814227105693528, 0.22366197269567212, -0.3938110624049968, 0.42201198690472097, 0.1913923707156067, 0.5721412029735135, 0.6567535461964629, 0.013985712409181686, 0.4132948743363208, 0.4086645421818367, -0.07980398752070415, 0.16570707096093132, 0.5047535312028582, 0.9123811371176008, -0.2625960801695806, -0.5832704129998726, 0.44197455983305, 0.9342013675406413, 0.9443668196404802, 0.5833932362522429, -0.10799481191032897, 0.2773323953106785, -0.2060111362412976, -0.19615165627031006, -0.10320088706059737, 0.5738808290510607, 0.4504624214157899, 0.42768011708329084, 0.5197649883241658, -0.34335521995230656, 0.5700148252740959, 0.01916893217498812, 0.3737163547615224, -0.10031767129675594, 1.0930058576750816, 0.6108813124130626, 0.7966002682693778, 0.4499851908903786},
    {0.6787115529622068, 0.9449012820745579, 0.40822508860703927, 0.25386922845786425, 0.7485430418022779, 0.39077263280380203, -0.18491588076494925, 0.8747696830621193, -0.4512455609167607, 0.4957227813108877, 0.4523060417459989, -0.16042266027621097, 0.25912459798295673, 1.110014532614444, 0.6696631390685424, -0.23587933212668205, 1.0781583989671417, 0.25894509533974036, 0.10372069149572806, -0.028507005499935394, 0.740793341654081, 0.9795292273102657, -0.11336499586126013, -0.004653170654100203, 0.8737842006644413, 0.4471945766591382, 0.40584701634798753, 0.43474272886650284, -0.4484617989845253, 0.6114942079573508, 0.2881102685099809, 0.3578472086334336, 0.7215109031063651, 0.1563655399342138, 0.5208424642652337, 0.6016139086422267, 0.19365715725677626, 0.047907492066232446, 0.1476132476897648, 0.9781083009197968, -0.0664828874394088, -0.5748012850401527, 0.5381312447141678, 0.7149268085103183, 0.9446331190110474, 0.7635746574796259, -0.4048727293902808, 0.7896830448372628, -0.4564347458958874, 0.10466109143357444, -0.4440974580264918, 0.7335979183698511, 0.6802532895350595, 0.7170005662497424, 0.4147498654257368, -0.5352244758598687, 0.7904931405234726, -0.16893022173458527, 0.4629603061571438, -0.07888863445170112, 1.0081964772864098, 0.6603619024624048, 0.6193590293291346, 0.15361722583067552},
    {0.4727406068574977, 0.4235191322892477, -0.2172973487704549, 0.35814812852652367, -0.06692219285277815, 0.14149946258147048, -0.1385090217256898, 0.2901966051943507, -0.10066721071464807, -0.15941588419528202, 0.3592577449373333, -0.383433423966291, 0.27071910172636543, -0.017268917270811843, 0.33232891324232805, -0.6214887419303925, 0.42309073779363454, -0.2812484682485985, -0.45656868959931146, -0.37346756860852215, 0.2732241861992829, -0.044606252584770904, -0.254347978996557, -0.9235673109997269, -0.0030066294295022825, -0.07160299089448374, 0.10564850642379388, -0.424358762559941, -0.4315492194594034, 0.1764036645550116, -0.6337998270633475, -0.019010956928744233, 0.8250513193524488, 0.14797777217606392, -0.2524236023053133, -0.22147839762114988, -0.5191265821641277, -0.21053751014372882, 0.14736100244993375, 0.14842669695916466, -0.526090818430174, -0.46727537427750027, 0.10353537610944005, 0.49514308864273204, 0.0626413801009506, 0.255243825323671, -0.30690435190024923, 0.10646171842192118, 0.059003177955209415, 0.26550541244960113, -0.7311652610830706, -0.08399625320581633, -0.2900229666006266, 0.29020761394832195, 0.2647350421154256, -0.2223922255657912, -0.10240998074902918, -0.13552567789584305, -0.2460236891536194, -0.44529788985317365, 0.6458944381423486, 0.15940832664530194, -0.3757699660780631, -0.15163282006002612},
    {0.5231832530070765, 0.5150515416050955, 0.5882670382579874, 0.610629350868799, 0.07661869811607304, 0.11776846100696035, -0.5250238849182841, 0.6141826794241476, 0.4000795338900324, 0.24858548251065612, 0.402713883317317, -0.3441048459084964, 0.2658983091140841, 0.15754724596079062, 0.3678973280423731, -0.19016905307307155, 0.3915200372069955, -0.2659827719972631, -0.4810774216386176, -0.13479447673508566, 0.3358449200035918, 0.7290192186081133, 0.2863192961956301, -0.38694271999378943, 0.16055839302103217, -0.04880422310193577, 0.41416067384116956, -0.02262005605899674, 0.11283657759065244, -0.2651122805517003, -0.23440257939422934, 0.6096851380759102, 0.49939925564190935, 0.5389732784592282, 0.4868330062551408, 0.9627461531553012, -0.0767197854971289, 0.06629773233835624, 0.5818216047143862, 0.2850589777462289, 0.4235352354003517, -0.6472538779584431, -0.031702277026556216, 0.4573166699984346, -0.16253736849686218, 0.335815539503673, -0.05608973779140797, 0.4716094180291616, 0.8376861315222789, 0.3348454157106876, -0.3960031644597715, 0.23853490577188852, -0.4864993307488016, 0.101698333886844, 0.5313619124147299, 0.22096978244220516, 0.32998151851040225, 0.4239361396024597, 0.33443727800441936, -0.4117732496128826, 0.6809609804712723, -0.16665432214588408, -0.0991362661841428, 0.43848801266344506},
    {0.22356605194990822, -0.05833846178504629, -0.7261808866007489, 0.2619150899648338, -0.23115389170505474, -0.7511302533355558, -0.233953531265576, -0.03692038670170307, 0.20549820928222215, -0.6336182840497229, -0.08552483960971609, 0.45980492158755953, -0.15318465613578278, -0.1762688247713444, 0.5265918484649049, 0.12014402595793221, 0.1924696402571386, -0.10937684481190743, -0.2597496191554135, 0.001153969151662819, -0.3443291305761294, -0.11175199831625252, -0.4175797402458419, -0.19080938966126385, -0.391884167088575, -0.3278097864986244, 0.3903726461195784, 0.021714426063889316, 0.3113423475878657, 0.02108834940892097, -0.6631673400514004, 0.25724440651337377, -0.2311210919819384, 0.5016583969861748, -0.06965645173425243, 0.21724883734365652, -0.04877657684020467, -0.10375477243861855, 0.620939570394493, -0.3193497740092865, 0.5229269117997943, -0.1020200285945716, 0.2958379184341588, -0.3797906184992879, 0.435438930270852, 0.3268496127277097, -0.05480279339830901, 0.0580252655085015, 0.6780183678810812, 0.38648349121726294, 0.0016291243685439948, -0.7414651208621514, -0.7715328536868449, -0.6130513184525076, 0.12041526798265446, 0.05048479811522523, -0.6698892150440017, 0.1933941288124598, -0.5972472773393085, 0.19573977593468578, -0.49636706921622586, 0.20847294290780366, 0.12776113156329788, 0.0009179543210614268},
    {0.39119952756116294, -0.12820735717236353, -0.6357457071673382, 0.2942158772177764, 0.5593746607769894, -0.09932586444296741, -0.3092131738458232, 0.353414298455785, -0.3962647773982919, -0.3317860111899488, -0.3950031728321227, -0.1737645411030019, -0.7968787479876508, 0.29781041838351313, 0.6070871929314949, -0.028215347977848314, -0.09865617870473092, 0.14760737463202928, 0.07386554403691672, -0.1868982418901463, 0.28761439867745076, 0.8617102788378971, -0.7722681318893657, 0.07967173172151452, 0.4121184039353918, -0.41369507532074323, 0.4509377298916442, 0.09328156393637071, 0.09661730873661951, 0.10257553151437214, -0.5171115330887196, 0.1650303607090083, -0.2383914001166605, -0.09501019841801751, 0.300144993626754, 0.34841662191317974, -0.12414047059035432, 0.1492935997141212, 0.5554244699519687, 0.4738767233945765, -0.2612628470218838, -0.4638434813683639, 0.5895610115382836, 0.08030770208225776, 0.6275806950727767, 0.235602974387915, -0.2210214443358324, 0.39037836779732066, 0.0655747733130132, -0.08009796058545898, -0.22224509494447126, -0.40223188119080483, -0.29806546674796197, -0.45118414205056107, 0.139243498655865, -0.5247332556944527, 0.1449235898598473, -0.0028790301109920383, -0.013060492502771304, 0.09519537003440762, 0.18260914641836726, 0.5531072926425593, 0.31594729121254234, -0.16260715360762834},
    {0.44838817874561865, 0.11302261255441386, -0.09536932884961705, -0.326669889515596, 0.08801685092952312, 0.5813208870470024, 0.41166083930579717, 0.10167776384008348, 0.8768838624346689, 0.014264305185209764, -0.025947238881060604, 0.19385407919324976, -0.19271218563250153, 0.06818553616143289, 0.19659843977154504, 0.07862159913346635, -0.24468717675935636, 0.3662771533792181, -0.3046292700431992, 0.22828260885385643, 0.4250326201170507, -0.03799547642073944, 0.5761400129873467, 0.4073017752586633, 0.5682210507515192, 0.3167260168121099, 0.3277689394405384, 0.3926283814981138, 0.07184363268581884, 0.008818397589099249, -0.16735915565203133, 0.41164151235971497, 0.05418754554951799, 0.39280325158933305, 0.13397566139886002, 0.7548165633523983, 0.3058543016512957, 0.5629691936547239, 0.13543811093170055, -0.6484251823753147, 0.793645203600468, 0.035567871465405354, 0.5994775628925924, 0.14259947760064853, -0.08785646956292435, 0.5269165043137455, 0.39424451266065474, 0.5492787641852391, 0.6488864653418539, -0.1315943760880887, 0.618273123327025, 0.2623055550599654, 0.23508142102343066, -0.14542125551937293, 0.4249016089049309, 0.6314423212532662, -0.07047853099212245, 0.5224713878324556, 0.6005181562569374, 0.3343158263824024, -0.10218479526506369, -0.11662252855197988, 0.45267633094301174, -0.17154743646697604},
    {0.9052524669441382, 0.19014789334567558, -0.04225621503633373, 0.29286337124639755, -0.5891028731249024, -0.83827484017627, 0.2063484559798897, 0.6267350621736113, 0.25893281961464554, 0.48308449295601763, 0.28652055794723347, 0.8382884474823394, 0.308303445948904, 0.01570478778356726, 0.5925439341477494, 0.4957286397016657, 0.7235747582098755, 0.1315569018409348, 0.351303929047042, 0.5218864062844522, -0.3325051559664432, 0.32934318152770814, 0.17323144550815206, 0.49790637868065435, -0.3251852976773336, 0.4419664742961826, -0.43610787530191863, -0.598737938331258, 0.7077237166564279, -0.2978756209032972, -0.2947360453312467, 0.30378631573064446, 0.5736315872824714, 0.11948128095966849, 0.40015750240227715, 0.047943394645661636, -1.030106262544106, -0.8198917094839785, 0.5689038034895842, -0.04137734237575486, 0.5285099338152218, 0.7443091562731191, 0.043240789682193644, 0.49179379215170593, 0.07832128350078556, -0.19830175615480122, 0.4708119248376693, -0.4255107435586276, 0.39970587642032446, 0.4071196158702917, 0.2577618505220298, -0.09709527865835098, -0.7335883892520404, -0.008214064225575636, 0.17817682212051633, 0.5825276950314789, -0.47188614014949154, 0.40936700966871065, -0.7707490929537463, -0.47993161072225565, 0.25388543022429183, -0.227598505704198, 0.36164239399681597, 0.7937881482525809},
    {-0.9740007855139415, -0.016740366794078112, -0.16457555533693377, -0.47394275014099924, 0.548165318142432, 0.08431780995805091, -0.6773898175683167, -0.1201455249864033, 0.033698817162669086, -0.1296377537189794, -0.504181858419883, -0.41969727063203394, -0.7952546632592643, 0.5933592634073577, -0.14703543111267348, -0.6232464932413478, 0.13135590346862977, 0.16283032221222682, -0.4964729990249094, -0.1920064514512759, 0.3669829318911007, -0.42763962810674294, -0.8722969662041814, -0.004261768189066908, 0.32577435805297533, -0.2497854794620206, 0.6797909653652474, 0.814929494183936, -0.23515198049815256, -0.9409706867767254, -0.19747675049035732, -0.14449439779318066, -0.26328524606732323, 0.15013445007247037, 0.20453859364604005, 0.8746061537159189, 0.13842112578435659, 0.9570319024069766, -0.18508092081752864, 0.2653949841139686, -0.2243754935989482, -0.739047152976314, 1.0012205365312228, -0.6000952558353401, -0.1539099570375751, 0.30920090527665245, -0.37910107897894674, 0.8355103184963132, -0.09057315333773301, -0.2539261165457875, -0.5684671110655348, 0.21494406905386515, 0.5411128591057064, -0.39093874886111235, -0.7166572808009288, -0.4994745222834386, 1.0145705936054046, -0.1189081508564538, 0.6452094249603194, 0.4117745886459355, -0.06688621948345701, 0.7472146765139568, 0.5434680974340088, -0.6968991070554315},
    {-0.6468843000345355, 0.11105646153448863, 0.7776047133004362, -0.4771602450019296, 0.6594883076825088, 0.565508904896418, -0.1418952945803998, -0.289868382582291, -0.21218793750207737, 0.6064027582473805, -0.1909635881005643, -0.7465503637616046, -0.6717418150224401, 0.3093206756022968, 0.04764178761349099, -0.3941491272775262, -0.023590968273923596, 0.9043904539125728, -0.2840893515240736, -0.20024005037461964, -0.006927104046984666, -0.3273697693107638, -0.5031245928215935, 0.5008678162341124, 0.41003513086392085, 0.25335980074556025, 0.14451669133773215, 0.20456288103454512, -0.523119065277752, -0.713796600568858, 0.4252898402398787, 0.24775709728860354, -0.5642438083255279, 0.37647018470733384, 0.32671474592551836, 0.32273788655908336, 0.555626956057119, 0.533361110580302, -0.8151305711371805, 0.4730618300528706, -0.0062518428883717335, -0.5833475923680694, 0.8098919860781779, -0.3431958482392504, 0.20496531734079593, 0.16587832977470757, -0.23434014834355765, 0.07074983949449537, -0.40705155568341833, 0.03790104322116902, 0.09355170377213118, 0.9232168245279588, 0.7564898390842332, -0.1822521178783008, -0.7132384977066102, -0.6148797379634181, 0.36041489803263566, 0.08633616759765256, 0.3452555770368859, 0.5938212910582857, 0.4460036409097932, 1.031324706955383, 1.0277937641807928, -0.21747472203105053},
    {-0.6669651421661058, 0.015263799598974349, 0.7295613381652258, -0.14697253293548504, -0.1502186618525117, -0.011496604010593952, -0.4484595364040945, -0.012477526596011526, -0.2454029926016557, 0.8698063929625481, 0.18433377188406513, 0.24308766393059228, -0.2186244855659155, 0.4344445881497563, -0.19101058718711486, 0.3032918098372004, 0.3200419111264911, 0.5949584370532071, 0.16375417384359006, 0.3956096319423771, -0.1984837117077183, 0.1594400419295132, -0.13151588989386204, 0.5178744897103766, -0.29664581331674533, 0.6186325966861501, -0.2831988103580446, -0.2145305338708623, 0.09814944857852352, -0.6763972819905242, 0.42532418123843213, 0.41837601137838876, 0.08368122951841463, 0.5210586906275733, 0.6904959619879243, 0.06650573162872266, 0.04801115479088484, 0.21263049453149976, -0.597746385937475, 0.653072426968418, 0.4980415457640654, 0.26025043225576217, 0.2895038690602766, -0.45506247820290796, -0.31026532180779626, -0.4227592085494328, 0.33487637994635, 0.08582680391670328, -0.010029408122005111, 0.4927672768191243, 0.12074976666913229, -0.0807012940549728, -0.22223167971140878, -0.4296541827546238, -0.5233910949183475, 0.022669208848346716, -0.054398037298702545, -0.07631880202139227, -0.3323397881393861, -0.03443351061537112, 0.5502600036652137, 0.6645065933895722, 0.3140481370329511, -0.09828208130339806},
    {-0.5339201431123808, 0.3386695236896702, 0.3057973600165525, -0.0462043622745012, 0.9791468954786761, 0.7044863801964849, -0.4773398746493887, -0.42114734629147227, 0.3615183112764085, 0.3361216160787921, -0.15055293293156724, -0.6295425338930496, -0.6329350213425582, 0.5114472147530054, 0.6564201725672119, -0.3660490123561706, 0.46748849409457693, 0.5891208243696756, -0.9148947118695844, -0.4950983388023424, 0.5924659852553957, -0.6246166742506447, -0.6988353933265247, -0.09211774210135264, 0.7814076489036168, -0.19476830968654152, 0.42150622312766345, 0.7332116494351187, -0.6760924230435786, -0.876975724889884, -0.1904061266526977, 0.39985119206830055, 0.304168062588547, 0.16023914922726099, 0.2759294358226495, 0.7356427296757069, 0.5352353562226293, 0.5030379974063223, -0.36851611941810597, 0.24332041076887426, -0.44995843184297407, -0.452297186124673, 0.7225978651596299, -0.47315496146781494, 0.6902104494458091, 0.4599898954622605, -0.5748837462110377, 0.7699341508898352, -0.5763666536354349, -0.29035856521044723, -0.5266008238308453, 0.24350962146517643, 0.5858821644768583, -0.4500359527807442, -0.24949567770288905, -0.7066582085850575, 0.9276529141712939, -0.04367788535678666, 0.357722919760595, 0.8464294664028733, 0.7015243585432972, 0.8459740362358448, 0.8156979978129166, -0.39727391004294876},
    {-0.08375543016254795, 0.5592446729313677, 0.4319550951460684, -0.2247962891388551, 0.752611755622231, 0.39608890487024906, -0.681579400608581, 0.19782001188347786, 0.30193844099501427, 0.556135077511876, 0.07539402995850465, -0.25100805294837064, -0.48709463155906235, 0.6094634892200129, 0.7744658203489486, -0.234772720935465, 0.7627215797031524, 0.6358565316915556, 0.000509090952618555, 0.02852285027036714, 0.5332503292487963, 0.11565103987244012, -0.33385700618340924, 0.39470178914702486, 0.7880595459660524, 0.5743305558126361, 0.6960458280859324, 0.37964422437151485, 0.07911250768165906, -0.10957782228785098, 0.398599505189358, 0.5406403900522653, -0.3477334797388214, 0.43929547231319016, 0.3600511067454923, 0.5826583145815422, 0.13947601859083375, 0.46839105408263104, 0.0805770388179961, 0.467877270497076, 0.7662900551174326, -0.37590346418545745, 0.9034721806039084, -0.41367419536963185, 0.680433034689957, 0.0940667245258661, 0.1042546486857451, 0.8540568584798114, 0.007323303313311937, -0.0029701441126427476, -0.30586395743510003, 0.6065240907091329, 0.8336479813819823, -0.2876404886011908, -0.03916173913460699, -0.18283044429959922, 0.9438174289052867, 0.00835491088105639, 0.6718294199052363, 0.6959575782185303, 0.7415016116722074, 0.7230572946327066, 1.0525557308559113, 0.15485009692820187},
    {-0.5763276788629729, 0.17789338333688948, 0.20617220659746058, -0.2512544055053533, 0.3723519611315589, 0.8118070840111402, -0.3071648390227827, 0.01411577384545081, 0.28382154054869135, 0.49122245626064587, -0.1537172914198422, -0.3706974406160896, -0.4739056185172496, 0.3156905319323792, 0.3317732002772606, -0.2061752216594416, -0.045895080506328095, 0.4034684235935058, -0.31740650230189377, -0.16865162059730995, 0.5815231650956189, -0.31038801574015223, -0.002602977963247418, 0.39038411304926374, 0.563766739944809, 0.09552793075122623, 0.11014698471998134, 0.13200845920964652, -0.01062178919347363, -0.18397497163749438, 0.34700014893091763, 0.2384635379057328, 0.10147114922197391, 0.44856784100754343, -0.1129858100275008, 0.6637976904156215, 0.5144657932322557, 0.0924964882140914, -0.1856670998760002, -0.48038153709203846, 0.39952526003985617, -0.4377350708380185, 0.33972632543780584, 0.3931317514540934, 0.1293546939180899, -0.040849295337351474, 0.04985111718081183, 0.32209396155326614, -0.005413625971930384, -0.3441766946139057, 0.0771300359967108, 0.5081081152666083, 0.5701709684895249, -0.2333248621969303, 0.16554383314842935, 0.06228109776604327, 0.6423777712919712, -0.06590594137371121, 0.17582132228791028, 0.26361581200402795, 0.5393600787807795, 0.24832068800372545, 0.605342939344716, -0.20619391958012154},
    {0.0997214191241112, -0.49996869534999494, -0.9180056840116854, 0.0066307196068204665, 0.5700668260938312, 0.18033912793637735, -0.48633793223494054, 0.09643409343989959, 0.4375212990750778, -0.46153253603358657, -0.45674856393850494, -0.4807763334882644, -0.5224983108379768, -0.17545380349562406, 0.0926705785736812, -0.7208825660072234, -0.1915584212491344, 0.19858179764530445, -0.3501489704176326, -0.7446175833142142, 0.9944845779346686, -0.29285124767058535, -0.4529862964887449, -0.5133375126014974, 0.43972074207582534, -0.14443777989332818, 0.2738325679171918, 0.6813144484322053, -0.13670478803481226, 0.26982136527977596, -0.5005076457427641, -0.23098487733298587, -0.22106150362889562, -0.6325012050731316, -0.34397752194255693, -0.2003441690515856, 0.043116220006559326, 0.27977904467761305, -0.3057349659663509, -0.36229447384870095, -0.5714960279626168, -0.3614991788221609, 0.40617785801359757, -0.5058897645612781, 0.5942047701109333, 0.7078944274525978, -0.4086122409960985, 0.9630348483719645, -0.25881490240008986, -0.5124853064746285, 0.13720438050148479, 0.4190156687834794, 0.24863151762918598, -0.03422543926395036, -0.14507980910233986, -0.3729417968699889, 0.4711308709904105, -0.48308765348827404, 0.5691438328815561, 0.5202498932339068, -0.05104554362721313, 0.43641850872435417, 0.5388694235393806, -0.21165154361949937},
    {-0.52005230675523, 0.109763337193956, -0.2585350030954387, -0.23428163606976674, 0.8392645967386685, 0.623424539324717, -0.6425507703422232, -0.575242762258368, 0.3397565937029843, 0.2168490693116332, -0.18718987461792624, -0.15072845899454929, -0.05586098871282702, 0.02294572027047346, -0.19092557705146426, -0.16435199753052096, -0.49815710038668315, 0.2690988657919621, -0.6938734547927164, -0.5506720160345194, 0.6647073784961428, -0.2784296851578721, -0.4743262050689599, 0.14217459234093738, 0.1402092571564073, -0.3312692207161777, 0.1163309060217737, 0.6532024222889707, -0.4293327408333646, -0.220819500707561, -0.05422263080250978, -0.5441505961918388, -0.5102580297002742, -0.5228850403491634, -0.46482487078011864, 0.04032737543219063, 0.3224958984486019, 0.5644485643779666, -0.7700547656283232, -0.3100694011585138, -0.5593125561555742, -0.47631472348381665, 0.3767121611908301, -0.5668777143123978, 0.0360814389771681, 0.038321343045245926, -0.1567669676649222, 0.11627013561303026, -0.5987330234051195, -0.7044189156324212, -0.05355988362132997, 0.05833678595395505, 0.4402420054565579, -0.3740453029535279, -0.42471055020609694, -0.37670400108591257, 0.20826677120267495, -0.16834329455891933, 0.456828493316952, 0.8373357922105295, 0.28687734770230583, 0.6735933861787213, 0.09569029626672412, -0.5561528016618822},
    {-0.8301797462059962, -0.5789536348549941, -0.5317709430355463, -0.7312651744846134, 0.4180562599059222, 0.7388165352798401, -0.5720266364434785, -0.6441904794032243, -0.35142709571651853, -0.0938585792321847, -0.4556846677734099, -0.46630398018773295, -0.4805983876085039, -0.1732673504129891, -0.26725241021234236, -0.7421894954225929, -0.3539667436229787, -0.19542832584266714, -0.7177963656670148, -0.5129177778821691, 0.22402230436809456, -0.5358772164131256, -0.9434103116123489, 0.10812732541067736, 0.20792163094106672, -0.7817930066082076, -0.0629257894876319, 0.45037621019740787, -0.5186193708640727, -0.45536856149840693, -0.48633999900574404, -0.5313217383513374, -0.30261461763028197, -0.2053244707205088, -0.33615987547018855, -0.11375610897235836, 0.6882656341563185, 0.46165033238859887, -0.49107129990069903, -0.04125527246685298, -0.9374763821491836, -0.8188409521771256, 0.770008842059696, -0.6134568347902378, 0.6925963987945293, 0.41146210683359347, -0.4737321645178235, -0.21650043404751562, -0.5769285890170995, -0.6522471907747293, -0.7045415258318585, -0.1601051419515305, 0.5786040721424973, -0.8414533038413453, -0.9333712471550691, -0.6577256855526382, 0.34571788704638984, -0.7349214668436497, 0.21355802612287642, 0.5567797504612852, -0.3567377249803201, 0.890189399589741, 0.24841588854308563, -0.6383384632355471},
    {-0.7387987481711169, -0.10592285350935686, -0.4834546522182664, -0.49836669832157504, 0.16676374508838113, 0.8376466031692239, -0.21249811457756007, -0.3858141283999083, 0.42858445959323394, -0.48502321086410205, -0.4081657185316187, -0.7377432131498123, -0.6258338538336722, -0.008612398157390606, -0.7918587509663151, -0.549947550847134, -0.577233053997512, -0.12124963158428942, -0.536612582332889, -0.7527429395720566, 0.3094850339002253, -0.673573608027746, -0.36579954926844477, -0.07636073479266993, 0.08059756247391081, 0.16509958035853625, -0.6206599907053023, 0.35869230362795135, -0.49178126525385196, -0.5891057901046474, -0.5712278174562541, -0.591226974562333, -0.45369015715954464, -0.7716832306936316, -0.7560452046908697, -0.3762202704443197, 0.43359088673830315, -0.07148850023810396, -0.7097479349663978, -0.5387216283452185, -0.6196277718174548, -0.5381877905204177, -0.06414111911708215, -0.5713747255928802, -0.1540111279607619, -0.23384456378778, -0.777486845587496, -0.18573819418427231, -0.72740995875011, -0.6319838481340818, -0.4881463259320107, -0.1544520434050829, 0.4011161634020813, -0.39937567682622405, -0.5405193681412002, -0.5570356914958838, 0.631011880759981, -0.5275495784134597, 0.37844486726762655, 1.0354731397027865, -0.7491820956940467, -0.060724784191641644, 0.1336291434039295, -0.3170448846654039},
    {-0.46605625441504867, -0.4889600664945213, -0.4087077887828427, -0.33521673224093496, 0.2107332939660504, 0.35191567502370336, -0.30601894766193866, -0.75236829807538, 0.22196585896939872, -0.6927371638035462, -0.17977685278187602, -0.561008755261167, -0.4977821513123303, -0.508894863403373, -0.5175163653377385, -0.5039650926576391, -0.6624541074027211, -0.6284072137410172, -0.8925991378239033, -0.28580246248153035, 0.35795891063961155, -0.9168325366499795, -0.478550268332311, -0.6831097152995743, -0.07687163417334633, -0.44188806517286117, -0.11491981852604195, 0.12747020131340686, -0.5828036414748399, -0.2987819066552197, -0.9607529675219961, -0.6299037804975749, -0.5247294274077764, -0.7503851037301476, -0.9322206050135322, -0.21450379128599623, 0.5017846581098682, -0.09255885918815261, -0.4710572056191104, -0.5302302232767931, -0.4795017654611702, 0.02119502790456054, -0.5237483340347331, -0.6622663024507225, 0.5522645166827461, -0.24216309271269032, -0.4872088607299851, -0.38168334070995236, -0.5201803251644985, -0.7924510107445161, -0.35915647034321696, -0.42028551073116033, 0.19702713629665136, -0.5867743680145382, -0.24284738124760666, -0.44749283944039003, -0.2408823785092082, -0.8821630208930612, 0.1910762428961072, 0.5598392436190218, -0.6949803550398536, 0.14400995548339246, -0.5337031033457034, -0.8704972745675852},
    {-0.38657786716230325, -0.40540182034680855, -0.3790129249048767, -0.16921645925046355, 0.8556230919975775, 0.6373493696787763, -0.09431450123717344, -0.45736172901632477, 0.5386207887955673, -0.7515641749908016, -0.7494115077268872, -0.4807842109979951, -0.6804325056784881, -0.07303955007879818, 0.06421834472283727, -0.6357937620171707, -0.670829777883757, -0.1968982069487156, -0.7378683478099144, -0.5361484467619554, 0.7965501181215793, -0.38219829279885714, -0.7233923448365227, 0.09306283171771743, 0.9520601026369402, -0.49648814689019205, 0.29752531016323014, 1.159457676736688, -0.48141793764385615, 0.011331456010141067, -0.23232430171217625, -0.3518011503168685, -0.40471530938963646, -0.5980241150374372, -0.49286917709645695, 0.4417643164573758, 0.5958132567120081, 0.6118190141260472, -0.23856039549293975, -0.2025186913622825, -0.5890427536967157, -0.5475020683522794, 0.7323390775064013, -0.4691839873498222, 0.3332753329291982, 0.15967271157522153, -0.4947333736956939, 0.830116644801053, -0.4420650075048081, -0.5338002586855949, -0.3373872221156449, 0.4005222581875361, 0.8324726428582155, -0.1852916131158109, 0.5064789580984965, -0.416030023766041, 0.9309644092453732, -0.48212796944230807, 1.129420283146684, 0.8616509003940164, -0.20523752005370233, 0.8553890872839502, -0.07268412216564087, -0.7068065004448643},
    {-0.04335787351519198, -0.6900899312682002, -0.5488733087913218, -0.4557978584700858, -0.044363642993021576, 0.7590644885162475, 0.3103687691605621, -0.7183984350706212, 0.7196578872394163, -0.8459788906009689, -0.4514262862118853, -0.09275737262594831, -0.20412479886617757, -0.20709281102140373, -0.37974040203643805, -0.2874118734102178, -0.730806353527236, -0.463758688569496, -0.7774873174720544, -0.5157622502451675, 0.43081296898605087, -0.5942589573518925, -0.16201083364548402, 0.11104692874867242, 0.3761702215291811, -0.6850835175328336, 0.1618021638812175, 0.6707996481965884, -0.3288709484831184, 0.0925740492595371, -0.33340789691770634, -0.7633748570543969, -0.6200440258366562, -0.31270405096328296, -0.8824772959375391, 0.017902897500186813, 0.5951921907750378, 0.6309480001464056, 0.2422957183593112, -0.6229827820248781, -0.5479072843937479, -0.20928141620636778, -0.16886895230868507, -0.07410248219078087, -0.09153226181985633, -0.32034003294782, -0.5818010857003986, -0.26653413345371496, -0.4651231734338495, -0.386606858782325, 0.10557822729512548, -0.3134023617367177, 0.4150992075996581, 0.15635994060819317, 0.16280661339583372, -0.10852450346973491, 0.3424954567429114, -0.4189652538339831, 0.7294108374339374, 0.7857215083610296, -0.9364171194870654, 0.044529787190595596, -0.7941863248247463, -0.7465501827077241},
    {-0.5389082559046923, -0.88147069782119, -0.801920433231548, -0.5810393940857791, 0.36402537676192254, 0.2743668965186617, 0.18235171200203804, -0.8619068957735806, 0.3807339030795063, -0.7650975643086922, -0.6737706263911889, -0.26765613398825083, -0.5934498316841416, -0.5387308769048801, -0.49933556633554116, -0.19729294509308534, -0.9475214157700877, 0.006296112036212228, -0.49694716554398943, -0.38113400348021537, 0.15645779460702153, -0.622001703474409, -0.9662903500617902, 0.1768018480800449, 0.007486324914746876, -0.5693935597909446, -0.04029453573394291, 0.6444394207519935, -0.6175161491866601, -0.7715046603788371, -0.12942692256187419, -0.8637611085753065, -0.8159802032112328, -0.2990844729138678, -0.9347749889059274, 0.03770223391613942, 0.900135758894185, 0.7846423804595032, -0.6683016136527598, -0.8133930659527616, -0.5739761938445986, -0.644496718586385, -0.008968793336729081, -0.7296977885587611, 0.278966376302397, -0.006904777423334469, -0.6486433477182058, -0.4523347915876892, -0.3840651807878424, -0.6460069052703279, -0.05116972202472209, -0.534238920291654, 0.34011955476873734, -0.7362701626055771, -0.5729042194390203, -0.02255122196922335, 0.4988836115661775, -0.5732554463823228, 0.3874646818610919, 0.9789456221213526, -0.7916963111074161, 0.3097344459244757, -0.5910935777761392, -0.7979389961767427},
    {-0.2632268106076716, -0.31915919491226824, -0.42398152969310277, 0.3686168546882085, 0.499403550869792, 0.4564796859494335, 0.5271798887520219, -0.15806832450906125, 0.2259421749272643, -0.594956184286981, 0.004889553236657506, -0.22289775072960097, 0.2338949796545079, 0.380146627146723, 0.07313966049223504, -0.48618134178720623, -0.5609319488271924, 0.14349138618171728, -0.3717484639669978, -0.16023389047661502, 0.48085013555029443, -0.1705960652420704, 0.09137616185818599, 0.029723747936807644, 0.7187297952860983, -0.36896840912718176, -0.41994273494874257, 0.014283854354171363, -0.1930758308222856, 0.36183882196665357, -0.23104813642964134, -0.41674874176350535, -0.300418525909191, -0.44483213214531386, -0.531387162214945, -0.22753873053280357, 0.7541939983588292, 0.10366063793033777, 0.12865751073096773, -0.5943016348906751, -0.39145297891562336, -0.4452267530310664, -0.12393998766475403, 0.3844336256661916, 0.4105117517563775, -0.07010458712217364, -0.36908028697524203, -0.19274122423829437, -0.34627291466693116, -0.3407377896027216, -0.08443842842426455, -0.22346368917444936, 0.36367909597615844, 0.09107226162230093, 0.21876828978800225, -0.11883194122300257, 0.7298876166688716, -0.32317509439179276, 0.5992667891160938, -0.10288864150174067, -0.13849601680905915, 0.3208583072278867, -0.2992932724770728, -0.42276582007210245},
    {-0.7552648955479886, -0.11643629919851857, -0.8095230854868277, -0.463825646091682, 0.7137232528646623, 0.5888433393009435, -0.11369714057591353, -0.4830346155480789, 0.42726923782297027, -0.8975224591707641, -0.35738052457613795, -0.303732175671294, -0.4567461917132974, -0.42108539907560205, 0.016615283769192895, -0.416183793516752, -0.704092758568463, 0.2903587392373874, -0.49930926193881936, -0.7058628348147665, 1.0613612928997518, -0.30840189144708385, -0.6393946445296581, -0.022929749010762987, 0.7888124222611381, -0.6631673025239521, 0.29475893210495613, 1.1147027497278021, -0.6573282155207654, -0.3380633831999194, -0.5319818569798904, -0.43720319196764534, -0.6811004417325489, -0.3926968707015458, -0.8139805857494345, 0.3190990113043491, 0.4987432128225554, 0.6718583074095226, -0.20076352672907616, -0.1230812096493603, -0.7376353945200425, -0.8855996698441229, 0.500667902973569, -0.6901672513496317, 0.5574385213163553, 0.2938937713936191, -0.4582068083103312, 0.27180299960080695, -0.4870507788156944, -0.8744755764890898, -0.3265565475614467, 0.2177781042508275, 0.43391083421798904, -0.17609410061745917, -0.21723633879283188, -0.6022689773660178, 0.9631077423700207, -0.7832292282215559, 0.4583377267971292, 0.7660156272173925, -0.28274447250558193, 0.7150305946856225, 0.07808034403668607, -0.6856350908598574},
    {-0.2818763817495156, 0.010084108994792233, -0.007892788673785057, -0.19045205306498286, 0.23791457312655237, 0.3137246712838524, -0.27292512332478663, -0.018579264777256712, 0.3427308871097178, -0.22860999261762593, -0.23938962611122086, -0.507844377203048, -0.6024490360996346, -0.4336836960261894, 0.08047792260822559, -0.2837938624336648, -0.17448735639349203, 0.8727866099176864, -0.3653287968784035, 0.27846679040095795, 0.5669185154203565, -0.00887510944643117, -0.2632362176580093, 0.045416655637457275, 0.6860647621258672, 0.06996073676718025, 0.4047009914426183, 0.11294487832749667, -0.6463447042097424, -0.04432088982186385, 0.2868400735536862, -0.5657134031431211, -0.597822702750701, 0.30033705388928705, -0.4067740852238387, 0.4657396720471036, 1.011890072819325, 0.4056141947831973, -0.3771719461814285, 0.03897617353179733, -0.5019869449741919, -1.00280093350904, 0.30117965452548057, -0.8243937196536043, 0.6229478627763833, 0.7233929207130676, -0.4905858441263725, 0.641077890017587, -0.5753563103290465, -0.5219341895009555, 0.025521370657607286, -0.017702719082271584, 0.47279156796774735, -0.36295877967463214, -0.47683664986933344, -0.6856821761053293, 0.9110236933835977, -0.3908693635306675, 0.4609732452414944, 0.7896628264797614, -0.2086373124762786, 0.741085754886721, 0.1827455588991771, -0.6563584253843756},
    {-0.7340916561929652, -0.8729922283321758, -0.46240696944932697, -0.6803452732266936, -0.7823083835556393, -0.0020058664476803336, -0.20549624556397078, -0.8679834976916354, -0.2971413661966271, -0.19928814631628364, -0.968328554253659, 0.12768335775078915, -0.8366355485237029, -0.687096100350938, -0.13818342177035897, 0.05646435767069912, -0.5666796153039828, 0.2519825601652073, -0.07792113526881461, -0.6573594357925702, -0.44485898367927307, -0.8827563135032143, -0.04043064164942318, 0.43953937491633366, -0.7798534654017419, -0.8503196476190796, 0.4464444706925114, 0.289784681245691, 0.11529120587446351, 0.3650116222414674, 0.33243158555430696, -0.6754610514370167, -0.756473968001728, -0.8111254190203054, -0.4195954562780036, -0.6957217562461027, -0.5232770039519485, -0.2659128687300574, -0.5745529405117052, -0.7090062337612204, -0.9396070073316745, 0.12031248889759576, -0.013806803721627662, -0.3961509366575442, -0.28587361762958813, -0.8182830256523774, 0.3226602699255381, -0.10602075172178081, -0.753485150754182, -0.39050793432523273, 0.17135015570710413, 0.21862359976102008, 0.5031861807672829, 0.16055807537647931, -0.7983508427428918, 0.27260439236292455, 0.4824626989531792, 0.4076888234553677, 0.3694434383849868, 0.32294755544601494, -0.6823104083277451, -0.49498204977593324, -0.08773799928044537, -0.5510376541174081},
    {-0.6056512844714361, -0.7696156056985196, -0.4201677152473216, -0.802051082385049, -0.6768207291495337, 0.4997904560781134, -0.3799583111866144, -0.7745834889057707, 0.46543436760660023, -0.5325084644795841, -0.8133339936058439, 0.10401425984825861, -0.5604273970651771, -0.6421852039763694, 5.4689096382211766e-05, -0.6056376272357242, -0.45407887634403604, 0.8319069174786063, -0.0419536994333535, -0.4951283694201534, 0.2344526834994541, -0.9097569543324081, -0.20833139219752014, 0.42579831640836346, 0.05433300345973569, -1.1028102655502727, 0.5754273247380822, 0.6166967262842756, -0.09069594964624389, 0.13563870282359375, 0.20854060076973163, -0.764667030569192, -0.5765386278853787, -0.6010977767521624, -0.805289870869198, -0.3714965799263331, -0.36859544082366014, 0.7102373087441337, -0.17338751187610435, -0.941596890848704, -0.30047127200522805, 0.07856131242529556, 0.7426438662595949, -0.18967124279513714, -0.3848490518569551, -0.09109533961470759, 0.010386374250999092, 0.6372669842284662, -0.5790816406702791, -0.30231755058985377, 0.3923627851879521, 0.6639302035815298, 0.7854379034161858, 0.11596471353187181, -0.41082458311222775, 0.2285967070769565, 0.47556997828014896, 0.4830808373679674, 0.8842925952527612, 0.5911995424408917, -0.7366023944584981, -0.1755782162578394, 0.0045986168619287495, -0.5390980511824589},
    {-0.3829288886998133, -0.6417047371851211, -0.27844410885481014, -0.3555723544147154, -0.8262876897634194, 0.2629143415540818, -0.1725066599711362, -0.4006554169416086, -0.28473541775383004, 0.079653834215604, -0.8962297487165847, 0.2350791633787205, -0.27393297737854083, -0.5393372558593965, 0.2852283162553224, -0.2620682093660893, -0.3464134404628739, 0.19068365551926272, -0.2340094876857195, -0.2599352059080574, 0.004449722023659926, -0.576401706859335, 0.0334963941733286, 0.7906890589231006, -0.17024008182914432, -0.3613759264889114, 0.12779634670282242, 0.44737770744533395, 0.43428255830606205, 0.2212345607309068, -0.1581098689007595, -0.4839282945791945, -0.4652050075390681, -0.5328198328901836, -0.10054833869936762, -0.5150332259212923, -0.7226071288441633, 0.15365570301077647, -0.4960266144884276, -0.5697370692913668, -0.21216477897623945, 0.303005004350867, 0.14441175795715824, 0.5630146715968564, -0.5650463349886669, -0.715333615607945, 0.2988767164347901, 0.42565153640033215, -0.02329315370451689, 0.2554140269779974, 0.265451833996844, 0.39267541557594954, 0.4502323868141711, 0.5389365635349205, -0.03736315892984291, 0.09451383956463635, 0.055869150454935214, 0.501489627026119, 0.19101461156869656, 0.31020278941172164, -0.6871924590583393, -0.8966095833063403, 0.2722508339989861, -0.4980733380834471},
    {-0.23677985798520093, -0.838033188481118, -0.13497845077868212, -0.5511295992756443, -0.5203469213224313, 0.11855053075948846, 0.08502689631083803, -0.47121649590374, 0.4282915302703862, 0.005610212354920109, -0.6266470581202063, 0.2781195436557955, 0.40133212166772203, -0.48869702904124707, -0.405809856221707, -0.19304718529868847, -0.4995297408390989, 0.8828559603367934, 0.013738448050542409, -0.12601024730402705, -0.6970833293630545, -0.3208123186545913, 0.32827354342781334, 0.6849382826723024, -0.6636037523202214, -0.763360883664407, 0.7598949012293923, 0.27847114961312097, 0.3738436366423968, 0.25395075741683876, 0.20701355256424375, -0.5645434257404522, -0.511446341461013, -0.5456440715172289, -0.101242803850203, -0.42057016661661484, -0.46098932274427873, 0.026565691966835125, 0.009811572117617441, -0.2892836935465735, 0.1369877010837087, 0.4502220302253811, 0.16300862307390052, 0.10288855824691623, -0.5183201899408493, -0.5697167102585385, 0.18755921402792025, 0.33462303459600695, -0.2987039411242968, -0.16306791174583685, 0.18036008786752353, 0.21328729552262957, 0.4103646903622441, 0.26281504505090547, 0.02577965495807855, 0.7221192320128952, 0.270050265797553, 0.7024478082306213, 0.4625170884590394, -0.11552499917458121, -0.5954827402211277, -0.6255004682149155, -0.3098286500582941, -0.05975653095740145},
    {0.4030315903454403, -0.8604449986965376, -0.06653977984927371, -0.12005595264413615, -0.06982610210553088, -0.10146168530096929, 0.12625060319232898, -0.4803984835546538, -0.24030594465297844, -0.23314208846615866, -0.35048855234067317, 0.9108252661946413, 0.2909655981386626, -0.4361019646783486, 0.2450959365849288, 0.2330880841145962, -0.5580661160953994, 0.36257021012978174, -0.08559790168213471, 0.014659710250534556, 0.444630285207888, 0.5791715194100876, 0.294581147129835, 0.2700421105089245, -0.23649733742519985, -0.4842844810069387, 0.38075012095601374, 0.49934081101633127, -0.14298659590672289, 0.6635712311766874, 0.48752247894901424, -0.1310424728415647, -0.0031764043025299445, -0.2235858449895907, -0.4358570363235776, -0.5455136998812893, -0.35561866151559557, -0.1669853934463305, 0.1644452395825967, -0.1992216538123612, -0.6375237231155476, 0.1341541010343232, 0.12987858730679863, 0.12815630092774222, 0.4999181116462532, 0.15657856251473634, 0.5097813574581043, 0.39985744101486254, -0.3963252205115616, -0.18970248240852072, 0.7164861465976815, 0.6901116580672264, 0.4892540005281147, 0.7875433535217138, 0.017389583754790123, -0.1538786189827619, 0.25573384275599503, 0.5030724040512167, 0.33314622137448957, 0.4411746838466149, 0.007704752278088574, -0.7073142981243814, -0.30697147169635375, -0.23024759992491659},
    {0.039914730055597626, -0.35911189729696774, 0.009793515879367939, -0.3408023550618959, 0.05282357347496021, 0.47037389170334404, -0.5928099933129847, -0.2175857883363611, -0.08879738496087447, -0.4742538739385188, -0.5107617665116598, 0.12201266676739815, 0.231619282254146, -0.22646391007814762, 0.19734448888172465, -0.0025566559563620873, -0.33796176918507864, 0.41129908907281104, 0.044397561804170774, 0.343359117214952, 0.45138135862775186, -0.15506536549803834, -0.017548747979702645, 0.014756389866380245, 0.026964290269083965, -0.8867798038068246, 0.9582609442227819, 0.5536490253135645, 0.7177519382085088, 0.2622106693759397, 0.3629541735890097, -0.5009072520223036, -0.44547570052056135, -0.28630600664361217, -0.33647727073464573, -0.4862996489684061, -0.009592090347492808, 0.2330063397541141, -0.12857251491291868, -0.3990786509141176, -0.6611275573400042, 0.4704968688100343, -0.3143237694120023, 0.10761925032246683, -0.19461951411727865, 0.16981782120266772, 0.23711981676312918, 0.6352730653069539, -0.29578946869019723, -0.24963395343201344, 0.7205875442278723, 0.26539038945982457, 0.5788712227097169, 0.3178413502117892, 0.6884923917422836, 0.6055449514419325, 0.20417535680367604, 0.5773802462835148, 0.9109705884169506, 0.546383600293942, -0.6137122804761705, -0.3840080494237028, 0.15123730321059728, -0.5563482505055941},
    {-0.19112717564423648, -0.4590699154575036, 0.0781716385844141, -0.43963069764192453, -0.5210108781394892, 0.26662904892429634, -0.44542892976673204, -0.003194431687274543, 0.3329276506292118, -0.3329421952120332, -0.0900461942347039, 0.3281581190699538, -0.5701779792723369, -0.45271985234246187, -0.186391181932153, -0.21377010714693404, -0.08291974074337943, 0.6024934994776996, 0.2406510138929676, -0.06330924240855408, 0.40637569328393464, -0.18726374896199716, 0.3864731268967666, 0.7446712385992508, -0.008305802585703324, -0.02213042748167706, 0.3585905076064591, 0.2235891273659047, 0.6372559814698451, -0.04058655627518052, 0.43363690741460775, 0.2469895752774446, -0.3302231343681001, -0.18446349957892405, -0.2684679956138422, 0.14449257735730364, -0.2746585374083729, 0.19098248477095014, 0.40106142442473247, -0.3948784923945626, -0.0021253240022035863, 0.11951694035932074, -0.26677889594961585, -0.017986901233638934, -0.21661954695697083, 0.13865819192222503, 0.724660639569435, -0.4248527990751254, -0.43062526353970615, 0.002716701757701438, -0.5267078729011118, 0.030451479933130042, 0.75709905797836, 0.723068785377963, 0.010303085050835445, 0.04934641260787527, 0.5380735284694693, 0.12271579588444446, 0.19835579911372883, 0.20761234541329848, -0.11484324860693201, -0.3286807795877836, -0.011933351023285492, 0.05595213768676557},
    {-0.15005861236165885, -0.25796840889221184, 0.3292268423766335, -0.8352220342738056, -0.29679896290962426, 0.8154173023711886, -0.23244440901384278, -0.4400975872242563, -0.09144614345334644, -0.2528297924104749, -0.1535603321091624, -0.22252638806606417, -0.28391009343416723, -0.4519302229828987, -0.30257327916915866, 0.4193973254828236, -0.6593538606829996, 0.20973794823622555, -0.5980178553069155, 0.07600317231301729, -0.1417859605802207, 0.20006120243264214, 0.7711181438337463, 0.23746835604324582, -0.2223626284019575, -0.20886293899907477, -0.33053051270121997, 0.365639953024261, 0.18017548450093726, -0.35419131206791654, 0.47308469515549095, -0.34913710601632264, -0.7594107299884374, -0.49463546312844286, -0.2265520472538729, -0.12414824001499822, -0.35043791473021013, -0.46114877855951814, -0.26930125318390596, -0.42540228999038215, 0.4843500346212551, 0.03011036205188804, -0.17970188877950116, -0.2561814630625599, -0.253745052225395, -0.3201725591529849, 0.2105945938345259, -0.3913944780141929, 0.12932739987524988, -0.03875068812878824, 0.24827358498854718, -0.15703423295611618, 0.6680261953397905, 0.21412221477950846, -0.654182371889077, -0.1463458989882869, 0.38114258826810116, 0.24698049132023056, -0.09173442507408507, -0.29628457578514633, 0.004105404195359723, 0.5041987905880099, 0.15420616941753246, -0.45389932822905255},
    {-0.4102570289550548, -0.563001705310643, 0.28277810777490947, -0.3120126698719385, -0.2615287473715315, 0.47666827417555996, -0.3358572612859838, -0.33853695037408255, 0.024370558270650426, -0.178078787317113, -0.591284045624037, -0.30365603371286226, -0.34718525289437785, -0.23995084500599434, -0.31425195471220535, -0.25469412105023176, -0.2752013386862353, 0.23098854209096573, -0.5222769737199502, 0.29508038910462775, 0.6003172584508206, -0.3457048570006899, -0.32126959307927594, 0.46086593098284506, -0.31692902633084963, -0.7647368431187963, 0.024646171923612712, 0.2942280181319458, 0.5125350737819652, -0.10919434057033166, -0.09510859843260892, -0.3672110324256082, 0.07955496624805185, -0.6368436311191182, 0.07594379929832573, 0.41491128832579793, 0.5280025117634503, 0.6461657081643423, -0.025698758534112714, -0.21860525972082623, 0.04739131633576025, -0.01226402037860123, 0.4481403168658243, -0.133769881023484, 0.5762014537980691, 0.091646588802403, -0.4095236045231239, 0.17171803038271996, -0.6128719164741979, -0.6094331565619467, 0.5630104875578585, -0.010017257600034786, 0.3648578810626256, 0.3958591875491408, -0.49613261357263894, -0.5176439336918109, 0.5593214343855558, 0.28909738114001166, 0.34997667193412835, 0.35665265408152197, 0.09346898700134991, 0.1958671015364221, -0.1785450412825893, -0.5403411687933288},
    {0.10455713505615975, -0.2451841535816357, 0.017703128848486297, -0.17697545651205965, -0.2726133178237859, 0.280331594453221, -0.08721467063167439, -0.26129510360979785, 0.6036912797284097, 0.2139733059049894, -0.09009246834435575, -0.5198793441793959, 0.14917456222351325, -0.022008584199954464, -0.4276874630902411, -0.07349039523892896, -0.427641100033868, 0.607229870901142, 0.197376961198208, 0.5698702554757462, 0.3035644537893832, 0.23299266547784403, 0.1542158533757523, 0.4705085716116518, -0.05803759153033585, -0.33328282219475347, -0.03053424846867148, 0.03155542797840273, -0.02285050650661108, 0.32154645449470143, 0.48875148376919386, -0.19631427700688311, 0.10779872345021324, -0.542809948039785, -0.009627272484701074, 0.5776657510041022, 0.24128561429337983, 0.758627386542556, 0.5360034749273872, -0.2598112285390663, -0.47230402975005453, 0.1443783588800887, 0.022743896382764157, -0.08831262394209936, -0.08172895143196575, 0.9288643896227008, -0.39482962096209856, 0.5716355704943124, -0.3515965430397289, 0.5360960857063719, -0.19027482813258909, -0.17329969674400417, 0.4132225438229287, 0.052086443909242566, 0.11950176691637938, 0.003607664951157662, -0.031032144198310064, 0.5558667593822114, 0.6356285763286937, -0.07836140647063808, 0.4364677858665157, 0.1788074561992995, -0.47422789521054426, -0.33425247512108125},
    {0.4073991809769116, -0.6163677061602919, 0.1577973970357414, -0.09435817367157052, -0.35259801783873923, -0.18568934680884502, -0.16852301509676812, -0.14654718694687238, 0.3892614665348789, -0.23371215476888726, -0.1331836364139941, 0.16636445998327773, 0.6891845619990138, -0.28580835811370836, -0.149907896014817, 0.5242065495061246, -0.12797739126616847, 0.563348272031031, 0.004325566663390461, 0.5927583549959488, 0.05754947499580251, -0.2678425376389947, 0.584818419051066, -0.10834283015351134, 0.1881563544042135, 0.7041100882020154, -0.052493133257575327, -0.06367099506215997, -0.3649940004540058, 0.19680584867126724, -0.17285640566157479, -0.6350886852222387, 0.048365749604888666, 0.14990809853293482, -0.39518418001367933, 0.24550622565325025, -0.477648859563922, 0.3547953242926177, -0.21796761124634909, -0.37676747573387875, -0.14953747777975762, 0.5377818215293511, 0.4047212771460562, 0.09667555941483179, -0.20730321772703533, 0.08292378480635546, 0.5109831022043402, 0.2850341095280886, 0.16885673099040047, 0.33389173243859493, 0.48570304644826784, 0.7249632666726876, 0.1935900282122956, 0.48484036513992207, 0.563174636782962, 0.5891016871361594, -0.413710828122768, -0.2538452524843273, 0.5007672992773862, 0.3248123198912836, -0.2095856043104598, -0.0184580399587691, 0.10980526078585288, 0.2844299306494765},
    {0.16253162801662702, -0.26011526633078813, -0.19955525522431497, -0.30135201922621396, -0.4114828363924892, 0.5206006001724779, 0.38851753293811053, -0.03677566343760776, 0.414493992010907, -0.41654156239990275, 0.10726714618398406, 0.7052975017935609, 0.5212331324471566, 0.13579127235374938, -0.23103561054434266, 0.7149172759631625, -0.16426155620842398, 0.09207244460510723, -0.23240122542392766, -0.06036978874236607, 0.1594943433828614, -0.2869383996886884, -0.11204057380679051, 0.2533270638007657, 0.5872560667305511, 0.0807384386055538, -0.19469209253256464, -0.01325074552809894, -0.27716422946133484, 0.027985609070117497, -0.13640417600047236, -0.2835639108211576, -0.3471271913336884, -0.07226062424931473, 0.1296134072768218, -0.4131564256741819, 0.029104416895796247, 0.46996870897110393, 0.4154247860824572, -0.18191378670273162, -0.012944740629730158, 0.7958028982151035, 0.21560810404623063, 0.0710872988378099, -0.19556072874714703, -0.14903050943193688, 0.07647592379349703, -0.08754379771214978, 0.2917855629055025, 0.3303832195395621, 0.7843378184807134, -0.4108754434444537, -0.21137931528639806, 0.24145846920363032, 0.03529559798429981, 0.022958263763128352, -0.11385145975519968, -0.030740000444564725, 0.15835975140777306, 0.18365168467540072, -0.42692527433403993, -0.24891157463731564, -0.0052226829089202535, 0.022624182654767348},
    {-0.18695294079466096, -0.2220114432468664, 0.04413798518659942, -0.38087261491094593, -0.4091019652569919, 0.04483737261184892, 0.2574350961286087, -0.1570362873778153, 0.5853210772746545, -0.14542317278240724, -0.6459881392582657, -0.2278767560957194, -0.11749778650058668, -0.5290846986431629, -0.2793547220072454, 0.08966019258111582, 0.14015541075388022, -0.10518247267179309, 0.09461990865240107, 0.5108103741339165, 0.5907478907403785, -0.45317066301102304, -0.3984732414757088, -0.39048137463234606, 0.061747406322280596, 0.09514311252576345, -0.2208537883953001, 0.42086830423258687, -0.2592465808909633, -0.05780157264118464, -0.7326088859487894, -0.5454385156907106, -0.29451180102096125, -0.036668344569350766, 0.24998175622340565, 0.004768919298901349, 0.13154457860191074, 0.3781469659277309, -0.03542452855705885, -0.1912857071852039, -0.4802125085961552, -0.39066180632385755, 0.06742854028287634, -0.4992882144575104, -0.31885603896250375, -0.02957470655160955, 0.21715503364888222, 0.24656453203464254, 0.05117303379419761, -0.12944347548646817, 0.05138463775931825, 0.3277962092638408, 0.2937599447222551, -0.09551741563693959, -0.30743804822360177, 0.3106082282760144, -0.022339655349055635, -0.11165994014382631, 0.45245904971741924, 0.29727171860706886, -0.16597572264756455, 0.15388721000282832, 0.10901591718967134, -0.4423739216907987},
    {-0.21879117189508415, -0.48401361092630624, 0.36469658357937507, -0.046416107110133976, 0.22612985618763165, 0.04302471541437832, 0.3460483417374895, 0.004189125383627778, 0.005919040086894449, -0.519041849327341, 0.0771407425806594, 0.24705141558183602, -0.615810669204624, 0.11148544776786556, -0.22134757880531264, -0.30682975022872533, -0.5919051490119706, -0.36389451591815974, -0.04894701059380773, 0.4532891585225944, 0.22822064255753938, -0.20183143738475845, 0.4321450621907599, 0.4838796547138348, -0.31399146580272824, -0.550389671410176, -0.32832867591325515, 0.08676450263947709, 0.108130676883303, 0.15711257281273242, 0.07772732628160493, 0.505617709961948, 0.22002756155404601, 0.024541243969721144, 0.13264783875505054, -0.22181106530033629, -0.02742386113275785, 0.33894058274972033, 0.07568508318778362, 0.5805659991681456, -0.20112098968795167, 0.6254118475813764, -0.23537522030989239, 0.14642674406189066, 0.5598330906401652, -0.41640638650325007, -0.39047533439354665, -0.24558871485675313, -0.2694428859124474, 0.043676577505400306, -0.11321746656332386, -0.10919493284212761, -0.09537407641643454, 0.6247211989152504, -0.12246913805169504, 0.5721962240140922, 0.007416867303711115, 0.0019892068989765706, 0.17014804469756337, 0.01122026992095493, -0.027076166880328774, -0.2975319407600348, 0.23426548829251215, 0.11620134654640596},
    {0.07259792998096312, 0.21145381781953043, -0.5591333901037429, -0.14810993175960982, 0.10499016853286908, 0.3535811639241851, 0.2899811288524387, 0.425353820217793, 0.08821159098260502, -0.24184704242650848, -0.45103541117462964, -0.07805654164463814, 0.1640843418430666, -0.03651965567460981, -0.07979410208067211, 0.38696835173880406, 0.47077741780600924, -0.22656033814021823, 0.19220282638254388, 0.050152046184071986, -0.33831168582260074, 0.07327429579578959, 0.1252597379897708, -0.413489364612244, 0.33687695850488364, -0.47637483045603357, 0.3533596260255651, -0.12170041384195723, 0.08599120392757388, 0.18049466903122938, 0.2107097120895816, -0.09693939746830085, -0.28175550671245764, 0.0014102504445297668, -0.1077470192229353, 0.525159530002971, -0.4767201146629329, 0.29218146629828556, 0.4077585659527294, -0.16399886273109884, -0.049439326026769814, 0.05119946659887826, -0.30311946747123775, -0.07109854450698579, 0.5594693356490176, 0.08677403436283015, -0.35332943152779206, -0.10393261151705083, -0.378178581328991, 0.404306487889223, 0.12749094514395964, -0.03488553519014104, 0.440680168579202, 0.4100053423944037, 0.39248429120907424, -0.07168635743399805, -0.3890133491638912, 0.555726411633462, 0.31420795303427823, 0.5021361285033278, 0.15192290787149643, -0.30242470526786563, 0.12182436387406298, -0.5736657894641006},
    {-0.19743819414878686, -0.19071666222374808, -0.29019197548434006, -0.32688345914460637, -0.07023101892561258, 0.25547245298788274, 0.12517498415408704, 0.017206006462594462, 0.5263307935414677, -0.6471884000729992, 0.3005496197652553, -0.3038018180568054, -0.09623756940248686, 0.399201165624504, 0.5391891239860153, -0.5134955665947852, 0.03178396544555741, 0.450658682717656, -0.3100374363655401, 0.3649208590699259, 0.16759248524727485, -0.3475462701333309, 0.19724378734809742, -0.202848304313805, 0.2757639700599083, -0.7935908572119663, 0.5047652665813416, 0.2172587845991876, -0.48125793842397274, 0.16640970860893298, 0.3664653661181749, 0.03509524099352766, -0.09446560967285199, -0.5550523525476379, -0.33133608034234946, 0.168372681479998, 0.3588659293841979, 0.2768369118329003, -0.6427112796114802, 0.338117795628466, -0.38311435523339743, -0.09505980906339255, -0.17569867354844704, -0.35649778227922746, 0.3041654686332478, 0.28809127332882406, -0.4859642556706439, 0.37100830935826334, -0.5012198390794211, -0.14822091819052388, -0.20787729187873125, -0.08265696175832735, 0.1984331003479077, -0.24680299314379278, 0.3050095482507147, -0.28589378873482585, 0.29290397509916566, -0.3624710124633587, 0.40448129468881006, 0.8378849950510864, -0.05507714994436826, -0.05502249215924892, 0.13878090964869158, -0.685152296863193},
    {0.13528593708847014, -0.21816584093148972, -0.08076290225129432, -0.022125532280525922, 0.38019999466972587, 0.09003422599632538, -0.6637642744493265, 0.11768541868692993, -0.00994697166078885, -0.05584032531712267, 0.13105269073893028, -0.44390345618962956, -0.16510648086496216, -0.08328904529817287, -0.1392060173003299, -0.7274524922483828, 0.14943619629515795, -0.068851975633412, -0.47027513044860747, 0.4940713949154383, 0.3750048238188914, -0.21638620061479352, 0.34724253058618765, -0.43460495752851563, -0.3270876765244049, -0.16893249957646528, 0.3289572695737584, 0.054717028828947495, -0.15847848300640632, 0.05440082437473137, 0.5938207309458978, 0.080722500836508, -0.28938636684969715, -0.09943805386690913, 0.25240823483695846, 0.5701991943502314, -0.40442731787595926, 0.3949538068031996, 0.42913977422941396, -0.3328603694899356, -0.14900142638032546, -0.03302384692938589, 0.338009614954923, 0.4697817947344474, -0.2661758664498036, -0.007946665309905399, 0.4003262818483858, 0.2337105416004309, -0.8870603622377624, -0.26007188705569334, -0.3866014606363929, -0.11922258156938464, -0.37937250735844924, 0.5885653005552836, 0.18663949300850696, 0.1039770099656489, 0.1419893414141768, 0.3113060677500483, -0.1860990090583448, -0.02309543742045465, -0.0034613543864654805, -0.16768357415319426, 0.05493395423104942, -0.012206406351479824},
    {-0.3610022974816352, 0.13860939337359862, 0.05828530984505392, 0.023650998590085154, -0.1441006179076105, 0.24591174468033586, 0.13165377069218834, 0.22757358467745228, 0.03204238376545059, -0.21130631828981486, -0.5040457586972755, -0.21044197225558944, -0.23193745386161585, 0.031042413991893114, -0.189260346152897, -0.08095733575181495, 0.05906365993345222, -0.16224281244879526, -0.10546570988498999, 0.2179376772524756, 0.31403794922054296, 0.10258588166634586, 0.18377993367523024, -0.44934447803456457, 0.03851988281440614, -0.0680332491582578, -0.38910935887615544, 0.5562634802970031, 0.18931151663915824, 0.20120814611909335, 0.05042417638015716, -0.2396566778487451, 0.36890997184881474, -0.25105814494367157, -0.19704139611142368, 0.10020323387731096, -0.5287273667163308, 0.27561197650381564, 0.5763754794339465, -0.0447363789471882, -0.10017429339461292, 0.4752189877412825, 0.4173718902157019, -0.24038681998658953, -0.6231251291339444, 0.011835634794665048, 0.5235888938591895, -0.09308892072552916, -0.49407933196455783, -0.01606748047060291, 0.41239483942986677, -0.5719839679097728, -0.3863587846844252, 0.7130019031763791, 0.06256111508461952, 0.07701791281522596, -0.12699851310578344, 0.24587664698076608, 0.11793771532061163, -0.1681831681729244, 0.25464623009676385, 0.32104194230281274, -0.0730810491782609, 0.415020636399104},
    {0.3947323306609837, -0.6364756736257126, -0.14905707037910068, -0.08230265845668433, -0.7411480895850631, 0.2774955629352704, -0.3048820898635771, 0.4501755946251535, 0.3856357676188271, 0.35727318338097114, -0.19307602089673034, -0.031235641355161676, -0.33367504574985885, -0.4359839839336335, -0.5919328353685505, 0.5839441002987533, 0.13930580044308832, -0.09213940852825628, 0.30650575457840945, -0.4031085681062742, 0.04187659797513291, 0.38606701807251526, 0.7111640060994204, 0.35611782361952804, -0.3608761397988895, 0.29587838107751, 0.3113110216140977, 0.8452302235350874, 0.7546031975109578, -0.15590850967043604, 0.05896806154871207, -0.434687963495324, 0.26357320737464585, 0.8789939725315804, 0.1277130858267383, -0.022509109505166297, -0.8106621995037544, 0.20889415210252982, 0.16306855126811343, -0.08852931025597684, 0.2843171468601422, 0.6052630988654968, 0.01822285918232163, 0.06437431078642239, -0.5333958440595841, 0.021077431558176866, 0.11275829654962623, 0.08454925124804351, -0.04020553780506182, 0.3475611480309683, -0.2783671668271525, 0.06181972627104738, -0.7090534445223211, 0.6120224513297864, 0.2812258675331776, 0.1699210910069882, -0.15369691740446068, 0.4153565650088441, 0.11159331601700237, -0.7959151916743293, -0.28477575741953925, -0.12737162622165274, 0.4022019428343533, -0.13525572566780703},
    {0.008689840345849265, 0.230237792534935, -0.08271247984213546, 0.3475664727073277, -0.2978511843583864, 0.08848750882822626, -0.2741263928979954, -0.2047918784809105, 0.5835551149846396, -0.07490502596340813, -0.049679119348625844, -0.14105013773787387, 0.37897769226204114, -0.3968674259061584, -0.26507740755630316, -0.010265710972719494, -0.43274423372011, -0.3449448564169264, 0.03565214578191762, 0.38409440152852986, 0.11467887312692437, -0.25201219929829877, 0.022243885961610334, -0.40375297028850493, 0.14776930028056728, 0.13455384584104224, -0.1695066116331287, 0.04331934578827579, 0.49037866404089875, 0.07480475930983381, -0.0481682813336961, -0.36125567856569574, 0.5883352089591601, -0.3856795199782947, 0.039182070514295675, 0.00875940118496373, -0.4079035518495796, 0.3097966458712883, 0.5381612998965288, 0.053963583334243496, 0.18640635134622965, 0.22404940188901562, -0.3040084297313638, 0.4485889754837358, -0.3921065534734844, 0.6337574554215171, 0.0926128241654195, -0.2220038165461523, -0.3821713375673815, 0.14832358185038322, 0.2562734462364747, 0.015082514372394211, 0.5510236574619988, 0.4317352177064352, 0.5046481974001498, -0.1373989608604039, -0.416186222141011, 0.2714629925612199, -0.29680079523827024, -0.4979778854183809, -0.152885244806907, -0.6032425455067312, -0.7711286017393618, 0.2692558928252048},
    {0.06187874814572138, -0.4891141752946546, 0.08686356996004478, 0.13803798492368632, -0.5094828071728084, 0.3838408039149861, 0.04263527736990909, 0.16842374369413224, 0.7392725225604125, 0.21117884481643506, -0.13582015783942575, -0.4303397216062561, 0.191581808930175, 0.23917087700885256, -0.3278366986167492, -0.7762205851319413, 0.18289026071249248, -0.5812909223199789, 0.172401118680607, 0.3543787013807444, 0.3647642956802876, -0.47611319526255175, 0.18466388504097278, -0.4866758143999712, 0.7247246331537052, -0.11837522405896465, -0.2852071765640177, 0.8976707325306882, -0.09416305434250595, 0.5057022783595831, -0.17599674762961728, 0.309723767980019, 0.3309627187207138, -0.05018260771301382, 0.26586674810125627, 0.14435943235459456, -0.3164686552749621, 0.0886370686696255, 0.30887924290669705, -0.34004284595141276, 0.4909630307345149, 0.8170329002745286, 0.40577796489283213, 0.2484183559123467, -0.15017711399964465, 0.06261485866549256, -0.015619712872269894, 0.7100550783693103, -0.0841305267353647, -0.3633605014526796, 0.023876043321450758, 0.008577442643890648, -0.5602093712650051, 0.23784765945189165, 0.6637206552814681, 0.7401828545305316, 0.13956577653635888, -0.12995468544127345, 0.43033527138766076, -0.05891838998751872, 0.17702905844345673, -0.24511925607273444, 0.22005092567338747, 0.16819179960121752},
    {0.46563442375323777, 0.3398390449883708, 0.14832000870566603, 0.6333130276910808, 0.2504803970454121, -0.033211922031705504, 0.13297873021437884, -0.3236998120148581, 0.49967314942030494, 0.16313068814736834, -0.18954414088257399, -0.3373975161264368, 0.14005270620877872, 0.31789205210317784, 0.06463322253113153, 0.1800583581705891, 0.1726008069365697, 0.4651829566584539, 0.03817160664338138, 0.47693647112221255, 0.2857971018141033, -0.3222833463235278, 0.07276161219367469, 0.36554285084861454, 0.24247997974240396, 0.21831235913042338, -0.36908287081936925, 0.06748238698728057, 0.09685838871184722, -0.02355541541454105, -0.27758960712086844, 0.0331045635287065, 0.13751594885550472, 0.2881616766825505, -0.21471240429701346, -0.3229994710905022, -0.10477155743136922, 0.060611396877150905, 0.6099067597107553, -0.18199153163764586, 0.2820544772470125, 0.5362378816112409, 0.4756808323040658, 0.2654831553941114, -0.5224260844472857, -0.16963211796728084, -0.07672531675804496, 1.0383604129425552, 0.29950416852641826, -0.044133571795945126, 0.22568694763221542, 0.3625648695851676, 0.2811090152227336, 0.13253608322911142, 0.43968965590859105, 0.7717067388642048, 0.15584705270517368, 0.6327837339107222, -0.1403414772167077, 0.15619756759146014, 0.1638031969595215, 0.13957297403893548, -0.26008923527570116, -0.34103030288211444},
    {0.13123675771162788, -0.08016364589217292, 0.03961015876958262, -0.35446240351081953, -0.12423065710486209, 0.086809849738471, 0.6379430154099174, 0.0015220779560429238, 0.4663885771771958, -0.37076032672109566, -0.2847856296341684, 0.11218293406738888, 0.1386008325221412, 0.3716992528912066, 0.45344998907273376, -0.11628653150446223, -0.22009715545920372, 0.07151277426109065, 0.30896625365305813, -0.19051417120295636, 0.25781410926551285, 0.3419628290267914, -0.44263391986413037, 0.41758622538874723, 0.4509852087830817, 0.2301667007454913, 0.808964428712284, 0.6306880987244357, -0.05656219248941019, 0.14358514806137965, 0.26289857639770114, -0.12267035683396074, 0.3003429100152397, 0.03057325829748193, 0.15480223933879222, -0.1325524756275881, -0.40327516835126165, 0.5620681765548939, 0.7014856938584163, 0.41998857474830886, -0.03957053413446096, 0.34637641915814354, 0.4203483497613537, -0.10967246425663098, -0.16977944087544763, 0.0551112976834605, -0.34506514902954766, 0.6378061900568028, 0.17573737895929484, 0.6249678239813999, 0.5978382672521984, -0.22885420814469948, -0.22843288946541868, 0.6893351112855626, 0.8072133876405614, 0.16559463928193566, 0.026466772960737902, 0.5698724132989269, 0.20724379282635225, 0.4191849546538988, -0.21003029546535576, -0.37023171071893085, 0.27636229614289265, -0.06203939878801543},
    {-0.4992990873462185, -0.12399809843545588, 0.34620385356878747, -0.09776634377393228, -0.40236831586437394, 0.30095265257136067, -0.36883143182477934, -0.13157804894606154, 0.1724434556877729, -0.052445132515109176, -0.3849685372424721, -0.3278241017800845, -0.35638963541908747, -0.16647283025132767, -0.025896977491282724, -0.21403559181833748, 0.6693143116006199, 0.29778084260235466, -0.04199503823104801, -0.09042591378232817, -0.15919858130112233, -0.6713514811258731, -0.3733434407269352, 0.19202984516443933, 0.24717133325715832, 0.7304747203574953, 0.06545842251135152, -0.15868042787796308, 0.215922306431035, -0.2618735541332236, 0.453128461601727, 0.32924984179918215, -0.4530022522809406, 0.19112816082259235, -0.1550309356038612, -0.14606524303915927, -0.17663258001012677, 0.2681515942183961, -0.5243919782379328, -0.5250537176224697, 0.35440871780091326, -0.07414074365379282, 0.2841805260607047, -0.3483811763662108, 0.04738560071693786, -0.3361865775944339, -0.4806628223315523, 0.1220423300453303, 0.10108781084054946, 0.6706880256238543, 0.16887092661315048, -0.04222972972539213, -0.3027111372665204, -0.6972770665083929, 0.7311970055049508, 0.1399692140101949, 0.008282691478885022, 0.20784809933830334, -0.09823805556300319, 0.22592572206562722, -0.39840738484086524, -0.28234423279292603, 0.24121655303868905, -0.49020504662976666},
    {-0.3017057573193607, -0.1571569495013917, 0.5188521245866606, -0.12045665910912964, 0.24414866045586375, 0.05702321952025413, -0.14813601453712685, -0.4407644084323263, -0.3452224331971941, -0.15987442152264478, 0.005657836672565785, -0.37620540553784504, -0.41797041874296376, -0.16617707009874608, 0.07239463213176883, -0.36552499404479616, -0.06679086600326267, -0.08439359356403052, 0.15684246633642387, -0.298148709060872, -0.034755180188577726, 0.0278600658114348, -0.10566800092734864, -0.21677312442522864, 0.3780405961731509, -0.31396797384270275, -0.6972461919095237, 0.4880365201532577, -0.3916119420012643, -0.2611378545175546, -0.23454010122859634, -0.34343561577259946, 0.1768550174777988, 0.25775367894601864, 0.1802539054048925, 0.5283041206751747, 0.626285875380819, 0.47205256369415316, 0.2353136445725432, 0.49021254145053444, -0.20707485022393501, 0.02801236049566891, 0.48590852372291193, 0.36242457070071604, -0.17068077704613277, -0.6132037011209711, -0.6366214914908533, -0.09354419266410437, -0.021628752395740712, -0.23030884646209615, 0.3477083759303404, 0.6967287946138485, 0.5648186949030711, 0.09196905001898362, 0.24040176922185447, 0.521373016763176, 0.6943770272082334, -0.6003746429721029, 0.27065308474604166, 0.13640186563685452, 0.24770327492218863, 0.04939300800309824, 0.3352137772267599, -0.18633323897866455},
    {-0.37908806321726013, -0.17740490150425375, -0.11517488216665324, 0.45149917783647986, 0.05183843987109833, -0.45011506072215623, -0.44828046375747893, 0.2552842306292173, 0.1388162238654084, 0.31656068149977473, -0.4951796615806059, -0.5052404856527594, 0.11019019312175889, 0.13927979121123021, -0.00279607804874783, -0.29626760014229153, -0.15435708073873725, 0.26704650932644763, -0.3581830975888327, 0.8440244066548758, 0.5704584116339079, -0.04214700210464922, 0.47284519490250254, -0.5063697740294771, 0.47479717330684856, 0.07537588030160089, 0.7306916236152531, 0.16130407151079576, -0.18432080109949803, -0.6012365008353983, 0.2004579172108394, -0.34009634771444275, -0.12413312802043645, 0.06531957727428792, -0.265553926126885, -0.5904831875878327, 0.03171036942668592, 0.22593252132551805, 0.25764319675263886, 0.05296014496780048, -0.04696940424379054, 0.3038343943541427, 0.6252866856622908, -0.4407509264509161, 0.46572693635938417, 0.6418400543964496, -0.29930883051395096, 0.2653942865896578, 0.10088624203325032, 0.028584986507039528, -0.5057420562427516, -0.35965696418209464, 0.4743952518245527, 0.684703977333164, 0.25357327822843245, -0.3364735670284403, -0.4453426033327012, 0.3300766923259603, 0.5256739664203005, -0.09704591802033571, -0.1507052103015461, -0.33415209820728486, 0.3319796792823538, -0.04635180018061708},
    {0.08971554660488819, -0.2026087767191863, -0.38726637002507486, 0.1764409060951091, 0.4470140117942214, -0.3049043278898949, 0.23320449703183102, 0.08810834300510786, 0.44927668004366683, 0.0868812307239031, -0.40739937581389946, -0.31969786196312217, -0.037443918593409814, -0.20831465145827846, -0.5483904910790283, 0.22974591683887086, -0.11349337561571762, 0.42810100053107814, 0.19377950629563348, -0.18453429054489703, -0.009326402555850087, -0.31930188035942214, -0.41096377424880437, 0.6974140360785925, 0.08254617197291099, -0.8074747026367106, 0.13605503396331134, 0.7357161574890142, -0.05342279506916204, 0.4839675172435681, -0.2120074622211168, 0.5166028753433868, -0.3696091248753945, 0.07675532248062053, -0.40203571972325225, 0.0641992080014374, 0.2588063081347733, 0.24386071425122582, 0.41574063123130156, -0.2845939653632591, 0.0760504645527489, 0.03859472896417057, 0.46004954335551435, -0.4789919175378668, 0.24832697615680335, 0.3717731204949631, -0.2553855243459063, -0.27581931899261697, -0.4172391775973628, 0.24060396772623685, 0.15307687787504204, 0.112104313834685, 0.22895233525926675, -0.04230019901261063, 0.2484845861950352, 0.08375894860468668, -0.26079885069474024, 0.4862505022732913, -0.008759949621854269, 0.5615513030202114, -0.2128011122861171, 0.1812975271891872, 0.18445413789650283, -0.040002932255146555},
    {0.4003361350031223, 0.131396834752587, 0.12665846275417952, 0.10065704261727829, 0.23530563688604908, 0.32659208125866107, 0.34897674048650273, 0.25456520066389937, 0.7177211199190893, -0.0004729201331124204, 0.41307772652997327, -0.4139964223616585, 0.01768237255084118, 0.42583974577867223, -0.429379666660942, -0.463258115199532, -0.5419921897163417, 0.5756091661081721, -0.2884828013938865, 0.3738732899688118, 0.14826391695176666, -0.1851528266608729, 0.0717686514370217, 0.14394669286160147, 0.21047525826982086, 0.5543751801947536, 0.2031645905295468, 0.23541233146572343, -0.16493200299391872, -0.2727908616449419, 0.5778844791777071, 0.6623229396505427, -0.009611928771480755, 0.23486336791133486, -0.07569341816218696, 0.5476497737308125, 0.4570812145765507, 0.47405048283801493, 0.05592820760887571, 0.1871965025346535, 0.543213297651165, 0.297355997876965, 0.1810134167982531, -0.34584036956677316, 0.600517738330099, 0.3593152183133012, -0.08152345532720973, 0.16584940973562226, 0.3313888648632235, 0.3142640737641007, 0.10568686504307051, 0.32123075210830215, 0.3282538136879893, 0.2415285194266596, -0.11265873597137979, -0.12222609438134412, 0.3022716712955154, 0.06830513238356285, 0.7651115532441365, 0.6618638552396199, 0.013790698069207666, 0.4395175141579594, 0.22680158023516422, -0.5230471502381197},
    {-0.4275929605624999, 0.2748253182714391, -0.11759660963253918, -0.30903578197320253, 0.16357769823021465, 0.41966939402609366, -0.30751462287834147, 0.026977417800045964, -0.3521383486586817, 0.08606793756546813, -0.3087784588711635, -0.5448864019871611, -0.07892056831256539, -0.14261603661820724, 0.06947391295784522, 0.7200069569406852, 0.04235613040218283, -0.6959464128667242, -0.36974944386324127, -0.49187261170532415, 0.6585382433240651, 0.113592557600521, -0.3118510881191277, -0.32665127462458154, 0.6855595642083594, -0.6236813946305821, 0.1853870190253256, 0.9147646791132458, 0.2571130540347409, 0.37541615330959943, 0.293247905828937, 0.4383877545515129, 0.2396399066589715, -0.038597927591829916, -0.015519275211084501, 0.4044442883771248, -0.2533781943551502, 0.27047084443713426, -0.07567342836424445, -0.16309347929590023, 0.6685081656636562, -0.2958367629074038, 0.8209474460598681, -0.29704768407980886, 0.5923458595681264, 0.4188018704907167, -0.4276801656026428, 0.7549638874307537, 0.5085388075102876, -0.17307563389829986, 0.22816711190707795, 0.7037930444227941, 0.42363742542095617, 0.2423313246621705, 0.5328811600907915, 0.6009213109891773, 0.48909201532215535, -0.17733149678715174, 0.5298712437961886, 0.44177035466264813, 0.17407326051333197, 0.7841979226639122, 0.5219120092787927, -0.5124214761792352},
    {-0.2196653650633867, -0.13030784604160592, -0.48350752988358503, -0.11212472047377499, 0.4532925013801021, 0.8638956349546757, -0.19370055566761554, -0.3482121579286154, 0.2534584948154962, 0.11711917727429681, -0.14565468843831664, -0.2440962710833026, 0.1244274753231858, -0.1302445816678058, 0.031362465982628304, 0.24221175644645548, -0.1827715963138316, -0.059181626988473054, -0.6731602425655941, -0.42542221557423365, 0.3509304970413039, -0.045907114871613044, -0.23919072933574395, -0.024358326677292062, 0.6665970123006675, -0.04059959176417567, 0.37248751125276575, 0.4733948512762608, -0.45234833869902336, -0.5704979306132539, -0.3351935015606485, 0.011555425557336194, 0.06577373539160378, 0.2497703502719617, 0.2152752210295452, 0.419946875070317, 0.45837221953671997, 0.5087416030533973, 0.09304428779405159, 0.5454546216417898, 0.45659077473284015, -0.37854488932516533, -0.28083741592327344, -0.263788807219439, 0.41427692091726337, 0.5583306457696866, -0.6274050848701574, 0.3097215435791948, -0.5171328530629066, -0.49991021380138195, -0.4562832369648881, 0.04099907050800978, 0.07137175548984911, -0.034351884018572414, -0.005045214830697132, -0.13352408088258383, 0.005489508584725213, -0.03439208853918358, 0.5114158885928971, 0.49809439917932286, -0.1150358801904054, 0.09880292548390225, 0.32397302062391725, -0.019335497740947102},
    {0.3323285334781512, 0.26717255093576503, -0.1354380190772271, 0.1647317705865077, 0.3749034127486189, -0.023714893498631182, -0.617145421535843, -0.09522611049959392, 0.24543237061249684, 0.5337668904757831, 0.409515251039768, -0.036390209438422236, 0.5647459042027574, -0.2171788975125463, 0.6173265533726117, -0.07995179052771578, -0.1906126575298129, -0.12534949139853288, -0.2311865910793, 0.40423761137951375, 0.33956576747278366, -0.021939905042819667, -0.3230954508198629, -0.1555580766706129, 0.21683044229352083, 0.10570369566011417, 0.030006391534688294, -0.06699867008994126, -0.3893657806800229, -0.20007904295097464, -0.3319939273713961, -0.34043508528208816, 0.07324113689372327, 0.14436529737437442, 0.3706971744974517, 0.4013897681904056, 0.2904855531644398, -0.030556620124938875, 0.3165990056193124, 0.19636757379897546, -0.24526223946672582, -0.5140279975350615, -0.17400829219432248, -0.16658135191746967, 0.23752314510790806, -0.35158918484355317, 0.12335413282208968, 0.2501465424302422, 0.28332715984129897, -0.5151118932090417, -0.17503837096366084, -0.07674005849734986, 0.16083630069548768, -0.18626593209365902, 0.09946273553885548, -0.16830261394363177, 0.30511592285955785, -0.43954375617482905, -0.07186143401527513, 0.03318731054908939, 0.06948977086729521, 0.33020676967748275, -0.4824373661305826, -0.008793855039384556},
    {-0.282371663368264, -0.10257633218777924, -0.16925763188474613, -0.08589359555751568, -0.8205121067766105, 0.3291320507432648, 0.19271357832566285, 0.21135459892428193, -0.5653511229879458, 0.29285674436130144, -0.29660259287610835, 0.19295247709900418, 0.33729498708055433, -0.08040797461766866, -0.14258123234821718, 0.16605830827119195, 0.15333336820620172, 0.14476115028543202, 0.007165161993502291, -0.04058355326172352, -0.3102214833722191, -0.49043655774611844, 0.09301237048738759, -0.2958279497483922, 0.3496038233765872, -0.182113250886217, -0.021984532034390585, -0.03537184324361597, 0.013122437187292784, -0.2313926586413289, -0.25228742284622296, 0.5999335340104636, -0.15818132061812765, -0.052383604495005974, 0.23008510709331836, -0.14565275274552647, 0.13070507740898568, -0.27318373531761964, 0.29249029656574393, 0.11653811084448062, -0.01994936201442241, 0.527151399419029, 0.25592553361307835, 0.38936447908229466, -0.4559309631348012, -0.2550651036989307, -0.2515865158560308, -0.06294969979539647, -0.01677428082529959, 0.6012329027405123, 0.013836921549992187, -0.3002809221541438, 0.361102248048937, -0.08314528710566634, 0.49716348185049075, 0.7824543976825243, 0.06288017716406573, 0.25530326971990763, -0.06018212429237595, 0.26051585784156306, 0.04259461205771522, -0.2720721579088362, -0.5333304591381027, 0.6028865648028837},
    {0.24773947039289923, -0.4067846281435646, 0.17674240467283459, 0.46650161829514286, -0.17486188222316892, -0.38353948028582807, 0.4669670125227825, -0.17284374016426887, -0.5253941110482917, -0.2775699197265141, 0.06371533479160194, 0.1366681761883278, -0.10175223951917038, 0.33405735213054666, -0.14238010642516288, 0.3689317434567878, -0.1790648669928308, 0.12215709292088998, 0.30299246487257364, -0.053404937451233286, 0.2240889255618842, 0.5525340845548081, 0.32034254907608034, 0.6417971966603699, 0.12609328689780722, 0.1467128405744569, -0.17502127547233567, -0.11157590372104106, -0.017784641662471498, -0.2931800026277075, -0.38227947759285325, 0.21139950481152783, -0.20758421146985717, 0.10148741830906134, 0.08190516398600142, 0.021634043522024617, -0.14453971525207177, 0.036394387474085334, -0.2321826682149686, -0.20871584394279577, 0.4945430714018522, -0.04283409076286134, 0.6523683813565584, 0.32793858864511544, -0.010145433684345609, -0.12129981424017597, -0.06690005113353617, -0.18654322525733713, 0.11246573795615854, 0.15330356112808904, 0.04723935027775665, -0.06171811955986836, -0.13400230544327904, 0.25703822058665693, 0.11513371485933423, 0.6957422847360105, -0.2994841937295613, 0.16148618564135367, 0.14711777658944938, -0.07345485176409869, 0.13172798984734135, 0.4475563999844445, 0.2117391506185047, 0.2592446181310159},
    {0.09195753881697474, 0.264498444931855, 0.14319341129355553, 0.6555029767923871, 0.21966713348529263, -0.0683570538871559, 0.13151559529388337, 0.016546377194183653, 0.22566745497305027, -0.16182563963977104, -0.2403118625080548, -0.23206900139556103, 0.18917850884933818, 0.6325886159960997, -0.24593443065670814, 0.4278069267479226, 0.14277803432590858, -0.005746830188485272, 0.43762413438279146, -0.15795905148042835, 0.7095184887039538, 0.2909427240512472, 0.6212569657772619, -0.08051726954594143, -0.049256510414979617, 0.14190801132536907, -0.014109005949844669, 0.18875116839618447, -0.3216377368856776, -0.41684434203393483, -0.11823283681937671, 0.4704884838533083, 0.3165936737773608, 0.40390872654250737, 0.08555688877017234, -0.5712215344263216, -0.16982898279397995, 0.09526595805248399, -0.1441325102523305, -0.060060193143474196, 0.4958129229448597, -0.2734118414289144, 0.2071498935254031, 0.3516446866721479, 0.20451282087868117, -0.10038465619033256, -0.2069963688548036, 0.018097818516298398, -0.3801408364273509, -0.04850309224648971, 0.4441403953795285, 0.4127950748437351, -0.4329573764942318, 0.309032452357574, -0.4512544319582549, -0.4196659325843536, -0.1514070447607243, -0.12300290189497691, 0.39658355642229604, 0.07446537598268543, 0.09723086875325412, 0.4102372950764294, 0.3902092203693986, -0.21253581215562384},
    {-0.38984891403288124, 0.0533560600697755, -0.7084532720890643, 0.21820774167702872, 0.40864081822833276, 0.025874020743798472, 0.11336038123731018, 0.3007303836866555, 0.06323420111129364, -0.507103972951661, -0.08104175533332805, -0.29853582816122193, -0.5355597257152556, -0.2541473037436453, -0.6004371136298259, 0.5218805812274552, -0.2283725893007159, -0.2899868539920314, 0.6143860749959197, 0.04460809438180921, -0.26780003511753436, 0.10597340349742425, 0.17667119065354026, -0.27000884869260594, -0.6598822855562403, -0.2399164720442194, 0.2446834098752015, 0.023799230838975834, -0.2878359209622397, -0.027276400301875156, 0.3873026216681808, -0.26407356923923986, 0.23318009376500778, -0.0021166938365813834, 0.06297111611190209, 0.09462069938580904, 0.11444577156912271, -0.3509947584493069, -0.21604514034830966, 0.13210710990017435, 0.054413448793609945, 0.06499431176253187, 0.11377394541529924, -0.07455854639413301, -0.19669196172938608, 0.7671958729063886, -0.012941119441814624, -0.39286356799125716, -0.21582676483392932, 0.005144798867099747, 0.18452346077619045, -0.22026794793024493, -0.10298603422419904, 0.3815404453684136, -0.34293229912463, -0.6058382947697376, -0.17134180606261057, -0.07701033970484361, 0.5109331478619278, -0.3701081254165839, -0.4788806978939311, -0.09157135874164835, -0.07680604212966116, -0.513006829366732},
    {0.01706588741968297, -0.006277781697150953, 0.1467990883254339, 0.16582340665576042, -0.0922792578233097, 0.2055451826797855, -0.2584657465267348, 0.21334312966314978, 0.6532113874195566, -0.4403637310592005, -0.37304136131553944, -0.20003804177889242, -0.47950756922232646, -0.5101492856730679, 0.5158931493920907, -0.18083220545333986, 0.001415840773429179, 0.1267010574254217, 0.053812057955651214, -0.20037932725630758, -0.09518514108851929, 0.062073122596039344, -0.346260316344131, -0.1870452968818383, 0.11424109741642698, -0.0936556722683349, 0.4852385826609366, 0.059220806722330724, -0.036870880381650296, 0.2177012391049916, 0.5662489330149357, -0.4678425663288613, 0.04960265637359717, -0.6832837915390714, -0.23283814533422445, 0.7884157720657948, 0.17226693541101262, 0.11824642189482046, 0.16920177408187537, -0.029778601945734753, 0.007025458269538747, 0.09768736592048406, 0.1587526312437756, 0.3232378999572755, 0.2039193347906564, 0.3682445901424976, -0.0012711125052882713, -0.10780058580821986, -0.24323717506751716, 0.3869479714500314, -0.2532241196250006, 0.3391509620851544, 0.5302665609782276, 0.20539896631554785, -0.21150117292023332, 0.10399456180509636, 0.29782770943808956, -0.6582689792087094, 0.3414907863048763, -0.534296247986255, -0.16514938096967927, 0.10059824850219694, 0.4241096651731719, -0.2826242798800633},
    {-0.21832133308411233, -0.40133870213676487, 0.09752865940574935, -0.30664367939711673, 0.09285802112591772, -0.3143265777209525, -0.2605189556019866, -0.20213998015710333, -0.09854765695847405, 0.04626647379666082, -0.20851289833369965, 0.2330856487564443, -0.26352616909057996, -0.23299957992079337, 0.6224078748575744, 0.028583712606132478, -0.1469841155746857, -0.038677875897030915, -0.22288882981760427, -0.29021437431328534, -0.020390565389727038, 0.19518977622543177, 0.10931981604475989, -0.05159298912331481, 0.16485580644738973, 0.5187722590598767, 0.2283914895914303, 0.16836541486431242, 0.42136168313671357, 0.28649081188610753, 0.16634885023298726, -0.05416232859480542, -0.009203065240738868, -0.12774395180630393, -0.09258357953001023, 0.49138171696398925, -0.11310534629825388, 0.5491204709276182, 0.0068434966246900975, -0.33507727595413084, -0.4814853312154625, -0.33496250321373955, -0.25653281972037195, -0.1358508874475306, 0.33602559334318066, -0.2636621732954507, 0.017349364021028428, 0.05667872368384751, 0.027997657405652708, -0.09617830840501894, -0.34795896610165855, 0.3465923693330001, -0.07027379493565708, -0.06073605172008962, -0.44831672460418065, -0.12270543399265621, 0.5225343441460104, -0.5115507851138613, -0.42220743855745324, -0.2749020801439799, 0.09767183929318597, 0.311346275850148, 0.5189822252337236, -0.3610845241084609},
    {-0.15771259315574057, 0.2586469328438876, 0.00028095789342872843, -0.42999250714434706, -0.34390612774531376, -0.3637682141320693, -0.18329943479361543, -0.2551072717902544, -0.5001023600463238, -0.3047077070161364, 0.26407848140228185, 0.3180048214904822, 0.195219161161274, -0.12059687599591302, -0.4918675925050581, -0.14712291527343796, -0.4498477110355019, -0.3007433327235934, 0.1477536460801125, 0.1356216232409047, -0.11321060315036846, -0.009452897415992829, 0.13154588460452882, -0.18580079604453262, 0.12020288125606689, 0.06932159634539749, -0.3889893172903602, 0.33878597765481266, 0.4648803005350217, 0.27310063092050757, -0.3596654022757401, -0.3502849274940944, 0.17962039408128777, 0.1540289897178484, 0.0583851850107064, -0.277323987525534, 0.07553726819729414, 0.5590061874229031, -0.3743204107577966, 0.03565209570021913, -0.6643297523453752, -0.4807602758303559, -0.5080970898571366, -0.040463476736557626, -0.16240711726793508, -0.0803236752206742, 0.24789306835469693, -0.3388639569165144, 0.29023758835481184, -0.36715676582388995, -0.4304868105393403, -0.3041511606481594, -0.4998346075592835, -0.08002803000437929, -0.5872055946508087, 0.2648116660402377, -0.24322395314537468, -0.19038234384863148, 0.07578473220598281, -0.3659245638392705, -0.33746440403642164, -0.361387670473302, 0.03509935840091313, -0.24240539859265026},
    {-0.5382101145108386, 0.4030007732373967, 0.3206272604875895, -0.3295086545515791, 0.2827338150298892, 0.2665780076940403, -0.33197217305989235, -0.20106833345903738, -0.11663112885169696, -0.2655576871718226, -0.3239919188879202, 0.13988660063369665, -0.0053786817394360885, 0.18357301686518626, -0.27400598655328673, 0.112924464274075, -0.06578826972039672, -0.3004770387084805, 0.05593784657859485, 0.43014893419491884, -0.3224804828559244, 0.20402342027024126, -0.17452665276532758, 0.12071450012129299, 0.2927409217178348, 0.5753429922867525, -0.2608843544614943, -0.1875574579803334, 0.3272574025873657, 0.2495556404048791, 0.11310384270682745, -0.28577604406484747, 0.11949814446323453, -0.4006601407728451, 0.04632342748498898, -0.3391364713502341, 0.0320361627015256, 0.34576659696925244, -0.010093792253324253, -0.2129413177023964, -0.41077649544026973, -0.2811223859678697, -0.19061954733937694, 0.2513726817244983, 0.13457263740398445, -0.1391017035751425, 0.15951741417539314, -0.5521949054901513, -0.4348908928522724, -0.39285238125078487, -0.0066135762340294646, -0.044906657469015974, 0.01031511813419738, 0.5397049077365427, 0.034763939904886076, -0.1739297070055088, -0.22017889675531807, -0.24985473897875016, -0.20175022506333978, -0.4151762389743914, -0.41502161977551605, -0.390477507233359, 0.2145901543289775, -0.33156948396974656},
    {-0.14955742567331326, -0.10113021696382893, -0.20776293707018123, 0.11885340985868985, 0.1807546706393959, 0.06358415438446705, -0.5237893414380875, -0.022890865557141208, -0.15716685609248846, -0.1044441908008082, 0.22062091322845023, 0.5692245260501504, 0.16130516376595996, 0.29088154029164603, 0.3611766169228805, 0.07734559818118583, 0.15373620042286967, -0.27870797846709067, -0.1969899184983851, 0.034763630693119794, -0.5424706287582256, -0.15955918152454845, -0.05876807652143182, 0.15890253705422816, -0.39424799776517516, -0.2005160976662198, 0.31634425510142483, -0.36616784556173043, -0.12553161536843205, 0.007440661982679661, 0.44485073295187, 0.7432628391153177, -0.09996651582882041, 0.4034526931110072, -0.4426543222881587, -0.5758243259500241, -0.45919531749672, -0.3974045989914096, 0.15081970405378467, -0.24606955272744227, 0.7200154532233212, 0.39958395015658865, -0.04963013692468492, 0.3102127944738367, 0.11280844453141085, -0.15870743061797887, -0.30335695963869674, 0.11398856219775798, -0.2957034815681848, 0.6063204414997418, -0.0781191746903639, 0.021661982822971132, 0.010983498257273365, 0.3498579717596517, 0.6114481955611626, 0.5999256097488511, -0.16604673571820883, -0.13182762777815796, -0.17512410640413228, -0.35780022706750775, -0.39808762140976545, -0.07943255014131716, -0.12993028198472678, -0.26003060285097845},
    {-0.4714813370510785, -0.015359125442927177, -0.317444284035601, 0.02597263829185395, 0.10589130077182671, 0.11729023481638218, 0.13766617433127232, 0.014976556975162213, -0.1016984794478418, -0.36502966568781686, 0.14535747334488516, 0.09691324820099091, -0.020813703530536486, 0.3386045448116801, -0.13185256442216323, -0.11915207593607169, -0.06366607045762025, 1.0234973119289446, -0.1362276873726027, 0.12887204580622988, -0.4447274613576921, 0.0927401104674945, -0.10168241083541538, 0.17858799372101195, -0.007808590220648593, -0.2632105495861619, 0.30509950628339283, -0.1434113559034891, -0.22849842877664256, 0.04865816069425002, -0.05671972361373648, 0.1890816051481225, -0.5957739114216657, 0.2165782031647924, -0.38719848506279, -0.46098663159327347, 0.06917938138657298, -0.1552536353385238, 0.4197758183872878, -0.3079170583842449, 0.39091967674577566, 0.3359557353315317, -0.2026102734209101, 0.23983956740895726, -0.3181744326030781, 0.3006802833456385, -0.04943623202730183, -0.12000200224280679, 0.45479150523603135, 0.06678886432286757, -0.41566594664361434, -0.047894485246298385, 0.10376009774728875, -0.3042870074466807, 0.24966830486976804, 0.1735342838813882, -0.23204677473690535, -0.10056769407817304, -0.5216080466987638, -0.1987088272227911, 0.27778389173505186, -0.1329256058106187, -0.4151430471205975, -0.07864593783952076},
    {0.011118389775101177, -0.03779512860154935, 0.013231194157674818, 0.22395407737444165, -0.2296409919576121, -0.2463405880194252, 0.5420079537469923, 0.00028590531337156544, -0.26506797571289525, -0.3533138123629394, 0.11022856182397839, -0.0442206994085539, 0.07350813454879009, -0.24658059519342243, -0.15594733911193864, 0.18485408300823106, 0.17468922866032455, 0.13392539314886737, 0.1525305803774102, -0.2881969557472554, -0.02924977909179247, -0.019179774021371398, -0.37755569108703907, -0.1633765487442793, 0.21218713116816637, -0.3595724687909219, 0.13504224483058302, 0.07928837792039588, -0.5469090807489753, 0.2592178250203869, -0.0065725202286719, 0.07784336266479908, -0.07245159420332967, -0.2676945562249284, 0.45821597520996876, -0.034718586859366664, 0.18131719805659252, -0.12995827354965847, -0.2644079402923451, -0.17024554101001899, 0.3728240403449576, 0.00985291808297016, 0.37399418276901014, -0.3786362538504633, 0.020254926739554587, -0.03483917949876199, -0.40748082697182514, 0.13079814110872312, 0.2549095131218725, -0.4760883139953757, -0.04374030914308991, -0.1951826861399013, -0.0367243625858303, -0.48061988210616496, 0.8663630615346951, 0.5222730125372462, -0.11139097429567331, 0.5308220870744434, -0.07836602307594345, 0.2826866594010883, 0.2799294911058519, -0.35332358198087405, -0.0992751842910285, 0.30591490979338176},
    {0.10181800107978548, 0.1781529852061636, -0.17452364086193684, -0.2838613315484988, -0.18567636718026126, -0.22517973154768872, 0.45714803032320595, -0.2688996708519515, -0.27694872960554134, 0.14573450711609764, -0.21616768756673507, 0.020488817845353408, 0.0895075416163509, 0.23723849135349862, -0.2180729825149154, 0.25453502280771995, 0.34105035282047075, -0.06590746306980852, 0.32840452016898886, -0.4642960524270932, 0.36472109236563643, -0.3069190112349059, -0.1212241275423256, -0.48582656660970375, -0.06059917699632658, -0.5013690581781932, 0.6483728126248207, -0.10749873685550794, -0.0513203587694634, 0.18381411185357555, -0.266306206988746, 0.37671487094404743, 0.0928632267410056, -0.3935997918554153, 0.018001040197066102, 0.3989815276152697, 0.05574539666915724, -0.25182010966780816, -0.24722493444717708, 0.48890549472111094, 0.054863414513689535, -0.05992370973237897, -0.0005548009761903176, -0.27631394277237237, -0.20644880955378522, -0.4053426972699332, -0.7236753013775591, 0.477175353583182, 0.07155981857529625, 0.10864524568333264, 0.6845714003624935, 0.6614333792389879, -0.24018474402043688, 0.24323483450962705, 0.3874470517868254, -0.4328223093905012, 0.12263330181061614, 0.3217509786808302, 0.6172810099420802, 0.05319628341829937, 0.4969644247711709, -0.29797736888392584, 0.4464310273434325, 0.29075109822487755},
    {0.18177896185683756, -0.2013330689772364, -0.23959976486484239, -0.2998623889121042, -0.43003244755692693, 0.044274765544453476, 0.4995211991084864, -0.20935047462385545, 0.20139937609931824, -0.012595773154774097, 0.10939003685099861, -0.06035222383263494, 0.06746784042679983, 0.09121556000194327, 0.18405699954921242, 0.17069146416464592, 0.17188015839725088, -0.06834540604232536, -0.10994952659877374, 0.44022587026566534, 0.05091315382287807, -0.018776673937487668, -0.23582035728292006, 0.005623739894546045, -0.3135268910109166, 0.15152365164342718, 0.3213044084630009, -0.11313794252708902, 0.3683403332830819, -0.258880491877034, 0.3054549237570976, -0.07570743733465828, 0.07674267378039243, -0.18724575812390493, -0.0633767066235052, 0.4428738894548397, 0.25311979789937716, 0.37808839174673475, 0.2980045754838841, 0.5209657769323208, -0.18089777946516405, 0.2730330951533036, 0.19801079308074593, 0.22122803346155254, 0.1915856046431575, 0.033678481749719665, 0.02834901245402919, -0.18863582066668053, 0.03595009001023059, 0.1862078186243131, -0.0411217864308435, -0.46519532864183294, 0.035381548799207393, 0.06709753682551742, -0.2949275507658295, -0.0412801524437066, 0.3307242366871683, 0.15513203097827677, 0.08665963692191062, -0.11172765190996396, -0.029606556577671972, -0.09211997967175592, 0.03836255109664708, -0.2408286860189528},
    {-0.38947494878256445, 0.0477099080277706, 0.1227347162477656, 0.46431195314870344, -0.20697727345327413, 0.06868432423192197, -0.11298202410406934, -0.008822215043326628, 0.15762808258116445, 0.19949540480315836, 0.37013000402185514, 0.3389923144296186, 0.08499161841890687, 0.19899272080948446, -0.31873718968132997, -0.07643080373093747, 0.38712698737492596, 0.5830891902374437, -0.2683615447930723, 0.14083726367481444, -0.10357975460578892, -0.36869553394806365, -0.3233537069446866, 0.44886845012116017, -0.07580361269891553, -0.19510410776255652, -0.4842804142750887, 0.3431757954562491, -0.08733094577088693, -0.10250881292505394, -0.11759218201238164, -0.5294754305193388, 0.00014290117270040649, 0.7207142957156438, 0.5023018491323448, 0.1830273614609582, -0.30181402868491847, -0.17404289192196662, -0.28462864687035744, 0.05757109489967017, -0.2636566732555237, -0.12052482670057864, -0.2156125027776414, 0.35340597136108864, -0.32413244605948704, -0.003987254153743036, 0.4910734096403617, -0.5158026091121245, 0.3510355814690386, -0.38967125181146434, 0.24439525145644414, -0.25692804133432134, 0.324628030848203, 0.08679860711192004, 0.0026609334685387172, -0.4357502791280353, -0.46417553651222326, 0.20295654058489143, 0.10949131844978516, -0.24764918024924373, 0.29083333935247774, -0.21181863180475863, 0.005066107639636837, 0.5377370607713151},
    {0.14309949851179585, 0.11675076094546077, 0.4053640255077717, 0.0026956655625313287, -0.00022433287685148744, 0.10950988253445457, 0.2224774268361876, 0.47911949674259074, -0.061760775800701544, 0.623805537585412, 0.3606175088132818, 0.3665064348606676, -0.1378945839470063, 0.3730650170899009, -0.145118025600518, -0.2308101531339372, -0.3627212718067611, 0.3162489626902406, 0.37753887966118566, -0.008817103626039538, -0.2434898976138234, 0.20455397003123515, 0.34770914249277346, -0.006835043000151191, 0.4136514019552217, 0.45782217455713575, -0.13957864970756256, -0.24603800018904956, -0.2107343358148814, 0.023451981719517352, -0.34772626243209914, -0.13435463833752037, -0.06525496430315819, 0.4524054385700405, 0.10366851054725079, 0.06676167511028037, -0.23832935895337692, -0.3895408413814144, 0.022256819007206528, 0.15418969681212946, -0.17536630726600363, -0.26319115264617393, -0.1684168233928344, 0.3419757522401425, -0.44605628736920283, 0.1282756831037319, 0.5039357702899127, -0.009621759581215137, 0.6702848559926488, -0.008891627612155187, 0.00021074172193959634, 0.0978170736674489, 0.2213562550090603, 0.4522666004648759, 0.010421552569980222, -0.3952251792313146, 0.0012505843605880025, 0.010488116222946434, 0.1803262456017499, 0.4243033770871437, 0.21437776609018624, -0.08571139941450678, 0.18558592179729588, 0.16345117164863218},
    {-0.06888296079089488, 0.07240330734186606, 0.31199607706282595, 0.05320572226371452, 0.2233736428423214, -0.12515645082004084, -0.18755783345507793, 0.11531981046027064, -0.14317484541551379, 0.13053093330196647, -0.023167189533551173, 0.3185922360204545, 0.22853041894983778, -0.18684978178996084, -0.12389331318782663, -0.5397519261359903, -0.06460543484600609, -0.30765828587430843, 0.1045749987954524, 0.1058462386560554, 0.28984632348089445, 0.037577426598022774, 0.47222586149576146, 0.04694573363742398, -0.032644423897993366, 0.40848698176120346, 0.010546320809487895, -0.08269479962695482, 0.028544111747730434, 0.40648307440906384, -0.22821471187469206, 0.36867667211633526, 0.15367801609195014, 0.0867840442876853, -0.2029967899301381, 0.29928128375765595, -0.20839580163403243, 0.21208780056524396, -0.10511089965751949, 0.16764744932488762, 0.16074922758266272, 0.13885484578829468, 0.5052484780808436, -0.340854015494098, 0.1416246065421845, -0.05425236726789499, -0.19592102492242425, -0.0665271617771251, -0.36137085533959673, 0.314876444027359, -0.191609547209421, -0.0008301522354236866, -0.13201524514630963, -0.33339154861712283, 0.07842281594159548, -0.8444928484952892, -0.16580371051044174, -0.5191829963753497, 0.21312739287281024, -0.10265863539921948, -0.2970523766741943, 0.07252226945431442, -0.5247159912709057, -0.21927508533257947},
    {-0.3261656760622581, -0.3872526617635497, -0.14387708571378832, -0.37048985579368954, -0.000693896908170253, -0.1994086629214369, -0.09484285652270066, 0.2935330320437163, 0.11485108051012069, 0.33692549721978027, -0.4006082257986984, -0.020929402725008296, -0.5791402586717649, -0.4391483227424456, 0.33341136480701755, -0.08723986935491433, 0.5767263378586064, -0.3049267838893792, 0.01733954086359297, 0.002021167221044759, 0.0330379517257557, 0.04755437479665411, -0.227604714225553, -0.22035320296524233, -0.4113577677615116, -0.24010452671883148, 0.1241595600672504, 0.2346983917436586, 0.22371173415522738, -0.1178599157868602, -0.38330251372777807, -0.07509505264938891, 0.188653987713943, 0.3007858996651185, -0.24362987175977766, -0.0032188567921354076, 0.06293306686138027, -0.007595646411004948, 0.03266572289236955, 0.34823659409352636, 0.425965715894252, -0.14410757539972804, 0.15248358736486353, -0.3761878549373378, -0.022773722543507163, -0.19281223960859575, 0.12090722631818535, 0.12469509390925808, -0.1751763150368118, -0.09881638294945802, 0.0528796841217694, -0.33136722001644137, 0.025230213773796095, 0.0007067819546335329, -0.10013794822024118, -0.24477067455604581, 0.06362766687706502, -0.09018857368576959, -0.2058765765274079, 0.18759262346826058, -0.2557308785929872, -0.25766791114333154, -0.28652668363226447, -0.11379329435376671},
    {-0.19379947333304848, 0.09876261070658313, -0.051111089774159735, 0.018909643348909325, 0.18909296317352622, -0.04163442588699027, -0.08109244601850424, 0.1368562073877529, -0.14031072089516278, 0.4276528157715151, -0.5324899354639817, 0.05202103071945934, -0.488747878601754, -0.05681066545828615, 0.3703609154637044, 0.2447947694080786, -0.18038527357906015, -0.02014523145561012, 0.08573129137589044, 0.1942171607311183, 0.5725515303164515, 0.25994940948268797, -0.3184863477134276, 0.3167721651807726, -0.27901424301655936, -0.22550028778670989, -0.02500855527731733, -0.24104545609874628, 0.19322530480405986, 0.16868855848862568, 0.3488968140108783, 0.09007623002402565, 0.13179986474010028, 0.18763599357648056, 0.14001336999935035, -0.029506845369453145, -0.23792666285312777, -0.1865037575848714, -0.04939800479123433, -0.15690978061433478, 0.04039879123987373, 0.07570905478435007, 0.059853708806596274, -0.7455237103352097, 0.08028334299860106, -0.394146700950561, 0.3120118074084374, 0.5902939669469455, -0.13589537882340602, 0.1058835611306121, -0.28248513823479665, -0.5516326529798695, 0.07947495916359061, 0.27316181148691937, 0.022994533789519322, 0.38200688601350014, 0.33759456944543587, -0.061504480006182624, 0.06720215870962103, 0.15071945805019274, 0.06307409780343382, -0.26973500851141796, -0.09466261928648802, 0.6123031109356162},
    {0.05270848642715822, 0.46832506563056137, 0.052189411904813285, 0.22339910537276486, 0.04049699772385526, 0.11501287851418202, -0.061907441325351635, -0.9954507730109896, 0.1782127018123948, 0.14223072950740426, -0.2846501724009107, 0.009611149763374377, 0.32641348736956416, -0.13185180823864778, -0.11992319151257266, 0.21620596540597412, -0.14760703917421564, 0.10916317386481748, 0.056909713721121184, 0.41953137691639486, 0.5077447001356963, -0.11921379349194046, -0.32050478218206824, -0.12277249215990556, 0.11343899888120797, -0.4335795490274079, 0.0771150672587808, -0.16047521328174918, -0.277550231042832, -0.31414350412946934, 0.11054867079213905, -0.18966616530865338, 0.32519055200323865, 0.16938071625293966, 0.19967920667851974, -0.48544034423134014, -0.11808985301408134, 0.24942189685505703, 0.0223899393136363, 0.07808740604114468, 0.09034834018231115, 0.3356436203338254, -0.21431290111582002, -0.5697542343431862, -0.12772369694328695, -0.3542317767353599, -0.27603033680274985, 0.44182997103138494, 0.14080693207955475, -0.19441405358343955, 0.656069228740534, 0.48627519864099134, 0.02209948416071112, -0.2477425332570253, 0.05432005164745963, -0.023087221502669612, -0.005399063282767558, -0.21678928742222994, 0.6735499222384249, -0.01885119189673539, -0.1949702497677487, -0.300721427899043, 0.09597264494791387, -0.3326178154832707},
    {-0.506639450741407, -0.032385424654321496, -0.7389360290429712, -0.025981460468040698, -0.17852219045684217, -0.31827861024179954, 0.019304314601673585, -0.34701236727939794, 0.2562699436665356, -0.26599151939493326, 0.09167820122242534, -0.14125739172145396, 0.36869859390180454, -0.03201585075965105, -0.3995353281234576, -0.0676169363725071, -0.31910161960502553, 0.39541527984695723, 0.13790490221672402, -0.17059752342490656, 0.3645936513548043, -0.6778274984783654, -0.29459589739004477, -0.45912226841036585, 0.025527024560188665, -0.250868130018895, 0.14149064425182106, 0.3146853546720208, -0.0858166087371552, 0.10462457791136315, 0.5112060466129412, -0.17763676376641138, 0.09715267764830798, -0.00451157729296021, 0.5307035675527945, -0.39542537222538005, 0.5141432239103348, -0.022134414298196372, 0.4886573340630117, 0.25208707103062666, -0.17407559023187882, -0.0123137956998853, -0.07025301215894345, 0.17386049707464551, -0.49001725233889487, -0.3672552623957075, -0.025271625536840158, -0.5863391101491958, 0.1929526875347815, -0.18943277730377464, 0.31473681985457286, 0.02678595331031781, -0.0670667474181153, -0.03336460576924116, 0.011015249421565709, 0.5396193981378424, -0.3951878270339341, 0.6221972681470723, -0.07886021240050442, -0.07608243002377284, 0.14238607755141672, -0.24950011126464156, -0.2468809772038468, 0.058822022761124},
    {-0.0020170235244757182, -0.04122151890513731, -0.17346493407781086, 0.1419475256098068, 0.16109083567517882, 0.1925853881417627, -0.11253570256583713, -0.15136484609824521, 0.13711685700110363, -0.18504146091385779, 0.153557944872786, 0.0638610172982499, 0.11313655787687307, -0.3539921112545842, 0.002109897529192794, -0.10057866399536679, 0.09327465165463754, -0.05319403656312517, 0.07543434241914111, -0.13658643309094803, -0.46444574826319734, -0.23794305465631138, -0.06372150995053588, 0.6349175863660473, 0.07659228249863188, -0.35526295006922776, -0.31383743297945144, -0.09854493262240187, 0.19574104253606397, 0.5624569356302863, -0.6977198682841083, -0.07848488415693912, -0.12131219730008291, -0.09687142984861175, -0.3969904948722658, -0.3777334011351984, -0.6790791681663164, -0.2812191547158751, -0.3376278680775915, -0.30925150631114673, -0.46614266305459057, -0.2634950784464544, -0.23403420145116108, 0.3064288614600254, -0.06542207098298608, 0.1517537919952077, 0.025759361118394025, -0.2699169835338191, 0.31616537173654163, -0.022062969392333504, 0.1882020776934857, 0.0009011190986337477, 0.3773325562085701, 0.07131157240368582, -0.09576983114607573, 0.27984615197326485, 0.11755439316456567, -0.006062132991317366, 0.21809593665310958, 0.5185391925735053, -0.17367024294365668, 0.12383321206538482, 0.10110158332753295, -0.009970723056004556},
    {0.22762744364701043, 0.1055441286450351, -0.12891602882211817, 0.1639163206563066, -0.060147366215121525, 0.4255528841845262, 0.32250352284196454, 0.18936870012420975, 0.4453678942788738, -0.2196349737908504, 0.30068980550944036, -0.1902826387947094, 0.05302238309251854, 0.17820805664421555, 0.047088881449418044, 0.37646885141348885, 0.23136025872296098, 0.4599499693609101, -0.4673223040843774, 0.09409283307218443, -0.5556907504350578, 0.20462518579523328, 0.006652068299054355, 0.030588672129441205, 0.45506991465063257, -0.29839653685609313, -0.0042964229581321295, -0.0896454784915414, -0.1650040072197025, -0.11646571239809961, 0.015526330134245842, 0.0019498571295203503, -0.37821650781310623, 0.029915533605036692, 0.13684996090684065, 0.42290291868686214, -0.13688966744012332, 0.12913233183618836, 0.3525197683835221, -0.2502855404637538, -0.20427133179318, -0.05046001821504939, 0.0993196075412171, 0.0002816725514316707, 0.26776855513934733, 0.08237663451689065, -0.12931162690946604, 0.5306271967787304, -0.23066664221302483, -0.09310192439787303, -0.5351533407662694, -0.14925466825032843, -0.05575512396365237, -0.029648340720587574, -0.10980890471822248, 0.19827359187158441, 0.03930425148136319, -0.13336602856470822, 0.6854967534742561, 0.05810546298272043, -0.22967800893593468, 0.6177666878125289, 0.6617430000386009, -0.30479177268300517},
    {0.24995186297420532, -0.03918957438582193, -0.16532067613268797, -0.27204491539050435, 0.05413972725102192, 0.7312995420754649, -0.3964090381156384, -0.0667397982200124, 0.32899860657586827, 0.010935042837643917, 0.21037139308761685, -0.40896582567692724, 0.4216706359002701, 0.006050339928769659, -0.37444153314250683, -0.19078325241949043, 0.5664596075585906, -0.16683673065865523, -0.11926836376372611, 0.19028493150168835, -0.13984113443208804, -0.0023296134258455623, -0.06613399931333716, -0.6195938775329982, 0.4980307344384297, -0.21750179864684677, -0.19080375813476982, 0.3080638334143738, -0.04002555712582263, 0.23806704022228542, 0.2698348069405319, -0.19915175953535247, 0.26412378918926854, 0.6168949706833664, 0.610806873568311, 0.033036119572349386, -0.054294933575673957, 0.32748074883114714, 0.1188532322117988, -0.0339605894690085, -0.577887847967182, -0.21296028013474091, 0.0934154268907702, -0.08703933844063125, 0.30660501807165996, -0.17285564538116596, 0.23195191725880063, 0.2908270331484492, -0.1898451200674016, 0.04712833099711211, -0.008562787570686393, 0.04857606576791332, -0.6344880169398417, -0.1497326196403557, 0.28041959438240105, -0.19149933976063202, -0.21256443661985813, 0.3147337200291377, -0.2804166973965759, -0.038511305469278105, 0.06914556298121832, 0.1972406978393795, 0.1875026098555495, -0.022164417835843806},
    {0.04649158031477962, 0.23297833341693946, 0.059467568221030116, -0.1430556081370379, -0.04463677794840472, -0.10140650095737992, -0.07449297296795186, -0.020791672629935743, -0.3633111141172833, -0.13916992441197878, -0.47562240755558344, -0.16628827810837316, 0.05737151597192827, -0.019982753823082185, 0.2253691674797735, -0.20733582503778372, -0.1263831379758702, -0.08650144840697795, 0.40946872084733105, -0.35133755086344737, 0.03916130569283258, -0.09574518236697148, 0.5396087036254447, -0.315406585072514, -0.6177820074575515, -0.3597430817496729, -0.24453013765954604, 0.17671613662545757, 0.408688311496128, -0.2555965147457839, -0.3576021302041377, -0.23837022342710645, 0.12229904858706034, -0.2241547593060759, 0.2475988293790697, -0.11124532862433, -0.40007068670124424, -0.017923589345561552, 0.09304610037744465, 0.29847255064659317, -0.3633561191780453, -0.2962049013017547, 0.4407514321697001, 0.019588462129126055, -0.2624618188236828, -0.0318017577674277, -0.11713782094225679, -0.16888608727395227, -0.2886654688064425, -0.15904171125677882, -0.1342306879178873, 0.5841270550806384, -0.11415088834650938, -0.08766863969440991, 0.17614148743628433, 0.41125260194947455, -0.23047462080555897, -0.1465053720130157, 0.009180433120027852, 0.15503671961888613, -0.12574744668521423, 0.17776581981711365, 0.06716344537243431, 0.17163759367123932},
    {-0.18383579017565113, -0.44810633928651145, 0.11051451262751531, -0.28848587038737605, -0.20699522080897734, -0.5958659366148656, 0.15005268430871274, -0.24647950657000883, -0.11936733487403281, -0.26461101362184336, 0.09176355245917799, 0.05890760470473129, 0.4619372877087286, -0.11963116874608448, 0.05915764787492529, -0.37230780587259116, -0.3667839937610489, 0.3431049706872299, -0.18010074859449487, 0.4878429931914992, 0.017178396660290158, 0.004905190694425242, 0.4069689795051754, 0.19634095993873854, -0.008058296746724774, -0.5750260729307599, 0.43737610012537875, 0.15505243139217909, 0.12346482941095359, -0.2512936807651488, -0.11482476691604714, -0.04915916896097747, 0.07722250008278092, -0.3082194058737675, 0.011414418885624835, 0.1776317953478764, -0.23640112986865588, 0.27752126856933657, 0.2770943360258655, 0.322067496123172, -0.09619474807581786, 0.5939383353887103, -0.18955718424247225, -0.15819435948150676, -0.4518974640228636, 0.4795851489835794, -0.4966532971542092, 0.5234757961823694, 0.11907343707996515, 0.10653519143352524, 0.14533451430422242, 0.26220383793240215, 0.39149782390418075, 0.7201570957993996, 0.5213629154808135, -0.029369783704505242, 0.3221073659895613, 0.4388953301802432, -0.05872625218583062, -0.10924904961251873, 0.2231739780434497, -0.4743714910298381, -0.2028540629389943, 0.48537603392572004},
    {-0.2992315406594067, -0.13254723576710284, -0.38249926267002565, -0.42879993357667445, -0.33510712115897096, 0.4607193298014324, -0.008619117139663577, -0.2759982742725521, -0.01593703642371287, -0.14746600798624748, -0.5123558302750266, -0.008448676471420611, -0.02590832677311811, -0.02660735866896117, 0.05921643016680041, 0.2736171141501608, -0.40774141510326223, -0.21401997825211616, -0.5763933246574822, 0.08517371747955525, 0.06029289808768676, -0.39042124387728827, 0.13345960416548733, 0.16262030218286755, 0.1514508328014612, -0.040909982552782775, 0.13033774684223176, -0.022487196756593157, -0.19515258052080076, 0.28896565598063156, 0.6545247880085409, -0.7781665731833707, -0.3573068190658655, 0.10081491290339338, 0.05132846807757574, -0.02129941518667602, -0.1526657050025918, 0.06127768182214927, -0.10376171644142239, -0.07456575482742657, 0.27468095084615207, 0.2553280675457193, 0.1694120168106565, -0.4302255431557702, -0.01974798885166627, 0.20823958524419495, 0.22803421429646129, 0.11168485611512066, 0.24314628615686826, -0.36536557413418075, 0.24312014550343505, 0.4372907699697622, -0.39179819153332557, -0.10279940803535047, -0.3363801046593196, 0.0004401893503415711, -0.2325212893028061, -0.3543516239543936, -0.2814209168926035, 0.041817381378877055, -0.014536821490139492, -0.09817985325974692, -0.08565473862963133, -0.23613937849123187},
    {0.2718985234869711, -0.1835507032780402, -0.03118036295284749, -0.37842257771965343, -0.5166844384713895, 0.06959692404665288, -0.12426853263887754, 0.25249609490920055, -0.01891599698417242, 0.4090874965159103, 0.22197965215081653, -0.6515449260516667, -0.2880834674132465, 0.5958922661750627, 0.12256537879303817, 0.2074171380161369, 0.3270404491917889, 0.13678320975961764, 0.18764642295284614, -0.31650345559928744, 0.20743747769495838, 0.2655015976578713, 0.222084986653692, 0.18806780230652909, 0.2752891690796165, -0.22172897706024064, -0.5306163345384622, -0.02894792981413205, 0.3752883760767231, 0.029221876216599222, 0.37176172404918645, 0.2412245031447704, -0.11865096156377518, 0.04230235211990537, -0.039838356328281796, -0.5564004660742464, 0.591268739704302, 0.053887885855507286, -0.1992354313480332, -0.33936990744686724, 0.10865019630145718, -0.009337672077025615, -0.17552326419255035, -0.05018111232548917, -0.1614762034839238, -0.4532627140841031, -0.3283766576462292, 0.036741390742367104, 0.031216389083042795, -0.2259369808864565, -0.3990793499249549, 0.2535999869331001, -0.3050327448559944, -0.26678846677626783, 0.04636358109602568, 0.5746837940175484, -0.2332392311036559, 0.11591084597889796, 0.17414016499777088, 0.20825148033145546, -0.1742663875201909, -0.2941229084362409, 0.34435556614108254, -0.5008047548588221},
    {0.020456951960369875, 0.01928649933039852, -0.44089838137912685, -0.22307429927679187, 0.011857625907461228, -0.13148339688003477, 0.23255005458264244, -0.35931545204889925, -0.5094910527888389, -0.47806108296397715, -0.01704553192187754, -0.15340453761827053, -0.33626462534000273, -0.13108927257484818, 0.19439685390035183, 0.2937636224728383, 0.3406371059033649, -0.4222074631453673, 0.42015623411306136, 0.3535139676246141, -0.22357555594532552, -0.3401193248204137, -0.3088291083690323, 0.035500694171633894, -0.15384168698163933, -0.5848966228826468, -0.2382063064467001, -0.049643217547669996, 0.44955430948778663, -0.027092125893068, -0.3475015402788538, -0.0557789268135333, -0.4654510283156906, -0.2410710509325956, -0.055383498005905786, -0.11985200337320324, -0.19134684400644872, 0.1732780860942919, 0.17591030714607328, -0.09524580553367859, 0.2457678484882701, -0.02337657110322186, -0.14361128981911342, -0.2271186305542009, -0.015728597656617552, -0.07832758345915287, -0.0863177203402971, 0.11735258025413704, -0.2505173704102014, -0.11874691831404746, -0.39260696608840107, -0.19948697667742732, -0.05383616158925161, 0.23856538928734042, -0.21870438820876698, -0.5426638572231592, -0.061984861430066374, 0.08741456394052052, -0.39638330529517607, 0.09419311696750074, -0.453890202280995, -0.05321076886668011, 0.03004660258041698, 0.25508432616380877},
    {-0.43669042612844644, 0.15005283266462455, -0.3058136080096242, 0.3717951984053505, -0.10323949420774826, -0.08209366047269086, 0.20249371539351596, -0.047447995234857626, 0.020222393198602702, 0.29715722709665326, 0.13318668913821186, 0.016793205178167226, -0.03767767067910739, 0.03634422541376982, 0.30795318525569687, 0.3177039584537355, 0.03146911266078213, 0.028716178601770826, -0.15083558426431626, -0.09978939533888294, 0.6052308353504263, 0.013366952128602798, -0.10162589059235048, 0.007730935911084569, -0.23497448502603324, 0.02464770466998636, 0.02625501096477286, -0.13620425934199645, 0.30811634098041624, -0.13337931036945647, 0.4932114088341325, -0.13025208735276247, 0.780645128642627, 0.41307730647382707, -0.6746221539587972, -0.16103138151986784, 0.1758241799877607, 0.22278705750144842, -0.4454671747625779, -0.24169965342186187, -0.34007252324001624, 0.02944801960835213, 0.41067911813180996, -0.10930767664879129, -0.5056281707622444, -0.10261237260753024, -0.21798258714661461, -0.003774986651191976, -0.17955275510774102, 0.6763817228812066, -0.27693133158107186, -0.09443027570321183, -0.011981815767844475, -0.18908935673248511, -0.13153770845294732, 0.11908706785869327, 0.26674409434109225, 0.15229793282045473, -0.30512601289475966, 0.06284918771927116, -0.2313707612198956, 0.240145417131074, -0.03272589674433378, -0.4390214843452191},
    {-0.9185268616457413, -0.8920891632514621, -0.3570294396003573, -0.6157371986202117, -0.6494943652718347, 0.2741919631753161, -0.5050951798665111, -0.9064847908502344, -0.04783611466414716, -0.06096755039876896, -0.828072523930591, 0.20521815786700057, -0.7586988457860233, -0.6543542233935339, 0.020686581017073997, -0.42955168767506535, -0.703479952699139, 0.46154622348472024, -0.1509848116658548, -0.4496654268152328, 0.09443195332330684, -0.8173365448110086, -0.3551486682498077, 0.09323243299309095, -0.28689166569427715, -1.0270979781553717, 0.6935519237868173, 0.5298570261125795, 0.14698206042883377, 0.12037048595824898, 0.013453713496801713, -0.7533541638842617, -0.8363469475932689, -0.658798088493673, -0.7506232658177957, -0.3476979628830092, -0.11526140636779747, 0.14823708933260257, -0.33425331446434564, -0.5424477564685114, -0.7129395287104134, -0.08338258618130905, 0.13229383751756843, -0.19326649335930898, 0.3737977340957778, 0.04290958372080076, 0.08451037871192194, 0.42724742723274833, -0.8379482392822464, -0.1205964898132694, 0.55798794948738, 0.11948551688596895, 0.5963189067253801, -0.20016886887016982, -0.3927543490477785, 0.26030890647379373, 0.5948073141198967, 0.37632099277288916, -0.07708405757523133, 0.7008307061005873, -0.5859376158226266, -0.006236556049321298, 0.1996791697508499, -0.7902640509296915},
    {-0.6799018103986411, -0.732509541394843, -0.3123406653848175, -0.583751053403476, -0.5190479230893422, 0.38153287598294394, -0.49595488828796946, -0.7673241889391694, 0.3164147743445698, -0.7391495810968217, -0.6187804900199121, -0.08669698180874082, -0.3294225174089507, -0.6842983749825704, 0.05875525798488788, -0.8685816881710217, -0.5312317277689854, 0.7356274071800898, -0.5281775338278661, -0.6086764371098129, 0.25350621814841007, -0.901637726601514, -0.5198282087226024, 0.35419482630122756, 0.11035041918821296, -0.7073711036736677, 0.7217954004169538, 0.6717926162392277, -0.08168833891110511, -0.263328260605606, 0.1601242346340371, -0.39698667785697167, -0.46656385815008117, -0.6070973097865988, -0.7244158827720102, -0.20930500455348525, 0.09353658904481472, 0.8321284345529995, -0.5112733455149477, -0.5813337562496347, -0.49924850055063164, -0.4183804937329255, 0.44398848380182554, -0.5615565088910739, 0.38798825345576743, 0.17349136025306272, -0.24641651302313738, 0.30858269495750446, -0.6660624049503975, -0.6208137775829902, 0.2162896048330746, 0.26775112588939154, 0.22843535339929005, -0.4532113701884049, -0.7060796363241348, -0.32845628703042407, 0.5948345749244618, 0.6001341173253215, 0.3029055184022393, 0.6532576307617171, -0.6158724541290242, 0.0946454822709011, -0.12223711557528974, -0.8794210537751069},
    {-0.43941499606263834, -0.7222702159162281, -0.4903754839794734, -0.22106088418636377, -0.41902455164999447, 0.18411925407523674, -0.33338569358315956, -0.10616118209344375, -0.1954419783885936, -0.3781684187424343, -0.349965091403656, 0.17277633724373187, -0.2099092998574564, -0.5292356038419693, 0.4260907134011382, -0.4772371918294771, -0.34378592115215284, -0.18234998310703288, -0.16355813387617524, -0.19622244779987424, -0.02034029253583128, -0.6309856389362654, 0.019260680261380662, 0.6537686939000096, -0.11183677767205806, -0.43136920716278865, 0.06771124566211752, 0.2991399665757145, 0.43491297159429826, -0.038605825684720534, 0.07112092818289013, -0.5716899634331475, -0.40606850430380126, -0.47168587701161596, -0.5305082378100365, -0.459543604985526, -0.18362401045672777, 0.5234122276852934, -0.11409785467772837, -0.3949356371340767, -0.47037918294583536, 0.3213285046426649, 0.2567838234837924, 0.20321021847323398, -0.13169294435574147, -0.418374048801287, 0.5267540609527572, 0.3023035743869078, -0.43281352717968813, 0.06256042773078029, 0.2291880806466942, 0.35035421106351883, 0.16950428303837, 0.43220939551006093, -0.41492262682836106, -0.041020853898896245, 0.008883444268457436, -0.04095671227840085, -0.25531315359776957, 0.5596737865922976, -0.7278075596960105, -0.5555284376960522, 0.11941353655185676, -0.45005034981230196},
    {-0.20371146986836705, -0.43403273226475836, -0.3112449472713952, -0.2590317829722673, -0.48280599914318884, 0.20923714700915047, -0.05702097073669623, -0.7239536598888797, 0.2506813731291371, -0.17044199029098447, -0.5762640625559112, -0.0037231989902951376, 0.21663970930840462, -0.28210333107643176, -0.45039585593480425, 0.11807467621990463, -0.4347543295567104, 0.5985017095028964, 0.08169359258260005, -0.17572145902763972, -0.396278395231548, -0.1902165464546928, 0.4564101523811841, 0.6903039527364438, -0.34403897299179176, -0.5693591302348997, 0.41436095986336086, 0.44051636231336744, 0.040463271944470955, 0.4275196571857493, 0.16827468159727227, -0.7272856066512219, -0.41098788127935915, -0.5140717917103513, -0.014789787703010596, -0.34563284828457475, -0.4487118521421907, -0.15874583660546648, 0.22902770107361528, -0.5894845385771237, 0.20101078959183788, 0.26251503981809493, 0.03561128361704157, 0.11727727240299031, -0.4232471709819491, -0.2138773456730187, 0.21090996497510792, 0.032210591532500776, -0.47011959025964994, 0.21286493268325404, 0.46176369933706407, 0.10476680991051562, 0.2260982259433396, 0.13902676524962343, 0.1794227664015076, 0.45299906278020796, 0.06993119242542838, 0.6023452079116545, 0.0008350913714156965, -0.06330477968372338, -0.4650934818121082, -0.7310602538679921, -0.41517450894030733, -0.17693258593048355},
    {-0.09599487432516747, -0.5295494758110353, 0.26530319271012104, -0.5062921770383241, -0.10763527370644524, -0.4954617724829503, -0.24520716669661927, -0.5611672660152547, -0.2810612760114526, -0.5350859568102092, -0.5236297929612006, 0.803872723519193, 0.15999817868302849, -0.7062533730207701, -0.1306803246030092, -0.12835024176591986, -0.4020452147908128, 0.38849234423515794, -0.4588972221316752, -0.37243164510913807, 0.2731236047914812, 0.2593470604407212, 0.13298478502931393, -0.02102933512533689, -0.20770720265710155, -0.23868385501332817, 0.7243829082892985, 0.5125078303495462, -0.6408277158289033, 0.12891564269742845, 0.26146426956032803, -0.25471378891440083, -0.37716390511414466, -0.1234917396182133, -0.21648542922432934, -0.13656923409059502, -0.600495894809324, -0.2024198354223794, -0.06712362940117544, -0.17794366743584047, -0.11005587162537253, 0.2430767022168169, 0.16837997522463521, -0.1753020925017481, 0.5955176115975532, 0.08708343389363868, 0.6956344022290986, 0.2566951771217126, -0.6238005813898645, -0.38326243653570385, 0.6766283102167944, 0.2716047547299558, 0.24222987534759496, 0.36193321885220264, -0.2966583779492148, -0.04487723874732095, 0.33169285857519815, 0.5339632261897275, -0.2801262520508006, 0.27695975065852935, -0.17156381810324978, -0.5526220298833173, -0.3244553635023601, -0.08748339617133259},
    {0.15912089458813997, -0.3214691876815382, 0.30060582096495514, -0.42724822681728414, -0.11497410777165042, 0.6109457828119746, -0.9283859177002124, -0.1737754268811413, -0.4315004225485499, -0.7682564888044595, -0.7572639014632552, -0.2754457947050068, -0.049714801419458984, -0.6202739489369502, 0.03630276353878617, -0.04772629492091822, -0.561939154204813, 0.5851405242219236, -0.15033010430448446, 0.1401111942428046, 0.22346857487913388, -0.12071226113457957, -0.283050809049859, 0.08769902633391886, 0.02507348294945628, -0.38911434985291204, 0.6610647217714744, 0.3788335671527241, 0.7072361256690498, 0.34123958356126816, 0.4461212023302951, -0.5596539122658848, -0.06799731784903235, -0.1504250108652997, -0.3713748689183325, -0.16373723859730308, -0.27972742569182957, 0.25193964940749863, 0.0030289553197485283, -0.8054331086336748, -0.6452433315417827, 0.27957776717621574, -0.07546812909751087, 0.13548137787815734, -0.32599273350611824, -0.00992114567849748, 0.5148720709966229, 0.4426275312311325, -0.4255346271713359, -0.46806482503730595, 0.359306037535187, -0.2032116201072445, 0.1762641915337801, 0.04922389416924914, 0.23085794605287469, 0.5671309504955544, 0.30026927784006924, 0.7117113542643834, 0.2854392855630398, 0.46860646561353997, -0.38586213877926406, -0.3646232025690294, 0.13412301859783776, -0.4058447221310356},
    {-0.4917856076604477, -0.5883914572791586, 0.23538340068826125, -0.631340697014488, 0.08695737606770376, 0.1409938315269919, -0.8278046061476376, -0.25159497057789915, 0.24615372147873416, -0.2268936304719083, 0.21941423313110517, 0.23042321725943413, -0.2222863065604705, -0.029470970862458118, -0.08422560728213067, -0.35570715631936783, 0.07859149723639107, 0.15475780762252025, -0.21282795417792452, -0.07476877873415143, 0.07209494708416263, -0.2651252046300615, 0.262710339353673, 0.42346447501200773, 0.24142067882682383, 0.09689095357839157, 0.7553873291144709, 0.5146679161883121, 0.4339311804974881, 0.04792841610639959, 0.3293268109136229, 0.46719552040238127, -0.4233481496020158, -0.23468327898775648, 0.009176058891315762, 0.3265747391293976, 0.11276434051481284, 0.054483514872250234, 0.12004056178516054, 0.019151601358956626, -0.014233729032991697, -0.006458564102160014, -0.10843784329421367, 0.02431601706817545, -0.23342372518483595, 0.23574079375458748, 0.2612392362042713, -0.3884317073655301, -0.12212877132813457, -0.31055703531825224, -0.15064391962329227, 0.37277671345648816, 0.633804582201263, 0.30717454131899463, -0.10393354466217569, 0.1496733529083534, 0.05435918911750042, 0.34471905501307604, 0.2580219061254884, 0.543700380214367, -0.1988696587777421, -0.029490138240028586, -0.0019081419363829555, -0.18350720337553286},
    {-0.43952735889738087, -0.3456097674321682, 0.40768865292388395, -0.9384629772614228, -0.6168304198621399, 0.5123513410857523, -0.5185907025698474, -0.4744962667492813, -0.40468864495684037, -0.17631807658933876, -0.5450708569740219, -0.5180261909031608, -0.060309548619525644, -0.20473384114254978, 0.05279479205937034, 0.23683630652293625, -0.636235928156712, 0.26627858066362925, -0.12228052561489049, 0.06744826011687914, -0.3029108699972728, 0.30264530185797417, 0.38111341338085614, -0.24818166810605422, -0.1355060583277449, -0.1292299806399113, 0.07629015931134703, 0.4368027612923786, 0.21749381228419665, -0.33687204443197893, 0.22463958574266948, -0.13683870210367097, -0.20390209295801157, -0.7264575883632394, -0.13790410182010235, -0.08752449096492854, -0.6454811272670821, -0.5713728196418711, -0.36504686530181535, -0.06185498391209631, 0.2608423955826257, -0.5663661571325667, 0.0915610531274848, -0.9565788723983242, -0.359768524743324, -0.20797105056525145, 0.3533967153313888, -0.11870391534695293, 0.012461889979444989, -0.18747969678701992, 0.31649504291088043, -0.40946519525763275, 0.41473824025839273, 0.18246941584854878, -0.2525489905082628, -0.45051472826629696, 0.06056239105445312, 0.2478719450791023, 0.181932110480913, -0.2618098439187377, 0.20912894768717705, 0.39111720646638337, 0.2721131041346349, -0.35345953527702195},
    {-0.5164106415926744, -0.3948317292284546, 0.07595723045741458, -0.0466248401773732, -0.5275332640214329, 0.2265755106629952, -0.39499441534456436, -0.1563924720808352, 0.1022873016003158, 0.047848769641896494, -0.20333396167726464, -0.6523661947803333, -0.36520480943569866, 0.16623754610139804, -0.22400838851966676, -0.3773551155455125, -0.10896039518964663, 0.2861081559830525, -0.43535776157116735, -0.11407430773722525, 0.49595408996062623, -0.49059698180012834, -0.4144829584973419, 0.637546630000265, 0.34269428363977555, -0.34697097154365186, 0.3249008972928333, 0.5499334776856254, 0.2555953100664965, -0.3097886740275364, -0.4050166614804974, -0.281190292272934, 0.2126857067303273, -0.530508760305764, 0.1379555949500934, 0.27744640822376077, 0.6902809551698132, 0.44269271887559397, -0.4206431263386368, -0.48916857634181005, 0.07774644061320678, 0.25402562902993614, 0.5662739027060503, -0.39836847068707776, 0.3052949461522335, -0.09517709681390116, -0.535710285451311, 0.18863666581076605, -0.5098686606555966, -0.07259323008068756, 0.7234708039887612, -0.09830249030256018, 0.45589656598834366, -0.03757833788889463, -0.5892552170461357, -0.7432977506798063, 0.31291810126993025, 0.3124462475788648, 0.7569156311992022, 0.47146950801302645, 0.2463259563901227, 0.199812392456468, -0.2544184773438755, -0.5606104713293752},
    {0.09467081795330079, -0.7125225214313022, -0.1714917539663638, -0.40702091085933495, -0.5689721621140049, 0.5346368136038182, -0.36771719914111245, -0.3872178362353513, 0.7172070179356982, -0.07082154390765671, -0.1288734641825096, -0.4739081679248411, -0.21492642282317898, 0.10485858162255113, 0.12857785034820185, -0.3345991692468453, -0.2582830658636432, 0.33504463028410886, -0.30212622810946604, 0.1654541343431978, 0.4211103922717746, 0.3556630337346451, 0.20462448662141713, 0.4961143077362129, 0.25663178837601247, -0.43123198149144043, 0.18846440864513167, -0.2351351448788657, 0.071717934879334, 0.2832879774780981, 0.32601894775726886, 0.11097604860488379, 0.31446746645664075, -0.865192016468562, 0.08276501996512314, 0.024275101733037912, 0.2856629492276908, 0.2968864569010533, 0.4226380912669015, -0.11267366569007856, -0.5173610459941753, 0.05382561359220661, -0.21120864734720401, 0.3692644253141089, -0.3199199074177215, 0.7137814017214696, -0.22984460086600225, 0.393257470937392, -0.4169294170279008, 0.4121585677606244, -0.5681066759805905, 0.018613663573387937, 0.3383208008557293, -0.3412233071072773, -0.16658723954111035, 0.5168211430765918, -0.10195739651798592, 0.6786272672994271, 0.4154869073664737, -0.03182495607236991, 0.24555723329913087, 0.3497479406915722, -0.7178302017595684, -0.29997261532678204},
    {0.31461920925708925, -0.2596705053291989, -0.1849527775499204, -0.4066590121962874, -0.19478016361985004, -0.1458301906492892, -0.3033790070748994, -0.2802992187226467, 0.3920861833101694, -0.5654180586794276, -0.4760001743988952, 0.012032625328398713, 0.5912090507171556, -0.8078185002708094, -0.060671816280701577, 0.292813076978669, -0.34661718430162036, 0.24739181095533114, -0.4411069480601307, 0.40139541324226985, 0.23715593138701677, -0.6823628549256952, 0.1904392472619185, 0.15453060775669591, -0.11595285611228069, 0.04942599583874698, 0.10641159682569246, -0.26240881002659133, -0.017922267963367024, 0.2684456507047723, 0.008891414032623958, -0.6348197125073403, 0.05183844213729488, -0.11751056482900228, -0.4888636270623677, -0.09672207853550281, -0.053312342536193255, -0.09827713700011488, -0.5588729143469302, 0.014691402732446948, -0.17797415543377157, 0.3742263683494986, 0.5323758759463152, -0.1657624063893767, -0.12053044303928659, 0.14604547627076767, 0.3379356654791891, -0.2422200254473883, 0.03625513904664469, 0.30076333360821317, 0.4537408838381506, 0.5329377301937318, 0.08877215282845553, 0.2741622348663364, 0.429179230935415, 0.20597845467520634, -0.2213348837042047, -0.4445114347417655, 0.5477812825775521, 0.2187200595030242, -0.2389621807404007, 0.011768898727439723, -0.13486966138685458, -0.05689972323157579},
    {0.2449376481919426, -0.17832467616106823, -0.2735504703495209, -0.29776618026482354, -0.27759617772752654, 0.38014976432727837, 0.4843115916643375, -0.010045406676872351, 0.19450323759122776, -0.2766564018489739, -0.10288882353795831, 0.28271255111630694, 0.3182287377117073, 0.17023860165586488, -0.24713137469927438, 0.4310063314741177, -0.08460746679566998, 0.28524641938603645, 0.060593585534815884, -0.13884057271118638, 0.4493021498299744, -0.09863168055598148, 0.040279681179474926, 0.3389357517910102, 0.7894858422626974, -0.004842270911995598, 0.10864321468504239, -0.12312660621802127, -0.36671528040833706, 0.5283403863599939, -0.24030947326797036, -0.2949330881597625, -0.20632963674571847, -0.2631539562515652, -0.007582905792382609, 0.09645374287573599, 0.21920268461180034, 0.6237194099603244, -0.2995106564724063, -0.0024767154267097643, -0.30610734979536874, 0.6054109193655848, 0.17282769143930368, -0.005879488640196798, 0.04236037118747665, 0.33951477738670477, 0.3087555548332854, 0.04633298967984195, -0.0231395067793028, 0.4729303185090799, 0.8944914498996404, -0.594317743427623, -0.12271567646323003, 0.6050138517357228, -0.15082868899347732, -0.07925259845855655, -0.1985905563141223, 0.23207069628117485, 0.32950377623325566, 0.2255788744739538, -0.3185905205667565, -0.4721665682593712, 0.23777688681690992, 0.16041812129944877},
    {-0.21788853667345737, -0.3071282786591837, 0.4071678379489575, -0.6414005623763881, -0.32531891789981376, 0.05476983796874575, -0.040109669291522106, -0.5684866027484532, 0.44950413197910305, -0.5123656812369688, -0.8191626168128073, -0.532487396640174, 0.12879513838210396, -0.31018254525500855, -0.2156484058075738, 0.27733659054750914, 0.05979566770039782, 0.5541755693982575, 0.09406785158104035, 0.14784171956152162, 0.6082261032111625, 0.07202306899570264, -0.3917843161976444, -0.01670062545439507, 0.2642894242633644, -0.15319594650281093, -0.01478971826360816, -0.049347826219011036, -0.6208530714498737, 0.016370361208481767, -0.011207463175532123, -0.32422302205786074, -0.4222745717973006, -0.0971349599402488, -0.6497801317636943, 0.28777114847309254, -0.049342513016124114, 0.26126313564741627, 0.23305564216355898, -0.24030529904373593, -0.260075494806706, -0.5016316916446762, 0.09810045821497392, -0.1915079521864104, -0.25690319071967693, -0.281712726798714, 0.21157245802081429, 0.4030447080901979, -0.03878448640599256, -0.20003249970002665, -0.25466027997986695, 0.41546741373624624, 0.45404228237342753, -0.07923112738363344, -0.454044735122244, 0.26172296536019185, 0.4413621853812991, 0.2519181062869979, 0.1332888902792014, 0.14140200125343888, 0.29069461904076865, 0.289846212764643, 0.24060729668465247, -0.13196469976754138},
    {0.12891770673960187, -0.4029988918956296, 0.40431841675774016, -0.09445230575921314, 0.23951758203845483, 0.44340751667254735, 0.049471080295433525, 0.01074923244659235, 0.02027495319744067, -0.3678871178703188, 0.2594136047795792, 0.3330925246333404, -0.2783088988129262, 0.04549692346609159, -0.021071960593177338, -0.17815366213916115, -0.32995231487734383, -0.43863923389688614, 0.18962061491475923, 0.29410050958458134, -0.06383157105266986, -0.0697263480861873, 0.16783594061527518, 0.29249898811136077, -0.4740611099476975, -0.5572560111585368, -0.4594105381126822, 0.636728650504801, 0.5842761210724879, 0.31583599013988617, 0.1715544520920906, 0.15703472248707082, 0.7240460664863235, -0.47491462607125, 0.09861381870990248, 0.2316055061124892, 0.08373798854132217, 0.18582725762293584, 0.13944495669713158, 0.4074614854817751, -0.01777414234950383, 0.7265307166388363, -0.0754381800575631, -0.12794582110581024, 0.20080342579745808, -0.17388026328542203, -0.46230403242289225, -0.5241139112319768, -0.3328049787036491, -0.46329768616477834, 0.17874662911214903, -0.1554703929063876, -0.013390648426251211, 0.8874816470892393, -0.3866221412078949, 0.14543382460641294, 0.15260286014506216, -0.0736414752266209, -0.2042515994650277, 0.0004470201757299807, -0.12084534403270906, -0.3676665133741895, 0.22163876543402145, 0.19437552392003196},
    {0.2307564102008672, 0.11682777666939653, -0.5734375728980793, -0.18978982773836625, -0.27277814363938785, 0.09445223180167295, 0.12283303125441163, 0.2089992741874021, -0.050195948131908266, -0.38079451904931005, -0.6634980737963159, -0.38853402625701905, 0.03167101152142685, -0.06810302983951481, -0.4152666559270793, 0.20447337230531643, -0.015335738479081996, -0.18636419878772714, 0.4086713482590906, -0.011664633400763555, -0.27383709063481615, -0.3186035546930547, -0.01703616949783099, -0.3988975892825471, 0.05274276647449413, -0.24776676012791074, -0.08174324971699141, 0.2534423423977238, 0.16184207722050453, -0.3149332362573901, 0.09678193895302259, -0.20303102810777313, -0.09520780043988507, -0.18142190630125793, 0.026574714190116044, 0.16828869389070908, -0.6895638484548845, 0.23643009797830714, 0.24004084605651133, -0.4279773871948589, -0.24522042282884185, -0.10297289686383417, -0.027466437580010227, -0.6710792144766465, 0.3578798220197353, 0.1660402206931496, 0.030449186847276776, -0.29209906324694146, -0.40719270035637717, 0.6185026433282129, 0.11755866028411599, -0.3334083074784313, -0.003571527276649563, 0.5681288439172737, 0.005725322465022105, 0.008352912435087635, -0.2105570522921562, 0.011586128313631297, 0.02391440727399679, 0.43088735422062324, -0.43219500968738683, -0.07581861949960383, 0.36684526285028984, -0.2833348475734285},
    {-0.3772587121171508, -0.24387622103558076, 0.24336045636866505, 0.1219135770787194, -0.029148680060205587, 0.18219552395591657, -0.29406086868277287, -0.2699663177969937, 0.013858793051400848, -0.2865554544265643, 0.05078736421041148, 0.23344060590494223, -0.5332487088968527, 0.3675335994580077, 0.5073433718614139, -0.7409749657351558, -0.15518006101041262, 0.39388275582877075, -0.10006122993529705, 0.4622829699285566, 0.26895929629595605, -0.28596938217860673, 0.10125432875124303, -0.4523594861257591, 0.010252667695246059, -0.799819209902065, 0.5206181528003343, 0.13640402201527024, -0.7677632670974367, 0.2660519273411216, 0.3691736874123741, 0.043793345984676345, 0.031330093238185516, -0.5764825872711045, -0.24618643220660313, 0.29326714316377317, 0.6144174313498686, 0.2908887841392347, -0.6319719568447217, 0.5676410688819328, -0.31495561972278563, 0.019164126899878453, 0.1814959081932752, -0.5416431480362283, 0.5374768940268649, 0.07446987629848002, -0.41804669446144754, 0.19666812902086878, -0.438126149650266, -0.6978383182655122, -0.023616939647230436, -0.21710675907567148, 0.5376205602312748, -0.3438300992789788, 0.09015168364852447, -0.3420203106907802, 0.43887622262385373, 0.04735334371010977, 0.439095251630468, 0.5461465231234797, 0.3603981698764038, 0.47348908584295696, 0.1846005135055498, -0.6445926033525402},
    {0.12001142086792523, -0.10215852457009383, -0.5224333533445251, 0.28803539923798455, 0.10647543369842814, 0.11797586643614691, -0.32455485086854, 0.28042155546053, -0.18140749897182518, 0.0041192783577343834, 0.0013253312238591661, -0.6970417721936636, -0.08969674558469021, -0.3065081676020911, -0.10599868871956072, -0.5321918897325829, -0.4597342518679299, -0.19515164595293852, -0.21181316971389924, 0.3640410196022302, -0.04967613838450344, 0.12246926179213226, -0.33026944804512265, -0.5202242810696639, -0.28989268993293726, -0.5245521321977736, 0.5936281491238744, 0.6275341226648175, -0.4676502301115635, -0.22085177627172495, 0.4141462960993305, 0.37653488143936614, -0.1494452180245741, -0.29906558119731874, 0.02317828008850223, 0.13460030543349932, -0.48702397780699114, 0.11072145082712986, 0.11699302098417531, -0.3126060463804954, -0.16407912904794136, -0.3499752075441258, 0.543209254533875, 0.593935822269825, 0.18146938695788045, -0.2498301974200278, 0.49668807944543353, 0.2230249788135203, -0.2835444146004164, -0.30855704653655924, -0.23326601984909892, -0.468461316781251, -0.35409980460614027, 0.20622830447857773, -0.14304809670638033, 0.11973834979094232, -0.15175375581908718, 0.16288901866096198, 0.036956901706537724, 0.24977308414126842, -0.03902291083855817, -0.08414749222031175, -0.033871875303802076, -0.3850419493710352},
    {-0.43226439910003395, -0.118166880875348, 0.02093297787171324, 0.20370638587012183, -0.031946204526680594, -0.17712954741282483, 0.334953597852433, 0.1966953249754137, 0.04055520382823106, -0.17438699343215877, -0.36270259555526774, -0.04504469416882762, -0.5232406426816639, -0.07469363791837945, -0.21048614853880251, -0.14389451734055783, -0.08281089189125916, 0.004664601324022962, -0.554370348670938, -0.21129376304236377, 0.1789042758729945, -0.19962604096380934, -0.27981860070184467, -0.4635153864673638, 0.40057634657806696, -0.04148658562054433, -0.3162399412046602, 0.14230762726773566, 0.10099087187809223, -0.36442237980688363, 0.05812865113906023, -0.29347596321141495, 0.07409561181265939, -0.2613772767798659, 0.03414741395633646, -0.29386643404177554, -0.16062130024751894, 0.08902945812058609, 0.22346576266045334, -0.32601820082798, 0.342850691240335, 0.2263624760525051, 0.24938452907882824, -0.4147091835269267, -0.6657999660470075, -0.447244549877463, -0.20810503353907495, -0.05766419848769428, -0.5712838543326515, 0.31513811966401545, 0.18353438580814072, -0.589800592739796, -0.34395902987792454, 0.2856973382805387, 0.16797424546140974, -0.05101825324864914, -0.2945033438276711, -0.27973897203970155, 0.05573153045180434, -0.09400122037754059, 0.17836980293184154, 0.11959428245258635, -0.5822816040752278, 0.03186618595203576},
    {0.3594223767003815, -0.8091277973078493, 0.12360351568559654, -0.1971088319274733, -0.5952989396249472, 0.25181522828413394, 0.16130196253988174, 0.16447404496194729, 0.35705337084863564, -0.028310928269797697, -0.03517246243349696, 0.33539879470784667, -0.5152853078976075, -0.4622622327380201, -0.6417930060801129, 0.41074286702543283, 0.16782480113866693, 0.0024165013245091085, 0.3167811247131601, -0.1777436604306508, -0.11060657742615444, 0.33759066619949246, -0.21442186188938173, 0.1916558071047314, -0.7208954989471236, -0.24940282989190307, 0.6292189636545463, 0.5372035210019196, 0.7582376230448903, -0.1057310120786045, -0.39990353231736164, -0.537319861272565, -0.24727905551643334, 0.5972663389260053, 0.19632893954069114, 0.1882730442219118, -0.435581429829485, -0.02308947663857365, -0.07677169277805021, -0.21961448914257325, -0.19996114984219557, 0.1955882737839598, -0.05853710094706898, -0.4290991310298819, -0.5269883575749744, -0.0047454241291698404, 0.027484321301345486, -0.6424982048892308, -0.20948655152124568, 0.20461602110108895, -0.051844081280515576, -0.17001417749983178, -0.504964389335003, 0.5250939229268327, 0.5084177112321158, 0.012923904893511385, -0.27789085973504213, 0.31827764604746717, 0.1524171510145263, -0.6773994018055288, -0.15773130777937694, -0.18517878288843106, 0.03423281965759692, -0.32578084569041577},
    {-0.3056476482418492, 0.13052310394381417, -0.19513381998961044, -0.03228565742181801, -0.4113919567252678, 0.02209729045600418, -0.4777424636367776, -0.23294383469965513, 0.3272866095836824, -0.3797837060516506, -0.5097426266742011, -0.27590413572648487, 0.5101014012789535, -0.46230568007858336, -0.42820254589645174, -0.17178500511685202, -0.590813652731, -0.17384156992431196, -0.3620851297182934, 0.523664219806369, -0.07293545469027243, -0.22347577213512484, -0.08951252933560488, -0.04820938842768433, 0.03803339978334386, 0.061972210904986384, -0.1562677371546019, 0.123589094458591, 0.2595544136072124, -0.093100103888768, -0.2576113411978584, -0.38493383722648356, 0.29538547629839274, -0.31281701969398734, -0.057897058446783146, -0.12170898711759448, -0.45945814960576875, 0.03523937127193307, 0.6513631369442954, -0.1495028111395113, 0.04477527296922162, 0.38807411795058605, -0.07269073417112833, 0.1979580288485115, -0.39156615980875675, 0.6444165576804942, -0.011211499288539227, -0.24076957867390913, -0.4066998967514751, 0.038169541706499964, 0.1705750023976366, 0.07670462663296052, 0.425896218505701, 0.3615591694059483, 0.4518668743165395, -0.17607566386285586, -0.49115553985714083, 0.23736921825433335, -0.1872982359624383, -0.3768150693917876, -0.4374902614987244, -0.27820839024411453, -0.7260065894788086, 0.19778120882436426},
    {-0.017387966797491897, -0.4085109199614014, -0.41729520524086455, 0.09083222181293801, -0.7396300864723879, 0.48327067168983984, -0.0001597161482720056, -0.35941958765184295, 0.4264549360062861, -0.2562899989668423, -0.6552588379554029, -0.1592433613565266, 0.2315990309942062, 0.21784672860602355, -0.3960260464130733, -0.7020379099327392, 0.24821050684851192, -0.2585279831095803, 0.1372971099169822, 0.6589379005942215, -0.007916551705639619, -0.6471461772203609, 0.10417102677492557, -0.5274158976245491, 0.3282642085283687, 0.14570002205209343, -0.28583185692657137, 0.470601891583103, -0.13593749192071056, -0.1165464536016241, 0.10344792080905635, 0.48562955176827743, -0.07780952448992978, -0.056689610432130236, 0.46486379865623234, -0.02113102164758079, -0.233285254089487, 0.20417926587737315, -0.17127013993909374, -0.5007805040128606, 0.6024881833111754, 0.9689683502315725, 0.01598428791206989, 0.015638879336247632, -0.29545946562460107, 0.19337762776571302, 0.23119670652432325, 0.6225501893847399, -0.005362987367804843, -0.1499144522991769, -0.053690968982169865, -0.2930686554244251, -0.394904342046316, 0.2700377357229489, 0.7795958093965042, 0.4127318803577389, -0.18741893088659003, -0.09950571345592095, -0.09127820070264894, -0.04935648568067262, -0.39646808397263483, -0.5277214287058161, -0.02030768663000498, 0.33739048907348895},
    {0.11021817887662613, 0.31760381850285196, 0.25658045874330426, 0.7998830287279156, 0.2231824632989198, 0.5683615225774253, 0.522174728970035, -0.4437792489989557, 0.5504300921992109, 0.46539030152844046, -0.43630598251601516, -0.19911150349532844, 0.498418958273894, 0.27085035066608343, 0.3135581509772789, 0.14223769830558874, 0.04350429615875746, 0.8694892646092297, 0.29352466437308494, 0.2890115846497244, 0.251023480033087, -0.5294035374658832, -0.3559319779006638, 0.46011570548236713, -0.1338104638191635, 0.09318572541971387, -0.3353463392856545, -0.2735459322659688, -0.08985118465491237, 0.27357086375069906, -0.05860442328679772, 0.21489214237052567, 0.7636237301192389, 0.07665485690380389, -0.1493236152658103, 0.42754032689228016, 0.0028860920043279484, 0.2249524018059841, 0.453622922882285, -0.604479234743305, 0.13546883408130359, 0.4598714197531615, 0.5544862837495945, 0.3425432139806571, -0.10658211664727432, -0.3356036635891656, -0.46838826376329773, 0.5733195824956804, -0.25751745042341706, -0.07407674176326685, 0.1766102246795769, 0.5500469911284446, 0.7166117269526636, -0.19382119716800167, 0.14661566977017415, 0.47081655625556323, -0.06353321708601582, 0.12993765533727492, 0.008050386599500515, 0.4404999180820555, -0.0022414678382212494, -0.010156584245544378, -0.13233838793154454, -0.2843107910586918},
    {0.1186501175057335, -0.030104903217320757, -0.18162150716284264, -0.04946573791427873, -0.30344088243321593, 0.19606057365977358, 0.38590811500261774, 0.09526114199509227, 0.4690872493346542, -0.31450729330320043, -0.04511402832802721, -0.17987994585999842, -0.14439617062379662, -0.0653066123446864, 0.09265443215795158, -0.5213968594922113, -0.11389795258816394, 0.04374894622719535, 0.5568631969839147, -0.6728989773594606, -0.15549749050387585, -0.26590229908668583, -0.13060319947654186, 0.0738460221233756, 0.3224729050006926, 0.05056036128421941, 0.854446560704693, 0.5452819037932793, 0.23149448529216546, 0.34132446246551573, 0.5328889028233755, 0.19092987725744764, 0.07249380759620828, 0.4476638236083122, -0.11332693697772442, 0.08570108721674297, -0.38508591944975284, 0.38425075571203715, 0.5904360251633112, 0.4217168537276872, -0.14472752814071316, 0.11462185263775976, 0.21260853206636543, 0.0846653359115865, -0.583677066761483, -0.10582804136756199, -0.013651714617096041, 0.2957710337369003, 0.6585278084180133, 0.4743433847517389, 0.48543547439184404, -0.7940723615765576, -0.08790036852450225, 0.5066777128055888, 0.37167939239349923, 0.36334263716093135, 0.23895556120540776, 0.2775372014218115, -0.07520774016762742, 0.16554834591152054, -0.344139586504638, -0.2771012891817736, 0.23787724275162755, -0.525361517786869},
    {-0.5796935647548961, -0.48786773520762394, 0.3595483936134985, -0.16046836847818247, -0.6035874209959136, 0.4046110819520963, -0.23435517732139752, 0.2579854404904055, 0.0544798456147836, -0.27548862407059055, -0.26886397125707395, -0.42009867913077253, 0.050412685354704966, 0.20832283584555253, -0.0814706880603061, -0.04073592937581614, -0.06865642058548185, -0.056435874348984026, 0.1850836034629763, -0.06481575571686962, -0.46705369392488605, 0.049525871659822106, 0.04314601357471378, 0.14141925394000995, -0.08958821352714794, 0.4733519481339141, 0.1965379616684971, -0.25721952672759846, 0.42032792217656884, 0.11928375726262894, 0.09177001395837454, 0.26684035147516083, -0.5585325128859696, -0.15897401996388885, -0.17499906337018029, -0.23337066622682157, -0.11587443443411143, -0.48939934673029933, -0.283912701728205, -0.3337583106614571, 0.5985200593123692, 0.36724898652697124, 0.141691248715485, -0.3829441965037913, 0.31628122356876764, -0.3386453506820327, -0.38229152128519756, 0.10735404263963225, 0.01627150476110212, 0.6685506099106554, 0.37312803580181375, 0.1443557677260514, -0.3633115040011917, -0.4486357111999889, 0.6933909925213679, 0.08362104679310949, 0.16177904957512695, 0.2341005196765546, -0.1178235658646711, -0.11265030783803325, -0.18675788512637215, -0.6927274695254656, -0.018035743806671372, -0.5465450046752331},
    {0.05044169265975202, -0.2500007598747019, 0.2639626772753893, -0.29122114711937536, -0.06222042436585795, -0.10682459815423835, -0.28785193277894466, -0.625988076363095, -0.5158359622921889, -0.28740627441479727, 0.06518001243084275, 0.09458550240498052, -0.3031521159714009, -0.49218386303407746, 0.0115240448377136, -0.06696002622467215, -0.3346363145207607, -0.2658065441783292, 0.2565113669131597, 0.19896844852883086, 0.40538339087318104, 0.1999517475805602, 0.0764952340085325, 0.15491298855934582, 0.1237123424049855, -0.054076611960989646, -0.4785251247182988, 0.12712850466139095, -0.40558220496793, 0.16217395029560353, -0.30188206731837797, -0.23059339662097963, 0.05404549163643292, 0.2963509787666253, 0.13229429949985141, 0.3333895815549927, 0.42234944156606574, 0.2096848042829952, 0.42225956057701236, 0.13789653721200476, -0.16359955711976953, -0.07658219855825078, 0.496745470763942, 0.14473236137019363, -0.49334411628855657, -0.46884533458820565, -0.36293534130321714, -0.2208958958184374, 0.16528768065321042, -0.32302823845509204, 0.2031171900210759, 0.28206798644722564, 0.40577984814188955, -0.011014723126505734, 0.18163997302706178, 0.08600897598160023, 0.1890592058243494, -0.5954215979195346, 0.13304637924483761, 0.04131526377920317, 0.05745054370094025, 0.19193332399093027, -0.3094386531040482, -0.2714160020795616},
    {-0.44921954454075386, -0.01660246753686584, -0.12363098162197933, 0.906244307597156, -0.07401218534444198, -0.5445581517920902, -0.4149374888382941, -0.1694860062162183, -0.1228161934841387, 0.04153502996462041, -0.4252334292959691, -0.32291832578845897, -0.34047551072948506, 0.10001704892451259, 0.04699497411927497, -0.20255870163978862, -0.28166669494753144, 0.019569775389632404, -0.3661312134070624, 0.5831233229199146, 0.3483460716186189, 0.2985103889011807, 0.4248730779532754, -0.4790505600084871, 0.06966866098618106, 0.02000460816590775, 0.21515654814602717, 0.4547529358243989, -0.09396514490340468, 0.04311559680239366, 0.4783701440033685, -0.322858797387613, -0.15943837872207564, 0.06390335713496556, 0.02140045891411612, -0.4291086379884754, -0.43978691790407326, 0.22010658142055586, 0.03639134650945671, 0.12901532147471273, 0.06107056979092018, 0.4008038133305558, 0.3732385950211986, -0.3511163012643297, 0.5489576441914187, 0.46148654031549163, -0.3140451055366696, 0.1898231399989469, 0.1738102520052728, 0.18102676687257113, -0.25774474148382587, -0.7807564443008222, 0.5155267371626007, 0.33115191718616116, 0.09982571059892703, -0.34420108927561194, -0.6500069810629525, 0.6149587371214633, 0.09660521659827223, -0.026684341361619516, -0.31770254097720835, -0.06103637073123793, 0.15492653098229864, 0.0848116837230309},
    {0.11830402020510573, -0.32809305216065926, -0.3243525586392078, 0.06867576029804802, 0.24334326022995706, -0.5827696407236962, 0.277391329317263, -0.10219969387340712, 0.34763615602756887, -0.2108939798544151, -0.35192967358521626, -0.45538542831641277, -0.5915583909414301, -0.08562462457016239, -0.470323851144521, 0.11326496339576084, 0.24499755152340782, 0.424869944207528, -0.1015817680541574, -0.16901064671921592, 0.12671873592053984, -0.607404156054359, 0.18276248277782137, 0.9043929463558014, -0.12416073506410305, -0.40603999115927986, 0.3420001976988462, 0.03884384116224357, 0.07886582727492257, 0.49578695473669593, -0.026080608148327494, 0.41887053454165263, -0.4218297776875119, 0.1336423568988014, -0.4819957259607651, 0.31246079239927127, 0.1853608572660656, 0.2996134507835222, 0.19123984173256448, -0.20429529719959455, 0.22028697731554617, -0.2876152429083919, 0.4265772350234062, -0.33133802297947856, 0.09586199713276723, 0.32625147905806384, -0.3974612648792224, -0.07049584518480424, -0.2226113230905083, -0.04032990661978528, 0.17169822952999877, -0.07796955043529417, 0.12897113665457918, 0.04981913808019348, 0.5438745173414584, 0.11622976729604169, -0.5498056549799374, 0.22144158610095313, 0.07393761307122482, 0.40652194971758776, -0.3988755077580762, -0.032538325037274426, 0.2999047486857643, 0.00388115375567172},
    {0.282234563287606, -0.24550473575770063, -0.08963628196705725, -0.17426076871583013, -0.5010218423262304, 0.39379921585428174, 0.4358437477525835, 0.22595644263233533, 0.4628252718487676, -0.4230816588628167, -0.14107013786473577, -0.5175570340193721, -0.4829272716268939, 0.26141852519548753, -0.09454605621961636, -0.24774328276893737, -0.6373551157635208, 0.6038907976543758, -0.4183988496474022, 0.23854973380465508, 0.1650538264496079, -0.07240255452767429, 0.04533048796851793, -0.21755465447981784, 0.034148020456765724, 0.3257675219856455, 0.3485359119331316, 0.24311343603232655, -0.037387993435834634, -0.011593981722699955, 0.5392193405080241, 0.11608508104509402, -0.2874685199050356, 0.05286222135153846, -0.24320528420061735, 0.5456365337697884, 0.3866955892828793, 0.12730485380673778, 0.24078584345339246, 0.17963322645487179, 0.9437465937750792, 0.2923261361958499, -0.6099157766826571, -0.03809624924436258, 0.1250008903751334, 0.4150669688240763, -0.17115872589063244, -0.008647273263759612, 0.34268162643315747, 0.26365997765199656, -0.08241012913879213, -0.2425799533518819, -0.006268021044339009, 0.22640962881904916, -0.1363335644989197, 0.2531913538190355, -0.15206126026738914, 0.16028842763696485, 0.5755056110885765, 0.21524469854754977, -0.2651540233135663, 0.20114373380465095, -0.3462078699213905, -0.22230920703801477},
    {0.2114115384883377, 0.5206768034585586, -0.3825186053257703, -0.4689433968684761, -0.0161854249557579, -0.0037826012810807563, -0.48939951838823853, -0.17217389981343514, -0.5155986005441339, 0.12470920258903884, -0.573108821422126, -0.041812850000527105, 0.28129369511735436, -0.09607138946284803, -0.008548660507361541, 0.31337612528646835, 0.1330162256586104, -0.5662031589882616, -0.34511225774695015, 0.29675792641614773, 0.5732474680412178, -0.03516087124448215, -0.18359049758672621, 0.1223746131575052, 0.5081627205992871, -0.2500898917420254, 0.08450919631281556, 0.5489572541983899, 0.06705401305067868, 0.42056634378396346, 0.4091779945771013, 0.07232243714084255, 0.4124198309571309, -0.5724549416294309, -0.1452474646816214, 0.4176407038239515, -0.5477341573834316, -0.19503987771155284, 0.08548198914961108, 0.20909494253832625, 0.3807457000528432, -0.14726341280513988, 0.5993031316350514, -0.14857778555092163, 0.2792413040372264, 0.006916518990552463, 0.16378529145037643, -0.06588484557714183, -0.08077258779719959, 0.03682528139803902, 0.6894014475666861, 0.7299510169449372, 0.26688204508660235, -0.15656604559514603, 0.4977459522115456, 0.31473742955303946, 0.020418499570249726, -0.16286094858532132, 0.10307373105870911, 0.3495033725658729, 0.14922283300884132, 0.5560475594915772, 0.44011364897268873, -0.4774036763318711},
    {-0.22709652107213274, 0.02495730219638901, -0.27311860598309523, -0.10884144778473516, 0.37434376762330135, 0.18382324533187774, -0.4640462116349824, -0.47015673517817613, 0.6973606089498559, -0.18556836401821536, 0.20870996928812732, -0.40808214428795264, 0.26499905776604304, -0.014250694935356608, -0.2253176308075352, 0.2800026415885378, -0.06286905950065748, 0.07681064315156282, -0.6227867875482143, -0.09548225813876204, 0.15508863985993518, -0.3392394925525988, 0.0849717539418928, 0.1058340220925285, 0.39464746528413186, -0.0054939131194807755, 0.3753118802820207, 0.3547761669192693, -0.23293322560887658, -0.24607291541697737, -0.0027364048304223763, -0.39169541483510834, -0.16971522358240956, 0.26470141451229906, 0.22049921365608025, 0.2736124824084104, 0.7494408340429561, 0.36468487254792764, -0.20377163223193503, 0.2291382344360917, 0.2192162144655638, -0.56087196414262, -0.14665459005373047, -0.4151954506180907, -0.03930951493894429, 0.5500175745136975, -0.3051014885144858, -0.06398058614400698, -0.5775021814658345, -0.4488404468205964, -0.38248463508663394, -0.3810216834311516, -0.022169069281338306, -0.2033832940503238, 0.09986171064034778, -0.5953234731705299, -0.2731036294547139, 0.012826601484996805, 0.5783808973319883, 0.1403736040269754, 0.13815528743793828, -0.7507145762699561, 0.6620059828590601, -0.0031241638629334804}
};

static const float b1[64] = {1.0068456108755874, 1.0047324302219862, 0.9187218971892452, 0.8247792125536941, 1.0497843557234285, 1.021340105337619, 0.953928994145826, 0.9609451911549838, 0.9690253921568418, 0.9152830392758313, 0.8514097950931737, 0.9091103292016413, 0.9259659501090096, 0.873148235911328, 0.8606531389024287, 0.9934343091227311, 0.9159822865700314, 1.0192262146752398, 0.8748917868325856, 0.9212458774750589, 0.9691081359348279, 0.9409119386381984, 0.9038641083530243, 0.9936354413833841, 0.9658033603074434, 1.0305709605219049, 1.0308453303694032, 1.0066738432130315, 0.9086909555455412, 0.8135722975801558, 0.960458044977905, 0.9181318897775889, 0.8392569518360166, 0.9475328649125578, 0.8600614561378241, 0.9739008286952365, 1.0800359955299295, 0.834610974765876, 0.9716432730740538, 0.9282616794389832, 0.9779103740179206, 1.0137400515552517, 1.019704939782234, 0.9218464471802358, 0.9451200959830617, 0.983370626069767, 0.8807008287975363, 1.046642425873797, 0.9416450800472514, 0.9103444233591163, 0.9685296210696236, 1.0193407613893606, 1.046006085300782, 0.9861503779632376, 1.0234103412217026, 1.0265360089971927, 1.0032116529043884, 0.9532358502998727, 1.0617102751583944, 1.057344103297902, 0.9343707688672015, 0.9996060774331401, 0.9941183533707136, 0.9748369607412141};

static const float w2[64][32] = {
    {0.6890593486995124, 0.4332994931745634, -0.11210898195261007, 1.044168423076138, 1.0288738260138752, 1.1280944380835403, 0.791906710359426, 0.5979496504804502, 0.6947312386045379, 0.7911915075267681, 0.9850994734697781, 0.6602469357820938, -0.10710444675877856, 0.7209824407289183, 0.8985280724126263, 1.2092485187227382, 0.06660805101433097, 1.1710435337636578, 0.7910949750493218, 0.8578099600894066, 1.059122916034284, 0.830466016192725, 1.0138295637380623, 0.7459896344746543, 0.7998288186193467, 0.9339668646370856, 1.0720367846594188, 1.0330519269746752, 0.8182023846097419, 0.20043872616941621, 0.5456287371364598, 0.5501678715319273},
    {0.7175987884853962, 0.7571996827942925, 0.002573690565461059, 0.8893216270061609, 0.9233179281285796, 0.8231809743737188, 0.8356488249954651, 0.783312928415211, 0.9298019023890467, 0.9600424910089954, 0.9377715047740088, 0.915740383694921, 0.09997224219482698, 0.7693387908391689, 0.8174640530186603, 1.0723054342969185, -0.38893668774410967, 0.8009431015766122, 0.5868205046597074, 0.6536465974084026, 0.9354610909979933, 0.8164094442287985, 0.7960992568285582, 1.1780510075306254, 0.9852238202710465, 0.8210503656927918, 0.7764148222808493, 0.47522175739453426, 0.6719797390510434, -0.28382048110405084, 0.6730802512138812, 0.6668487830616763},
    {0.7031837979806072, 0.7512464422290116, -0.231946429123893, 0.9006930731059485, 0.89718253264689, 0.6678392390262002, 0.9811343134751128, 0.6543273380808634, 0.8932401752889277, 0.6521779245154263, 0.7376073501618097, 0.954241745875265, 0.06826005018471601, 0.7084545824842168, 0.7211399323061491, 1.204860288453315, -0.25143955617702896, 0.3585723476381878, 0.7711320817997461, 0.595481398719314, 0.7710120610493246, 1.06911477466826, 1.1707956480928912, 0.846377238406096, 0.8534881018291017, 0.8328750758931772, 0.9936809789747553, 0.8954945190417896, 0.7903212128303697, -0.10151856866437481, 0.6858822067183136, 1.1076096423022979},
    {0.7138739423852546, 0.36470429413365485, 0.006547870939638861, 0.5891742512865188, 0.8279150259318441, 0.7959816840869551, 0.9005070602364001, 0.8233950491268996, 0.8700586985200963, 0.8857473413529475, 0.7425768405808761, 0.5625601931433454, 0.15741567995055655, 0.8111867376422278, 0.8401174414374437, 1.058924545441703, -0.0633051510175986, 0.564114905267677, 0.5968509876904025, 0.821848961748844, 0.8787246851710908, 0.9106391344765232, 0.46297832428541674, 0.8802963674618229, 0.8247261706272111, 0.796784570218573, 0.9028169312405794, 0.8553144095433132, 0.7933713482786834, -0.04915130589985197, 0.7788833016225953, 0.9290656923528491},
    {0.6005956264680682, 0.5519463358501994, -0.02663898023426384, 1.1999560156218372, 0.7931998253634485, 1.2311687419533535, 0.6802757291964401, 0.8008788104525258, 0.8043436348830034, 0.8964251147832388, 1.0317573956129265, 0.7870145691462481, -0.19987856122392575, 0.8381540753064954, 0.8295197946230622, 0.8977220611065294, -0.009599630889749036, 0.6731551550834048, 0.6658594029261476, 0.824336226455552, 1.3428392064514798, 0.8057257005003056, 0.869717581572573, 0.6383105656709435, 0.7685856724628845, 0.6950159107496, 1.2023200502508062, 0.8653350226021153, 0.8632897943349159, -0.10033966843061794, 0.7907864189153712, 0.6978211017862779},
    {0.660848166598156, 0.7860871842339938, 0.04822219777086841, 1.0509959754769016, 0.8693592328755001, 1.1704640800245492, 0.8581867714625946, 0.6377877028040203, 0.9751207733164551, 1.2507654132916919, 0.7720146914926478, 0.730115638976523, -0.23724576241849835, 0.8838747057042748, 0.8028344302566802, 0.8331681427165405, -0.1287118245436627, 0.9264221768577258, 0.9117838072722358, 1.0917383955125697, 0.7387570422193247, 0.6957936407775813, 1.0214660683757923, 0.8983312071242442, 0.8318480799829266, 1.0502849525797888, 0.8243579769843336, 0.6357152931665909, 0.5189211906567396, -0.21962816531393278, 0.8346415585900303, 0.8182563729813392},
    {0.8280680578352793, 0.630748498288207, 0.10632727308590478, 1.222560250202578, 0.7237716865109732, 0.7024737495858853, 0.9075834604620071, 0.9261698719769735, 0.5940376572213647, 0.8683928860050135, 0.8474197205557931, 0.7091968620347188, 0.2261561196685815, 0.7931579876197902, 0.909815824192051, 0.8620359156906184, -0.004264849709810522, 0.8601261356295677, 0.7931032521093911, 0.804650089327797, 0.9023289720629936, 1.2612532950314788, 0.7742600597441262, 0.792741588121503, 1.3092188177130557, 0.6416378930943473, 0.8075399222632411, 0.685795149919111, 0.5342097104174365, -0.17270323515026867, 0.29135817973389194, 0.998106747931136},
    {0.6500891420490539, 0.6833028601956681, -0.023861271071786816, 1.0880648165661366, 0.8735567871191374, 1.070008326402877, 0.6577410614587619, 0.721530351308557, 1.125303398722402, 0.8666570186092064, 0.6513151847438063, 0.779330108075203, 0.08840837469856136, 0.7498738449008835, 0.8824732419258444, 0.7916767748823098, -0.23621489283273223, 0.7725625431739921, 0.9848314278950697, 0.587669751776418, 0.8004470973564742, 0.6297044517752585, 0.7891485541736666, 0.4767375447147502, 1.0470806214654553, 0.748208749854554, 0.6725886051070208, 0.8055613044738876, 0.6387560857482465, -0.07124952130636052, 0.8678910920416291, 1.0244916461533817},
    {1.0556270203988243, 0.8560820852474939, 0.02066126620887857, 0.8331636209445643, 0.8129460451718479, 1.1438617231139256, 0.9985428709732662, 0.7659699908536315, 1.0372619327763137, 1.2904989457082505, 0.8300053634074912, 0.6085923837261082, -0.06106693723277796, 1.0522337271264939, 1.101512083726389, 0.6318005511005362, -0.16023328045073737, 0.6148417406965458, 0.8133679623320796, 1.0374592274774925, 1.288051522166347, 0.8998372107956957, 0.8831886846089629, 0.8903790113803013, 0.5619109004647475, 0.8950376506468241, 0.6976483797129077, 0.8559911566668184, 1.0296662872804359, 0.17325134993876987, 0.8892186829717348, 0.9285242252375727},
    {1.003982973865068, 0.6995065942808392, -0.04670049366261555, 0.7922440687633793, 0.6485866968745387, 0.9409232923695381, 0.6845279915027284, 1.0505912096969956, 0.8452170403119992, 0.9804964192621275, 0.9863147480287361, 0.4546897326667514, -0.07212617976864631, 0.8585361584386448, 0.8086296285160004, 0.7564020558753766, 0.09587057674760151, 0.7625804674080643, 0.741438185236748, 0.8292496065600048, 0.8112367378336665, 0.855996918227717, 0.9765122579280671, 0.8254693605885175, 0.8423347016415308, 1.0618616910694403, 1.0023819691997906, 0.6742618202214857, 0.4158442815923335, -0.07150946460417784, 0.5099313967843991, 1.0168762478734552},
    {0.9686900358413243, 0.5432486282159253, -0.037508556040114854, 0.8013977623390741, 0.8674074930478617, 0.8708494551026188, 0.9887324225765978, 0.7334318032927085, 0.9136858190542404, 0.8145789496677732, 1.0448929930981123, 1.0754339297545044, -0.040875128158456044, 0.8364299746797659, 0.8285191576571544, 0.8591368762286877, -0.3272284065823199, 0.9203776755357984, 0.5615089174082053, 0.9694565707973667, 0.8966224990221571, 0.9524574436136671, 0.8887428579493625, 0.6708676363101185, 0.9222062650894589, 0.8604773665224582, 0.8635100591000244, 0.5070594029751528, 0.4263876724434858, 0.22083373534337827, 0.4286667890602329, 0.5789801850595628},
    {0.4894545819118134, 0.8788379136325664, -0.34648996524659353, 0.792461270066843, 0.9154630398404607, 0.9563192470503219, 1.0381669580192852, 0.7696706022045313, 1.0311971125175263, 0.969776287357954, 0.6692359493839904, 0.5501663721797058, 0.14655013918688667, 0.7066380177855199, 0.7922694274845041, 0.9335799105930304, -0.15799842639632788, 0.42722571986200936, 0.9940427846833595, 0.811261283389262, 0.9087006442238785, 1.1627218063953602, 0.47221660250371345, 1.0183111508143858, 0.7655847808309513, 1.2424734341782397, 0.9402346930258102, 0.7963485007860118, 0.7843987249908387, -0.0030890090430019633, 0.7228822284415933, 0.8529671615109935},
    {0.5287523961774714, 0.6284278985566076, -0.1073676085506808, 1.107316654897022, 0.5442671541250192, 0.6364315956761403, 0.5465204795016124, 0.6355484197351483, 0.9739858923626904, 0.7463674936339092, 0.8197031420149632, 0.7353820383482594, -0.12167451635177805, 1.0201957144168068, 0.9498703866190376, 0.7062818195833794, -0.21100756871133475, 0.6879896180694154, 0.8009307728614717, 0.9341907146653394, 1.1094906006503786, 1.0232126461215836, 1.0506993425916327, 0.8376561358499763, 1.3689509347942206, 0.7671107247477528, 0.8770993888141, 1.0597464605526696, 0.6023532661320264, 0.14873998335968833, 0.2762450719427062, 1.0390517955333813},
    {0.4518207178752838, 0.9730121194294206, -0.1904394876219992, 0.5193891448646282, 0.8038046067100639, 0.5670618707198378, 0.9168143899758018, 0.31854922238119326, 0.9457561198713549, 0.8857618533791701, 0.8581358084234605, 0.5591153775481028, -0.14397042763940973, 0.6870243974745559, 0.905003111369629, 1.1859508032949544, -0.08565341648870835, 0.5410729836682666, 0.7761269344596343, 0.8950958977647576, 1.0958426797266814, 0.938211385254157, 0.7941911514612352, 0.6955323145969592, 0.7815800265285469, 0.8628814638490094, 1.0319149510178982, 0.5766734217292042, 0.8861305532207107, -0.1938554752439705, 0.5276565896401207, 0.8501461278965607},
    {0.5824820944577692, 0.587154570452948, 0.17543832617978783, 0.8082447864396167, 1.0943340853268135, 0.8371801972420151, 0.880649325323862, 0.9855779281864121, 0.9309314223782182, 0.8261950858757784, 0.7916756711083774, 0.8865571426687238, 0.05639811404258244, 1.2593983941976445, 1.0812790128960406, 0.861183173289388, -0.08474115513813503, 0.74717735052738, 0.7737247172798305, 0.9398004512604651, 0.7861403702760683, 0.9674853306257696, 0.6971842025895036, 0.7388592859785588, 0.8450242259294447, 0.7732742414353498, 1.3459514665030243, 1.012130976399928, 0.7223783853808413, 0.2551923974809069, 0.7454890076953783, 0.6214280726003139},
    {0.4545843153350624, 0.578251083997074, -0.30973253570372355, 0.9232334785679877, 0.9788134064528852, 1.279763282896504, 0.5567554267211734, 0.7741013906616925, 0.9586117417411505, 0.9312928526457505, 0.7272727228048388, 0.4880240426148326, 0.3535667363968927, 0.8579852161642957, 0.8761466375942515, 0.942604585585208, -0.2698706877751805, 0.926552031624264, 0.9026840499311068, 0.9213689833324575, 0.9410559401423958, 1.144559992361808, 0.7011452307407191, 0.8649538354336516, 0.8180653901748335, 0.89692527707389, 0.8621678762541518, 0.6175629445250829, 0.44263271072318183, -0.1103478044607105, 0.8696059937615704, 0.5355823090505519},
    {0.714803347375378, 0.6163911622405122, -0.221789014660472, 0.8538540887973375, 0.9716436771192185, 0.8697951698552119, 0.7421807005992785, 0.9000987268156561, 0.9094919436356109, 0.7779191505052342, 0.9093698205783434, 0.6959827626214145, 0.03640943368572512, 0.8824046144851497, 0.7978564943809421, 0.9923810781894752, -0.12988861394595044, 0.8946537876000952, 0.7579492629057691, 0.9891150101220926, 1.07815079779002, 1.0934354767232992, 0.6392789444891541, 0.5776630064663316, 1.0093664346148223, 0.742376945419742, 0.8786288179225422, 0.7492661454538572, 0.8354801628643648, 0.07006751486994403, 0.75808636480535, 0.7926221705525565},
    {0.6799384501018254, 0.43851962927958527, -0.0031694566324902904, 0.9041415291218945, 0.9071645873300008, 0.7819385494688159, 0.535024158728386, 0.9391394207361183, 0.7062925058859509, 0.9398598240107737, 0.6462380232511744, 0.6849666332738201, -0.48174434622951373, 0.980231636993635, 0.9494467434509136, 1.0745464536620175, -0.21894981463968544, 0.6574407908516862, 0.625232941242161, 0.9295534143924701, 0.9324314178211907, 0.9869967891631204, 1.0433811755333187, 0.7751814952144066, 0.9561036335153568, 0.9846080654783467, 0.8407121048474654, 0.8793216468563242, 0.6430034361665542, -0.024652732605714902, 0.6992599739109396, 0.7600557087398007},
    {0.6004992126997591, 0.6286083391828533, 0.017853222706036478, 0.8706855022029447, 1.1752496448296539, 0.49102263859263034, 0.5276415369422788, 0.7343548262986849, 0.7831686232361273, 0.5928943897358048, 0.6026377154831446, 0.7723775772428311, -0.30651336937098955, 0.5350474455507553, 1.2316463747756623, 1.1030884862230474, -0.053908169463549205, 0.804784916341867, 0.8517275512800924, 0.9197054853291459, 0.7957107167606566, 1.0161258231540617, 1.0025204341874616, 1.0214156171121096, 0.7325929259365431, 0.7634557423732711, 0.9719964337351954, 0.4032579825082094, 0.7335192327893549, 0.17807099736900375, 0.5470664777733554, 0.932372743817203},
    {1.1404470938960791, 0.6858326204162325, 0.056923117985080846, 0.8638579611934474, 0.7295369390881372, 1.0442964793250402, 0.9203172896458613, 0.5263811325096508, 0.6123536247487901, 0.9977540758110097, 0.8640162108115459, 0.9294661450310734, 0.10490979577354022, 0.822868103735096, 0.9371926738328548, 1.0109562509189192, 0.06582795702009497, 0.7491492979265566, 0.8037795921791072, 1.008430998792453, 0.902628341925787, 0.7735007303566116, 0.8905179008589047, 0.8600396340112525, 0.9948443025629988, 0.8387361562115946, 0.8717433872316707, 0.5536305719253398, 0.7043360875140035, -0.04569040522125534, 0.6771735318526924, 0.7757675786009222},
    {0.852542114602143, 0.7272858909445099, -0.25465884746705053, 0.9132806538513956, 0.8760866616964205, 0.9415189715562561, 1.182611855327239, 0.4161751800854314, 0.9294775789741528, 1.1233334231999204, 0.7343337026569141, 0.6834460883970849, -0.013798473542391394, 0.8835670143043981, 0.960639740426532, 0.9421503091998921, 0.17642866421694692, 0.9563969420788858, 1.0862597365675815, 1.102095834161717, 0.47769762063700305, 0.9093180451905363, 0.899073605959283, 0.4615205002202851, 0.9113663728438196, 0.9606934285887477, 1.0269867164393962, 0.7881492487131643, 0.7919828675900342, -0.2142529381153441, 0.5718267979004311, 1.144445115126204},
    {0.8280252831988161, 0.5102749209099355, 0.14349635395718846, 1.0737111790522353, 1.0158800005293396, 0.8581515466870369, 0.7401207638286481, 0.837868815970184, 0.8059590798870008, 0.9084151661749593, 0.6444638959756758, 0.7353132363959761, -0.17569310462522872, 0.7193122679287742, 1.1114410264995944, 0.6063595254357922, 0.2245551936173977, 0.9156622670541826, 0.61151188085728, 0.9403731803652025, 0.8487001407322448, 1.0019738373462799, 0.9097084785532874, 0.5439802889144468, 0.963160297475337, 0.735854798518368, 1.0123735104483378, 0.6785087686839526, 0.510190758541586, -0.2347908489876484, 0.5808929601853561, 0.9375029212481486},
    {0.6433264603860404, 0.8305153318180123, 0.022378092563142424, 1.0674110903536547, 1.001900305960098, 0.7012101206923971, 0.5402686352031292, 0.7887045098180946, 0.8153131177013521, 0.7105213335959506, 1.1102671950375609, 0.7878144878767015, -0.014158725838391801, 0.6478361136909789, 0.5520298475622761, 0.5881678667596455, 0.043642755509846115, 0.6365791489012742, 0.9980761382377139, 0.9506625299790628, 0.7723270057745568, 0.8257848222239538, 1.0635496189518923, 0.6245025194512226, 1.1216409683144735, 1.0140493987836738, 0.9129138975079535, 0.7511298147319873, 0.6942846959566198, 0.07667995210632057, 0.6854493206637506, 0.8476757745434786},
    {0.9155884656522874, 0.25808123821344287, -0.03219237920915359, 1.0097939304500845, 0.7262821268049144, 0.8576255272930483, 0.6367642963394878, 0.888627041017475, 0.6999569424191903, 1.0707060493819827, 0.7521927743331881, 0.5590061519750601, -0.22823163825049209, 0.8029221952476423, 0.9391383137217426, 1.0372593771826932, -0.27837482209615644, 0.8306877618813421, 1.219394801725128, 0.7678105503800006, 0.7292698231532435, 1.1437692160706108, 0.9487538323623863, 0.6767444076238585, 0.9907519445588379, 0.9286868956872286, 0.8709950116521918, 0.9236002221532023, 0.7390481509674813, -0.1544527283476399, 0.7938218480258998, 0.749054429232753},
    {1.0775360347727323, 0.42746946448603307, -0.046599880649203146, 0.8210352955755956, 1.0384075694039125, 0.9166125093007258, 1.087983729325191, 0.8244229319130446, 0.9544866945266189, 1.147947549549542, 0.51352550984862, 0.898952518482143, 0.07274156586903102, 0.8664336156112333, 0.7685903911151467, 0.9012785344695009, -0.10607067005766749, 0.9430894797490382, 0.9986957339310301, 0.8403528643547548, 1.094052543599114, 1.2189441916929638, 0.8486411792074744, 0.7581908451189648, 0.706346037038763, 0.8349091790069038, 0.9848785256514727, 0.6249741519791631, 0.279546027216128, 0.11548184967373505, 0.5946905060509029, 0.9180076273872749},
    {0.3929187985320812, 0.611088422117196, -0.026201508628894803, 0.6665032506460621, 1.064043705184563, 0.9754958850608195, 0.6890475589173033, 0.4208353578374615, 0.8202385213029878, 0.7999579317352278, 0.7513884435752143, 0.6746526341303191, -0.18420810595727663, 0.8728104974652918, 0.8859948683556323, 0.8569187110374616, 0.2075644246167917, 0.7087343589539024, 0.6587680488588001, 0.6064952742942936, 1.2554406067758686, 0.8505842705024728, 0.9096506526109426, 0.6566909785441473, 1.0244278956051698, 1.0687612104523778, 0.5098665620580799, 0.6866991083457249, 0.35942526455160606, -0.1317911197459036, 0.6901905772701957, 0.9554417277968139},
    {0.8244830660033996, 0.32203222465562037, 0.05570227705106614, 1.0520862059883938, 1.0628552569622098, 0.9671206444293395, 0.595328384492344, 0.6963416460425178, 0.856971395615251, 0.8622063782835108, 0.855772646378265, 0.41563671322994666, 0.0063215349166696, 0.9492127272081844, 1.0063535860343198, 0.7395592050537659, -0.138808353695239, 0.6199153999081991, 0.7506855934959437, 0.6417971999008987, 1.0779117024659888, 0.7956234610569827, 0.9963906496929048, 0.9438337286934168, 0.8203628052711892, 0.6613613075910558, 0.8374952065710464, 0.4876735576240193, 0.55022053197873, -0.18415635972762415, 0.8696675983061602, 0.8616920565304799},
    {0.9712812735991598, 0.5432040485159806, -0.07705985128212475, 0.8039282514734564, 1.0095682587761188, 0.7687766551262685, 0.9955504132632588, 0.6063641510324284, 0.5538140549094325, 1.0921686232360452, 0.5776518985948255, 0.8897011246151831, 0.14974302008959048, 0.8873355373722062, 0.7963582831874538, 0.9153436926539152, -0.3895002819106754, 0.9422290067138868, 1.026140639886576, 0.7544597985568611, 0.8271853719081735, 0.7438877634634087, 0.9766761310914543, 0.8337063721853798, 1.1902387576440678, 0.663455261548479, 0.9182324819550962, 0.6106139774022502, 1.0230897929003204, 0.11174526826520524, 0.7108898791580159, 0.7678561454016194},
    {0.7044087229283997, 0.41596570654726656, 0.1504386218635549, 0.763391834971751, 1.0238339840716613, 0.8480791077148253, 0.7286498929710415, 0.7827452657931967, 0.8228030062268334, 0.9230063918093442, 1.1895795883704667, 0.5697821111073541, -0.16484457627189056, 1.007993227468202, 0.9560360478427824, 0.7254168938733724, -0.11329701983605787, 0.8577955710537527, 0.840277379421718, 0.7954991212504077, 0.6034612108975739, 0.8473806070736336, 0.7781362775926938, 0.5982543399765797, 0.7861974620121199, 0.8952383878164821, 0.9719475173411656, 0.6074993786650899, 1.00550024023087, -0.1421771669591098, 0.4966295418452111, 0.8209241732215162},
    {0.554352504429601, 0.5474707263667951, -0.0037188759385839085, 0.6908586579035099, 1.05778207416436, 0.5917745343371953, 0.8108167156391721, 0.7120721961655321, 1.1930693514657187, 0.7143679405306078, 1.012727311517522, 0.5839155703489428, -0.14238838098200382, 0.7928918473743404, 0.6440195882740926, 0.6325430066125307, -0.3245897014547603, 0.8246611257215954, 0.9665353021829535, 0.9057107061843106, 1.107000698641043, 1.0386185230296303, 0.941311764519494, 0.7383358771926394, 1.0195385790769946, 0.8168483730948239, 0.3655178521208576, 1.0558462936219488, 0.6844717720292659, -0.29506438738519797, 0.8207509330054087, 0.739555892709689},
    {0.9089069128044586, 0.4114721376320425, -0.28202741523790736, 0.6827671413423204, 1.055455737366943, 0.8612272328648598, 0.6550513005896508, 0.8588416256760978, 0.8307543656011652, 0.748647176346013, 0.723433177207678, 0.8547770197508258, -0.18715977764264452, 0.6856255147209067, 0.5128948696446817, 0.6747319911988697, -0.14802353170497853, 0.6455748866526602, 0.4291683441259057, 0.5954769494660542, 0.9201999127662357, 0.9562701747945407, 0.9743056744312923, 0.9140138710299461, 0.7319068343513478, 0.3316955679668518, 0.5959359889771002, 0.8369026720459748, 0.6328769138000134, -0.157770094786163, 0.6535116772808364, 0.8208568509639588},
    {0.8918431979837286, 0.6397010694031843, -0.10895299871477436, 1.1614396246852077, 0.8678308354896923, 1.043774414196196, 0.8264512095213463, 0.6752661062987424, 1.0897806283610454, 1.0382604759372032, 1.0838839713606965, 0.9606819821865645, 0.004026011273624319, 0.5875176759043644, 0.7374150785539799, 0.8159059620233201, 0.01188709016551303, 0.9711441830469315, 0.8841508154693166, 0.7023258131095008, 0.8922715561926774, 0.8697927019607381, 1.08584894084268, 0.6719089926399018, 0.8607530973146299, 0.9649638423885826, 0.9714405279553485, 0.6417133719290838, 0.6862125920068386, -0.20126333016799558, 0.5890997713989493, 1.1145482049560627},
    {0.8582005197977357, 0.7026003177517283, -0.10804934035549298, 0.7774897894390005, 0.6570533112494275, 1.0138403147596948, 0.7407126628326813, 0.36623619660733747, 0.935998569434333, 0.6576117513797289, 0.9467903454607042, 0.9337732110038935, -0.04024601377901619, 0.7506691610296743, 0.47624938770430025, 1.0815652816216077, -0.12453354823393444, 0.686695499359943, 0.7098992796410339, 0.819657200821889, 0.7857028926165162, 1.2376165305895332, 0.5015077461412906, 1.053819162719714, 0.7617718146869028, 0.6831913542863226, 1.3162606035602447, 0.7275272906953403, 0.5566353275082878, -0.2974228171867625, 0.6328660829580297, 0.8091234021769717},
    {0.8022322506372324, 0.7396391187408589, -0.013625417457426984, 0.932764524930962, 0.6564892263527272, 0.6381502063573474, 0.7906570747637885, 0.8851592777198486, 0.965837939887186, 1.1231388847267165, 1.1622109695975062, 0.9270926293927058, -0.004087906491617182, 0.947950528956835, 1.0802575069723068, 1.0391492537755642, -0.12064558738950604, 1.032314027911701, 0.8408594908949202, 0.8878095229748983, 0.7975796045920563, 1.1440455750238363, 0.8958468271525101, 0.45140448508096614, 1.0579570998662182, 0.7509417320021275, 0.5637942991865019, 0.6651335321080017, 0.5999206356878855, -0.26977103183687545, 0.39642663658624616, 0.9549558418582391},
    {0.6539857921182686, 0.9395045612854921, -0.05590713357613187, 0.7734016772767608, 0.8298172574186019, 0.6782929149727075, 0.6399028871480488, 0.6575268482129156, 0.8601693157438846, 0.8448168123979575, 0.9396756606817114, 0.7939432424799022, 0.06978060367572993, 0.9639570922443004, 0.8073532570340146, 1.1167995317967399, 0.24875076706728066, 0.9459673649479555, 0.6056054159297741, 0.8364268809187279, 0.8728996074434063, 0.8864888762663778, 0.5059032829125675, 0.91712432673905, 0.8364821530845016, 0.748284766586776, 0.9672231269684133, 0.5986814705956996, 0.9078192312973631, -0.28736537578791044, 0.6742467578304377, 0.9405745091142652},
    {0.5747386594963764, 0.2579094479663107, -0.09922433826161581, 0.7933802019371996, 1.0276648313057726, 0.8877014128094431, 1.1435671689055762, 0.9003216021146297, 1.1689688183881086, 0.9281173502408584, 0.620504009493971, 0.6814005676648404, -0.1973299961213943, 0.7325447767007933, 0.9383651237038201, 1.1641568755316398, -0.08015269988623833, 1.090450952767284, 0.5871700890160748, 0.8129659114108702, 0.8852801268620688, 0.893517855484951, 0.6441005472425694, 0.6528915508346338, 1.0859269401682803, 1.1446144106393397, 0.8465631529229194, 0.629597549267743, 0.5109451116230502, -0.31195294227616555, 0.36805211844754054, 0.9297356373087817},
    {0.7099149419277434, 0.9064826880115882, 0.0617193737128429, 1.124775818887637, 1.1636628246996852, 1.2216772516778107, 0.8970064732231575, 0.700208045983629, 0.7961071601140561, 0.9994362816282406, 0.8382419586890288, 0.8371713419277702, -0.28299578449494883, 1.0236734094549704, 0.6232628053341323, 1.138730991748284, -0.16584718627137238, 0.8373002493952704, 0.8411389065359594, 0.8010043853724303, 0.9839517419891438, 1.0807073839216375, 0.7763886758517133, 0.8459582941361636, 0.9858940655612065, 0.6467787845050983, 1.083766696967874, 0.7849020781773854, 0.9684735633576198, -0.08288374886272888, 0.5107086407514525, 0.8861227965542592},
    {0.7530950037578643, 0.6285403567479253, -0.17398588597179593, 0.5744075577377493, 0.8367841640901984, 0.9089186769233135, 0.7099269897560702, 0.9937096406922676, 0.8215076658455883, 0.8479289381798846, 1.005276641415159, 0.6101560224092389, 0.1738826641829084, 1.0116273977044385, 0.878444150546011, 0.9254903282585472, -0.2136155844467665, 0.7563930465306269, 0.9763318685156219, 0.689272617949158, 0.8333890734819631, 0.6628008422717756, 0.9221065189364452, 1.1473774860704504, 0.707205079187336, 0.7547968430282366, 0.9744490615450141, 0.7627276373235059, 0.8812295851473765, -0.012216071692835865, 0.8573171392085197, 1.032147567323407},
    {0.6441980353690528, 0.3848929266258291, -0.013545335499597404, 0.9054502219623833, 0.9586561605113809, 0.7681128915933094, 0.9325428422671762, 0.7476065550209694, 1.0528038299887164, 0.9575451407661976, 0.6786382198149742, 0.6735134368840385, 0.06158909062262062, 0.8762342639741482, 0.7834669781543809, 0.6401295394959697, -0.03511406239541959, 0.8941659197781027, 0.7992912060684466, 0.6198477280741697, 0.8983550817961238, 0.5333737854127472, 1.08322069094278, 0.8273633375693195, 1.0433000900639438, 0.8550864919583347, 0.7610305605321964, 0.92981312506104, 0.7475348043354545, -0.0824074953133191, 0.6843363297472665, 0.9306040264727335},
    {0.6648716245736096, 0.4318027284404941, 0.10706042074492014, 0.9561179217442164, 0.8834443970204805, 0.7335856792306977, 0.6037635699048983, 0.9351576386550303, 0.7743000275914611, 0.8660887855016938, 0.7056033509469237, 0.788626467677443, 0.0960626713671198, 0.7734146095424458, 0.8036862600780387, 0.7886373257974669, 0.23029111642897904, 0.7944789496355116, 0.5911202555482438, 0.7130664561248945, 1.1847097997975469, 1.0305188402077672, 0.9766160777353334, 0.6715652586687219, 0.8054944991586602, 1.2979746346890153, 0.7552377175795238, 0.5758960870379881, 0.7186352776257154, 0.27912544877635087, 0.9153350977268698, 0.6933808160781517},
    {0.9550219105208613, 0.3174822292482872, 0.0645856582020604, 0.832394295440699, 1.0965353720840727, 1.0789878200060066, 1.013214914635473, 0.5096944084894509, 0.9501670943771782, 0.9916988682690746, 0.7008069090725352, 0.6780939104833502, -0.0820353164422385, 1.0790329202667164, 0.7670791745203369, 0.9250915658826881, -0.036480220997248375, 0.7258730190370649, 0.8675057059010012, 0.6626976662975226, 1.0386488322640475, 1.0755486458833359, 1.1248262175710648, 0.9686408661950296, 1.0435247650249124, 0.9364791242485944, 0.8679973315996005, 0.824831850470551, 0.8700494939789996, -0.1624176993137472, 0.6763016247420085, 0.76461256168972},
    {0.6573861054762207, 0.4571230674902158, 0.17289078508926597, 0.8884474194951145, 0.8249995702573386, 0.7250596265621222, 1.0369003347140024, 0.8119676675109733, 0.9099893835405853, 0.8991062503347084, 0.8615585597111919, 0.31510562835101996, -0.36098916886419696, 0.49357131426265377, 0.563260890397869, 0.8796362861051511, -0.008944729331471647, 1.0119436855737078, 0.5831170947457494, 0.6848446218715419, 1.0527133023482895, 0.798040683641081, 0.8878359055162566, 0.6453818791134452, 1.2259198128538005, 0.7761078772797173, 0.7032025418313549, 0.34933594555748865, 1.0216694428732216, -0.10899227678627181, 0.6428722655053636, 1.0146385357656895},
    {0.7091661142220871, 0.39364266042564905, 0.08704341473043718, 0.8331407428196118, 0.9854326715109492, 0.8851132744128314, 0.6971591868759899, 0.7607076669630044, 0.6093141032741392, 1.0338847743467758, 0.9425878896296407, 0.9115452239386441, 0.10881729489149447, 0.7721311417250445, 0.8384833406812445, 1.3152775042752713, 0.03876424254221099, 0.8797822340573881, 1.0206728750092116, 0.6673967645719767, 1.1128585696076772, 0.9388606728133615, 0.9060833241626721, 0.7258328636443129, 0.991250220521141, 0.8920400052913204, 1.3530141592195042, 1.0610375005012058, 0.9412601894146473, -0.06730343966791445, 0.9161853953377941, 0.6965319707423259},
    {0.8498881898561451, 0.3695178206743779, -0.10562377730262716, 0.9419857445750766, 0.8928587309978409, 0.5391456497910333, 1.0338759201135268, 1.0500744572216225, 0.6778130261248164, 0.7475557302786553, 0.5601242665351521, 0.769062630565302, -0.2474353506391832, 0.9460186970463342, 0.8059275987782307, 0.7115113942774746, 0.0875258076188655, 1.1082191766538063, 0.8234295417759875, 0.5376762819687576, 0.7858853119761275, 0.6800526564448801, 1.0669662714516404, 0.9556528492238658, 1.0230994038201617, 0.7127339541318497, 0.7278694203853829, 0.4859557638992751, 0.6546107525775338, -0.12163062137680722, 0.7341478413139738, 1.1377717060201635},
    {0.7677166495029095, 0.7167401985594116, -0.223328173081069, 0.7509816116309636, 0.7123427399476766, 0.8036806884103836, 0.6967979464668301, 0.4341403061158823, 0.8065914211353578, 0.9159238207400311, 0.7113534923410713, 0.9474229000777854, -0.26100298229231883, 0.7734162203306545, 0.39109620480351054, 1.017892970912008, -0.1782282224580563, 0.8571222879508456, 0.8720773570717857, 0.9249012096174827, 0.8053716202867914, 0.8241045448148396, 1.0552443074016895, 0.5345342152604807, 1.0822252175470628, 0.8734481879699607, 0.6569655862484816, 0.6525738442600719, 0.6383187802262215, -0.34368711076283387, 0.714687503730351, 1.0007768983592953},
    {0.7999777616526894, 0.6282776437933905, -0.4284796860120771, 0.7081994277752603, 0.948081970194667, 0.7816909473602078, 1.0864003006191811, 0.6544724365142235, 0.8108295703860534, 0.874245362617319, 1.1720166924205646, 0.4960110039271636, -0.011424714251757345, 0.8765396701555926, 1.016563563878369, 0.4746731801656814, 0.008355935676292772, 0.9953451077996028, 0.8954066040074999, 0.5034509383757899, 0.8999057915488556, 1.1340019194460602, 0.8054925391733043, 0.7137371352257494, 1.0374692394950638, 1.2162994138967702, 0.9220361081442604, 0.9055528945152748, 0.8504882950820748, 0.25089613772141073, 0.8005584407230444, 1.1544387846895323},
    {0.9364135782062043, 0.29758144097920625, -0.09900579154349992, 0.59953607691175, 0.8711524078989219, 0.6363532252885264, 0.6941018441991322, 0.6940140881466074, 0.8358378642824493, 0.7485946785680814, 0.6458799655903172, 0.5875710721967785, 0.013575759311757118, 0.9359974294187626, 0.8684833107692677, 0.681302629992692, -0.1239182686377867, 0.628074205258504, 0.7658834436200764, 0.6631114946011227, 0.8341957279640396, 0.8431038349927381, 1.0802700085848738, 1.0716133545921374, 1.0251451368380153, 0.835515733946365, 1.1940260586961542, 0.6273659157717428, 1.0873749092080005, -0.20631623967040885, 0.7193218288787271, 1.0857252041770524},
    {0.8266058346417997, 0.5218331192423991, 0.10234616944951405, 0.9411707014224256, 0.8117037751549971, 1.0064950367199306, 0.7583496120685191, 0.8050166441837945, 0.7765410399861182, 0.9966948999435785, 0.6172103760775963, 0.8547819741710363, -0.09623651831652187, 1.0432150951179018, 0.4577552813572883, 0.6974071862008593, 0.12610196374850136, 0.5886459959976619, 0.6810825023753752, 0.7079512553896795, 0.9890385356455893, 0.8903900199426348, 0.7497138988209765, 0.906767279632938, 1.1489657310015056, 0.7705631617678453, 1.2060889616573778, 0.955250682190078, 0.7197496150350231, -0.032390934106036134, 0.31616303297862247, 0.9674046971329503},
    {0.6440986754831426, 0.743517114937572, -0.33874840187436356, 0.9355783422340621, 0.9529320609549086, 1.183925364995977, 0.5195432072861429, 1.0830219158524257, 1.3395762929148116, 0.9548996261911303, 1.1639103132090858, 0.7743625983433581, 0.056181299770965, 1.039365511617472, 0.6997076214212948, 1.210031151506236, 0.3205504176703182, 1.057427129247427, 0.8324072407600449, 0.8411095316204898, 1.0635988856119916, 1.0898045823616163, 1.0288852325270121, 0.8134630519975152, 0.8702522888958081, 0.6588933488113834, 0.560435060823106, 0.9006838627658472, 0.7873640593019274, -0.1211343235967828, 0.7378077648438165, 0.8692323830979986},
    {0.8048574807935915, 0.5691535308806543, -0.23165474961685825, 0.9839708640900227, 0.9953039218260894, 0.9108566457267054, 0.925973567920237, 0.49256449275178277, 0.9193448823925815, 0.8595871691711473, 1.0142751013539741, 0.9126698396513004, -0.2912624464990678, 0.7380127150535432, 0.7098336681296749, 0.8050370847237314, -0.4077221264629638, 0.7908680674710643, 1.2072111628149453, 0.7825514871806444, 0.9738197901683701, 0.5787780714640541, 0.5660605871084977, 0.9197624372585598, 0.7296303235398022, 0.7253694347460045, 1.0891752848261191, 0.43617115799578476, 0.855515225749836, -0.0976168871292664, 0.7321344550440602, 0.9544332442038186},
    {0.74444573151695, 0.7745800790725703, -0.1667913711432482, 0.9044843554839818, 0.8998965647785945, 0.9632287015983946, 0.7120273424454766, 0.9024642550086541, 0.741944694009623, 0.9002505084805248, 0.9535360804760014, 1.179209417816979, -0.2834573831018371, 0.810361152978276, 0.5844291182293974, 1.0314535638888709, -0.2503817421125633, 0.9435812223070132, 0.7801651353012983, 0.8567638804653299, 0.7556987243353016, 0.8853169559227468, 0.9991226533006778, 0.7647774040158302, 0.7795331175822462, 0.9608058315372966, 0.8414293886327675, 0.904662925358866, 0.7135340140046857, -0.1899763091820893, 0.5767546196870988, 0.8865997380289334},
    {1.0020188645769887, 0.34329955984473964, -0.15144137811443323, 0.8044071467981262, 0.8075867933435739, 1.0280190538695824, 0.9066115701678218, 0.9061657036697979, 1.0112971417960446, 0.9848984830055826, 1.189774970688506, 0.6847515363946729, -0.11145018068446884, 0.7336729887097014, 0.7778717179934256, 0.8174908174564267, -0.039221128549731483, 0.7282147718427535, 0.7566817191492429, 0.7196178308743637, 1.0081426236270725, 1.1091058354261458, 0.9855730168427385, 0.8345774812934118, 0.901328572663289, 1.0057563346764888, 0.8721410666072353, 0.47167678363354437, 0.5512882650220882, -0.32339698462500016, 0.6167936260595686, 0.659207535738092},
    {0.9163310082373448, 0.7251457176290524, -0.17748451804013607, 0.9654060516440671, 0.9626099586447756, 0.9509626597841625, 0.8498172286394571, 0.5561252352772598, 0.8570143308831987, 1.032803755786145, 0.594420626819123, 0.49495183858015634, 0.17934716885561172, 1.0621558753004134, 0.9526999354186184, 0.8725144519042646, -0.1859363487577513, 0.778974693046155, 0.9919350678533794, 0.5003999611558834, 1.0830438778298033, 0.761956732345324, 0.7777645994806582, 0.7820980779542179, 1.0116695824488666, 0.8382598018591583, 1.0241219774578125, 0.756455062136931, 0.5344562111261443, -0.25007602630371273, 0.7305118302424987, 0.9650808882558436},
    {0.8237637804539197, 0.3938831231145176, -0.13562746640834217, 0.6939231642357424, 0.9540537595059508, 0.9862913929188245, 0.8605409598257561, 0.8371551369155608, 0.7433476977427588, 0.8313105365117384, 1.036983933505072, 0.27399728295815723, -0.08593473999518243, 0.9973303239113139, 0.7190654427694471, 0.9268460380575596, -0.22673725105071588, 0.837439206905003, 0.6549456211973905, 0.6308990092347176, 0.8197034175425638, 0.859614314807254, 1.0009021690531323, 0.5779534062968563, 1.0087833738965661, 1.1214340500698667, 0.7974223719841977, 0.8943199865579949, 0.8234996182327274, -0.14682240499306823, 0.5813544439915548, 1.213953373374019},
    {0.5423361176265568, 0.5177888420879656, -0.18721946139827658, 0.9574247869248473, 0.7150702503835786, 1.084857755422782, 0.8083771592333577, 0.45032711173462175, 1.0873815379689722, 0.9988389426880008, 0.7875495436446645, 0.42085888102371977, -0.06780581240112567, 0.5707126703370763, 0.8092339034004239, 0.7855602064698758, 0.43390946891592996, 1.0038049701114424, 0.8505993454446253, 0.9443987553761163, 1.1594308431691531, 0.7346647600200623, 1.1635217591279632, 0.6159889101378079, 0.9286629930222775, 0.9094300172000859, 0.8750308707722609, 0.9417745834862973, 0.7112224109750757, -0.2803560319105287, 0.6092683558260111, 1.007683139928166},
    {0.5836159072896059, 0.7739902230109142, -0.462176788089259, 0.9853898834033621, 0.9723081370338316, 0.9245390219329912, 1.0114217881432772, 0.8113902834140414, 0.9787247119796534, 1.0904904895752692, 1.0069497065732838, 0.5520083903165122, -0.2640074678472073, 0.6751313673681082, 0.5999043954301999, 0.8660320774847218, -0.5252456394506098, 0.38823664665612057, 0.6484316439017697, 0.6744097303250035, 1.1292121485307292, 1.0995741730273048, 0.6563602893627437, 0.7721550835753752, 0.9737222464123139, 1.121089440497452, 1.0131934895760235, 0.5075760103824352, 0.5672164745796975, -0.13438343983202128, 0.3872189434255666, 0.8046534480747717},
    {0.7151928870714297, 0.9446689572746897, 0.0912942371995885, 1.0165829763741456, 0.6742126386840449, 1.3211757506005992, 0.9892625456791935, 0.7903765644804805, 0.8898387435108974, 0.803648828655334, 0.581078912669042, 0.6225427850388018, 0.12354097235181172, 0.7502096769158677, 0.8114101386524926, 0.895388437286866, 0.09685476217349327, 0.7164027582460134, 0.6689736839441495, 0.588427980967632, 1.1291496633268445, 0.8353756380735599, 0.9696125695907097, 0.55940060563202, 0.8325215230444102, 0.7085611584634709, 1.2299596414096508, 0.6722316623465704, 0.6798305903783418, 0.10677519818693916, 0.4789385196389205, 0.8156794320485149},
    {0.6826167524460428, 0.5221496863869619, 0.18265881964560776, 1.0068220283396736, 0.9166760976925284, 1.2076837128543945, 0.9652255933895312, 0.8246932728422922, 0.6722408316083186, 0.6134241590669122, 0.9631769046112933, 0.8959724812617779, 0.12773402174863643, 0.5472150104935098, 0.8340051438041026, 0.9512631062714793, 0.02556736100968848, 0.8385236545136409, 0.660613254679062, 0.5045194108393439, 0.9224211082736811, 1.146046855055604, 0.8900647519901097, 0.6573543909066955, 0.8376599522606921, 0.7160742186278338, 1.0813011847054865, 0.804027945316644, 0.8381639644873318, -0.14749566470665756, 0.3250028586165159, 0.7505282645645497},
    {0.8696319034437769, 0.5233800511675903, -0.1820438804967396, 1.046026926789467, 0.7537108511354046, 0.9887464542639071, 0.5925350378808399, 0.8140653033091294, 0.8640180810470431, 0.9572602331627492, 0.6982694664007284, 0.7865378294177744, -0.10279733239615461, 0.5783517662663472, 0.5908349367513633, 0.8608355658818319, -0.19449730817486377, 0.8678817901001094, 0.8129908603410165, 0.7850389972820652, 0.9372015796324245, 0.8715055149540855, 0.9633025238547696, 0.5057374005469288, 0.958550881937525, 0.951950209435492, 0.7541188932610391, 0.8364452574826462, 0.8064298406211565, 0.09234550424708374, 0.31295996071862087, 0.8737142763211433},
    {0.9670000664762988, 0.6334290429008178, -0.030007451330158936, 0.866697906693836, 0.8846996042986192, 1.0444605389171389, 0.7388087588240945, 0.8693160117367487, 0.7175504237037794, 1.078101769784144, 0.829730236222846, 0.5933655282786015, -0.18627405188531806, 0.5712020476091543, 0.6025628360199892, 0.9143215531735898, 0.015225589393337844, 0.9091957531242209, 1.0993540386971774, 0.8510684648841533, 0.6882145548956168, 0.8152926624403087, 1.0086567910066329, 0.6914761341425268, 1.0524969600824066, 0.9750510567351477, 0.7466893257533974, 0.8773725419889813, 0.9063184588128403, -0.1864384471040448, 1.0063489877712648, 0.7795128639304915},
    {0.6601351268437241, 0.34599666820207786, -0.09864763439643037, 0.9331740853612128, 0.6394570558056047, 0.7823225729896063, 0.6640219832128927, 0.5338566395361154, 0.6615217563623513, 0.8276573361475238, 1.2700228132917184, 0.4559846551196473, -0.07732235548583828, 0.7826441125268582, 0.6319059114961949, 0.6312172225357, -0.17415633062965236, 0.7858145287562334, 0.7948794604570935, 0.8745288353085154, 1.151634152977894, 0.9689995508552749, 0.9085995618174153, 0.7113009726924624, 0.8703738409086204, 1.0232815258492354, 1.082508947689702, 0.9780828091943159, 0.790092191076816, 0.013420324972478114, 0.47254583599615435, 0.7706782828892711},
    {0.9844963209173653, 0.7059535131164647, 0.016797105249094717, 1.175985049598267, 1.193409469843981, 0.8824789916838244, 0.9001308924976011, 0.8702323988729891, 0.6708085872532209, 0.7580545043945917, 0.9295307865344787, 0.5609895413155301, -0.48102075275957934, 0.800142759138128, 0.7401233957391061, 0.9293761345712801, -0.2110475919483638, 0.672253274036616, 0.7630028352317548, 0.7544315846008719, 1.1651481228791931, 0.8440185455043968, 1.1003172677201527, 0.7861123483982343, 1.0068950687024423, 0.5337534369037085, 0.8566950733931633, 1.0111355321269608, 0.8907694031986052, 0.18154480376818832, 0.7932838764707658, 1.0733524439072415},
    {0.6427152207736111, 0.5387745253572271, -0.027625793289708826, 1.01959238067004, 0.8179017296594566, 1.0893615879037482, 1.2819263318724263, 0.8868298746894607, 0.9950302652586142, 1.0548213775278426, 0.9630848148764142, 0.4888106356987686, -0.0026811219836976787, 0.7761893343855545, 1.1249808358691749, 0.9993939786711966, 0.09892823411819479, 0.9351292262917195, 0.5580758458312497, 0.8326306365311115, 0.8839690157379966, 0.882564929475665, 0.9508731569650004, 0.9342448886716798, 0.831117753338987, 0.8714906922932157, 0.9661905507966829, 0.861260012779825, 0.6657498866006661, -0.3632124031717548, 0.7191277118792934, 0.7474100694278822},
    {0.645401037084533, 0.7236857624213885, -0.18044085088338266, 0.8991372385334596, 0.6613329016481918, 0.9607742535253638, 0.8612264239820288, 0.83115566305185, 0.5793497679263764, 0.9854097789955498, 0.7153464194094371, 0.5313199739022455, -0.06407714907971898, 1.1143861401375457, 0.7424464125830833, 1.1665188959373276, 0.11874423692485414, 0.8567262748782333, 0.46916176876592675, 0.7835936665610399, 0.7831176933014732, 0.7576601888890948, 0.9167770436626723, 0.6869093755386125, 0.6968353417780471, 0.8374252967805526, 1.1285212335604664, 0.6518714811661858, 0.7915907685654426, -0.20516940089632668, 0.4998118724084548, 0.6916223855209886}
};

static const float b2[32] = {0.7388003835803731, 0.6156868820480453, -0.056903120275114544, 0.8257419316974204, 0.8795205497329373, 0.8639196799096787, 0.7605130858772178, 0.6872633781535238, 0.8002974683191826, 0.8514017021907304, 0.8364969065241855, 0.6927473893699755, -0.08534427300602924, 0.8631092620230373, 0.7469443996878115, 0.8759437888075524, -0.0012215809652324822, 0.7838990130451183, 0.7199604938036943, 0.6923961228671877, 0.8829852286545888, 0.856153955606032, 0.855317357836761, 0.7609997245804048, 0.875092415828406, 0.7624248605232328, 0.7796485712937807, 0.7124405653589375, 0.7163369052501297, -0.05706699090788852, 0.6683508174969146, 0.7871196766560403};

static const float w3[32][16] = {
    {1.0684080211538525, 0.598322938351331, 0.697819896342113, 1.117028675592145, -0.14221619588562998, 0.22682926868294032, 0.5995885104796849, 0.08070955184461105, 1.3376237407070495, 0.6961674062718298, 0.11070052209219064, 1.2351707388719242, -0.036014262465905555, 0.2910621271827704, 0.5268066249846536, 0.9269576060659392},
    {0.5988000387232509, 0.6553549781227237, 0.45877201521097827, 0.5956680459677987, 0.03633128939232531, -0.4909601840937658, 0.8442151767334622, 0.10541749124763063, 0.763976805130125, 0.9130300856011844, -0.2059894681176038, 1.031510692800824, 0.13237280511077817, 0.17351648517278903, 0.42672331817241077, 1.0895108563309361},
    {-0.2498658472976216, 0.23839183561999422, 0.2079404983241123, -0.011243366714062127, 0.019398178459682284, 0.35986852525824786, -0.48614195690810325, -0.09304290654031436, -0.08933920206578905, -0.1855542095464485, -0.21766057975379632, 0.382529127987435, 0.14038251590156783, -0.13983221443132482, 0.26652713174548714, -0.2495045480223938},
    {0.723723889738854, 0.5998352085236052, 1.3035804382095892, 0.9074016662518981, -0.2803610834795375, -0.1505203252468326, 0.5043561942437904, -0.1625175281689038, 1.2113446432405677, 1.1696699352636195, -0.42962796266821546, 0.9061673117244327, -0.030347266999180767, -0.35040264846020724, 0.10407890228169007, 1.1236878196306768},
    {0.7885214388043569, 1.1505424793772199, 1.085775911313649, 1.2639522386337512, -0.08277711546283328, -0.2298756999013694, 1.1653045580506167, -0.09272397969050028, 0.9064834791629152, 1.3652912847495957, 0.14141384623226286, 0.9906557269687882, -0.045302406895124166, -0.2443090977433274, -0.2810090660653734, 0.6836985586120486},
    {0.4489497879858548, 0.27617277902467674, 0.6980505102657036, 1.1543155091616182, 0.0737430447525398, 0.3011683496094714, 1.3052893920544102, -0.5573685548665299, 0.8810409941555067, 1.2441958403837676, -0.15333761685825162, 1.138500926343973, 0.11724682810720512, 0.028747603584666794, 0.11700479077188146, 1.0445640591574157},
    {0.6473555314638669, 1.0064001693557258, 0.7791127317290508, 1.0145203058247132, 0.06909020384168318, -0.11585027327116246, 1.1791770030642212, -0.2371058103358206, 0.7085605139846783, 1.1827992217993983, 0.025633224998053872, 1.2239619546099079, -0.07988073359307353, -0.04525908407582987, 0.48168985360819516, 1.0117543322167364},
    {1.4303255161958919, 1.15783162306851, 0.6664483642532145, 1.0853933328335552, -0.0576952620302843, 0.3009263376024949, 1.2973894519090599, 0.011662893937365092, 0.6484360712243022, 0.5425832745340647, -0.3754391612719217, 1.198356107834072, -0.0490394874027176, 0.11395879927190011, 0.04636681478208872, 0.9691799532127745},
    {0.8646995865947981, 0.6329162694142261, 1.4308242583896325, 1.0162581646989066, 0.15478417039748069, 0.15795809780086253, 0.5375644955278368, -0.18585224379226312, 1.0847869111771724, 0.6851548888356835, -0.11720338394575314, 0.5315767403342848, -0.17086848513015895, -0.4789574703683839, -0.00551113301670916, 1.0548844937694324},
    {1.070672541015232, 0.6946959332891144, 0.9141194004423776, 1.2414288178619752, -0.5676710657564898, -0.355329213577971, 1.159136517966706, -0.2548224503202478, 1.412232658231068, 1.2592121248184593, -0.2529122604183469, 1.2181703954709606, -0.17419511025479278, -0.29715864402005543, -0.3234784819802289, 0.8524074010110572},
    {0.7482488770177534, 0.6480492332185598, 0.6850763263787821, 1.1595664363947626, -0.5586030681815201, 0.38449212751741235, 0.7973319617249776, -0.06723134291709484, 1.008852472282556, 1.0870482157441628, 0.06560609782481311, 0.9835228130072793, -0.08662571695584517, -0.31298896842756774, 0.16756174334618112, 0.7725997921038337},
    {1.1292602341805507, 1.112769168575359, 0.34196671882106083, 0.9332220186426938, 0.07337464159760998, 0.2593324848393468, 1.151376572482913, -0.1467029455816491, 0.8080946335777367, 1.1530813514566756, 0.17140665498065596, 0.8965258885166302, 0.4287597555424182, 0.014851490375541036, 0.3435262265338524, 1.0264640157236138},
    {0.02030318171925629, -0.2866159240056205, 0.0025135890567870352, -0.20263951126541135, -0.4527857504666275, 0.08150326702744302, -0.019077468418926883, 0.09105451540286007, -0.02829537171737725, 0.34757489988180645, -0.4642032137341477, -0.13749096911913158, -0.273112105740545, 0.2748981362178737, 0.18060726545051023, 0.08915244041316107},
    {0.43485088488112345, 1.1972259669295806, 1.2917698198807286, 0.9062920571862519, -0.29486385963115747, -0.18053982146940573, 1.3433766539244887, 0.2392268833259475, 0.9004178482994452, 0.9498332710359116, -0.18430713465556572, 0.894787209672988, 0.06263515937951013, -0.022661765476432366, -0.23519764198022144, 0.9586861186328444},
    {0.42502372440781017, 0.7181931517863647, 0.7554336763283376, 1.0068820836261796, -0.08641004983018755, 0.4552078242228724, 1.0062779616844244, -0.17955846211916132, 1.2428785793187824, 1.506488422710909, 0.04349578858099057, 1.0413332514231517, -0.3491146996630414, 0.18933364414891304, 0.12822522619150217, 0.27100375772185614},
    {0.8031715614392848, 0.8115017015443633, 0.9075842788975924, 0.998486549906198, -0.2402035664250528, -0.25187132770506715, 1.063258909242869, 0.02116577831588388, 0.7949767469223605, 1.3303161303365207, 0.040404530911797104, 0.9902351332307269, -0.05860592361173078, -0.37484869969423346, 0.15204469679832056, 0.879446883192711},
    {-0.407764098739042, -0.6501100595015594, 0.07207983911268755, 0.1712998564369567, -0.036513220890174634, -0.14610600668598708, -0.11273062056589851, 0.20129983111537514, -0.050885406280207, 0.2739797928685697, -0.0085927679325432, 0.26761172290994645, 0.31175557851834396, -0.09150086708135918, 0.06373588310315927, -0.17290814050666603},
    {0.9792589937326854, 0.9635412456876692, 0.8905359790418578, 1.0336528593092345, -0.33063345011127326, 0.006579073488885544, 1.113597510111191, -0.17138845995173016, 0.6841415334702279, 0.9363242208569649, 0.3841749239654742, 0.9116947743382048, 0.09949283606639477, 0.15059115179349025, -0.5890972878769164, 0.6578858818959572},
    {0.9997442382011793, 0.7518223427658299, 0.6362383457772174, 0.8823977669962424, 0.21836846480750632, -0.022579990722420736, 0.9699045695668939, 0.06368979590134567, 0.9247027218130699, 0.8868127721495962, 0.31880737865840775, 1.305725281422728, -0.4664780304918198, 0.05564463125515905, 0.3430554724763704, 0.8230945485464162},
    {0.9408071802372145, 1.0734736238318001, 1.1046641958054046, 0.8569201718746967, -0.3407964949343566, 0.46046300433727244, 0.7968769018527292, 0.0100232427434795, 0.9916784129484626, 0.827555584348091, -0.1913996709451257, 0.8428057776293023, 0.3617980473747707, 0.17123300335682012, -0.2031011548125827, 0.8537116355100729},
    {0.9473150060015266, 0.6946627487560251, 0.9541245872388188, 1.142404769775255, -0.16820431234966488, -0.3535312414065877, 0.3298647917516656, 0.010511351223322545, 0.8547196144740764, 1.1768421735562038, -0.04668801856666466, 0.7650631653126101, -0.023311235188067315, 0.19247743622743285, -0.020455902423884613, 0.8542487493922906},
    {1.074909562160155, 0.8517793358344866, 1.0907968728313313, 1.0900185855380407, -0.3645966048825644, -0.12416672274281679, 1.1948080910547894, -0.16190436795071392, 0.6694945036913024, 1.0302359503475482, -0.02457410377318331, 0.8631919524982661, 0.020635330689261513, 0.10399140835023066, -0.2334280566327874, 1.2884249944360942},
    {0.9149380081100984, 0.7057011399614639, 1.036679834842636, 1.2237464200170916, 0.29189407426997205, -0.41058073134686557, 0.5604814410675636, 0.3602046886732913, 0.7182710255538183, 0.9533326231658324, 0.038351627341452595, 1.056355962766243, -0.06073449712111322, 0.09979041291735681, 0.04345715698757046, 1.4149454112868918},
    {0.6951600059086263, 1.2812399251098987, 0.6961027817901235, 1.324412366065964, 0.14343388986315275, 0.05428469774426794, 1.1948955545710425, -0.082649180243714, 0.7054949348274863, 0.74422407754456, 0.021260602506323382, 0.7296882411589849, -0.3830047926384715, -0.031137074897145775, 0.1426147458526399, 0.9514702213891032},
    {0.8419105284815782, 0.6192702019841159, 1.0732611598581723, 0.8274543907593208, 0.17410789105585872, -0.0028857163749864976, 0.5422760531865808, -0.7282519444896254, 0.9903786666994737, 1.013395735319471, -0.4023028771763456, 1.017951767230365, -0.2341430661894026, 0.2868203798099539, -0.5769771826472796, 0.8188012926468674},
    {1.0120018208295245, 1.1220757125458374, 0.9824982834474609, 0.9575790066276885, 0.05233354981169683, -0.2114200656119221, 0.6163225128842944, -0.41417404103871863, 0.9142373423210427, 1.220302146016249, -1.0028106900170912, 0.6012239874503952, 0.07025730129640495, -0.3802866296232596, 0.15357305479259897, 0.8848077925822676},
    {0.8464225270898788, 0.6376196081364248, 0.9585588519219568, 0.8309768432680674, 0.22998075726084113, -0.040835118813922856, 0.8409806968929275, 0.1006443265926174, 1.2385006352408574, 1.045001107883028, 0.02229669276591032, 0.8454984709299279, -0.3489284533121784, -0.05651939570336738, -0.15726912304268287, 0.6713288076261541},
    {0.7415588874379591, 0.4280538749267141, 0.7570898415124386, 1.1281129068303555, 0.17739631072505727, 0.11266378267473276, 0.9121607529933775, 0.22099906911251155, 0.8088182303654357, 0.7305728523031872, 0.6995171076255211, 0.6495414641852931, -0.093593495208669, -0.2751719558919151, 0.012036551096550609, 0.6091491143101848},
    {0.5746080180969431, 1.0344657026172188, 0.9472434209048421, 0.9068694982422377, -0.032097269658029975, -0.02770957941712082, 0.708646974355064, 0.1253893131857167, 1.2990229624669531, 0.571783921192964, -0.0021594170358080356, 0.6693977137007995, 0.36620337895277105, 0.10855181673900828, -0.19969780953500174, 0.8380088782277426},
    {0.5792958530694946, 0.17197484071852437, -0.017389223740162323, -0.12902601299328112, -0.520056953928028, -0.0276237213644917, -0.38584884454470963, 0.11634396006633202, -0.06912656762927322, 0.1898397943643474, 0.5110811887369621, -0.23038969090368802, 0.046864229002393086, 0.03599280182699416, 0.4193929013940979, -0.00970637803139079},
    {0.73101953337909, 1.30263618767146, 0.8175433292222554, 0.5698740704581012, -0.7867866176206328, 0.10231197009337632, 1.1911076081011462, 0.0024037898879183763, 1.0000003420771335, 0.7856759582074618, 0.16370209935905386, 1.080454443077765, 0.020857391184065443, 0.6091670063216196, -0.4160610041441229, 1.2036207065359195},
    {1.0066571970501021, 0.9955754050702673, 1.2970270263312798, 1.126085068683468, -0.2282596425701607, 0.12241729492329328, 0.8314141863561798, 0.436498404342648, 1.041002368670286, 0.8996215968807432, -0.05420548832847723, 1.3161580598631442, 0.04282394235339159, -0.24029698364806726, 0.05218214902973728, 1.0582704125449385}
};

static const float b3[16] = {0.45692056892880806, 0.502437078260746, 0.4957718188373172, 0.6042134048664701, -0.02467570132068451, -0.016837894589630174, 0.6919088047256879, -0.028873915930759518, 0.5781384031683728, 0.695100980490398, -0.04660312407401209, 0.6590297665066447, -0.044073116039754216, -0.08472357791870914, -0.0526741499581284, 0.6671192283425227};

static const float w4[16][12] = {
    {-0.33043989221597914, -0.028282576696639184, -1.0268285812410243, -0.7925526934120573, -0.9987786756208927, -0.6532671738054168, -0.7573947816857887, -0.5671408172860333, -0.6928799933746133, -1.06774804229523, -0.566798818730651, -0.6427882831759177},
    {-0.3512136502239838, -0.4096493111594126, -0.9239563429291618, -0.9894082219700279, -0.20460132638170844, -0.47676116508630917, -0.5834204847530786, -0.9642454181267076, -0.5579257365661862, -0.6852955507179828, -0.7493774035701429, -0.6797606223591057},
    {-1.0378111656709845, -0.9250776518173566, -1.0076234622492317, -0.39621707649190374, -0.47744134241508823, -1.0683372191608045, -0.08205422425751312, -0.5651767850006063, -1.402448085524705, -0.9645502024949116, -0.6718459923213271, -0.5825019852395608},
    {-0.8198092253610946, -1.1246294667289185, -1.2624542636095033, -1.2554087835525611, -0.8104537470760015, -0.4382129074034895, -1.827371192909737, -1.2595699849836144, -0.8062169261017237, -0.5243455553396693, -0.21863159271483437, -1.4608224247645571},
    {-0.2864726410249531, 0.4024837238634195, -0.5982106482889556, 0.5435388637786565, 0.06884180090047615, 0.24188065153524682, 0.08439832733706493, -0.4877023505982844, 0.09373134953571999, -0.46276552341046673, -0.2661281219665035, 0.23960210133977183},
    {-0.38184098238830305, -0.8890964859343421, 0.005361344008533334, 0.5773795406510037, 0.37491149693990833, 0.6324239545735334, -0.0035396522771037613, 0.137610437201817, -0.42998520920459726, 0.026562585851829777, -0.20914604210535942, 0.07864994062527317},
    {-0.9298631741603375, -1.2911720271843217, -0.7533356931048906, -0.3233577893542979, -0.7832346199646754, -0.911193235094336, -0.5952688322513043, -0.6102000054280031, -1.099180765089851, -0.44754281411988955, -1.1088322696546185, -0.7477043634797839},
    {-0.1757227268840495, 0.11387090856710425, -0.9909265296545376, 0.04410567458540323, -0.16502886723554225, 0.17882798120003615, 0.10617287778022602, 0.1919332267213844, -0.34577056396754613, 0.3179453624088542, 0.4703878929302968, 0.0014656079052606922},
    {-0.554467218197401, -0.5060812501039009, -0.9565504836090873, -0.8296560691305772, -0.6927055185691315, -0.6637138681904055, -0.8555844584377387, -1.3709427421794098, -0.8045192084617198, -0.907620292505856, -0.9276826621574692, -0.739971247246635},
    {-0.4799908398378411, -0.8435322708575866, -0.5150668555731084, -0.9662293419711179, -0.7344902507001929, -1.1413773610545983, -1.1907604160853555, -1.1997223525453349, -0.6563686552919771, -1.4040057895669, -1.1296327137438296, -0.6002741190913103},
    {0.11993266054899215, -0.19364731753394315, -0.026119812587722318, 0.3103620794096696, -0.01799957443758418, 0.09498176040489367, 0.5108491072033324, -0.23040840954299316, 0.08037238961565141, 0.17849536860945317, 0.03420419472552501, -0.05057054921232913},
    {-1.1271964265975953, -0.9133044018249119, -0.6370280942079951, -1.0852747191920387, -1.3154414819925953, -0.895968348912803, -0.6549533236378243, -0.24466534671235945, -0.5489580708495633, -0.6852787337578128, -0.8653050142546131, -0.20657252416999},
    {0.4182057803308902, -0.10570973441554068, 0.3062944598297709, -0.1978348707340166, 0.20760766753311335, 0.24493049706174402, 0.01917005689544426, -0.2940947502305239, 0.4435447985113184, -0.08117216170787933, 0.19821943685140767, -0.6078805783582133},
    {-0.2806349283119838, -0.42149653775576973, 0.31059743283252633, 0.11898860572129454, 0.20804166723544681, 0.010914637643551814, -0.51918318793657, 0.06931064636658517, -0.10132074959317819, 0.09094288693658516, 0.7654103874476604, 0.261090959337902},
    {0.10864125785538518, 0.4369743182683081, 0.8315454907785671, -0.25916852121395534, 0.018822614947914512, 0.7700841962504507, 0.13197029032629856, -0.34955143553756185, 0.19250583537116975, -0.2325069357390245, 0.2791262909269468, -0.28844265583446954},
    {-1.657670555944671, -1.1584364704024837, -0.24681391152414442, -0.5891960556092193, -1.229805191872906, -1.0274376203645776, -0.6024556129456001, -0.44941019390853276, -0.6898969472565556, -0.6747216416375671, -1.058131281640814, -1.6432079523826664}
};

static const float b4[12] = {-0.28790649014930964, -0.30514897427611837, -0.33210881389776126, -0.3906431967446585, -0.2729901967783493, -0.17119464548724406, -0.37564632575096507, -0.37203170854894574, -0.3581834542809404, -0.28397395056827657, -0.23599825827422077, -0.23080604998653834};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
