#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.641530273854132, 0.7167586062572157, 1.0766535516920968, -1.282106078908458, 2.795336706058656, -0.6683393563834351, -0.335718973173989, 1.6305466341115251, 1.0364582867586918, 0.5937075772968253, -0.6364535849600411, -1.3038402180731221, 1.5399070605108813, -0.03537376712679137, 1.8296782447970827, -1.0111470566084055, -1.243307575339593, 4.430053201669654, 1.1821061751858317, 0.7278232800231471, 0.5803201516994455, 1.6305343585257448, 2.8456236750992514, 0.7209485082337277, 2.741056366940772, 0.27495456063710483, 0.9676570807586352, 2.433608128876527, 1.5297521088982362, 2.986460273580263, -2.0907155386605276, 2.7677171861098855},
    {2.3779940474430803, 0.006156107529422405, 0.28625975147083976, -0.6174526354572725, 0.7766077408013046, 1.1803530605463322, -3.394445686551072, -0.6957477200501028, 0.79134652245396, -0.9757148525524154, 1.0479787752178893, -1.0072518304035456, -0.3258015900123956, -0.3800470024229241, -1.9647755246242036, 0.7490837814187078, -1.2561292061763436, 2.0484676617040023, 0.10202034801677548, -0.7629594828641024, -1.4942767312787963, -2.745898979272365, 0.14411402974728157, -0.6921408619258576, 1.758391089465248, 1.5799926486158153, 0.05112319065132152, 0.8533196703484898, -0.9751235049594352, 0.6910089128512771, -1.6833234704803521, 0.3424716144679177},
    {2.5958525780056547, -1.5750833105086108, 0.07271221157002411, -3.598077011003362, 1.955646064449813, 1.0463496722573673, -0.6872863349522755, -0.5756424222025154, 0.5303623663539485, -1.320471992082878, 1.0750625551037187, -2.3394268872820336, -0.8368148583703168, 2.439969087576145, -0.06993052250984577, -0.17934576937603922, -1.1469634151907158, 4.657097228126849, 0.888665518007405, -0.5002797570656607, -2.148153232224187, -1.2626816127862044, 3.3355439377837555, 0.13986315179943407, -1.2942508979324099, 0.12829326647132086, -2.4093881643127615, 2.5835861818723806, -0.22727579605461776, 4.185978049338245, -2.990712851674104, 3.6523313425995165},
    {0.2327041469468911, -3.4517194390646404, -2.379713301351552, -3.97122067741845, 2.6686493509355427, -1.7953042747429546, -3.69845655594671, 0.3087118141425034, -1.570955564729629, -5.4326697348228, 0.42464009018679044, -2.7888824530436183, 0.220997674968361, -1.3673709811479402, -2.0274791462658945, -0.31999735636821547, -0.5444169822025305, 2.62071893304062, -0.24070783388843245, -0.041374064138620444, -3.5496520297161, -2.4968843530670335, 2.6264954527565396, -0.6750469073804831, -3.2185867147368303, -4.095804651634533, -0.1627488886593856, 1.8417345822731803, -0.9583083234673534, 5.268580832379677, -2.3533130515525227, -0.8656873009252146},
    {-0.6506067173434229, -2.692820320084524, -4.160361571576407, -3.7420703922912195, 1.7676125991445422, -3.8358473691741977, -2.420108223466868, -1.7278920931588477, -0.16569153939709555, -1.8626505388507713, 0.30481237988321086, -4.0142826954966155, -0.2060439512115553, -2.8994006911237538, -2.611438449075552, -3.5098384882388207, -2.0109478385275645, -1.1560249519719046, -1.0946701815671258, -2.5600884131478243, -4.481190895022506, -2.368887914793288, 2.757762987733547, -2.49012853885573, -1.9388907100983916, -3.3470675506324272, -3.3804849841444145, 2.2708803466556966, -3.787470275959399, 2.9337620336883647, -3.2966240812207253, 0.7043779177753893},
    {-1.5943468918358843, -2.1482907631044394, -4.923896776681749, -4.202948702835774, 1.1105223240474495, -4.575835144314731, -3.755256155480081, -2.4257491690320196, -2.025693287240671, -3.366410436167796, 0.8553433438435494, -5.187277637821229, -2.001619564178416, -2.4612319596088845, -3.3078883007756663, -2.249805782228082, -4.401770936994779, 2.643450013930447, -2.4748387978752184, -2.2461777497110034, -3.7590966896987212, -4.16577928087917, 1.079501812235535, -1.8731790694677, -3.608727358156426, -4.118089405819914, -5.068817245864304, 2.001043204875733, -3.3991305714447058, 1.0805446983008204, -5.312040633311001, 0.1473461504443375},
    {-0.8136358713079616, -5.30157870664677, -4.670752958980868, -5.45070829004395, -0.09135577137550797, -4.256201021174007, -2.7214948341184377, -4.669624497916439, -2.2821517692284807, -4.468480389662295, -1.6537033449452714, -5.680005690621239, -1.137090446960736, -2.3273256011661783, -1.8693059566693286, -2.6326505916090794, -2.824501361456282, 0.7400077807994517, -2.2355586302124153, -1.875181691559932, -3.697838364205564, -1.7117575858261713, 1.5056770297880766, -1.047325566299294, -4.068140250791744, -3.6106207100851666, -1.231263142005001, -0.11390649232684491, -2.693726667722819, 2.3386868816184383, -4.511635611375613, -1.102089006751125},
    {-1.839236897320379, -4.115728490229053, -5.47515470821249, -5.464495597708178, 1.958913925817447, -1.5057418427697085, -2.27937427796846, -2.0876583269991187, -2.8564510981905546, -5.2397570639744915, -1.618912440139956, -3.407945295913932, -1.5993081751993876, -2.7731659030179117, -3.175704482368512, -1.489759264524391, -2.8653077669177915, 0.28244939828337023, -3.1931496032559017, -1.9073707110858078, -3.8293527275337453, -3.2208522113882516, 2.0031078642855706, -4.185684509253239, -4.446757255618729, -4.431273727479222, -5.864782010832246, 2.615810258276055, -0.30619340055623234, 0.5662320252368919, -4.281616137003981, -0.30529619851914036},
    {1.5788426976280372, -3.1411754950032034, -3.540612035322067, -5.000396201061134, 2.1399525813593647, -3.105420805371542, -1.9751034062197956, -2.754282698776147, -1.384816196826292, -2.806525760198828, 1.0856984717927887, -3.8469650957626476, -2.5001415871895594, -0.7648634087092638, -1.9837888102499992, -3.9058017964467653, -2.2526658463012583, 2.1528760630603077, 0.4377405046374721, -1.9472396192442858, -4.016544117092918, -4.5075351397446735, 2.029025904240965, -2.1583638187751393, -3.370039809215106, -2.6244181258189707, -1.0986006564431174, 1.012387566899759, -0.606733898780262, 1.4334080000350018, -5.6144295607816925, -1.0379277904387885},
    {1.6836977748649276, -5.1320366528226655, -2.2190960359314813, -3.9409077464858995, 1.6056946582952543, -0.1781625587249896, -4.832558168001795, -3.584934379800333, -0.7249872485365191, -3.797946843887325, 1.4507779746120055, -2.5571589154240058, -2.7402573174304723, -1.888110607266402, -3.1243833501975047, -2.0062059514877095, -3.4096742681436436, 1.5603189616220043, -1.2272024474703092, -2.6799441533590205, -2.7872895626917416, -3.774154180869559, 1.2443237307206862, -1.993817617341795, -1.6811960880769288, -2.983612439930431, -2.2627985075297583, 1.2633297304860107, -1.6746139480627218, 1.5148140868681366, -5.224997787759371, 0.10651756261115702},
    {2.5851929771792985, -2.0538028905647616, -3.754540978822373, -2.8666846680502576, 1.5506372437297735, -0.32510834081185286, -4.982469636916324, -2.5088589476666665, -0.3002997557950303, -3.3349220616028843, 0.5172679342447063, -2.723059315379551, -2.4904407330800393, -1.2282323078474786, -2.459897643287432, -2.6116005506686024, -0.6776776479842507, 0.2538265470023176, -1.328583404392881, -1.4327368657246997, -4.898868375822171, -1.88931653271874, 0.7472190158969086, -0.5038673178120608, -1.3682089245583813, -3.599971418027227, -2.0495775131416987, 1.0758848457222074, -4.025807505619993, 3.6203788310686393, -2.737414337449939, 0.8527276071249106},
    {-0.09792205418208796, -4.429213806397811, -1.9006417214749831, -1.923909220375233, 1.683600934946061, -1.845740659951941, -2.8863756434796173, -2.1361400795870433, -1.842346328619652, -5.094292144208991, -1.8519232233157537, -2.3169943266864417, -0.5560699040350978, -1.0590823072571183, -1.85224898998662, -3.663517923372172, -0.8541353392182611, -1.0190150951427008, -0.23964063110833614, -1.7881777111908366, -3.9941195173275377, -3.949123376319521, -0.14542907589710072, -3.059764250068501, -2.4112674269133763, -2.915807351910145, -2.60235403940629, 1.1388549568764013, -3.3961450262637123, 0.8636398101954982, -5.540562188817074, -0.8701767552654647},
    {0.8974034750136787, -2.4305434654889395, -2.9278340234817244, -1.3090493361610864, 1.871806970335201, -4.936112897518143, -2.7198988257591266, -3.2721923079960353, -0.461970519801157, -3.6572644039535582, -0.13795265218740743, -1.777134667881464, -2.487602226694699, -0.15177652979713935, -2.4233400521324175, -2.99344854115944, -2.195961090172449, 1.41482641854612, -1.902529087500599, -3.3198857665872725, -4.40762654588984, -3.5416603118234122, 2.753135687392272, -4.118118639188294, -0.9256755721888877, -2.945731698079172, -1.8970842824980567, 2.0045864097721906, -2.9420810493799583, -0.21763567591217708, -3.1659916124379035, 0.22855176082567955},
    {-1.0219229188514372, -5.981638863192854, -1.789095193039016, -4.735055110975808, 2.5465548885911162, -4.8303795815157695, -3.1072758764978623, -1.140504511933444, -0.06658954751170745, -4.648646345137258, 1.6068972478113106, -2.1400090601191653, -2.2893094880934366, -2.5974508687216997, -3.6831546544002323, -2.126535739657332, -1.963648305269473, 1.4633056512017948, -2.7654519151152317, -2.032302167242067, -3.2305484845644656, -2.933201331586197, -0.050981669257361896, -2.1968784518226965, -2.8152813797375775, -1.699445219980135, -2.081762458959447, 2.76574739167779, -0.7203205675667443, 1.3325264820949572, -3.8343576863743567, 0.776826222591342},
    {0.16611451844931435, -3.5685768751409217, -3.052112831422924, -3.1203076122511764, 1.9136444770777885, -1.7223303235655447, -2.272265220120632, -1.3504395798464006, -1.4666989299900026, -2.6047071566989555, 0.9085479344319635, -3.4736681321475067, 0.5052278273851805, -2.1078898755274826, -2.7938024679794458, -2.670802293340612, -0.4663916070884447, 0.5001717859267073, -1.2036773156990477, -3.331399087283447, -3.1560564003403444, -4.500221696475251, 1.6213742581096244, -2.180129427625816, -2.723373564711461, -3.1567420588823154, -3.2214554420207873, 1.6989232295862702, -1.0847014357321365, 0.6589185387851796, -4.096961536792774, -1.345715552848272},
    {1.9519734105972, -3.2143772889073134, -4.480388833013924, -3.1507655746165875, 2.747524764444027, -3.040441251760279, -2.660481209623821, 0.2959265589775027, -1.5965619271331828, -2.479944512802983, -0.6022803039231389, -4.196510055345208, -1.56305635994386, -0.839525497303133, -2.890773670853543, -2.167268602959379, -1.5785633606236582, 2.6191536046567845, -1.8628808822518548, -3.1289871023573537, -5.803037524076919, -2.230357858523617, 2.734531467840199, -1.9048314568188247, -2.1273445035037453, -4.260041324004524, -0.9475474334838003, 1.0397252811232152, -2.581796388765808, 0.3391544331869956, -4.63079919537472, 1.328300801546068},
    {1.9628248443869716, -1.6073821879634178, -2.13651814190024, -4.702333012547529, 2.146616713365095, -2.303302217509855, -1.8272520979560383, -1.171268511820091, -0.6039729110318809, -2.4805420672781793, 0.9739067046367212, -2.5410403054195663, -2.129350849395577, -1.1424392012916824, -1.1079909561693546, -2.4829894525458416, -1.7944700092291508, 2.405454708973608, -1.0447216663243637, -0.9171450162566902, -2.7198002912214823, -1.3192364221366215, 2.929361732552463, -2.4534720199823155, -1.725304211555597, -3.2319087128672765, -2.638820643931106, 1.0060608560446203, -2.7957187402795354, 2.8822160046454286, -3.7423168025976774, 1.5285873290806966},
    {1.542262829503701, -3.552735673148289, -2.277434271800688, -3.671387793371826, 3.2857642478562257, -2.2194019860949172, -4.317577637150464, -0.3204779470960235, -0.6365746282865041, -2.0089588599711052, 3.1038079478300475, 0.027042659853025997, -1.347680822362565, -1.741615687231101, -2.6247761863089174, -3.2339380716141495, -0.31105246560227334, 3.493872546185522, 0.580559466284442, -2.3033744610773144, -3.641117897030552, 0.5301562117458629, 3.8254686222864227, -2.073571816318198, -0.6703185343251088, -2.494266174767807, -1.5210822290943922, 2.205746261508397, -0.3303289626121531, 6.259200041660727, -0.9513648625809762, 1.8734103141566205},
    {2.2244266073820835, -3.1502495340539722, -4.513559646317356, -3.591578006691505, 3.3874969881340626, 0.8744606473320349, -4.156472731204905, 0.9322283573582997, -0.8142380387669137, -3.1233340519978605, 0.5240903196717102, -3.1085362744279115, -1.0197620429382726, -0.4987735344423117, -2.010588229612734, -3.7120460861953495, -2.0783873150852914, 3.332331424271258, -0.5658179751883485, 0.21222130310127635, -3.580959804281552, -2.5574916142123105, 3.4026366178575524, -1.8081750174342066, -2.5847877616279895, -4.431084419670885, -1.5635124106609406, 2.561974979352844, -0.9070231350657845, 3.2672095476410217, -3.434056369911742, 0.7015021275261963},
    {1.784088546073814, -2.1429180987084413, -1.9961885822454413, -2.303463383411202, 2.7605479778938986, -0.8709770990364056, -3.738588480937554, -0.6155618625831606, -0.9001553931910261, -3.6199129027643355, 0.561720059338788, -3.3342007689659345, -2.068000388355422, 0.31177949688953843, -1.8911049558743689, -1.3809756001718587, -1.6417312071241288, 2.2236639330765153, -1.13808321215414, -1.588269813961826, -4.6837067570867275, -2.91378460888484, 2.8571081143193635, -4.046663747595011, 0.04097286976267738, -3.416189301862398, -1.7715818452709546, 1.6346368242535636, -1.5826593140546115, 2.5664686198308804, -3.3491199949940933, 1.7401176162238374},
    {2.1633312446027575, -3.7597813506675357, -1.2538877287794024, -2.0544138586456455, 2.358688990840586, -1.633152091773753, -2.355984288771853, -3.5596715324447397, 1.2820164697943495, -2.885681740387435, 0.09411112861955721, -1.3049142450568607, -1.0345314211336576, -2.5856554230598894, -2.350763998393512, -1.7305466391758555, -0.9247159584885969, 2.0323832098370933, -1.2187797960221938, -1.8220901621555161, -3.7244192647148164, -1.8473166110102168, 3.4477025808636195, -1.9531920082629441, -1.784974090060915, -3.899108149844911, -1.3944091528124036, 1.7426225625276595, 0.41992517166106064, 5.300296871987162, -4.588269636473272, 1.1572469616312404},
    {2.4515097146213356, -3.542739826656327, -1.222522545259499, -1.1827813976513664, 1.8294165721709603, -1.0832539259687288, -2.1463855104387335, -0.17751752966198356, -0.24075996245883122, -0.9447321646232243, 0.9833430518180944, -0.5625454824496061, -1.8978916923184368, -0.09065925160998549, -0.9509580628377853, -2.2399541642386733, -0.5211788484785371, 5.289353376991056, 1.0206937609663538, -1.5635126726915851, -1.482180302845799, -1.1890726525839668, 2.355371817572026, 0.45393973288344625, -0.1173789588490941, -3.48804628166973, -0.19824853984371674, 5.048048831530217, 0.39038923531235376, 3.7030516156177966, -3.9458957480816217, 2.787444836540428},
    {2.437313826281409, -2.8496978098592733, -1.5206684157447676, -2.010124547757387, 4.258818153645472, -0.8238625027051518, -3.0592318097478324, -0.0643675187937798, -0.5731614896920985, -0.7333717228783156, 0.8082968580076194, 0.4573511618762357, -0.6084763418211604, -0.004871905499035636, -1.1632509731337035, -0.19035378360163646, -1.5361170128766757, 6.113674482713827, 0.9534420611921216, -1.451940121402021, -4.2765244284132615, -0.4443766450587201, 2.860280251540453, -1.8929163969500555, 1.2888030851902263, -1.5239176523731166, -1.769433192458063, 3.342322912513128, -0.47730183568262663, 1.9620539833970474, -1.512456947211662, 1.5062782214758812},
    {0.7989688233792951, -2.8906335534041245, -1.1360830144820793, -4.558000290364724, 3.4233952714633555, -1.3350095431567717, -2.9881572691344656, -1.7213472749536478, 0.6749500376605561, -2.1505417458653424, 0.6918066666697271, -0.8902440345434854, 1.1873120843915972, -0.7651186303148622, -0.7511214753526698, -1.3808039209559815, -2.580629761066344, 2.8858507209094553, 0.9397977317493604, -2.0549824668609884, -2.2138976737460085, -0.37239088092428824, 3.2190813765829978, -0.6757935303129111, -0.8377377961370251, -0.6764327602870632, -1.2907143703578727, 3.7635970254331386, -2.9200832779490176, 3.6603315819132183, -2.264032898508066, -0.49902343885380024},
    {3.3398819197836707, -4.139247328810247, -1.7290151604123354, -1.548266727423602, 0.8544841276972279, -0.21458412631432486, -2.9713796612593812, -1.7164751077617468, 1.65519046572216, -1.9471617152962044, 1.3932606274544137, -1.3033400857573967, -2.471993897996175, -2.0845793972380533, -2.1114361251992073, -1.8191134155795086, -1.4634744294735031, 3.399719619855253, 1.344671290705703, -0.6489179603547737, -4.430406642598742, -3.422240697306407, 1.7269308076562597, -1.853888274688663, -1.4582547841912554, -3.9740625804407506, -0.5458440547704648, 3.4868727151674714, -0.015846631404992945, 2.7135352757792925, -5.140399581003132, 1.4591308392084794},
    {3.18276382665427, -3.6532052037785134, -2.570080532254513, -3.9220617979679147, 3.0118571446035634, 0.28411415566245596, -2.8737932749350437, -1.5013123198945428, -0.5396252721176045, -4.404852670960051, 0.49556645565502994, -1.926499650842991, -0.868230152659293, -1.071368544379796, -4.14210632299735, -1.2081803055401925, 0.02744419763096076, 2.9102435938713413, 1.2561919688108227, -1.0865799802494351, -4.328938047963045, -0.31954651349185714, 3.2631540124190717, -2.2123659102339994, -0.9911376731974292, -2.0557131083227946, -0.5909439854527994, 1.3541520844714838, -2.277958771730921, 1.7950904819343672, -2.573981561341399, 1.0632574114922366},
    {3.0698964660158503, -2.4994861806462088, -0.7975201078666, -2.4438746345017868, 0.48344784562269244, -1.646293962935263, -0.8943658157109161, -1.4952518374991912, -1.7475506583758642, -1.5171433685807227, 1.85208100736016, -2.1540343437055784, 0.9627579636639277, -0.889932072914986, -0.8792039207729646, -1.6310597433763045, -0.5366458770615117, 4.037830391275556, 0.11599041630377158, -0.08744990269675301, -4.300389325442554, -1.512813951604977, 2.265311928489752, -1.6037162100796396, -1.821654288681038, -2.7632359506588156, -1.345069168661328, 1.649960184198753, -2.2219400155331903, 4.995664196026405, -2.7079404750091083, 1.6185142832880375},
    {2.5817403451921304, -1.7260177605175695, -2.469057497339985, -4.103947649915127, 0.3656383463505436, -1.6481439778283828, -1.4952533204868261, 0.5777003673548007, 1.6661483188018242, -1.9665860762915743, 0.1401290660454794, -0.764775301452288, -0.36115868458583333, -2.568432984274406, -1.3092742341814951, -1.1962708006629412, -1.327866941906424, 2.7902839085641893, 3.23285931060401, -1.5512049715985472, -3.279178568664538, -1.8595883666029538, 3.2548895564677363, -2.4194103383455667, 0.19370953130947396, -1.4635536700572498, -1.4528224855426854, 2.4272129128505977, -2.258126768688401, 2.8902742037358125, -3.238958408853065, 1.7973372112645472},
    {1.6814983789424154, -4.055067794696582, -0.19780831626319767, -1.8270226358451525, 2.6850268604892302, -0.8022628604858371, -2.1627957568009406, -1.0176159969804897, 1.7969689830378055, -3.51450102277468, 1.5708468941153846, -0.7132590441368974, -1.5141773459004444, -1.2725577524367895, -1.844575402883433, -0.007843475611056363, -2.9240828184615744, 3.986733294519172, -0.19487981762658943, -0.959212159036408, -2.163681454225432, -4.1210048476350805, 2.515062440872362, -2.3210414306785254, -1.2316762740666656, -2.3581868443274216, -1.8961435343813164, 2.7108986805610757, -3.1631965410860996, 4.48594459834854, -3.0614382779827274, 1.7516298803939747},
    {2.901491507690605, -2.265852075290774, -0.3143327673476295, -4.245881158869404, 3.10435900233909, 2.969824839673432, -2.776841522920211, -0.5807280286902909, -0.9051187909429015, -2.0198168181047875, 1.5272656909364128, -1.1989653915140377, -1.7355907183669077, -0.2995807717081865, -2.6044160630387725, -2.613407830755588, -2.285108365384206, 3.1104195775187424, 0.4117140308772744, -0.9262832375125597, -3.2531234237983746, -1.0151117615947343, 2.2885377095234487, -0.8533151960941469, -2.4670225644981016, -0.6940224308267251, 0.2910652901000565, 1.5820242515995715, -0.0015418743909815567, 3.0808416736371913, -1.8495976070042242, 1.6235277656964517},
    {-2.0260724755231476, -2.371221574763466, -1.074943363763592, 0.23927455914275766, -0.18239908328480978, -0.038959293148265295, -1.1882323898893639, -0.38430673120634445, 0.7852169417072294, -1.312082703857606, -0.3388752525658424, 1.951103372517438, -0.2681732306694438, 1.727381360622671, 0.19950991529395817, 0.07612898957783194, -2.4183287336366233, -1.2391490788080186, 1.180293992303019, -0.8506857357368411, 0.7683850496578065, -1.3214290062059906, 2.1645084422168526, 1.0679592556730475, 0.33270147612865275, 1.2556630226111447, 0.050588921212412874, 1.144020709689933, 2.507232772331802, -1.649296248734996, 1.1157901994831558, 2.5787274840320125},
    {0.0991921953438837, -2.2355062316143086, -1.361114036472889, 0.8502792541349645, 1.2064790547628013, 0.6554665500421539, -1.0623893364659331, -1.53682800031904, -0.9143143716807028, -2.3902409230345683, -0.5991599633784256, -2.0615525899364977, -0.3576437173286654, -0.10106018346949755, -1.226788886491367, -0.25201356560907034, -1.9546156644337258, 1.5877661582448552, 1.1562893585450562, -1.1918595621311867, -1.1130718897608796, -1.6588554140372413, 2.402104669067077, -0.7165644446767837, -0.018098666158777837, 0.08782169656513017, 0.6519622450114324, 2.346664308045036, 0.17837015050836175, 2.1646843419394073, -3.0221435500766467, 2.1863985589239228},
    {-0.959402872678513, -4.383554357768066, -3.7049670122550222, -1.8318281585669087, 0.5614271834207238, -0.9371780022228091, 0.3159363688903455, -0.2723651447459844, -2.668250376048184, 0.1248201580150581, -3.21922394902395, -3.1067376462955134, -0.15506770009779547, 0.21773848850380215, -1.1919463388617901, -2.2061355489263716, 1.6931453322375896, 0.09994579172716457, -1.5611887254244055, -1.131620190160494, -1.2808330378260966, 0.18033668087273988, 0.004269607929629398, -2.616847113627508, -2.960546161795941, -1.086248184948822, -2.9432182605982744, -0.5844385900525997, -2.129984285788586, -0.25750419074594055, -4.044705113637635, 0.9455697616607631},
    {1.4915659466739577, -1.980896934129715, -1.5610677364841843, -1.2270122357887896, 1.6551009197337454, -2.548079101960325, -2.99618494030652, 0.29961072162176855, -3.710218075476579, -0.09674272283575755, -2.306199130509046, 0.02127238663362728, -2.2069624478191416, -0.9160762294530398, -3.643331675290406, -3.279244081043998, 0.976666589405089, -0.5379682770512281, -2.9475706781956186, 0.7476214363248734, -2.5503298984042284, 1.0750110257141896, 0.6122524881754187, -0.07359835239439362, 0.11035731012907794, -1.3395128616680165, -2.003077283441423, -0.2505065841042084, -1.965826376425279, -2.0694554890188064, -1.1708715476523333, -0.7625132957122087},
    {-1.5616057684675138, -1.6186569667813084, -0.892105086662322, -0.563963307962482, 0.5474773772449315, -1.4199414815159266, -2.172299381346211, 0.08311810246295703, -3.5882269632200545, -1.7001132396485599, -0.43951084616505115, -4.0709789597651875, -1.5167061006958067, -3.0385806886196716, -1.2867586714762809, -0.7756165645326933, -0.5170899207658455, -0.473616149079899, -1.3578214109995375, -2.3398335978416243, -1.4681071322855204, -0.09969692287153543, -0.9253943925029862, -2.538010095703112, -3.7583300744897765, -0.11201245923357382, -1.5531240746735904, 0.612709610952666, -0.7213065649616165, -0.5262721473086828, -2.236603542487857, -0.3952802047275729},
    {-0.7646213242635532, -0.3938374489111603, -2.45990220000095, -0.44812692648667063, 2.507085900065582, -3.3476145876900025, -2.060966336631134, -0.0679032624082386, -2.350702012095805, -1.9603761688795889, -2.8221420208835646, -2.4930994633614936, -1.1504182851617062, -0.4417697236466139, 1.8669199892366763, -1.080990889667813, -0.4596746105087129, -1.0995740498526627, -1.030745307037138, -1.4455557689286556, -1.7979142485452997, -3.135003380645129, 1.1316868232344266, -1.9687812426395528, -0.9984523867510517, 0.2173984720949121, -0.631869344206322, -2.5543440418505683, -0.28130153011090475, 0.42563729212157636, -1.4158987268694454, -1.1573956414572653},
    {-0.6325978459930564, -1.0756181959398823, -2.337841079586519, -3.205836711582572, -0.2028604847814174, -2.726944224830926, -4.584080242224092, 1.3566740991721147, -0.4919966138282587, -1.6094413078555663, -1.2766617950782562, -0.7156357182989219, -1.87862725402654, -3.586237497240506, 1.0281195682188724, -0.9907318208675358, -1.370662952174186, 0.43907007663733005, -1.4534591414627955, -1.9966733262200456, -0.9223583605642315, -3.925585210084883, 2.002775289269304, -1.4392180365580705, -0.9344984327545934, -0.8641984298080452, -3.933217176480793, -2.2564255318917135, -1.0562711562227383, 0.19184620653335918, -2.0650518147831725, -1.6145767448956885},
    {1.6645024763966911, 0.6567484299353903, -2.4291156917557393, -2.645107500500128, -0.11103058467956216, -1.77258357224652, -0.657461104861452, -1.0956081967208164, 0.608128427604958, -1.0272139765764154, -2.3234518075788357, -1.0246069890243967, -0.12870839375524182, -1.2251638590463667, -1.2914459704860286, -1.4049335991572331, -0.21549341867300764, -0.32530440788726667, -0.8858581689001247, -2.098039799562973, -1.3803343400266186, -1.9470444351960734, 1.329876164435798, -2.973214098484076, -0.9068428526732863, -1.3683829755974517, -1.9265438497668506, -2.4038567614163195, -1.5889209201549344, -1.1457590349485, -2.0014765248720416, -3.2441877592829735},
    {-0.04182335387162927, -2.33784870494846, -1.519154728083032, -1.3372900503099583, 0.7404440030591398, -1.7571483180721357, 0.20112175273088126, 0.04990645057143614, -3.1685392815331612, -3.5619341802643394, -0.49293132393986955, -2.6414038186918183, -1.1259752894767012, -2.4568039732393157, -0.8034495537606434, -2.000499883000169, 0.21264948838132913, -0.5259757029999076, -2.863815304525389, -1.2775740462018461, -0.9546862792572264, -1.7690812955206228, -1.3478756490043449, -1.8196995823275437, -1.7998606016828835, -2.3473975688810924, -0.6364977538328822, -0.2467969247018718, 0.40149779084155784, 1.0372536326975856, -2.4966682233817323, -2.010885970441663},
    {-1.5283461573417416, -1.1736590625177663, -3.13761100753019, -3.397501347157532, 1.6842097904741522, -1.4977695661597732, -0.14234309393824696, -0.6300369479159731, -2.21533276897367, -3.5299373569782007, -0.8606184731304958, -2.347287493232646, 0.2162675603548878, -0.2983416926729214, -2.259826604763983, -1.753309001798421, -1.5208691063032924, 0.43583353588403373, -0.9099295200139866, -1.0004609937223239, -2.826505056977719, -4.466188222443073, -0.9874308892236207, -2.9731423061684064, -2.5146006087495274, -1.322527361590737, -2.6852756352264526, 0.5145205576774414, -2.627477337399465, -0.5632599709983668, -1.892769316369204, -1.157714127336671},
    {1.074103718526566, -0.8440035028076384, -1.5385009991565073, -1.5072888645903773, -0.4609827420687619, -3.384876733356802, -1.268846761147387, 0.5182814538865308, -2.580316753039978, -1.5700276815591463, -4.0398865560974775, -2.315678402408831, -1.8121907580757786, -1.4430592906326765, -3.741624441587815, -3.8596589581376275, -0.0851910060812716, -0.7927413523837177, -3.7687677702069355, -0.8290240107707806, -1.9661830659352184, -2.3509369440092107, -0.1792844394573589, -0.5309899684254075, -3.22281511888171, -2.1518498645389776, -1.517448318691298, 0.4210975916789654, -2.180634465013726, -1.5847233588272036, -0.34312703109891923, -1.1774620681454315},
    {0.9319611938175909, -1.1016528645949204, -3.887773589547453, -1.3048626950345261, 0.9077580410494919, -2.0749403452880926, -0.7043242873952107, 0.0271199180294436, -1.1109414391253247, -3.5503467349305744, 0.5239687406581236, -1.995666139164636, -2.8859864738261574, -3.27175268598569, -0.978954162614266, -3.1798885241698547, -1.9126741351844128, -0.01870688695637515, -2.0447374355423773, -0.9651070316003267, -1.5599314233604467, -0.3562240446741143, 0.8860290596854183, -1.5716000470874785, -1.9686449652551143, -2.416927260302123, -3.7374932741427687, 1.2199516128554786, -1.0609527792461673, -0.028660614257423455, -3.0824170341804056, -0.6155815004120346},
    {1.4529552190429889, -3.2301863699446987, -3.552883836449531, -2.81636245971795, -1.201308761096049, -1.0970089106322882, -0.0841765266474751, -1.0853736722746858, -0.7784455160458941, -3.7371375982557966, -1.9567573761129358, -3.1450446678183206, -1.1568192973883178, -3.971856174089107, -0.008554581467152926, -0.3969727144183253, -0.01745750990738133, 1.2585588497629456, -1.024803575224051, -1.3385256971667856, -0.20796964941186816, -3.489580278450438, -1.18570388830707, -0.9757355483214915, -2.4785471879668606, -1.2011682906117696, -2.0953200763680875, -0.603178589717463, -0.6880510247267269, -0.307725375240353, -3.919516949886856, -1.6366655382795767},
    {-0.20054361165813575, -3.0765816924179483, -2.3796336330968284, -3.8276926727564673, 1.6109403726135096, -3.671565863958228, -0.5991460764562678, -2.339087561449541, -0.662838898048824, -0.8389308123601401, -0.01530945218654787, -2.753648384070259, -1.6466703100476021, -2.7472885520412778, -2.944859510350132, -3.1899322392953455, -1.8110905928756895, -0.21167214781427535, -1.1789773099620806, -0.026020427469468, 0.266381187296531, -1.8421529053460095, 1.2843746263049758, -2.5284922441490587, -2.8913293877270916, -3.1029861781852226, -1.4505791863656314, 0.9623569492819893, -2.0431303757944677, -1.6278993106559476, -0.9905695771429854, -0.44795167558225113},
    {-2.061458105195313, -2.0162049377414513, -3.791554023644499, -1.1188187457935574, 0.14464673250220286, -3.3200202535118457, 0.4535320282754873, -0.49306995232701856, -1.3670304984615156, -1.7823729725518307, 0.19262129186955762, -2.4085733221282206, -0.729357214536914, -2.9349977929438933, -1.5866770373521093, -2.2777601948961226, -1.6009409245156632, 1.5579118560691214, -1.0058686909404058, -2.0786339580170123, -1.945392090828168, -2.985775772169024, 1.9407055377431521, 0.33575069972528887, -2.365484551584996, -2.5679758286724232, -3.428910028138142, -0.4935183144055962, -1.211445339315204, 0.612164137147616, -2.270529013579027, -1.236919698597902},
    {0.9002070951743414, -1.3378283595110858, -2.4472133794584283, -1.5136863225901234, 0.5936462991780589, -2.9333186266003426, -2.854272677363556, 2.65392669372147, -1.827619259315769, -2.663279610373319, -1.0463683232641345, -1.5104408067011645, -2.3626894973238626, -1.401210927346723, -2.7533901813235335, -2.450205610923845, -2.5758932384333737, 0.609045350985564, -0.9130927320198926, -1.400583162148843, -1.5355688965709005, -1.2442999819478349, 0.7920709654461753, -0.6515195937549556, -1.8285316914750651, -3.182487648191209, -2.1537129519075555, 1.1615420424822174, 0.7814249141637276, -1.0469557071932836, -1.7220795518535827, 0.7144983855020374},
    {0.48929552242131236, -2.9136908184242567, -3.7739943391591897, -2.6532918016721028, -0.11354263133171133, -2.8309569720598615, -1.3176204127124433, -1.0506221478264082, -2.678715161014099, -0.8272227825707248, -2.7808063105526046, -1.7364878354923126, -2.189651470936129, -0.916717952580122, -1.6880236780841607, -4.398990861970124, -0.42409073974631367, -1.951408656062106, 0.15064501125031246, -0.6885032965149296, -2.0930630934845196, 0.08574469507884176, -0.07029267130930165, -1.1953490579779396, -1.242518926439102, -2.5473277245918284, -1.8577779857598582, 2.7820243883583204, -1.7654726855494747, -0.6868092723079433, -0.16244529567391228, -1.9218669907611656},
    {2.310225673436571, -0.9960183579697657, -1.0359093820127414, -1.531246792228209, 1.609615357575684, 0.04022028191409897, -1.1211806572755478, 0.11401860166369197, -2.714942545689307, 0.0016837846532021656, 0.20005212738113998, -2.661754327695206, -2.448017635468042, -3.1831974342639855, -0.21852871931763657, -0.9288142228996226, 0.9063780697375028, 0.9913586284003831, -0.22481955639377849, -0.36073103329792483, -1.013572866868961, -1.798860875414747, -0.20620810091610936, -2.430947295540496, 0.31141343682702494, -3.800949723374471, -2.4922280062460063, 1.8353776843243808, 0.29385550977073027, 1.3281646928017963, -3.059561570290451, -0.8319857245521284},
    {0.7109258581124295, -1.0800100188485846, -2.041567433835283, -3.1363143846757566, -0.559549156064051, -3.423909555403617, -0.5336512042131278, 0.24832217904136744, -2.81245616788855, 0.0673100493336025, -2.0575318332499672, -3.1587601618722037, -1.4330500896843663, -2.773064708734975, -1.3649376260991555, -1.2158538679196957, 1.0443799050839166, -0.27596805720989187, -2.1987332514824747, -1.4761688552448042, -0.7958333990754481, -0.9879400184865123, 1.6449384002919378, -2.540299688206792, -3.010158240058325, -2.5253237091306304, -0.47372017221089596, 0.43202419622379695, -1.789947426421934, -0.7323527407578028, -1.3069337447333595, -0.5488560938636827},
    {-1.6767575255124154, -2.5762059286099044, -4.29202272933766, -2.5619288478003566, 0.1398385228362493, -0.943880031434432, -0.1561655750271885, 0.6849799766916373, -3.077824941412445, -0.2721577059959297, -1.757778394698878, -2.5470978037452277, -1.3720924345480698, -3.2068151400152547, -2.2526383409138107, -2.871371530689141, -1.5280051866055147, -0.7073022765179714, -2.080460770360074, -1.18213657261646, 0.8733007696088589, -1.6510761544122834, 0.9979032891152286, -3.5409924346619834, -3.6969142312599077, -1.6763163558470846, -0.7284910441118347, 1.0870792428024285, -3.241683340725535, -0.6109691034337955, -0.1592966926675689, -0.24055922691577342},
    {-0.6798725289016425, -4.612952708550146, -2.2813409423305337, -4.983522097509534, -0.5697036165801289, -2.985971223659183, -2.7700440596510547, -2.3141205045548614, -1.5270302679276395, -2.5778002669165527, -2.8274392755133073, -3.6261951489442077, -2.909648938026193, -1.6627652333105118, -1.7038828068427911, -2.4895626534426527, -1.553349983455243, -3.4283552974924096, -2.8330282908175137, -1.79414975616933, -2.43979527120921, 0.8002604092042023, -0.29650323204455525, -4.173233913657189, -0.26623451695985584, -1.9658955113150216, -3.5039637091731155, 0.5791721956415964, -4.961744670500125, -0.8499261624837232, -3.2395501842126757, -0.3683159409368242},
    {-1.6995936082772334, -1.0613936374617488, -3.003234278044008, -1.001905821763091, 2.4651957550536294, -4.902632042587542, -1.4624201439293931, 1.399059812000408, -1.4745075868767656, -1.9100763727302785, -2.0406705614023224, -4.112835665170797, -2.297460676458521, -3.744677490549104, -3.9593700309942994, -1.9655509546963332, -0.5223287580885615, 1.1082822443708242, -1.2809452480369665, -0.8547070579741095, 0.8375555462733848, -2.004583924819391, 1.5166300301378484, 0.039327038873889976, -2.0706758566858072, -1.2913029854557505, -0.9727613537372726, 1.7886483744599622, -3.0159717117132994, 2.146038244749232, -2.0722276773257473, 1.6757791512196105},
    {-0.6443420616362168, -2.004387393815012, -3.4246040751852043, -3.066690921360126, 0.5895831653486184, -4.782598022043626, -0.9176630693403599, 1.2798665983675115, -4.145625031770186, 1.7211681177446274, -2.2014651680449067, -2.2859204272277713, 1.4067102256264952, -0.6626883584948338, -1.7519451332678309, -1.387820490056444, -0.3516677264211041, 1.6951462689588748, -2.7797053065155652, 0.9962033607650902, 1.2436740093009597, 0.30421524702709407, 3.175249141708663, -1.4795608301095093, -2.3430859250986407, -3.3919818321105932, -1.1872427015771139, 1.3775452183254846, 0.15825022848286033, -0.49230253459157614, -1.8341276288123918, -0.2323365240706723},
    {-1.5754138842910899, -2.204053985957043, -4.059314958144183, -1.2501935734849392, 1.38994527815806, -4.91339398009432, -0.7599550021516805, 0.6947513077517751, -3.292002892579261, -2.1533983884737498, -3.079299158056169, -4.418321560394222, 1.121714714058379, -1.2046359585647086, -3.5734744800952543, -3.6841559366998884, -4.412164230542446, 0.35705710930389256, -1.6603929647699909, 1.5471172932775688, -0.3824350170850615, -2.6201354387099607, 2.3472318333713424, -2.960099982906217, -1.5694317395552961, -2.5526040996958423, -3.4674143694017863, -3.379057734130978, -1.919015542245359, -1.5292616880956273, -1.6812644380563873, -0.016193440592458974},
    {-1.911499877931783, -1.8787453332995592, -4.0322319231321755, -2.3477124180153726, 2.076381305461537, -2.555117825821995, -2.868621746394471, 0.41297021262710704, -4.839474596840139, -1.0814645006617472, -2.286715641337834, -3.388837310675654, -1.8288235846213756, -2.9202584359967756, -2.587553052714897, -5.4497227727424, -2.8248878013699623, 0.43694486334932753, -3.215344963424379, -1.4330315754258796, -0.7890048339398374, -1.762108935626052, -0.19409736977862063, -2.0051383318708407, -3.5149050874340335, -4.491013578598879, -1.9456129289620547, -0.011203111385569892, -2.071894830047948, -0.5350488091119304, -3.9418389104193077, -1.7978771206440944},
    {1.230077516341312, -1.8827162644422732, -2.4574651710196496, -1.0164269815841318, 0.42212464305800806, -2.875171794342627, -2.5929967212695, 2.489682170593002, -2.8778531524522197, -0.8578996930713618, -3.1946315717819465, -2.7712017662950266, 0.2980955743514085, -2.497442027715893, -1.7515911156400263, -2.0662268018464167, 0.08183997093392978, -0.8930944956943565, -4.4016834291601326, -1.3934560041461983, -1.919993253333271, -0.4200966796683741, 0.23850521839721903, 0.016017160455294145, -1.8032200110786911, -4.391695202528123, -3.8132787650635462, -0.23807101895401878, -1.5549376464483482, -0.6763801968439708, -1.2672198659527796, -1.2997798947560462},
    {0.5527463409580855, -2.1443034541580843, -3.853611229350674, -4.299921730299608, 0.824343934965627, -2.5496156208992784, -1.414164246868336, 1.4274288770968597, -4.796650240208707, -2.1837039630776207, -1.8750631524775598, -2.9146384488446517, -1.2686227476792986, -2.2404886264530144, -3.5653822606488026, -3.581827037993197, -0.9660558912936708, 1.714555502949192, -2.7775342778087935, 0.149244203282231, -0.49674580236988186, -2.4843391668345816, 0.9629332233672768, -0.9875587577378467, -2.3304140101004096, -2.292913345055413, -3.0094420545135967, 1.1594760752590532, -1.0889947695060957, 1.108944661950919, -4.729064629811879, 1.0451137146069014},
    {1.605806375431217, -2.037564308925021, -2.663222085662067, -2.614069724537013, 0.8747250670520429, -2.1949469634608767, -0.6570175512315847, 1.5126507940799514, -3.0035135982880954, -2.657301151932096, -2.4474866840812566, -2.619114195385945, -0.8099721758750552, -2.3822080300181443, -3.8668746343858675, -3.545706266824064, -1.7496348832091508, 0.10075004927321499, -2.0110081050557067, -1.1343370444162164, -0.12950149803279457, -2.1298873337010478, -0.760479887888286, 0.3885441331204822, -0.9917185129794885, -2.6261675437718695, -3.0324814391922916, -0.06368836261652112, -2.778410765866028, 1.7242367500730518, -3.3626488944083177, -0.3338462356205725},
    {1.7353933311823573, -1.84607640790833, -3.9748634723805734, -1.5350989824155736, 1.0256079066377657, -3.7088050151354106, -2.6869220138784726, 0.1510796748734484, -5.159882532246203, -1.830270950383998, -3.0182717818984592, -4.347101854229757, -2.5167731422793223, -1.9428435201625043, -1.7025105105765466, -4.666921509925366, 0.19673244289873504, 0.6956920572504903, -4.377693697351246, 0.19694635995348259, 0.8969330841181302, 0.01478020437643189, 0.8011762477211534, 1.8825505360157455, -4.884121416915159, -2.502980475678486, -3.45000983971067, 0.0764415928497953, -0.9504354963717483, 0.846688297345688, -2.0679944738150824, 0.195768687097486},
    {0.7110453981306327, -2.2905054272735894, -3.8340002390500403, -2.8806481513021662, 1.3975873065284854, -2.725523058363896, -0.46213320619818554, 0.010619660865798545, -2.3011515933379396, -2.9887365806189745, -0.19203021859132072, -2.4616098234043076, 0.10021890723938982, -2.184929212651032, -1.2046170280337065, -3.0390869779997316, -0.4956796008613085, -0.6313994851803375, -2.5430052197250945, -1.9225515293695672, -0.597547788965683, -1.215653338946503, 2.094864278128371, -1.234826716860296, -0.6068728333280554, -2.7823696701491247, -3.4419015266492, 0.8582787801307639, -1.8569988523940266, -0.08974828824940902, -2.399231192386133, -0.5624051152782407},
    {-0.35423228992093286, 0.012390805286807999, -0.18895256646589176, 0.12196857741505804, 0.1411657077329708, 0.45445685933556934, 0.8379468452952905, -0.4486421143856769, -1.929514417633718, -1.0555751000855564, -0.5198083742272933, -0.05851921686398633, -5.75823355589931, 0.8395045199066794, 0.20161012446042714, -0.255319503213705, 0.7596794456195798, -1.1094230050448042, 0.8681129715076863, 0.7891183963627434, -1.7436660666850696, 0.1716278894085129, 1.1100069210622023, 1.9454331356956014, 2.0038644063364623, 1.6695445277694458, 0.14265282340998983, -3.349109974910057, 1.5001347382039787, 2.752496740299078, 0.5588728832620609, -0.619137002492922},
    {2.412540230303569, 0.9679055743245839, 1.2018043598061545, 0.28546770392159987, -1.4181984594941788, 0.0702944307484303, 0.07750593991950862, -0.6865056456142811, -0.9749947416819442, 1.0811505910816896, 2.54370094815024, 0.21534463034224396, -3.407093131448726, -1.3551720534917264, 1.8016536390345488, -0.01599153884218434, 1.517647875907869, 0.5086076136894375, 0.4384937334925017, 1.076761635192001, 0.8662936238690129, 1.9191768131251405, -1.8672904924805296, 0.2767534736552886, 1.729023335159256, 0.6361722916395122, 1.7226295001582017, 0.16677519166015517, 1.681917844603888, 1.08437084411462, -0.6132694094257303, 0.057234294976798654},
    {-2.692407924742674, 2.3580416826550312, 0.44261138109791714, 1.6443885995242988, 0.18490823054847316, -0.8472466627270143, -1.3114342845159792, 0.34165081539022985, -0.8285173817516349, -3.106791803216597, 0.908263003383495, -0.6380125854697786, -2.827098010778657, 0.32229303467876946, 3.839041827714299, -0.08280534334456835, 2.013309376508965, -1.6306589310547466, 2.229152080025195, -3.0004421184641283, -2.9823313786958083, 1.6634117809233369, 0.4986686253752763, 3.40292304068719, 2.608022539853192, 0.7304220391529584, 1.3327207336101492, 0.05061603111611929, 4.355540130258155, -1.3587270307152974, -2.263102903702408, 0.2912051505972266},
    {-1.69101021173784, 3.4328627059483465, 1.7394554542728282, -0.8371277764341836, 0.8849587337737026, -1.2790159234776666, 1.2241500402120984, 1.1241917157524035, 1.053812620886967, -1.5692356374605663, -0.04072309599378205, 0.9137861888103248, -0.04956046289056694, 1.8863439885213351, 2.402535810222064, 2.8017611984354747, 2.8712649914337876, 0.08853599008421452, 2.3561037913131293, -1.1470325505744874, -0.25085235753894003, 1.5900458229646548, 1.6204722639481275, 2.9588873395040567, 0.3352161829104495, 0.26221212729605137, 2.0375161044060732, 1.1596631228182943, 2.7577617307238924, 0.927717484555402, 0.8196729544049842, 2.243748509505885},
    {-1.3646636727780577, 1.2421451064449938, 1.834079573694006, 0.9451980963587076, 2.166908631163951, -2.621219419773369, -0.14994612549132624, -1.3148022383409657, 0.9516202016126519, -0.48032264265605973, 1.5739921478071863, -0.694032386515545, -0.2603632703349346, -0.48636125141137126, 2.0921317010037224, 0.7804348857638969, 2.3969872860913486, -1.0706766730866824, 1.9325861870137893, -3.277486956351291, -0.1814834652227235, 0.02471172303610451, 1.260856882709507, 1.44906160500953, 1.570300667889711, 0.579147045871376, 1.6057280753890177, 0.7185969980100096, 1.6010678758018706, 0.9764275210388974, -1.2378925744391998, 2.753093110885931},
    {-0.04807819795677221, 2.7751414682867197, 2.6980567753857727, 0.9495580824345008, -1.1105828307668675, 0.2592654863378231, -1.912910537615936, -3.796384720755797, 2.0554530815582113, -1.1397819054246154, 1.3093540331858304, -0.08044272390636077, -1.7667632947795595, 3.2067012846384397, 1.8541250249130645, 0.09592867162974275, 0.6330060254917129, -0.9697876491905114, 2.9109382914253157, -1.8232223648247012, -0.2107098784653486, 3.6830680074626794, 2.800818829566008, 1.5554996984527378, -0.11611777909594281, -0.5154551504135482, 0.5213018919694243, 0.34674242792646087, 0.4345242156906617, 1.354691633072477, -1.3421184186002924, 0.6047098011640876},
    {-0.44599328622016693, 3.312032780955758, -0.5655624324591518, 0.9424970122054009, -0.87669690394847, 0.06529526286526102, -1.579734654512798, -2.3181643595818735, -0.39627873898502275, 0.04130879383152165, 1.4124309551440277, 0.42752777034486683, -0.6566568982958386, 0.8248472002732489, 1.572759041282451, 0.03410851522048463, 0.0681197412234792, -0.09488317270719773, 2.7069726715110063, -2.8071762281040638, -4.149656511619752, 0.9796329629715247, -0.8888626643065368, 2.6570406883348614, 1.424969994007389, -1.246745622651844, 2.467060888555313, -0.5869613925675079, 0.4876230890641934, -0.1538220053828196, -2.229526755740765, 0.9224902393987761},
    {-1.9599434018664645, 3.072068669415554, 0.04933910042187951, 1.3653257531781122, -0.023157954233221773, 1.4884402036079512, -0.9244407984538525, -3.569171334918839, 1.4915995916050027, -3.2486123290370115, 0.7511931408464992, 0.9764594090285388, -0.6088700773294587, 2.236170672573528, 2.2523592650033426, 1.0739449706146604, 1.5361615259585615, 0.07268364577522539, 0.5145072177491553, -1.8496280376596013, -1.6709471455865132, 2.644059924124287, 0.6325489530095858, 4.316026897021898, 1.4113459489977793, 2.511123352947471, 3.182828247147584, 0.3038829295250196, 3.1362731134333792, -0.7769224062588119, -0.9205137807260515, 2.698458553975164},
    {-0.06088962571894719, 1.8455866473508329, 0.9871538070409408, 2.6195180465744192, 2.3354216912455255, 0.6428671995473669, -2.448464862434396, -0.2626354660790457, 1.9297262685543897, -1.7506308242040105, 1.4322792241686613, -0.08884413521417919, -0.10095608032065764, 3.3080575404695924, 3.6440451810815033, -0.2618413552802102, 2.522616408352852, -0.14733267788694734, -0.16511297186196894, -1.796643600625706, -0.7129237722062145, 0.3552153400706215, -0.372869487271781, 2.894351393107523, 1.7133918460455488, 0.993510816894318, 3.0895023509353727, -1.292513446044182, 1.2602729974871762, 1.30565818650146, -0.4310786631847682, 1.0250192065277306},
    {-1.9232654838692937, 3.1315343703706913, 1.4384243261408272, -0.59299230941928, 0.4135099076077802, 0.207429410135199, -0.9092969506165979, -0.5459449829462353, -1.6062476840690063, -1.0324315500468202, 2.3440134208283716, -1.3868608252781338, -1.4860821213240747, -0.8871465690865126, 1.0414075898343285, 1.1456455202922973, 2.5064320080468545, -0.5839094134088937, 1.529911492539926, -1.3614103500102956, -2.1873831744729255, 1.2567811654775676, -1.3434723367978472, 1.6962487581096526, 0.9690735934224165, -1.7383873391755713, 2.2371415890308293, -1.0749646430837176, 4.685151509747638, -0.8772302785839321, 0.13000340590582288, 2.8199725189032785},
    {-2.500800311553971, 1.1083146427931159, 0.3089696461807658, 1.4104831036886325, -0.21685186447084767, 0.1695955704073237, -1.266026276439795, -1.883923528893231, 0.09738222617843094, -0.4292796957587101, 2.911786576237543, 0.1699998288547428, 0.5661211811633818, 1.3128995083277866, 1.6668487320906429, -0.25181409979232633, 1.8595741456596337, -1.2256340087598743, 1.7346042661579018, -3.8446783470322416, -2.1158008911447883, 2.215443413813251, 0.6094128184075578, 3.714551068441515, 2.959841027961249, -0.564583425367164, 2.9176301227966683, -1.441310369517308, 2.82786536536581, 0.5679405795533967, -0.606977919567139, 0.9530454465920686},
    {-0.3419133378246485, 2.5186135942755636, 0.17170576290615905, -0.9149357531694824, -0.11247139027939881, -0.16664631155928253, -3.333001482129283, -1.5383447172536724, 0.377846703271516, 0.33321895667418383, 0.29636475333547135, 1.1593867377919376, -2.2146013677403342, 3.147102377533485, 0.5899696777398615, 2.5800821040350446, 2.043419229655295, -2.8784572006348625, 1.6147124985140775, -1.274785993764605, 1.2051255136283445, 2.645622398738177, 0.897286817237755, 1.0966116229638425, 1.3388350278345684, -1.9876032639547274, 0.4714491951678442, -1.2661377054690461, 3.3813209577283434, 0.2501010670106749, -0.6189396749539764, 1.5309979861284626},
    {0.5848258036419682, 2.00418153190099, 1.6917062519599937, -1.3450061351884626, -1.3898931220603372, -0.24550925908280302, -0.7866178480569159, -1.936726800208369, 0.8345386671304551, -0.268327205437168, -1.5607591782330885, 0.838465415677873, -3.3080897303720165, 1.3272094981848543, 3.3329976917024706, 1.360713799807548, 0.12865539710464588, -0.5135036746819562, 0.7916350364684841, -2.308680132464156, -2.421290121663589, 0.7849782690074956, 0.2508570799548855, 2.8255274537990895, 1.7583802491826104, 0.12115293791818146, 2.587886663084918, -3.1497669487638844, 2.249722995476777, 1.280420857883419, -1.419593795776027, 3.016892131524502},
    {-0.7693450240794194, 2.8264683454880655, 1.7825311603992873, 0.4080454305445678, 1.753701547320318, 1.472994064384098, -0.8129215635814356, -1.9914904563791624, 1.0336243666892007, -0.21622077808897827, 0.6364667834848804, -1.5112921302863347, -1.7485171368727968, 1.7294320404156305, 1.802730346626331, 2.6236182650352724, -1.6043333288458694, -2.0336380453854743, 0.6922701205000391, 0.24685640806032827, -0.3699837374070002, 0.6101711753855302, 0.19227464199309205, 2.2491535740040347, 2.9839902988813387, 0.5345636408879911, 2.369923933803259, 0.8907967618203791, 2.134552323883384, 2.7976629635068724, -2.2308650321106325, 5.335764488000138},
    {-0.2529222999329223, 3.035522420097198, 1.2409798833280823, 2.594896706070991, 2.265509026795303, -0.8402682376041603, -1.7197826173795796, -0.8285342271690951, 0.19132124629598732, -0.30659356682756816, 1.0438762132886144, 0.26583561907062575, -1.201706848588986, 1.0592149320840405, 2.0392154180630166, 1.838466314029765, -0.08801762268091061, -0.07112712413772045, 2.9069402177289576, -1.245696278724717, -0.0585764906191815, 1.6918454181576807, 0.9666830262346188, 0.9577557486628796, 1.8241733817716206, -1.7153301267816647, 0.6844912357446487, -1.6549410311331443, 4.331343001304298, -0.06840810363845141, -2.814135600698088, 2.7805781683375024},
    {-1.554118243891828, 2.611276748692629, 0.9574916827822164, -0.8786124765384671, -1.3971152870617938, 0.9663205983375419, -2.6942130322281628, 1.0111056358600543, 2.0860097186975968, -0.24659688795232124, -0.5057266509630258, 0.13680964948714178, -3.6960786434796287, 0.7929977388453361, 4.3549189140517335, -1.3868449267190899, 1.0355775667622746, -0.26712448761238594, 5.806293253064672, -3.0078172505227765, -0.8169988624594643, 2.236405658732014, 1.125235466693508, 2.2256739138657244, 1.783106164961964, 0.2318117420601188, 1.4428765002439494, -1.9273225976843273, 1.8144917866497097, 2.4707361819009437, 0.3575048355982268, 2.0258107716094362},
    {0.5275928197512297, -0.11870107950031081, -0.0542694067446641, 1.4964905837652076, 0.424612686487608, 0.7804557435616876, -1.0019382662320069, -1.3995754387175108, -0.2888541360976742, 0.14582523335578537, 0.9755491397918848, -1.6175680299248694, -0.09129481561529702, -1.058050099763017, -0.05009315710046645, 1.930629366116184, -1.1350826640015867, -0.4321695681531823, 1.0164978815722046, -1.335352283158089, -0.4732816831206433, 2.876874583145221, -0.6639032373078799, 2.7456304597737726, 2.8108822099563726, -0.4784942685722714, 1.8635052829829877, 0.6459323992216748, 0.8915779345706506, -1.5487059595641681, 0.8639041207175404, 1.58395132819364},
    {1.9592017011268206, 1.1886861866860945, -0.17857489662200393, 0.22589333358971855, 0.29828547208671197, 1.1310346000079163, -0.8151088340784531, -0.3015199124133361, -0.1359660704211789, -1.3338678272122835, 2.0238827716208325, -0.21424706753786046, -0.425028939012724, 4.597975574058568, 0.5846855254384432, 1.286717168617763, -0.13315929876257127, -1.9627259193092295, 0.27488169925431954, -2.115065937760712, -1.4096632667067917, 3.0650767881439527, 0.7435722397892655, 4.148311948715344, 2.926860156811291, 0.3275958739685108, 3.423262138148638, -0.2290790573307648, 1.202606683164146, 1.0954177407835282, -0.3651284699352242, 2.0351529473195344},
    {-2.6611486739025554, 1.526922331359562, 1.3603726754004233, -0.6721218577225743, -0.4677287598686736, 1.5653800049685431, 0.16546104242231335, -1.6975582807723544, -0.15134625575997385, 0.40466163102402397, 0.44167655888549223, 1.1826902097057614, -0.5033641299382116, 3.2797561316880373, 2.063328569540629, 1.579555661457842, 0.7586579421775282, -0.8382706505592067, 0.2565462007874864, 0.2721743072610956, -0.4795307584667003, 1.7471110887242107, 0.56246230343116, 1.9624308097402383, 4.02414595988042, 0.9104398269318056, 4.338081111540233, -0.5885516224724306, 3.3768727998008625, 0.21832518158678585, 1.2932431431996185, 2.641153233717519},
    {-0.6225964827139614, 0.8348787271035419, 1.4028791374754739, 3.0947127552009674, 0.19125255554354553, 1.1554861670443026, -1.8892524104585489, -2.574606184440505, -0.6919913629171631, -2.0963582925193784, -0.6565277338981631, 0.5311693769639878, -0.8064655988179813, 2.706676900425121, 2.2913132283672044, 1.5826305178610125, -1.9719426150498134, 0.022881135426639974, 1.452705749290475, -0.7625564129974031, 0.47843340690571234, 2.40275441877549, -0.05740880981586345, 4.897736993824096, 1.0943049018185145, 1.1493544424829991, 1.3577638637575082, -1.4240533121921126, 3.140028558704987, 0.40299421745183067, 0.3882756761812053, 3.256549504604377},
    {-0.013005935429703751, -0.23829608859758994, -0.7073294754686595, 0.28027382561318, -0.7337095281896641, -0.5837238423039224, -1.5906189696929427, -0.6701442331356536, 0.6665505739144406, -4.162502449924208, 1.1327251978925867, -0.3612235289271307, -1.387141085021285, 0.6999982870989891, 4.500210087624128, 0.3778419597118002, -0.903980652222176, -1.5898842756910405, 0.05509651260917626, -1.7534565865598994, -3.8760166184382077, 1.9076771527188339, -2.519010052533669, 2.731798937952997, 3.076647911845037, 1.466763876036435, -0.040901302384098136, 0.9723902634344074, 2.784118520457725, -0.30919432097280325, 0.2558698000877084, 2.542520030833879},
    {-0.5477218663558899, -0.5562128138186139, -1.7296879016456632, -1.042410911623795, 1.305539980962593, -0.65552638648041, -2.935760918300969, -0.9861097363450827, -0.942653982423502, -1.7791892598177723, 1.072822670125286, 0.19153453251859817, -0.7729247026746147, 4.495241556639725, 2.812430927955143, 0.5776887835264597, 1.0791449206009711, -0.028029346797689363, 1.3878838847807662, -0.5223282568030156, -0.8836122454584437, 3.0142290004264582, -0.1089009910435959, 3.86360004089608, 2.7315917741961413, -0.006881587262415779, 0.6879291106651252, -0.854636069964897, 2.8186022919395453, 1.7569695085124426, 2.1744838500440475, 2.631856434975934},
    {-1.6883185079481244, -0.9094030851402134, -1.7637962224940278, 0.2666191473485231, 2.673996092757567, 0.9187174705848056, -0.6359133628105983, 0.6947588974562601, 1.043089304904555, -1.3717465165496328, 0.6501500910515282, 0.17997158794769097, -1.5123655113433787, 3.3976570312514833, 2.6874059566803736, 2.2559120284731176, 0.8424626608536672, -1.821750161377496, 1.7998336458349857, -0.8209740453690406, -0.9762918472843812, 2.2725721336111033, 1.7819629047621883, 2.910714713703914, 0.7240693254151458, 0.38724924062873617, 2.0049901881454986, -0.4820257329395742, 2.673476452401804, 2.1459714806149965, 0.9551105432247755, 0.7121409357092489},
    {0.4281560923687135, 1.774456363925493, 0.92302855103459, -0.7953332053803875, -0.8492023518315417, -0.12938432176904124, -2.9486079317200398, -1.0430900779110277, 2.5498215224497867, -2.251632780013765, -0.007262352329435332, -0.5926806248177087, -1.9672019277140214, 0.18786473418704805, 1.1539453421481776, 4.045642140936233, 2.593108828341113, -1.6556434707809342, 2.3107027782175233, -1.0243144065778322, 0.7830358591873295, 2.02094328301857, -0.417333255294941, 1.744731047023209, 0.7676099886780579, -0.7038914447568737, -0.10510501462815927, -3.1305808805554256, 0.06363640295381545, 1.432130699368407, -1.1836667913915808, 1.1343589830488094},
    {-0.17211114894572105, 0.35407849412243836, -1.5409903714990238, 0.12929464603615354, 0.26285979250757174, 0.2769821759310776, -2.4148124472260184, -1.0601083839209755, 0.15702303151100297, -1.14195510760398, 0.2850422959338027, -0.9762858888042659, -3.0707735490737997, 2.366817660961367, 2.6798179095790644, 1.5934743273935135, 2.47704860134896, -2.824727264355512, 1.8840271248366733, -1.2860670952073334, -0.39902171782645657, 1.7377331823055449, 1.0804062225250832, 3.7919444679879812, 0.9565763981318106, 2.5748403416822363, -0.09955574375980367, 0.5091146274295536, 2.356871505436697, 0.16059903304686962, 0.7787710343235182, 1.5986221141476185},
    {-1.7899662987371918, 2.15432464158373, 0.8366332485858121, 1.736790472388332, 1.295007119624246, -1.9345856642347568, -1.6204660515474827, -1.2352618851850454, 0.2903434625617566, -1.2997646247360135, 2.951119224026327, -1.9656716528972173, -1.9758437056446276, 2.684417934975122, 1.657684440668658, 4.180676121847466, -0.23164529769927578, -2.271229930545896, 0.1661672988942132, -1.2461008240095843, -1.5738098583371545, 3.4925811363392207, -0.9260513682074306, 2.914611775203566, 2.1961702448220097, -1.5979194497076652, 1.2646379709659852, -0.07622434160726477, -0.15507920993914903, -0.18955625454947783, -0.7656979028423267, 0.11813973447817998},
    {-1.164978441510416, 0.8799281619911333, 0.39968217785776317, 0.36476554671184896, -0.08156041181002124, -2.6122200890641043, -1.6201060828394485, 0.4211367490683018, 2.274639689498009, -0.505333997719688, 1.3615346387507656, -0.5208441959788196, -3.3585014332182177, 3.5394136899523754, 4.022812863320368, 3.3723320294015333, 1.9729988673262275, -1.7214138060823545, 1.0066844729633226, -1.449156269284403, -0.8867932710281747, 2.4348560432016293, 1.689035850444209, 1.6458710385157609, 3.1054773064060583, -0.2582772150122516, 3.4981530478497085, -0.7113085460781523, 3.666111027478993, -0.24608407397198548, -1.3246354662955107, 1.108150057268833},
    {-2.0762283584609897, 1.1705569859087397, 1.304489254314489, -0.31030729472165736, 2.5813122559689385, -2.125169336507349, -3.5536084875578267, 0.762799508773593, -0.15433461664533546, -0.021716148468271027, 0.7921919038820103, -0.3890506612279988, -2.3851817492452216, 2.5015908641584295, 2.22840044657645, 0.1360145258758233, 2.847749465177822, -1.4335029637861185, -0.7572220520945442, -0.7952717673319012, 0.020128908212959335, 3.0851796736697588, 1.0536239301962145, 4.4651944109168795, 2.0369029440901274, -0.3272059411173528, -0.48477898241476436, -1.4996052316510609, 1.419841254966058, 1.0179629605128042, -0.3785079342584511, 2.6131631568547906},
    {-0.08450619939282665, -0.7270596038318582, -0.5942905056164143, -0.36605784662865454, -0.7159728733605063, -1.3533618922698918, -1.4287681759803548, 0.03785531539553093, -1.0465771091157794, -1.1961944502741526, 2.352014647547563, 0.6157233737067517, -0.1374428360022083, 1.2765021947914028, 3.3908908110434437, 2.796500651577267, 1.7316077350993775, -0.09700494194892278, -0.06280070976136366, -2.1844517450549694, -0.4592047612029586, 0.41138791382682305, 1.9062196457663243, 5.493030318778765, 0.9448469182724653, 0.3973862292903828, 2.3178782967597806, -1.5812055004589698, 3.564914842146177, 0.9530187656717852, -1.2772010589144092, 2.317372500059934},
    {0.0360014639617006, 1.137921913379663, -0.4306491315226453, 1.0135728974290814, 0.18700298317566735, -0.22567299684846656, -3.7427297350574187, -1.2868954908074668, 0.3116973369848699, -3.128121897261982, -0.23454545132867996, -1.0627482642149635, 1.3063917341850637, 1.1503256785134734, 2.0823833235608498, 1.3318504326640204, 2.104266733952193, 1.8997994214578047, 1.9842590674015024, -0.8974989741664445, -2.774263690654789, 2.4459064619292117, 1.061762908292592, 4.384810350691956, 2.8158408750170714, 3.711877338111779, 2.4333122269677028, 0.6340817579025899, 2.29365747225551, -0.30713021370567695, -0.6428146483159884, 1.5550204778397274},
    {-0.23126332156913285, -0.36486747459530766, -0.11543310801775454, -0.6418267136815451, -0.22460068007934725, -1.615531081087734, 1.2093508231907086, 1.4399437706361755, -1.4370818287288287, -1.7618213758548351, -1.5402842243236314, 2.1966705159010624, -0.2183460477357381, 1.8492484469889927, -2.627825647211064, -0.6925982094070134, 1.6608846224973273, -2.8511489196080255, -0.6364745221232722, 0.6853447518962827, -0.3214792969701616, -1.01462282518135, 0.3577022985248139, -1.3973335886421518, -1.4610883339140874, 0.39296564948837037, -0.3153201873963539, -0.07305379910677048, 0.4186843984785365, -1.407380418970575, 0.5002443651504197, 2.586646403823894},
    {-0.9283068973744856, -2.463162263086738, -1.0617155909671088, 0.20921109939956414, -1.5074891706077695, -0.2941604006713822, -0.6724188417671775, 2.080271861006716, -4.142794145158959, 0.09448540628250983, -2.183818849984607, -0.11901631179369374, 1.950969367688418, -0.7389700448612637, -0.2158961368997052, -0.9978144651439302, -3.0390878454869634, 1.648825685091768, -2.757504970161198, 2.1625829933683254, 1.8696177623539885, -0.37218922923044956, 0.003447700934715942, -2.144016571659928, -0.41672577453674736, -1.083736551803983, -2.168568523474234, -0.2764007941482555, 0.4952567247204483, -0.7817082134899037, -1.4877769537472028, 2.6225753714544333},
    {-2.0561176334830518, -0.7011922312281563, -3.720378624532516, -2.8872330716911128, 0.15527808341732383, -1.9201518321554256, 2.3743751549906698, 1.6106077425777034, -0.8227430306563049, -0.2208581217955282, -3.4220760598030853, -1.8548521979496788, -1.2954676526363473, 0.02775414828361574, -3.2328823329840355, -1.2917701180914434, -0.8768428270858902, -0.8058379103010774, -1.1210996948725982, 0.606279582845189, 0.990522430476311, 0.6890337918589066, 2.7180884567140873, -0.3979121035145824, -2.8587651956339455, -1.5496007327716106, -1.6765998503967656, 1.2503714233712444, -1.3237844316902168, 0.7766384277891807, -1.6624645682497683, 1.039315070527299},
    {-2.4250034385791603, -0.4651433593663233, -2.323953104639471, 1.4140580233666884, -1.1536776833902465, -1.3815077943752272, 0.17517664722278495, 0.6461849240251618, -3.2404380149482686, -0.5321521244438211, -1.9161959360296694, -1.0651076782195894, -1.5007914301456993, -1.8561512120932406, -1.6525751457294668, -0.8940019587854074, 0.6350322882351297, 0.38134226785421627, -2.8668151808847955, 0.03085510660645667, -2.471995461563328, -0.7684658899571754, -1.7275879638874934, -0.08366184516845245, -1.8393438476784305, -1.5961199949399614, -2.455424634575379, -0.49419544794371373, -0.18690720747341122, 1.1909067895470118, -0.17192836510370735, -2.0795048408033234},
    {-0.4778057196729508, -0.13149162460579064, -2.8371336783884065, -1.6703296972073571, -0.6217669009433122, -3.458550659409201, -3.9276759866230586, -0.21995715983576747, -1.425681980230782, -1.9940345777344302, -1.6105592632888384, -2.5666886882821784, 1.2790132686703763, -3.8441132714841486, -1.9059983295614762, -0.3159062155592828, -1.666907000378286, 1.7067233284021157, -1.159653165422049, -0.8458237986524416, -0.6358146979325061, 0.13887223713614016, 0.08639921618674318, -0.7476605018246207, -2.161549417698372, -2.176377987710515, -2.247321819646895, -1.7126426021609218, 0.6031183874009524, -1.0313596516480013, -3.3398251475561374, -2.330453075071025},
    {-1.104103044259934, -1.3482268307239997, -0.45490599534041504, -0.7166373491180006, 1.7982676232225334, -2.7915626858012836, -2.8214407963693806, 0.7323861370788041, -0.9195344351764827, -2.337048376498564, -0.5330249871370616, -1.3103980741159378, -1.5445721060976274, 0.59650873942539, 0.23033492992040508, -1.5361531560270443, -0.7258987433598039, -0.44768899557372543, 0.9216035692169655, -0.958235444433379, 0.3670633105930977, -1.727562583711947, -1.3304865200522047, -1.4393278219207546, -0.837682864406882, -0.34950842296089724, -1.523431075545021, -1.5552835236040365, -0.6147394969749758, -0.3036167526529687, -1.24835845685905, -0.6852558129594141},
    {1.8894792003536003, -0.997040810554312, -1.836649022412256, -0.9777227111942878, 0.43789621473880247, -2.7007347235073746, -3.39953248930905, 0.968535674027879, -0.37937873468623484, -0.8965660851237963, -1.5869253322424552, -1.4709672358642185, -3.2443646973259765, -1.9221582717465835, -0.4822778496914838, -0.7435329401717143, 1.0544704878884181, 0.32628643057533424, -2.1576715349524056, -0.7251734810559723, -1.8093925262839494, -1.9077808826541982, -1.785584446584721, -2.4341088796978076, 0.2923075901261418, 0.05839343787794074, -2.035146796730413, 0.9742710518501657, 1.4803074233295361, 0.18893552174516212, -3.2075927305006027, -0.29575516554416753},
    {1.0967715224011916, 0.6615891912850573, -1.371113509292408, -0.8355706550011193, -0.810469139715508, -0.9107441173719054, -1.087725956230539, -1.4474624845096924, -0.8825144479095713, -1.095052362753288, -2.1947370954081897, -1.7087419253755851, -0.10676102522663669, 0.08898657110022382, -1.8008562035343154, 0.35482988849607894, -0.09008954786632045, -1.4982126055838108, 0.5184188266458001, -0.8092806007271007, 1.3317274305141922, 0.5995218088472674, -1.4951807134818107, 0.03613541589924634, -0.1162564813697706, -2.257319306731467, -1.4214746726268648, 0.7019559172270373, 0.8032167198598655, 0.06986110364933382, -1.2208142805248599, -1.707042045699497},
    {-0.5658320926674274, 1.1333417946362243, -1.1218271653197742, -1.9190169793407164, 0.7753613180274871, -2.8508356124743033, 1.8803525144741506, -1.8599280024436073, -1.6139359530669457, -1.5060479010079073, -0.9563469649242659, -2.444378852112692, -2.190800707573545, -0.20340201187344106, -2.5206632811321663, -0.4291621114898875, -0.8888983185819836, -0.3182924559911469, -2.216049858343511, 0.3468042306759669, -0.03674922826497309, -0.3438771112592884, 1.6717734746929638, -1.2505781528213142, -0.14050353965040513, -1.5973899478125488, -1.5226423540460174, 1.624510347186215, 2.2638383570565996, 0.5378370195571641, -1.5333943869006803, -0.6853817920409332},
    {-0.2773215358074456, 0.9095767538390196, -1.2654021287809833, -1.7148945186493019, 0.8025728450591469, -2.407844607268317, -2.5322044767155454, 0.1481197601712227, -3.123518757136818, -0.26688204388669245, 1.0432500551410793, -0.8762490638304886, 0.7434965278851806, -0.7003009752500298, -0.4772758922091378, 0.4161068579274295, -0.25090489725799703, 0.2190942476878277, -1.2679858848955794, -1.6966898483530797, -0.6678938381875922, -3.6949583438132056, 1.8983053035207689, -2.0685617900551723, -0.21679034095696656, -2.410698253061511, -3.1718041167143047, 0.4001560813401317, 0.29851229108578187, -1.5374696789515359, -1.7838846447405299, -1.5439491879023877},
    {-2.614256930290287, 0.8178279967549799, -0.9787015774265675, 0.6024171540953783, 1.2852186320847137, -1.921432827054268, -2.028160504544004, -0.23129793400166793, -3.5519457699687247, -1.2153026050592854, -1.8369218187303487, -1.2519066785548085, 0.4707509348620461, -0.9017942972128921, -0.5349547798508704, -0.6828443619964313, 2.0775504525896205, -1.6534214087740355, 0.8341507938650223, -0.6038258626752351, 0.8208260853087598, -0.32732635056694626, 0.9043243765337924, -0.3687497009151195, -1.4215607495177947, -2.2701253841286513, -0.4417091924522193, -1.480253684719918, -1.7524823192140326, 1.1493320933281457, -1.0215390980014543, 0.692996844440647},
    {-0.22466554250215737, 0.32184311157437967, -1.7391289805672134, -2.322454545652922, 1.6656964116872792, -2.2448377556357175, 0.062334356601607015, -2.15712308453192, -0.414771885352478, -0.6764258283568577, -1.7599208946421363, -3.1555695174356693, -1.8918750868877434, -0.453499517901013, -1.82065624625595, -2.7639245966820556, -1.8576654910391686, 0.08682262672831753, -2.975354139223003, 0.14015258563907115, -1.04608505133597, -2.707417359403664, 1.0297480296475883, 0.3380140950083574, -1.8918422209841252, 0.30099490881492863, -4.210928116515004, 0.5263546171471615, 1.6294094138606772, -1.023524083178755, -1.5156014975615955, -0.29258594543342015},
    {-1.8005849563800747, -1.5411295215894867, 0.09440834770754968, -3.0981441796076594, 0.3341582925801512, -2.347394159303803, -3.25336688647421, -1.759496032978234, -0.253134951613261, -0.56677907379337, 0.1588994938906574, -1.7307380497668658, -0.986150832373275, -1.5174281299379038, -2.194127779287781, -2.2056289871635015, 0.7072231049506856, 1.1822560093018315, -0.12060954650101546, -0.8259650520061441, -0.5630576379780712, -1.5355657117146837, 0.1994159754232562, 0.6971289798494512, -1.2471280670342526, -0.8745233909589583, -1.9371541703369028, 2.780757417366655, 1.327988644399321, -1.4792060753321774, -1.7055930085308677, 0.4597466877986636},
    {-1.6422065166531252, -0.7490652738062279, -3.5183432823058025, -1.411949844129643, 0.2812185892775475, -3.735965762609103, -1.0558775692252544, -1.0238160770145694, -3.640998664831315, -2.17798483429311, -1.1348470905963568, -1.2655874349282767, -2.9735535023485977, -1.8631530708492383, -3.115539252265269, -1.3216647981030678, 0.9746386442410763, -1.675776547087278, -0.9367168810405694, -2.299503190765761, -1.09076997204908, 1.065373283633253, 0.5295564597932946, 0.31762418886807575, -1.1143449611189926, -1.2736420199961955, -0.9223733817571461, 0.7802400190550373, -1.5568285608766355, -0.6415800898174128, -1.1015582470888479, -1.8801920846472482},
    {-0.9174500942353753, -0.37390963585696985, -2.300453747785898, -1.2570090459309378, 0.313895711687048, -1.8704240664998288, -0.44102182220097513, 0.3746506390378372, -0.9450738895531073, -1.152147729032691, 0.1402108954015059, -1.4659402151458012, -2.088939796624439, -2.0489436187874115, -0.22331257348363387, -2.1013381127062036, 1.407915529329533, 0.9314316860668388, -1.5315282121126141, -1.407256243833671, 0.5748843105802421, -0.09731294714872976, 1.6368237605988933, -1.2108756693381404, -3.2253247254347364, -3.058817808781449, -0.2225612202603389, -1.2247998386321435, -2.114176490919634, 0.19833966123188773, 0.9999992766259461, 1.6975514386551478},
    {-0.9324808562568767, -1.0280503075838885, -2.475247831497378, -0.35795074394680854, 1.7956763166858614, -2.495513864728658, -1.1773137849308999, -0.06228173526606611, -1.4487414283309508, -0.146116867245197, 0.3776958318228621, -0.5730103602595531, -2.6611030118755057, -2.00060017485962, -2.000374361010938, -2.4830355210575736, -0.10879401784714898, 0.5403698165342303, -2.98220424623342, -0.9545404615145057, -0.5543247552657068, 0.9677113708402404, 1.0282088128556617, -2.220545471463603, -1.5885202641087601, -2.7395505254181605, -1.126566626284309, -1.5426346251222973, -1.2958856756246298, -0.5693586328899957, -1.0773966605534433, 1.805842634963546},
    {2.295577604948292, -3.2722804411246806, -2.7486409317000087, -2.673646636191856, -2.0395244215789723, -2.0566177026114487, 0.5236557486980458, 0.2537014967455305, -2.263333515890109, -0.5142299299871066, -1.686949125712671, -2.052033543470119, -1.5521335790659054, -2.176978256099387, -2.4709659899726826, -2.7375546858761974, 0.5833144136908017, -0.7763895015491993, -2.0739209148407505, 0.201805949360874, -0.9264328215083396, -2.0344185961251156, 0.16247930214071257, -2.5172203885195747, -3.497133837833068, -4.996323128443087, -1.7510565283765525, -0.8981102196521453, 0.25857927309268347, -0.5849228467060242, -1.4312901885154738, -1.1412759493346265},
    {-0.8123515850109195, -1.6985134604136913, -2.196599277209722, -3.718059016231788, 0.9060244580595662, -1.681279052591195, -0.9321184975316226, 2.559535533477236, -3.6592061869805845, -0.39705276315091437, -1.8627381923195196, -2.35756147409186, -1.4520559627134564, -1.4792935814270198, -0.20894018316855878, -1.9619859814112675, 2.4697614929472294, 0.07686851084211628, -0.9379937791556029, -0.9567574051793789, -1.499273861325045, -1.9241854660476811, 1.8081207399549646, -2.3575045390116975, -1.2287624833742896, -3.1817586136748917, -1.1326184525812484, 0.11676456874982254, -1.085621132354415, -1.774478863254482, -1.547370835252626, -0.41457688181068236},
    {-0.4814454371156495, -0.7445667814308953, -2.0797064752934142, -0.21701293994392964, 1.318935678940324, -4.441280488339821, -1.2290689926398572, 0.11776495370112694, -2.7842290824683826, -1.401458096558426, -0.37172906121035626, -2.559973051381661, -0.7982081043560307, 0.7239752902251684, -0.10914770356337163, -2.980093631946815, -0.9973988335465971, -1.2294581460678007, 1.4249960557123886, -0.10408715864241161, -0.35158112528963176, 0.5100095437713369, 1.4752245392395842, -1.06765489035004, -0.4942302833495863, -5.631169249420501, -1.3930807597008654, -0.414677295365469, -1.2804015083013136, 0.104418428838707, -0.5886604371629536, -0.8125132089010596},
    {-0.21555852203766074, -0.0049408000666147, -0.9247381072027804, -2.180708889472984, 0.9263435822781232, -2.907022505416317, -0.4028001338369574, -0.6602320967908801, -1.2022810876918397, -0.4810395073901399, 0.24202237301331628, -2.7352366090568925, -0.4035674347169897, -2.230741646820406, -2.0933067027568715, -3.6847237139050404, -1.1075407593375093, 0.8012524899539317, -1.683054609255461, -2.764135719316267, 0.27129293073037625, 0.7661812425189007, 0.1461814902524824, -2.3535449889280518, -3.1093457044930655, -0.6010444697840779, -0.26083590404036827, -0.6467006980793306, -2.6927995696569154, -1.1855513770453339, -0.881554519732888, 1.0256612213820007},
    {0.41860208326776793, -1.6166806425298788, -3.19647090095482, -0.7074480612262211, -1.2537952226063411, -4.362989539596911, -0.8249035402442274, 0.2830529513116173, -2.5391377556312964, -0.4008839619884515, -3.114736715809316, -0.31751680127451687, 0.09176367949067132, -2.269590120838393, -1.092149169532485, -3.621565787380731, 0.2928027963131706, -1.3932449102478035, -1.4947176433085598, 0.2546562235419007, -0.736934333490221, 0.7075819086863033, 1.1101426390557405, -3.052611175237083, -3.638703931169697, -3.436041240917282, -0.5094671307539342, 0.44073798688319643, -1.1951543318954307, -1.375313473986246, 0.4473226201722782, -0.7234974343361982},
    {-2.2255957612531683, -1.5034280380199838, -2.1510711995516516, -0.17798140639738816, 1.1713744343989385, -1.749234358027261, -0.347475384903304, 1.505898125182915, -3.3444587477364487, 0.1322272874247414, -2.4558321530131475, -4.299450866224283, 0.8384713202362001, -1.078952702544837, -2.527571982511605, -1.645472171559145, -0.9411357052842738, -0.7992533654810076, -0.23401071755969952, -0.49251802047071946, 1.096899469575073, -0.3921884142125115, 2.001180596720492, 0.14416629203748715, -1.3042334326512055, -2.090266859781061, -3.901948586691445, -0.566673908764026, -1.3429997482527152, 0.06821004766179371, -1.3804757098174887, -1.7130005950518603},
    {-0.7011152590735896, 0.5259232421261636, -3.340559995248297, -1.6675470581317497, -1.299819499261931, -3.255494365120942, -0.9212921515960548, 2.3548040287228966, -2.5463864304351076, 0.21630757251516866, -2.142607286191433, -2.774750709196567, 0.9791389750135485, -0.5416978861117849, 0.9582935925327805, -2.411710158568403, -1.2786770974604464, -0.804445135213496, -2.8132704742234664, 0.23390968331756334, 0.4699755282169624, -0.9925469708528537, 2.3761017923774164, -0.7710772508408564, -1.9556280072281733, -4.348894074943078, -2.722168480157042, -1.4807156604585168, -1.1524365401314955, 0.06941898607142408, 0.4686660632573436, -0.2628638383218937},
    {-1.9484292034026691, 0.4961646682964012, -2.403435677534384, -2.4043436983395092, -0.3833019835930445, -2.5827927601745917, 0.5945278421109439, 1.2523459623451427, -2.6401782699687137, -1.9611882474042168, -2.2472931810925876, -3.347980487459002, 1.5482986542721728, -0.8970579380847741, -1.7641349026773279, -2.618260694142966, -1.4078119625995993, -0.28976057577726816, -1.3577911371095712, -0.7576828659705399, 3.52635744659006, 0.7337568219784353, 1.0976929591502758, 0.9821933631059313, -0.9514097760175037, -3.0885053390103367, -3.7776444195771735, 0.9389411347145308, -1.136930444351209, -0.9005945275014007, -1.3186315081536342, -0.1716510526865818},
    {-2.6716190794055765, -0.9211564421580142, -5.689565644944993, 0.18538376039301535, 1.7409923812258254, -3.0852940725770615, -0.2644831957557946, -0.5999605524700681, -4.593726902347982, 0.5376698547643483, -1.7695812936660555, -3.3204366079509686, -0.3099062763195755, -1.6646184227398857, -3.4142103509761403, -2.6869099787763213, -1.33246299389453, -1.4042535130118794, -1.4816375102069734, -1.075223298889279, -0.759844887058718, 0.04623329821373648, -1.2933693278795426, -1.3308453517161971, -2.9054103508421116, -4.284437484468754, -3.681385563142888, -0.108931510848714, -0.4299647990144471, 1.52925304097127, -0.45265806587929497, -0.3715928379625842},
    {0.8794439824679852, -0.9052443848101049, -4.082099834400383, -0.5895676390760632, 0.4320717073144913, -6.081741926784806, -1.0949703526662231, 2.9749544613600807, -4.218381884595758, -0.2621707167161662, -2.292869482673341, -1.6841367018813151, 0.8179745493044369, -4.100691510046097, -1.7607095551873733, -3.309382846462446, -0.5420165995575311, -2.1150268243225736, -2.2800359782597015, 1.3323651286264824, 0.5815096183368446, -0.9908359270031122, 2.069150460650524, -0.9281644306229273, -4.120934747510667, -2.3849685007924863, -1.5735046294319652, -1.9522533755634937, -0.47433420831055423, -0.23841508399280012, -0.48101938999831056, -0.06332500243318033},
    {-0.8470254046919248, -0.1773679592518621, -3.2395330993297318, -2.734074577635671, 0.991488228522098, -5.305978341512637, -1.689365028636455, 5.630907397888968, -4.893096727381082, -0.8478024936832105, -0.2610797388467161, -2.65395789837789, -1.1353980167625024, -1.30997456815207, -2.3101433458840597, -3.745331788839145, 0.5912807546337464, 0.3155463146408488, -2.461501084393389, -0.15053966897704274, -0.5008872733017431, -0.495429590337083, 1.5379280840236806, -0.9069284702153713, 0.9264996137072448, -2.968920628076958, -1.7819513669645293, -1.2900734224494754, 0.3759064756544633, 0.06443807867054512, -0.11168601129856828, 0.40667455002738956},
    {-1.734059655302494, -1.5023567157599143, -2.340353963029265, -2.739156973807813, -1.9476350444810642, -3.6870643257636995, -2.8065670205907964, 3.25353807674482, -4.118781528382982, -1.6178826826788724, -5.06596815109519, -2.7600593793936117, 0.4676069670704077, -2.7360406542134528, -2.2955788096228362, -3.452495952276008, -2.643357356403128, -0.43943180089001305, -2.1886331118032727, -1.4771379477138158, 0.47453837205070165, -1.2679501411691987, 1.3268982108931442, -2.724789465198232, -1.5337648389315157, -3.141725642080123, -3.1079727563129045, -1.1875886987600328, -2.8520872916090587, -1.1046148024974594, 0.28599586917329195, -1.1984077038765628},
    {-1.5610110400258317, -2.0671265762638695, -2.8993356110655824, -3.2454876991304378, 0.7332077698512239, -6.165653061097936, -0.3324929783220912, 2.9562009808201974, -5.098475627050801, 0.9091398886050578, -1.3183518230417657, -1.5003128344794248, -0.9450235925368315, -3.8250224448173853, -1.91619953993517, -2.5089812043213637, -0.9116239607357278, -0.4396243458923261, -3.213551622998504, 0.2735256870440231, 1.088154171843959, -0.2578931918526851, 1.4239409719782303, 0.41073533481214813, -2.267141540864229, -3.0371841625589675, -3.48027852462282, -0.012583743192680739, 0.3240717240766121, -1.0581637987374137, -0.879856178572469, 0.5763876340809025},
    {-0.06574208114193121, -1.1957515124357074, -4.94060617501115, -1.2121616375905266, -1.7553686731208653, -2.4479218380450254, -0.4352528415599832, 2.635817580751336, -5.519284580374736, -1.035313979470798, -2.7128576766531705, -2.0965708914313037, -1.9816846576666847, -2.102674298155742, -1.5499348114538458, -4.94960069112373, -1.8973362086181478, 0.8373970634472492, -2.499489698564635, -0.4703773349601727, 2.0183775903246635, -0.06961265181752785, 0.17699468949417643, 1.0659835394611226, 0.14251409850344351, -3.3676899007425503, -3.6314920367335812, -1.972510051230513, -1.5774975420194803, -0.7800141771649151, -1.2778023644811753, -0.817646013181347}
};

static const float b1[32] = {5.478828721512527, 5.735724941299171, 6.125781529749389, 6.03812354788651, 3.6044697395679344, 6.0760561406933835, 5.599703478457363, 4.874919502436273, 5.866809689778921, 5.435359605205766, 4.538529964072946, 5.565163494520564, 6.045317278829904, 5.940953481000222, 6.106696319123244, 5.851202639096444, 4.930417988324182, 5.494721122906319, 5.082605193719599, 3.8763086541820124, 5.7298763257644145, 5.318016307234171, 4.999692668422655, 6.17394701434896, 5.817420895998364, 5.995249624579781, 5.982979881202991, 4.517722780783046, 6.049942965413918, 4.113744857311636, 6.055520775667297, 5.153310400390254};

static const float w2[32][16] = {
    {2.520606405465352, 2.9928097138704426, 3.991552990886262, -1.3494028444942632, 5.213806327187749, 3.766840809229784, 3.697371086061526, 1.3183154551222185, 0.5014993169759518, 1.2793473223110146, -0.7969545513621795, -0.034118072129540114, 2.7522433134883935, 3.204763490926505, -0.4122577104729534, 5.325479684982224},
    {3.232651526508024, 3.652170562501465, 6.38275137972785, 0.11836080625696212, 5.106671620212779, 5.361203179717023, 4.715263246828903, 3.1346251239993794, 0.7786702925012902, 3.549377774562014, -0.842396578663695, -0.09069125249293093, 3.9942664058366204, 2.8817572831234983, -0.8819122293972772, 3.504907688326659},
    {4.063928355161736, 3.071836848732431, 5.515392432021355, -2.645071645458553, 6.117538551140665, 6.719129199867346, 4.188619649334017, 2.6242719198731215, 2.935482977786235, 4.471240554649541, -0.346926496547522, -1.2038198418217951, 4.125865917949864, 2.7941628846102686, 1.0134721357624898, 6.676472643350494},
    {3.3509481242802486, 2.5357232239844283, 3.556864953705061, -2.5789854299239905, 5.474214511509152, 4.489962510434, 4.800046558149568, 2.1461692118915474, 1.6880236507188793, 4.319850091541869, -0.30283526674811917, 1.591514887990625, 1.9146024065116067, 3.047478003720617, 0.5080431095398452, 5.545211867133337},
    {1.8653110026737982, 1.37917484222576, 3.1278547922021627, -0.7814954650739603, 2.841776368653656, 1.0532001205005719, 1.4619468302713123, 2.643121574392848, -0.25502929457407014, 1.9593125421755475, -0.5148559644573428, 0.21160770417832436, 1.1085477778993145, 1.5525535379142288, 0.22773256193611707, 2.4590769349662005},
    {5.951466394649613, 1.2905580914209511, 4.905188329547537, -0.5006944651750053, 6.139369513166226, 5.639150818319833, 5.25482023679584, 1.1150142340621092, 1.7524961145288473, 4.777619898134689, -0.628980174274736, 1.6111627511842157, 2.207839656266716, 2.0358753416162494, -1.7693655714621883, 6.004429878929471},
    {3.7194380224799253, 3.8868184424406067, 4.275500652859112, -0.8969100616369214, 6.46000806853218, 4.067380818488424, 5.2577337761484495, 3.522507968827425, 2.0641723744845737, 3.5602726409167786, -0.15669017925040238, -0.806247697870318, 2.8573330597552564, 2.188252817830633, 1.50765279261696, 5.077219536867969},
    {2.0931277012424285, 2.3562356335623815, 3.221671847999114, -0.7622355278603274, 4.330831488286001, 3.8880301768554486, 4.576025957707199, 4.663092011936625, 1.717257447710098, 2.3115465145198257, -1.7206135682906005, 0.45416482956106485, 2.9840674938417204, 1.6019885699250855, 2.2878986467193045, 3.070210459126378},
    {3.6922681108951947, 3.0410660857745007, 5.742732677649143, 0.506589561367458, 5.2352916444686, 5.439952493141708, 6.279371365365054, 1.8437622985482087, 2.678471020090121, 4.332393579753128, -0.6741073339724934, -0.23087034740593762, 2.9833218101785755, 3.407908571037867, 0.5180386782675515, 4.301203343730212},
    {4.5099782366775845, 4.049214599243289, 4.451691215446612, -0.4768354836728158, 5.903130961767268, 4.378290013797124, 3.043660345127096, 2.924883459476933, 2.4620540222063503, 3.892559613006824, 1.4579570550494019, -0.1843029808819865, 1.3482547969396148, 4.778867834699136, 0.6620021935148946, 3.695466553520859},
    {2.967317071388776, 4.441969938323306, 4.006571034275002, 0.057594878755050184, 3.9982693073749314, 4.061378888796071, 4.488046796988583, 4.466517512800869, 2.14949099537942, 2.5679720396711834, -2.098041220982895, -1.3766753825625384, 4.840444487835269, 3.1235208703916566, -0.3242202976750994, 3.3968615138768508},
    {3.4337262372714226, 3.588864650614553, 5.340977743275201, -2.4182276168820698, 5.38817866551864, 4.203510617090847, 5.205756798998952, 2.8747327498592345, 1.9053849113858239, 4.40895200669183, -0.2515735980412674, -1.1599049700900403, 4.257880984999513, 2.817118282943051, -1.2168831632445445, 5.47495924092573},
    {3.9271564255086293, 3.183644340652356, 5.777943095718333, -0.6529076899977675, 6.302279500205696, 5.6721723032840226, 4.163088114512259, 1.8170090883413403, 1.7810471235628835, 2.8310524955228535, -0.3084885553370102, -1.1254417195479658, 2.5549454948521, 2.250367220013082, 0.8217981220122585, 4.868745316655545},
    {4.565439576162051, 3.926931911789819, 4.116410783385375, 0.31198756138211253, 5.719451876369302, 5.0367114163731115, 5.280193606326044, 3.3343516175498107, 2.4479447047685046, 3.012233266012418, -0.6948258563147164, -0.09667045809346195, 3.3106753326617544, 4.28273300773564, 0.3392995148872541, 6.411216991141682},
    {3.780504809801262, 3.1501316098218775, 3.8512635384254006, -0.5790786506682043, 5.210028598946198, 5.828441516320815, 4.515466724020636, 2.594844168445069, 0.4541319172360464, 3.071243492663571, 0.3261024160815658, -0.5295255565575866, 3.7081863591042374, 0.8540047194782653, 0.8286241947184888, 8.116274575670184},
    {3.019176568741484, 3.3619472369536045, 5.3678654461678565, -1.1788749783333266, 6.2780864736442, 4.851003705067597, 3.780672620217003, 2.5893713214156815, 2.2137855835348326, 3.543384375118727, -1.089642714181425, 0.5960085769452368, 5.310141568546845, 2.319347294093756, -2.5574791826539043, 5.067618618316317},
    {4.64204777119904, 4.172703206094409, 2.2644441132163644, -0.4835645363211928, 5.842780945847261, 3.057085488809974, 2.616911645396534, 1.5130934456433893, 2.357845364281618, 2.1682263885553934, -0.80517123203697, -1.9150862254343095, 2.9204950829288427, 3.6140081269363034, 0.2740531272442906, 4.257499916573068},
    {1.696307813076968, 4.269056200328611, 3.698551210570084, -1.2766232300889226, 5.902757611259519, 3.986500025838614, 1.8351493530426848, 1.983539124878392, 2.1696419696198035, 4.121620059512919, 0.43284696551336677, -0.31538364302303146, 2.306311396020936, 3.4822278012522982, -0.2940884312034755, 3.7262455990426466},
    {4.809184590376612, 2.4517933261178317, 3.2513682774607076, -1.1219191552591115, 4.818562662611027, 4.231082387380441, 3.971861309430198, 3.4350738928399274, 0.643353764253256, 2.8126540972415652, 1.8495222638216071, -1.0818688950587434, 2.121656193394154, 3.224176340544371, 0.0725409330093385, 5.258078973597681},
    {3.0587326091811273, 3.0757796314041164, 4.315106367020997, -2.2000947247099703, 3.098690532611847, 3.1505129257122326, 3.3483186863061425, 3.509828012091299, 0.6064711037635767, 3.959990647440385, -1.3156211212041256, 1.3237121485423764, 3.998525700826473, 3.087602834670175, -0.8694930849720178, 4.988054728786309},
    {3.0584092608882387, 2.9902618108543475, 4.954775267976523, 1.3511800164227379, 6.368211481024309, 4.614499187536772, 4.80972761279256, 3.3480595628076553, 0.9987976204500573, 5.163481941301652, -1.5285519560485803, -1.84447891430811, 2.4461620832561453, 3.988164197188412, -0.14155511593779616, 2.5109664012926673},
    {3.4160737491080444, 4.50485482603528, 3.3283105252682934, -0.3341784530782147, 5.250405666834706, 4.548921026888138, 3.028992282488511, 1.211492043234456, 2.8182662644723515, 3.4153518208107845, 0.23524578362022203, 1.456108849270773, 4.402762331297661, 2.802489235201295, -0.6632826145043168, 4.884942367609794},
    {2.4277571034619925, 2.1577452761178746, 2.6057274914192132, 0.3310280137880282, 3.757210043121354, 2.8251578501702275, 1.399689025257424, 2.8614152087288125, -0.195403569267065, 3.202938006357257, 0.44934561181662425, 0.6334544052707651, 1.6194822393912585, 2.7811098803156873, -0.17516214685884976, 3.671473724063049},
    {3.531548927477291, 3.0280086729459827, 3.8741063773153965, -0.016516508918658374, 5.6034929866845715, 4.7324208903322855, 3.999184427806738, 1.1132784085829721, 1.2984025066999012, 3.594031935130501, -1.4682237312818363, -0.46721644891334513, 2.4748198650983206, 2.7323041173022484, 1.191870476646134, 3.485132414689931},
    {4.536006096576793, 4.0390104792064125, 5.188339638758227, -1.4389111148297646, 5.482655087611571, 4.766698759770057, 4.1371187669081495, 2.6990700233860263, 3.305942120094125, 2.4964152870123875, -0.5075212361377919, 2.2414031160266834, 3.8852170114470295, 3.557510778951696, -1.412324021626225, 4.636719741861739},
    {4.863313395549536, 3.307650285819292, 5.631784217222187, 0.26454106174480224, 5.516202167131217, 4.8369316905796005, 4.458016112064676, 2.1152507495789137, 2.4535727865490413, 2.830808996721928, -1.611720561247605, 0.11647320616044986, 2.908108876716217, 3.797687027306429, 0.6345031771444399, 4.600323271836541},
    {2.53590165899613, 2.9869105468845008, 5.486683872660776, -0.376721781827575, 7.269724577404549, 5.405988619178961, 5.246718464689668, 2.734267540456956, 1.7649546269858518, 3.6893327099452273, 0.710909134588487, 1.6254852281110417, 1.704920871206916, 4.226253081193362, -1.0843474875537706, 6.2288923288437665},
    {2.14177634852045, 0.014024227182964498, 5.230342979200749, -1.8657896817044466, 2.2352327095612186, 3.7328313295154985, 3.04581201653695, 2.079163534918427, 1.6147823805502324, 2.836157807150552, -1.048268695773254, 0.18888361487292954, 2.6463927666772786, 2.140664624188381, 0.5004198858467498, 3.235299375526815},
    {3.2122840173271356, 1.903142041142846, 4.236313460080004, -0.7584477715504095, 5.0682509364125865, 5.482420735873026, 4.045304545578936, 3.215705568219547, 1.2356035265927323, 2.181538598486872, -0.2547066626275161, -0.4853368534919141, 2.1417464007907117, 3.548770221727574, -0.8810051745444194, 5.514838711234368},
    {1.2080855001451714, 3.225318187179378, 3.0499551312941287, -0.528341108765928, 4.639849157252882, 2.209435682768757, 2.918086078390105, 0.662755808393568, 2.356711305875422, 2.3605571359557724, -0.8861640584612142, -1.025871146268905, 3.2920894678334705, 1.8204248911874252, -0.06199941020852151, 4.2089480566116695},
    {3.3141248829084304, 1.9029983258542718, 5.354642304221813, 0.18598079009507842, 6.004946133034627, 4.7098354994674745, 3.6779261827412895, 3.1395828984023098, 1.2070383100340718, 3.689442599147381, 1.7259526678975854, -0.12879327227027684, 2.684539660461582, 1.848019100469596, -1.7216057767345845, 4.998931482251109},
    {4.36055565812819, 3.014829098780508, 6.6175628534566755, -1.0629443273609953, 2.9999697719107723, 4.744461893708229, 5.2187926076448, 2.8921620486561355, 2.791875434306574, 4.487669302217927, -0.4275688263652494, 0.7490206829423443, 1.9525429706248325, 3.4398098350889446, -0.5130441360108745, 4.473519170239319}
};

static const float b2[16] = {4.0785349994344475, 3.4872542529848856, 5.405688775372134, -0.112680626930196, 6.119780641849236, 5.515401076057329, 4.57893455357234, 3.6094416221340584, 2.6792940972855024, 3.9165317889036526, -0.3831328799833306, 0.01654130585753363, 3.410951929839785, 3.7034342069711856, 0.334339450472056, 5.6823700474568595};

static const float w3[16][12] = {
    {-2.334744177899282, -3.52980941014031, -1.3720989491307807, -0.5360472611202528, -1.7106143889367706, -2.1396151865427395, -2.6286076591917933, -5.587982407948389, -4.063662932559505, -2.5746891256227045, -2.656641420966973, -5.31514106658359},
    {-3.0071166348203455, -1.5638150692710153, -3.2342981359878338, -1.9196462769784028, -2.602844074015301, -1.0525548747467959, -2.69674703066996, -2.569817552059887, -2.184265929844913, -2.8167963902560262, -3.537363428189588, -1.9397038070790602},
    {-3.26623685604951, -2.8391621806951095, -4.691633795862731, -3.1193474549378366, -4.282868408086558, -2.670811529034579, -2.0058613301422943, -4.058137591083655, -2.593841505438062, -2.4939801880793806, -3.2857690457072635, -2.1688245829468498},
    {-1.0624485420651497, 0.9435981400457274, -0.018941098552298977, -0.3260640359986033, 1.2730782758365125, -0.3071783834509669, -0.5617305518064492, -0.5894042227606786, -1.4416616293486368, 1.0527994740687507, -0.3639594321276746, 0.530486411583542},
    {-3.3815842447067057, -4.07497462260978, -4.279052536602288, -4.086192501226204, -3.6366389017591536, -2.9347562327880157, -2.995675534062593, -2.5825052424338555, -3.0069606958780004, -2.800569057454604, -3.8686916409127297, -3.286486017573786},
    {-2.4346317035617275, -3.0060738263564186, -1.6591390213669, -4.35288745563077, -3.457731228625863, -3.5232251936948336, -1.821420145692393, -5.336772471607104, -3.5768853903332647, -2.6838844871713285, -3.249214532976811, -2.3073669910312637},
    {-3.6541636401233752, -2.8271683549801603, -1.867847349429749, -3.89916844517158, -1.9291020037865827, -2.418060449856467, -3.9254992699913975, -0.05853649242922087, -3.017911227111595, -2.5559683282227916, -1.64211629142283, -3.3494040427446024},
    {-1.8641552525591598, -2.1491834834302974, -1.7117573576557974, -1.506290079731639, -2.0286433475320313, -1.6717331077220199, -1.8953075757294437, -2.7768156827472716, -0.6197377845196734, -3.7701550138982616, -1.0430622685571478, -3.4041092323942577},
    {-1.3201434391912, -1.4039850101195146, -0.436574820711277, -3.6075023253907648, -2.4689842847952517, -1.8318734901843332, -2.7473903701661064, -2.072384007221002, -1.9464946655492554, -0.25086097605000696, -2.931022036913641, -0.045064565229176075},
    {-1.4392414349616542, -1.8407234651803839, -2.652264837883315, -1.6416669234175234, -1.7132192827929402, -4.244503976195105, -2.675274651939625, -2.5648996520642977, -4.110224168211958, -1.5227144414582996, -2.735673156014327, -2.1797107834932072},
    {-1.6667999671144595, 0.18757969736427255, -1.9042851341025604, 0.06185704929319727, -0.18529243482689936, 0.818005109642165, 1.897896361752781, -0.7671508761667212, 1.5248579966741813, 1.2711373843150375, 0.35066660156764196, -0.04295744166118454},
    {-1.2734238137285498, 1.136872310653582, -1.5400565590196467, -3.0724403977004235, 0.6215269704441403, 0.603595950244221, 0.816790554140055, -0.5528252002503665, -2.2737738781051466, -2.1099374417294174, 0.4195279050832536, -0.8292770263318928},
    {-3.110936479097549, -2.0964619530410897, -4.154489502403421, -0.6801326892533901, -4.034026564568162, -3.5307864906466286, -3.804777156944633, -0.13166696742426887, -2.3688637869179368, -2.600411402250194, -1.6721038828870725, -3.4564446417844987},
    {-3.56319034930816, -2.493524062627878, -1.7617567396504192, -3.133891243385798, -1.5763906425923484, -1.6839261092571274, -3.0310680454482997, -1.4314077144100248, -1.842932491064727, -3.208610115651357, -0.9605968634953401, -1.655024769124384},
    {0.604456108264635, -1.3799365287596537, -0.3547647068605069, -0.6744817361060816, -1.0334968104145394, -0.1719129767997387, -1.6959824090420221, -0.3230879355548395, 0.5778717369002868, 1.5422230447968004, -1.0154260035321079, -2.9728360420784354},
    {-2.447078018877641, -3.189558272671587, -2.999620251066479, -2.8288300696141166, -2.4045279692522588, -3.7680707003781078, -2.9313362017625924, -2.551918147874993, -2.343064624847985, -4.41945567269494, -3.725721352940902, -2.6657586769424872}
};

static const float b3[12] = {-2.8086377768535846, -2.5733812973100942, -1.852830735139505, -3.08924838751109, -2.3997598910693694, -2.5280953358785254, -2.2404976561389773, -2.1345995793973325, -2.189437235851425, -1.800912320388618, -2.330301422658419, -2.276291204354427};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
