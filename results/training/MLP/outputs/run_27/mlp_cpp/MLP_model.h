#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-4.756197859708934, 1.8445067531677868, 1.8962317216334041, 2.6307948702640935, 1.5022027452392523, 1.7178886900320387, 2.0819604207073623, 1.0321017714349296, 2.2811902277100464, -3.7349761950553284, 2.426621816574294, 2.0142308480404485, -2.8600798068535274, -3.378264625334325, 0.9075038623313555, 1.8979260157699218, -3.290553086562132, -4.0488619462724715, 1.4004421480311415, -4.242675816969638, 2.675115758835059, 0.3790036984335692, -4.558861922614474, -2.114360712328583, -3.986429832381883, -1.969541501832107, -2.9623539275667397, 2.0597795022915464, -4.096810852430898, -0.7862189913476579, -3.0792926742934066, -0.3409484629105909},
    {3.8697498112781346, 1.3645299636109853, -2.3470460568030944, -3.2876216632290727, -3.3220963193011728, 0.8154590714674459, 1.7972254717253904, -0.7829651149831819, -0.47918804207578863, 2.6713387790090772, 0.553914533357065, 1.3174983209528726, -0.8410557870997822, 2.543871976009438, -3.4766591451829916, 0.6214376229231625, 0.29923037138269787, 1.3118616805675667, -1.5394017399714512, 1.6351618721290209, 1.242232953763339, -0.8262305165252776, 1.542093557929849, 1.5601609940760144, 1.2587003297974413, 0.309371086573346, 2.214675894420609, 0.8166076944389724, 2.0074764884139435, 2.5579706475594244, 0.4753428939008962, -3.231298154790325},
    {4.720983107905595, 2.232837980857922, 2.851657866466865, 2.9222627655195192, 3.668925497813441, 2.479296267454089, 1.7351549752395434, -0.5053914901119656, 2.494599293397809, 4.405745013929897, 2.8711492411734683, -0.7429301374245911, 1.0552170401780585, 5.584738777837239, 2.593281702146024, 2.6575781707852926, 2.5313907730485026, 5.449166903066455, 0.39624629814500345, 5.763636022309508, -0.37876093891128554, 4.0222481682599245, 4.803172583693268, 3.879607264992671, 4.527880114173462, 4.071184081217758, 5.223979469136201, 3.565461368727206, 5.142138835713317, 3.1435754023501787, 4.564572356762581, -2.2231702300384963},
    {4.024464535409409, 1.8006629276612596, 3.8597005155149104, 4.975564088583342, 4.692155291848276, 2.0336048702728107, 1.2989692962129769, 1.441639590585023, 2.244450821442193, 3.7950368789468594, 2.6399574778124384, -0.5238893269422153, 3.1853091469125006, 2.365414489382301, 4.366008910174404, 1.524882668698474, 2.4600411256212125, 3.367358358924708, 1.4969205300646236, 3.2322840298786932, -0.7838897817276188, 3.3913139426336247, 3.6681316863891156, 0.9883527392852305, 3.71628210227143, 3.6334902808235108, 4.2813165458067735, 1.939820399288428, 3.800812961528762, 3.748907223404946, 4.663201044617283, 0.10812602984738134},
    {4.724415485740093, -1.0198096336206826, 2.0738835176604193, 2.4155137701559317, 2.724859756726723, -0.6549354008419852, -1.096482414257754, -0.5402394600006479, -0.6940366973865608, 2.880922066033833, 0.1881765771440627, -2.0786270698934874, 1.0351720785862313, 3.835357873034893, 1.3997430732111997, -0.21913394909733966, 4.345105412623237, 5.534772671518907, -0.44621004690097515, 5.236366083671858, -2.8848380182993165, 3.0874871198581326, 4.645568154263327, 3.751734809777173, 4.295223793532796, 2.6287460174813067, 4.222231488597155, -0.18520523018969526, 4.625447163641078, 1.0801321332158398, 3.8562985044581053, -0.9164926149591905},
    {4.498783139109554, -1.7917671516315816, 2.7018092201676005, 3.977520521157393, 3.85415930913688, 0.37451646936497485, -1.630776316509048, 2.1185025454804656, 0.2714125464982202, 2.62680565188458, -1.0798148908728122, -2.6362585387943174, 5.053160454911993, 5.364422211068212, 4.9009167964003675, 0.5999394763812729, 7.242607124526685, 7.179624817552931, 2.337557070558629, 6.736836651795624, -3.6071825519972376, 6.38511071545913, 7.345406552433372, 5.566472914525624, 7.151616517644651, 6.724816032329213, 3.7967680952409344, -0.9444194447712989, 7.005611133800323, 2.3907397893810054, 7.0608293394471, 4.4984468491952745},
    {3.620300152981503, -1.4026960492547789, 3.7438669111100444, 4.349058368366352, 4.534980737818008, 1.125414580970179, -0.9515265298037195, 1.8196442286295043, 0.43679810580212386, 2.9296371888846964, -0.10295212388353772, -2.0637359434055216, 5.4726898977152665, 4.411595696939596, 5.377254535801146, 0.6692567261346049, 6.845241704699567, 6.462550677575288, 2.4618413566683093, 5.959915430203387, -3.1787936411646567, 6.03380107532193, 6.959102788286012, 4.731827608519635, 6.575051137552964, 6.126408785680044, 3.7531437570132873, -0.11096964969308383, 6.148039608366821, 2.3923498630632927, 6.8195311215831556, 4.487568149328432},
    {3.8758705964398836, -0.4057148012559421, -0.7389951799015806, -0.25395733494497336, -1.4077114044368866, 0.37312472715597744, 0.84205226458242, -2.2635135267617983, -1.1432534227151374, 2.3154446164615083, 0.7661355692249949, -0.7651116735058753, -1.595392323272943, 2.7546154981929223, -1.926305484618878, -0.16141318313210382, 1.8177990606611387, 3.3952095751054796, -2.487394892605628, 3.0965198565897865, -2.035442038730182, 2.4306369271867343, 3.3915022606757157, 1.196238545668707, 2.6324813945951746, 1.4452528282666564, 2.5955744686002435, -0.7249321571257842, 2.393336895090077, 1.9839451343143906, 2.5945127349782733, -2.73437198499304},
    {3.116774538618247, -1.6985539654996773, -2.392741985443189, -0.1653801710646756, -2.2236246919607043, -1.2416277210621463, -2.062305509763434, -3.3927076891441543, -3.265067877761383, 1.5361538023799763, -1.4695456595345144, -3.0501261824701884, -1.5303229912033858, 2.47152740505953, -1.896809726703315, -1.5382830989895797, 1.0905083030833855, 2.713829983071041, -3.0106937448248883, 1.9175471638501365, -3.311682423912746, 2.8873474795851037, 3.1648750511224444, -0.42399073443178453, 3.065398160866442, 1.2425153806705198, 1.3062497329100304, -2.975671760317331, 2.238313178349523, 2.049293013808099, 2.79209358905947, -3.4118206175971015},
    {2.6324550670109432, 3.326773529637703, -0.3772313251011676, -1.367280539209627, -2.9606621857174273, 1.6890638017639823, 3.8917549006934267, 2.5175696965329712, 1.3670601365569506, 3.0872436055253325, 2.529006082793864, 3.754189249457046, -0.609786698614682, -0.8371752613491406, -3.358513527306181, 2.6371981400507827, -0.7098148597475534, -0.8409064360294004, 2.077214155896763, -1.9547533378786894, 2.8622747539409916, -2.229986092931511, -1.8750239630327628, -0.24107903442951573, -2.2158774335445326, -1.6992761171888509, 0.681660076665893, 1.2182262888255373, -2.3810882347356306, 3.736798482526294, -2.145700574475816, 0.1683853623344931},
    {1.143518420843792, 0.5782047410800237, 1.5486161603436515, 1.003970781600483, -0.031997918817752345, 0.5966842771335935, 0.4796600012073136, 3.019338526404399, 1.1719453970858602, 1.559372351406959, -0.3112285251186136, 1.0763890524460757, 2.451131957782289, -1.7523643634839425, 1.5832266874233447, 0.6705232538094992, 0.5274308008868018, 0.2952066029926489, 3.253585541054142, -1.266847690647034, -0.19075417875876627, -1.0087548501156152, -0.0647756676958751, -0.7337132149973075, -0.7032397968467848, -0.32939794358972774, 0.07440597398482882, -1.157121850939878, -1.0333096246834885, 2.290626725251854, -0.295720391594939, 3.697125194703685},
    {2.020572536550505, 3.0524083078005484, 3.0095102947374683, 2.6996067576654723, 2.297285875562759, 2.617253698562984, 2.755728827977261, 2.44740040889337, 2.7450165762371426, 4.127388947028342, 2.0885524917456055, 1.7110568788967078, 2.1865144237604253, 1.1934314587761845, 2.2595690857267234, 3.0097289775488445, 0.5801738387393633, 1.4525790114858428, 2.5868434153323845, 1.2161452976656735, 2.895583052098127, 1.7277481814722582, 1.904139198072892, -0.34110148454728406, 1.8730563382405696, 1.8258260887251623, 2.794118255357537, 2.446631697216168, 2.0594998312012733, 4.028356016737301, 2.398209887780055, -0.7793411974877011},
    {-2.7841804945116757, -1.9349678960209515, -2.601297749845387, -3.607600664567139, -2.653549870988935, -1.2988738604944212, -1.9229982614544223, -1.980223470095916, -1.3869308961332012, -1.9717642388581236, -3.147751206794974, -1.397901020875106, 0.1527911334705952, 1.3912397559162368, -0.8136246374049355, -2.0417673026270475, 2.1139480538630915, 0.4761467547880282, -1.5604519886660424, 0.9433708588896191, -2.0228631211693413, 0.7499975648285915, 0.8490882211300499, 2.5060046748157285, 1.017301820288201, 0.5021130918923108, -3.224184983902312, -1.901103697748749, 1.7620571645707752, -2.0509641692664635, 0.04759548398599901, 0.7076220920826737},
    {0.27790858633579535, -1.0146342211870012, 1.7781900744920096, 3.7784729099520593, 0.41117706151433353, 0.1549831073718588, -1.0645259360136856, 2.4402443369053413, -0.6019490874320909, -0.062482457867583864, -1.704325804680488, -1.251012473508799, 4.0481696197159796, -1.670471215485666, 3.656634085317054, -1.0013311574916202, 2.1421658669988393, 0.3290426921964098, 2.180540222366795, -0.6622834622296099, -1.7830171695764294, 2.742904656411705, 3.7486982128365125, -2.276080024993867, 3.861341190595138, 4.262369868724253, -0.1599288954064334, -2.2922528076058364, 2.5212821908549494, 1.7468648058321181, 3.7326792091983383, 3.6063184048073413},
    {-3.161693382540841, -3.77161104938982, -0.47488742479841034, 2.446242352182917, 0.8739841492360564, -2.677250808864239, -4.204945122902331, 0.23073931658569147, -2.9015947563796534, -3.248070102029343, -4.446304750646716, -3.7825691956208605, 3.4606295716285564, -2.4395467708064964, 4.084970043352595, -3.4050935937687976, 2.8862854494540597, -0.9270996566467267, -0.24917700328187387, -1.406367274770141, -3.5620326437611927, 3.2439687776170865, 3.415875388932479, -2.829285107838681, 3.1473618561041192, 4.0778892590884075, -2.803175549511561, -4.368153583295561, 2.0733746182478066, -2.8799419645221733, 3.5539541281796785, 4.215100183774891},
    {-3.981926594604894, -4.606505335771931, -3.7647974646298916, -3.1727950722854787, -3.618893834087235, -3.820635192168479, -5.127378665544526, -2.5715746177708114, -4.4771906926601766, -4.679272313791912, -5.294733345838677, -4.135176180494281, 0.021428612727529564, -1.5494547027373318, -1.1093601977021752, -4.780562824952541, 1.2574657616854648, -1.7127788184106478, -3.05653623700088, -1.375243369985957, -3.536857268261636, 1.4667160300493833, 2.258780276500412, -2.7334973165736725, 1.6354927307455314, 1.3459835758255378, -5.024613310244598, -5.143246901129214, 1.1744869207963824, -4.0545085519181185, 0.46889301512098985, 1.0127084124708376},
    {1.209222034048248, -1.9917016192126082, 1.4513061922939774, 3.4753061159700684, 3.0384645141740947, -0.07474724905548866, -1.2109164114180637, 3.3169561818055104, -1.2391798250628376, 0.3372324266953468, -1.8841803898348748, -1.4297743349732337, 5.739528785161844, -1.3810084102716869, 5.477785372724672, -0.8317715593523243, 4.58909921686825, 0.8236451732868174, 2.7871053232014678, 0.12649007390068115, -1.5226847008206779, 3.343843790568865, 4.615765852534192, -1.9526287310499286, 4.382435199125006, 5.393962263975782, 0.06670527294967896, -2.697285199289909, 3.313631262608548, 2.09427078043375, 4.685771407594521, 5.3254298024525095},
    {-0.17514928355674977, -1.9788920241262506, 2.1322113579596538, 2.6730581757199037, 3.0180108983982787, -0.698405459693217, -1.8884526974189304, 3.3929635779819765, -0.4248441923184547, -0.4162879854424078, -2.3364834378655046, -1.2271309317649013, 5.249285841721658, 0.21538188423051985, 5.157106066492329, -0.8379754126540448, 4.351106022949312, 1.9630561345668707, 2.9447042741897667, 2.0002307042246974, -1.2612280942617495, 3.1813996612099826, 4.600057059997551, 0.7862749855450494, 4.207818298863101, 4.531972549603883, -0.49955944086712184, -1.7458139282004415, 4.34002867478216, 1.2223496186658998, 4.725178490050031, 4.707649168036765},
    {-1.9666689584371868, -2.6955523476265095, -0.7647508445942609, -0.6782267751591229, 1.3126061670938651, -1.494244643340658, -2.5924299483433777, -1.0133829301681654, -1.9375082603046663, -1.391731679860866, -1.9627567048355266, -2.602749872087567, 2.9440661989242844, -0.838403435112924, 3.5369295838440675, -1.7442809642700217, 1.014432455051616, -0.6729501383328714, -0.3944946085643114, 0.5990335365946574, -2.000947228569756, 1.9514382284090142, 2.196046343368989, -0.6051122350429621, 1.8870515704251536, 2.4003074516668286, -1.5240284674260234, -1.78769819459719, 1.8299550468371948, -1.2645752721447892, 2.0672788464499336, 0.4845067678178552},
    {0.6539656931478606, 2.652816187442992, 3.0286960793301203, 3.18930245526069, 3.589559268450965, 3.445466728694351, 3.378134999118115, 3.619182080773647, 3.6633476218449794, 1.9433431369249143, 2.965852675609957, 3.4617463677835048, 4.433835708891692, -0.10480552313978225, 3.9192192433217294, 2.977645574754228, 0.3013605866931942, -1.6706665642630267, 3.4111662765336335, -0.49580543228890506, 2.2953254052613588, -0.9821751697176982, -0.5979376900522699, -0.8816073633289145, -0.16335234580919764, 2.47596786172187, 1.7358023747326685, 3.112672166902854, -1.1499167240295454, 3.3279395519168866, 1.2286733608768208, 4.281610291295248},
    {-1.7895527015603685, -0.6804358868307662, 0.420538810643715, 1.5364169492705653, 2.263405649665023, -0.12226856674925889, -1.2190902023901373, 0.8641775817359918, -0.009831596818496586, -1.3475289063393068, -0.31027406648601485, -0.42957332198175513, 3.287606885722863, -2.1176816734405546, 3.7481956169741926, -1.4678552160879808, -0.8293496615071274, -2.7467835575612427, 0.5783045434094483, -2.0030813163593346, -0.5952630996198071, -1.6641926600546877, -0.34108841453116173, -2.6393006248835613, -0.7434375411821799, 0.38501284191022295, -0.9023358124339019, -0.42400833692395706, -1.0653502386854339, -1.22608846792561, 0.6029580027682798, 3.2792242664187734},
    {-2.087033278256498, -1.074815384494581, 0.4459522943486001, 1.1217796261299358, 0.19655529035402927, -0.8006756495687216, -0.4773421281138984, 1.9967462075546971, -0.22611396359930583, -2.155386157412732, -0.8970088934213478, 1.1765838966552356, 2.8233065943819047, -5.018357723171636, 2.2758116263920347, -1.3917575414547736, -2.2335802609951285, -4.0705253833032655, 1.3110161378542182, -4.86383872628362, -0.22804749836213098, -3.459358711241793, -1.7233076255660105, -5.130714852412361, -2.3148903484501298, -0.1544586670430163, -2.671177621998713, -2.0829215704557744, -3.6232453164313707, -0.716918830017462, -1.4101471399308958, 4.224217954071475},
    {-2.299384865493529, 0.26174941672763846, -0.06722887009356841, -0.5796235716803729, 1.904055538704598, 0.23903431206140627, -0.364840203080966, 1.1151301230953914, 0.5559919775826596, -1.199727475318817, 0.1379898171598126, 0.7456192322140368, 2.9655526924373703, -2.523872461380773, 2.660343122166571, -1.0849980425934902, -2.6468901082507603, -4.0336955476132035, 0.5465723916374364, -3.018522753755041, 1.0969460528540607, -2.3048957950065643, -1.6415930436629227, -3.2802470315289733, -1.865418340209817, -0.049346599512002855, -0.9754264738257189, 0.09211747031926053, -1.708286830596359, -2.069824401940894, -0.18045433035771563, 2.66550772274102},
    {-0.7334372723007716, 2.4279888267144782, -0.07912437011886889, -1.9760637110280543, 0.4746048654666307, 1.7845723458478828, 2.9836348875639342, 2.8434577183560523, 2.338529877252715, 0.545097197854506, 2.7251602076494668, 3.899316108865972, 1.6475668335711353, -3.5952624454409716, -0.3968461454723212, 0.5805278614306844, -3.958043375383759, -4.408273663591872, 1.3137607575586314, -3.72964115017598, 2.9852849368724965, -5.432379266940225, -4.3948159527187025, -3.587073613442501, -4.408985563108196, -3.7489889159361023, 0.20171469863059485, 1.7365053306305105, -4.695413517171022, -0.21199809206284473, -4.162993032681647, 1.6598649350124353},
    {2.122350386570879, 4.957474355599394, 4.799449479122715, 5.258462480445557, 5.777083700248575, 4.997658055278312, 5.480059912175772, 5.449665722024543, 5.45580444974976, 4.695300435621146, 5.455654441581097, 5.262163953756781, 4.907228191299199, -1.1871007941420553, 5.225573647442077, 4.327723949693416, -1.4652932606405658, -1.4234917738250188, 5.7633380032511665, -1.32548576473332, 4.906607279395872, -2.075194529547181, -1.8287886256065464, -2.0168554435085073, -1.7645980964590557, 0.024340175752385305, 3.3786102263286315, 4.886264490069868, -2.0745566272794154, 4.8840551479250145, 0.00038643768408194186, 4.01073301940492},
    {0.5068608480867139, 4.819001875253866, 3.247539556825393, 2.809277228871681, 3.8879169075758964, 4.0478657803189035, 4.924316249849658, 3.667322057823739, 4.57972122590716, 3.602056647232281, 5.0617415068882465, 4.9340804467342805, 1.6833992279390486, -2.4641235106063264, 2.233598522744384, 3.576742142804019, -3.904231013462208, -3.920201655072843, 3.8378273294111267, -3.46079969638196, 4.841757174169473, -4.196832996718774, -5.39691620076501, -1.887379381372825, -5.317709101951038, -3.5577333596434593, 1.891957663062933, 5.011113508953392, -4.895434336280032, 3.083429124788318, -3.6855352738949048, 1.6251040148189908},
    {-2.6871112817550307, 1.9755679407742426, 1.3687664885596516, 1.3982378059419451, 1.7704163740960657, 0.8726597011537547, 2.3755974448692014, 3.316422708929749, 1.8941020339565027, 0.6846450105668043, 1.3995985392050945, 3.5106836212052155, 1.993681311208595, -5.864522533190117, 0.7379511232737983, 0.7371558775432349, -4.719968407159162, -6.228231931512257, 3.0284342751699014, -6.050646348585217, 3.4222875131100055, -6.07187264365207, -6.067809442929993, -5.319311989338967, -6.297439202555069, -5.034396440566636, -1.8822213157727012, 0.5380821621852409, -6.325757397430182, 0.31538854531379285, -5.512648774725999, 3.277152507592017},
    {-0.47738849980910086, 2.738376310163783, 1.8749635118848103, 0.18001228428994592, 3.6029299633139087, 2.7669311737047573, 1.6464943965463108, 1.8535853911272262, 3.499702717498993, 2.354130598626403, 2.635096969113745, 2.727572195561014, 2.1755249025257326, -0.683601963835388, 2.2198877254281113, 1.0786355873515303, -1.6348350688172912, -1.7034608800348305, 2.7145912319375354, -0.47597573799298215, 1.81483752449124, -3.76544328735078, -3.040666423062533, 0.6170488036201033, -3.023885679277028, -2.358476785073016, 1.2154708587202383, 2.8106934862101207, -2.335439234006295, -0.05002717099126377, -2.570213787118892, 2.5655969322437087},
    {0.8081405373168614, 3.360481008834644, 4.13522319990518, 4.200951182134434, 4.751582434694342, 3.455508656651114, 3.350667955135203, 5.300539171311538, 3.8914684207955186, 3.8705223211111996, 3.526501975565337, 3.813574011148343, 4.8217810336138935, -4.099321367811001, 4.1954400665511455, 2.4823372872927143, -0.733163252682417, -3.0849639329359935, 4.689491468798182, -3.5246986994806333, 3.1198364230005273, -2.832936738418409, -2.1613698371193695, -3.60156797618751, -2.3023249229799916, -0.5559599098339483, 1.5667346119829928, 2.45209343492595, -2.760947142322759, 3.8691885178013488, -0.8769310921763889, 4.225236769808184},
    {-0.7628916889867478, -0.8990503900247654, 1.740468858760581, 1.995292762668171, 2.6943261815825297, -0.06686604114849604, -1.0647030435444458, 2.42098209405655, -0.026530289231684465, 2.3401821520579404, -1.2549314560628975, -0.39093101918410983, 2.996641880678159, -2.9769033838324837, 2.6737476206426587, -1.1460774530027182, -0.2760775918107612, -1.5477039488084208, 2.525353604067974, -2.0968573051568002, -0.2632304694123047, -1.7253983935712922, -0.3310451349971111, -2.8307557451627323, -0.6542461809016322, -0.5118314915663601, -0.012525258358508587, -1.0663860770244005, -1.1763366769305954, -0.12744495996930988, -0.3554287637482751, 2.700814508337641},
    {-4.14705706770554, 2.1058610531001696, 1.8413646884096162, 2.025032955641653, 1.8917769311704218, 1.942754086985102, 2.4821282001807248, 2.271339084429257, 2.1352032756229122, -0.6716091446312056, 2.3151741541165967, 2.110646304763695, 0.027708826209512556, -6.63743194605743, 1.4188164692949918, 1.9744489125093394, -3.2747025264665255, -5.861964241928648, 2.2820678019816243, -6.028158067725913, 1.6770190819440167, -0.44094130322235203, -6.219700883646383, -2.2015076906032025, -6.7109808387401255, -0.6539763770306283, -0.8743609916303627, 2.0651143870814908, -6.2592889195331445, 1.0632123365416435, -5.036784252564072, 1.723478806760584},
    {-0.2947289421408988, 3.342282590494701, 3.394005536047235, 3.16053536059289, 2.9974757738477744, 3.036738370014027, 3.4212679777323443, 2.817620153992166, 3.44316878821761, 1.740215348658107, 3.3122224544607666, 3.0972943865825364, 0.6663015932330624, -4.090614888583464, 1.9816388846134743, 3.1891005175043343, -3.8670609009516705, -3.6291757231771027, 2.858046651376316, -4.382397520990417, 3.2129965381485333, -0.09339720914153696, -3.8304743549159133, -3.1692035890649057, -4.513666565376822, -0.14675526848897133, 1.390408783115, 3.0539082318381006, -4.529492494091371, 3.350613353725348, -2.130398751998075, 1.6397644132779348},
    {-2.6081266682940205, 3.5868336491096326, 2.479772263041256, 1.9617669427504418, 2.040874773736896, 2.8439354045250473, 3.831892638646422, 2.677644505425719, 3.4957473350540886, 0.2548427319524883, 3.7898249459843947, 3.273060402800877, -0.9022916178951271, -2.120853115379371, 1.047062806006124, 3.781426338289056, -1.9175596409787405, -1.540634888938996, 2.6453555437596608, -2.5903045816339105, 3.1069021800167764, 0.9308881671853995, -2.798051517624487, 0.42619316704543164, -2.916948376949233, 0.5231554028954549, 0.2883963027557203, 3.6197358623646365, -2.5074040909669137, 2.819908433680808, -1.424814593611271, 1.1318663241497655},
    {-1.9244995391457689, 2.953751391784413, 2.1276446100283635, 1.8789599200336211, 1.0936234321283205, 2.3335602184226176, 3.0205131195458184, 2.193799227079, 2.8612656766271476, 0.7047474070697647, 2.6804094020053064, 2.852673649725099, -1.6676903735740845, -1.5041019239482303, -0.5597665024834233, 2.625612126157866, -2.5497268919920812, -1.4171085695418053, 2.225470204122026, -1.9240296650270337, 2.2516966978327493, 1.140894525358888, -3.0638512159572064, 0.1948691636696798, -2.9293774526267597, 0.3342036506783691, 0.9143632384071502, 2.6887888860197555, -2.257538834512646, 1.4932416572825458, -1.8590850383407087, -0.36212703321681394},
    {-0.9658497640529702, 3.808616525733311, 2.853985941697466, 2.034136272706241, 1.9448450567111442, 2.9674886352530585, 3.4685229258322536, 2.639088251156525, 2.8400860013823026, 1.047393967164986, 2.9137040475882974, 3.1383659161329214, -0.20948118135154445, -1.845459287706964, 1.0687651962890574, 2.831035001984402, -1.2006464626663746, -1.1431329689669665, 2.5039158117212503, -1.0934745176350296, 2.909835847604878, -0.5642985639229269, -3.060214147196697, 0.9178090527858886, -3.604676277661185, -0.1897675667691366, 1.6020749958789504, 2.7342002463012656, -2.9419578005608336, 2.5014276574212673, -1.8771947176964376, 1.799990154757006},
    {0.9019407503074433, 3.2372939158112883, 3.3580689166232927, 1.8530163336022965, 2.61776379664938, 2.7408310982397173, 3.407430019673189, 3.535268614679512, 3.7104662484858904, 1.7293902125658274, 3.445423062690807, 3.8625851702156524, 0.8883048054427798, -0.8005715062298788, 1.5308325886647558, 3.72847836840612, -1.1708229232358882, -0.024154182458974067, 2.9775991778267907, -0.5544320920374312, 2.9707346060888806, -0.16611982283544885, -2.3240915365156254, 0.627598850687007, -1.5257437655327926, 0.05952846273150216, 0.9637085014380457, 3.6135827829186176, -1.9729241307593943, 2.535041806291017, -1.313069201546968, 2.3160422426031424},
    {-1.463784928903639, 2.416547954286178, 1.588469759627013, 0.32803745173877835, 2.109342499997694, 1.9612913030544266, 1.3303301821488678, 2.5147912366684606, 1.7624666811055252, 1.0225240741473094, 1.657997564428774, 0.7326275555225381, -0.2636485684812552, -1.3163454070759486, 1.1229175784308627, 2.2499687966300677, -1.4147514077302525, 0.3635161559987257, 2.5427426374276405, -0.7412818398055921, 2.6630953628789555, 0.7464913337665261, -1.567107889383686, 0.9278141340662637, -0.9724510200806177, 1.1435291768105738, 0.5839460945415537, 2.6393836274244076, -0.6765285248814776, 1.472991057502426, -1.7139730139276412, 1.9473854141576452},
    {-2.011107324823513, -1.4662546750761296, 1.4034697386541326, 1.2489853857983024, -0.5661392833536913, -0.6876754388503001, -0.9558936783293304, 1.1746766224922525, -0.028925004986662523, -1.4145987237326862, -0.9354493932081667, -0.1500049404589809, -1.5221838914216002, -1.7071833883271985, 0.3302164140467367, -0.16233777908824348, -1.6000833868367375, -0.8692282775194993, 0.408920276371625, -2.0169332010021623, -0.09024489108171074, -0.23479254736812089, -0.3292801121969792, -2.047036902203162, -1.1435699424223225, -0.6810333082401209, -1.0836721334445616, -0.13788616777524423, -0.8985175511932221, -1.2623736892962585, -0.586068442420778, 0.26236478828674586},
    {-0.6959715352207516, 1.695940640266787, 1.3459685251567919, 0.7969226211814138, 1.256592510313875, 2.0267210714725574, 0.9431529905842592, 1.043096826790987, 0.4078250640196764, 1.226389591933575, -0.5537058283220078, 0.8471090081210831, 1.2039263109866212, -1.3628387262520094, 1.7428633631277832, 0.45830092386284815, -2.4413145659425624, -1.5862750039821198, 0.9736831308428757, -1.838076899369109, 1.5143191475650406, -0.8234318013918696, -1.5948652515966713, -3.6180520222943087, -1.8928886587061649, -0.6228266264111001, -0.9054136322501507, 0.762519214175862, -2.4800435618543775, 0.9493952490663896, -1.5349380180342918, 1.4413081391885199},
    {-0.0343554479060046, 0.8909550662094337, 1.125671705086313, -0.1543614011665328, 0.10153489765268764, 1.0205560859617302, 0.9803053896549492, 1.0890079494105789, 2.085449384628851, 0.6643052984164085, 0.6326695665079124, 0.3228769295126767, -0.08713683531665037, 0.4805772654693763, 0.7562221421475855, 1.4791260246892775, -0.23291684960939388, 0.2563263817987077, -0.023572979692618252, 0.03017842367078446, 1.4470626320174134, 0.14692123704340268, 0.1622818145119404, -1.5005374170342964, -0.45345151968314595, -0.2604376037219792, 1.3414017409870735, 1.2682775641691015, -0.8085223171393792, 1.3994393018449152, 0.35576532758851004, 0.7412793618555479},
    {0.27149711621556655, 2.464345384797973, 1.8188866368111425, 0.9675511572951129, 1.9745727179476158, 2.356067966460221, 2.690449360184489, 1.2361346816203527, 2.284236446259408, 1.791447430178514, 1.7616312022738567, 2.20254369022551, -0.11827837235438131, 0.9983515907356297, 0.15512765953765595, 2.393273303283751, -1.0792887876344446, 0.16502080394090288, 1.6827549126750172, 0.5106417295882586, 2.1999330693300325, -0.49439078908106937, 0.1251752701338245, -0.2982171164970182, -1.0731237362112989, -0.21013172415430895, 1.647226185964651, 2.3677954168054605, -0.002125697850219421, 2.1291570098572663, -0.0818507464881997, 1.277099037701816},
    {-0.4503894340975046, 1.4126704634143845, 0.11856274221104937, -0.33363948578294245, 0.8447028292305788, -0.061425497132192024, 1.0279414880218074, 1.3261298389962564, 1.7658595115211757, 2.1309113077166426, 1.0543077746973646, 2.4388378063809957, 0.4326328189104557, 0.08372252112223236, 0.14182397463356441, 1.5262493708696607, -2.268405580011294, -1.3461583561211636, 0.31166623080136385, -1.5764303696960313, 1.4660473398595457, -1.675034182394331, -0.7778231689628867, -0.6062029782324542, -1.4453071443506011, 0.10834782051573974, 0.7987640025992845, 1.9006084921162714, -0.8060303380492303, 1.3479006867551289, -1.0431286192324083, -0.7181905852464312},
    {0.21776020819241035, -0.04898579676813992, 1.4049118096709154, 0.9348867617094505, -0.3144712701117378, 0.3939216266835644, 0.004078090648395896, 1.1656942449831482, 0.704149479349518, 0.5012943535571972, -0.6732180451770441, 0.5980972431416226, 0.3426031857551237, -1.4620667435280916, -0.8888179006705613, 0.4876193865782264, -1.1745074147564774, -1.541732652642484, -1.0931384821523045, -1.3068408638860454, -0.37685929304777177, 0.589018799618934, 0.3398022169455918, -2.4821446033102426, 0.21091752833271749, 0.28518182358447763, -0.02508294060788681, -1.1715231404101512, -0.9475208537775145, 0.517105973221713, 0.5033871548633018, -0.9890659841457832},
    {-1.451663952573372, -1.8484015967768623, -2.1454754369815094, -0.18187850853461465, -1.4257710142523368, -1.3132379736109556, -1.8168149511702525, -1.5960300865502641, -1.0883808230231522, -1.7552478346342635, -1.7324855935146568, 0.2968373448359453, -0.5638507665402249, -1.2329764254570246, -0.4622043694643249, -1.635690036388883, -2.2757068393145943, -1.3025397227480815, 0.25568255628312325, -1.7849980819926372, -0.6203036936470578, -1.4413488784368116, -1.23427866112338, -2.4448872063944025, -1.4433889462565994, -1.029078225001373, -1.6010254382991616, -1.317965254211457, -1.4737991519390459, -1.3656586327938813, -1.3326588290584005, -0.8925720031786888},
    {0.3402486774622002, -0.5668780473451015, 1.039765784053374, 0.7132833709055016, 0.1434518454387663, 2.236417112802035, 0.5317288025415127, -0.11016967565225891, 0.8948946125827913, 1.7299756294527224, 1.1510423943903259, 0.6831320279866515, 0.8796439978316822, 1.9505146798541473, 0.2538335700597749, 0.968125796759835, -0.18023508857396026, 2.0934276031769636, 0.6856465141432534, 0.9737717158719339, -0.26792794518017504, 0.4256143051407007, 1.0322839167822597, 0.21746044920816088, 0.7593666619570449, 0.2979822989492309, 0.7279600182625733, 1.3086385082695782, 0.8591982465486439, 0.8311913503681139, 0.5630234172247861, -0.37444882905565235},
    {0.4273977159078833, 1.7658367811961826, 0.6634880274768469, 1.408902577491136, 0.7406700410747554, 2.1663800380724214, 2.3717148607708722, 2.0548830475694335, 2.0172114778246977, 1.5245163796256487, 2.2705818909816164, 1.6493167340945856, 1.263885690944101, -1.2270793130593056, -0.8149206319402383, 1.354128629311117, -2.710497266717473, -1.6445745966776943, 1.69282623099412, -1.6287169374815293, 1.0436837658015712, -1.073563578778264, -0.8129503075483344, -1.5302445938269966, -1.5297867139474854, -1.5155172199791263, 1.9851507501060066, 1.5917703133956507, -1.3345714728814453, 1.8673068498809964, 0.3717332770762767, -0.9326617002171024},
    {-0.14483623043673283, 1.0721065122372895, 0.4800994364036617, 0.29917270769106075, -1.3230713078705845, 1.0259285350897225, 0.4899107709300827, -0.8623039404519346, 0.9252831590106512, -0.08724492603612134, 1.8262424528566392, -0.2385936073866885, -1.585757057889323, 0.6877680911048548, -2.3141384109948095, 0.5215750485429269, -2.638108072295876, 1.3977285989217503, -0.6424030109069548, 0.23252585481464957, -0.16013145439086843, -1.6515338550419776, 0.7308316678929715, 0.04765585316163871, 0.42127878151103076, 1.0707166921108398, 2.5870166201987037, 1.1184777583036756, 0.699350506481166, 1.287936708588568, 0.4051054938945081, -1.2306029993968615},
    {0.6943414181307991, 1.9747085756690683, 0.5887093117018699, 0.12655505107750611, -0.23006557113307502, 3.108900604602975, 1.1087624485693268, -0.15384183399787407, 1.7662715523087351, 2.25436806860833, 0.6522009881457231, 0.6133503322516467, 0.3855269054331331, 2.9147055487628757, 1.2440231105180644, 1.5079080695208322, -0.791660187886318, 2.0254673417453626, -1.4298305141109586, 2.160810528491429, 0.12567368968031395, -1.6529221789401463, 1.0897463327329326, 0.9868665916355924, 0.9379076100261233, 1.4166092105536783, 2.249434901835648, 1.7975307028048304, 0.49698830533591465, 1.200515031343144, 0.12464670946527572, -0.9649421549055113},
    {2.2962206737414332, 0.7826800091193017, 1.9302603092664237, 1.6932735762969502, -1.0595982476050125, 1.8424380383324492, 1.7288880222166771, -0.6896315040654928, 2.082964115102908, 0.8951271001292072, 1.5658124235555098, -0.23978052026397167, -0.40282988394995206, 2.3090311124005147, -0.8861342056722646, 2.2129043951133602, -0.3255267530051194, 3.0367465543333667, 0.38144469827552496, 2.0915220133139543, 1.3255447745704958, 0.8213883705265957, 1.4865308219385083, 0.9192928759506289, 1.623060146811432, 1.7794955291142243, 2.7925691048626318, 2.3915524796105845, 1.897136965975122, 1.6873082881583628, 1.6244612469272501, -0.8533413406804345},
    {2.074098571376342, 1.1894918627382562, 0.37923084759135056, 0.385487717417752, -0.1537260172990084, 1.7378938921741078, 1.2514109261384585, -0.2466545575677884, 1.3161519540509836, 1.8585666502728337, 2.0518990607136427, -0.46116832940865154, 0.15128371615354153, 2.430535077621883, -0.3152774038467728, 1.3041009369905583, -0.8780274254359356, 1.2924915322663209, 0.3804181975439008, 2.0707843283443093, 1.410686972456415, 0.6765637996485989, 0.5331309978856663, 0.33020315274112155, 0.8428798829691425, 1.0699309270544457, 2.875565761001515, 1.9976053704107486, 1.1735805291839518, 1.914409247455498, 1.273674382498063, -2.3269831018823357},
    {1.9802781282639765, 2.2600913780286347, 0.7790305904488848, 2.028581323056276, 1.357221046748802, 0.5921510900779614, 2.441268865197432, 0.26835070880264755, 1.8229044499444194, 1.7005118486373791, 2.1056035646976863, 0.6897772353782892, 0.9032598979935629, 2.9383223349618866, 0.36427724920727445, 2.6992876575454074, -0.8884516876791674, 1.31205788887474, 1.0457697753475248, 1.9222947002523054, 0.7017355133953207, 1.2970904314768983, 1.6754971867684068, 1.156523724729765, 1.9890004795905338, 0.17798807784526505, 1.7318126823016915, 2.431744666857708, 2.3709616918999616, 3.147088352522518, 2.2404467255297806, -3.1002121566853913},
    {2.950335385893663, 1.7283991193763784, 1.4726975537911622, 1.1178949489338144, 0.7686548183648848, 2.5453281151655514, 2.1342422792277227, 1.5265774945757367, 1.9986979016066648, 2.3805205368005278, 1.5831864139283016, 0.6417237822176608, 1.8721671627566574, 2.0568462610616707, 1.3082576218725588, 2.76191565961184, 1.3888240676020063, 2.060252322628637, 0.24900907009995135, 2.0464984921999725, 1.4413089494505944, 0.6077539041437426, 0.9879411176094752, 1.0727997726475638, 0.8374001025246173, 1.2041842694886125, 2.7465330431649524, 2.7574923032416896, 1.1854704557827285, 3.5756193148617412, 1.211048266946019, -0.25712948892302356},
    {1.0694641041859518, 1.0734707122584866, 2.106735688614968, 2.1818020365682065, 0.5163347729099638, 2.1861292644897237, 0.9949983811716173, 0.6511664043979843, 0.7338998454967312, 2.733989275506146, 0.6217824639294542, 0.026215990729169466, 0.2993583309807349, 0.7414333398182978, 0.24786374239514397, 2.4461142485840983, -0.11809466778941778, 1.1675531738122535, 0.158820926254849, 0.9257733522322547, 0.041482888930504384, 1.39287303581841, 0.8796968241535891, 1.3519239894173354, 0.30445642445350896, 1.777183234840339, 2.305454622108799, 2.1349599636714793, 0.6871298999255793, 1.5039695517343226, 1.6885302192215057, 0.9372943542030122},
    {0.41589758707723673, 0.7461534859099743, 1.1832882698319847, 0.4752026666380137, 0.10560370049851615, 0.7079705281995013, 0.22148460291507896, -0.8039229449275545, -0.8394601510424317, 0.8188087533804915, -0.7878433308137704, -0.7239112794271183, 0.3723547593570857, 0.21821226075270225, -0.9809785244263082, 0.7320456168772245, -1.7533567218191066, 0.12217911647429061, 0.7623203441636169, 0.6155542460963834, -0.042437352500729546, -1.8170623701019153, -0.34271137193817386, -1.1726090711239332, -0.2781279952916789, -0.5266045961728348, 0.337636482067957, 0.31168132730359543, -0.08849049012699467, 1.490010244793586, -0.5915510116388065, 0.19741626567319184},
    {-1.5408916493133253, -1.0260692474587312, -1.2313131111170732, 0.7683923915306244, -0.6905470140007458, -1.14410724019378, -1.7516884550090022, -0.8371631383550182, -0.7297077011391884, -0.33941042797291476, -1.3083020027717371, -0.8967548134451456, 1.3618548986908485, -1.1560982396365374, 0.7754992617942337, -1.347169756400743, -0.5494329142336423, -0.23743523542856826, 0.17269233807724113, -0.36950360125235254, -0.6150249172324487, 1.4449303969935567, 0.9625600416211075, -2.663716716580667, 0.5427151400883861, -1.0714426052711492, -1.2338652078337478, -1.50784070553584, -0.09427776480802434, 1.3567029820762788, -0.23866786166484405, -0.5886713588254946},
    {2.193656839398054, 1.1093812459795365, 1.4513683077402197, 0.39705213251430793, 0.3603242876130953, 0.8944566415257474, 0.5542169284385676, 0.7259609419898669, 1.3567583649304258, 1.9576705607508085, -0.0790532998152633, 0.756847780921762, 0.04477071539330146, 1.0178496031309445, 0.5050881054231218, 1.3708255967398184, 0.4932713187714464, 1.201791662426248, 1.112858089970454, 1.7032461170847193, -0.6159028666336847, -1.0302569914162998, -0.2273878557095676, -0.09000002399741239, 0.6474567037433026, -0.5361536881588792, 1.8486626620074706, 0.7368108765419435, -0.03015243876173654, 1.3445119921584896, 0.5563946869218814, 0.8954032113162965},
    {-0.638341514797627, 0.28829505647647413, -0.7526136952668373, 0.9950436030911145, -0.6764291999350244, 0.4668764229208883, 0.21024870596565925, 1.0138216100451536, -0.6496826569495167, 0.04301597087541733, -0.35552824382235404, 1.3148484668872227, 0.4322362595363067, -1.4873257108436748, -1.0216686887725217, 0.7955414675973441, -0.5409341954458582, -1.2285305674406297, 0.9700282838957174, -1.0843158073238521, 0.699073535966478, -0.016980024353654255, -0.6817763125456998, -1.021695806708784, -0.5989573111766497, 0.6390005154976232, -0.8064916760038643, -0.38455348276337203, -0.8294386461019764, 1.1680891409207064, -1.000742549289488, -1.0679134145017846},
    {0.1950342336438172, 1.3115657140557608, 1.7446340454781417, 1.8763026698209555, 1.8695207251840562, 0.9779473412966301, 1.2529825787997466, 1.081223359465516, 1.3049610773656866, 1.2170418028356307, 1.3016388539159243, 2.1001707203694178, 2.646291693710425, 0.33221242996966766, 1.0955748376732468, 0.3829190118296011, -0.9721391444138909, 0.2294682044963453, 1.2248218697209479, -1.0854902524968728, 0.9143754489718874, -1.803907965314523, 0.02611574333379581, -1.328672565716732, 0.5365048979602586, -1.5199385232232119, 1.1596684763603375, 1.3261910429076713, -0.2248425497920158, 2.1964093557239175, -0.6515823702076661, 1.2995127994126272},
    {1.6782797651424943, 1.5096825230497923, 2.85307225432379, 2.793067454264766, 2.767957470619557, 2.6729671083208393, 2.636674934530136, 1.5124634471393268, 0.9793066107277961, 2.958543565801765, 1.425837206401959, 1.2179330858479465, 2.8484414657608106, 1.5186367290262877, 1.4178722072639223, 2.5189106840420457, -0.2858266680666032, 0.8690039920119437, 2.059882169659196, 1.4553437381417396, 1.514638877480891, 0.48343901541280215, 0.027172184235197672, -0.7738975475477398, 1.483055398687807, 1.6864865582219715, 1.8096798777312209, 2.3605589890977283, 0.060372251859205465, 2.8069057359376886, 1.4673715730182708, 0.9256199089076979},
    {0.2739838173818872, 1.0989582644469857, 0.602911237650859, -0.1365411902641078, 1.5317509800774145, -1.406945420548097, 1.576701867360864, 0.9861904068938908, -0.0856804385213886, 1.733524186192207, 1.0935410794785694, 1.5229471519147502, 0.6776835910793839, -0.8920219201521841, 0.5194264828949313, 1.4731850641832382, 0.2847302828025156, 0.5246441280006073, -0.04214716647150701, -0.4977652191020457, -0.07033769898906393, 0.5876518201352464, 0.7455347967783506, -0.45892090715046646, -0.30541957745831, 0.7370684805367342, 0.8027394486312524, -0.2900374847972232, 0.31447656435133864, 1.4005169642273272, -0.11546887507501132, -0.291479001224873},
    {0.5233323471917, -0.4140489968334852, 0.13475885295398024, -0.4395320905016266, 0.2648555231117273, -0.9455221248016399, -0.45287871320907197, -0.3912205018877825, 0.09366157464997586, 0.08335383977817787, -0.7229265560525545, -0.8397096412945508, 0.5089214922068832, 0.3178121863983358, -1.0529806962592176, -0.1461734556894092, 0.098335468435622, 1.361204326413533, -0.4664993537909338, 0.9020622716849191, -0.6044570853370095, 0.02469277645739224, 0.4582289032604836, 0.9887341401716231, 0.26227508751801654, -0.27933349468679164, -0.7381646337608955, -0.6842211004344827, 0.5035303474164262, -0.48436500986081554, 1.271802883800129, -1.1418429618015942},
    {0.8151808117740021, 0.024957120993979398, -0.22694519605975352, 0.6931023834868534, 1.2427944515459175, -0.1796861557599847, -0.7672139192739245, -0.08680351745580524, -0.03366432764548553, 0.16535386012087, -0.35590319180905927, -0.46709830993677126, 0.46223354370877734, -0.3097984003837173, 0.9262517866622787, -0.18903801094141368, 0.2527803697479827, 0.38848181953410765, 0.6315868022456799, 0.60579060039527, 0.24947719574686825, 0.8320289524082657, 0.07244281180474686, 1.306220944391457, -0.2014012999228379, -0.6269190254839924, -0.780281087800064, 0.39239441022865107, 0.6944370629003804, -0.6686543412769385, 0.9504807645918679, -0.566363766698053},
    {-0.47395534036915865, -0.33985873124115806, -0.5295242449231767, 0.36888342904749555, 0.08091664256636154, -0.7170612211608136, -0.8359606289251208, -0.1419717229857587, -0.9280776828715451, -0.9482272515431955, 0.09744679216266497, 0.1382229614679048, 0.4147479146666741, -1.2549951434559026, -0.17756890772927406, -0.24399845947850624, 1.1256458184490907, -0.46299001642358045, -0.14827670089606615, -0.9960810099157443, -0.6069189956268906, 0.6238841132181235, 0.30385833767249704, -0.47537560485305613, 0.15631904913637643, 0.7441206565863601, -2.11319541955182, -0.6402095726559177, -0.17954601633421102, -0.44182254110522656, 0.09632355383112431, 0.5184445127545283},
    {-0.6891459513274839, -0.25427622427892627, -0.4638530449744435, -0.2554198405817723, 0.5975007744411434, 0.045673062630326056, -0.12390361468510808, 0.40912282846366627, -0.22926447243990772, 0.41513753792700203, -0.2819363703074216, 0.31744955310315703, -0.5319146262857358, -0.2987551827067309, 0.46474860992899913, -0.39977001234609827, -0.07158999801873228, -1.0173647734102487, -0.2494166570068483, -0.863456984249121, -0.9832822726476117, -0.4337197457333636, -0.10939325920004077, -1.452790551508491, 0.2874777890271514, 0.7980275676953839, 0.28947606070142, 0.2332132949919687, -0.36932855227002276, -0.45468068189895555, -0.8340775909030959, 1.5756812838203513},
    {-1.0375431088200502, 0.2579163125048661, -0.8667310977471298, -1.0329846220676269, -0.9283138983130858, 1.4403512009928776, 0.025211239425378368, 0.4362348858950027, 0.21843813145522611, 0.13520808756243677, 0.1341451748251327, 0.13765300893947072, -2.896895891118302e-05, 1.2266008469961687, 0.09648288984448299, 0.2696689934737804, -0.678801873376369, -0.5584110699841476, -0.01842485356708081, -0.30007634449650183, -0.04321332506384878, -1.0490558506631442, 0.5295993789429196, -0.7557017488843818, -0.18836792339655778, 0.39437398369380344, 1.6302762561101443, 0.3317326682152792, -1.005594973056514, 0.1943249983369454, -0.8298228925693623, -0.6635881149879614},
    {0.5135161882498278, 1.0723680187099176, 0.7758377358215818, 0.12532780051849496, 0.9187426925846016, 1.6654571601826829, 0.697392061718035, 0.47392779242323785, 0.7346548098258076, 1.3354259007120113, 0.20646103879740688, -0.30307869485418787, 1.194326643245515, 0.5183218410623625, 1.7573593026361907, 0.8351297302597006, 0.4763000551616561, -0.08934396489915762, 1.2814384439268138, 0.2348588625527201, 0.6527119849359639, 0.33081542435524064, 0.02263324858547565, -0.4485786814220619, -0.2333636111375814, 0.6567375386408807, 0.7189344589665607, 0.854694361060384, -0.08410002479633356, 1.1149240786849615, -0.6902677266940103, 0.4348140563044159},
    {0.5938186774345894, 0.1022386142633165, 0.7184541593878486, 0.24519577652228525, 0.16740767233442835, 0.5646191522922506, 1.1339193967738717, 0.5312169532447927, 0.6165726575131393, 1.270722286410244, 1.054572248673778, 0.15906828361549308, -0.8245550593222065, -0.2758390993646044, 0.18448197913883868, 0.6783128736965719, -1.0373571248255664, -0.17485328149193952, 1.3628802766838746, -0.6899642441205505, 0.6183051436887227, 0.5930429891625787, -0.8807862218120585, 0.12759972088597685, -0.7898602368799118, -0.1235707573729158, 1.007667176377089, 0.30444266865710473, 0.3412083282552474, 0.0691320543968788, -0.2993789146770133, 0.9285489078397489},
    {-0.2994385392470109, -0.6683296300395618, -0.8373497209952194, -1.3041485035295932, -1.8769005984124167, -1.3441444998187564, -0.6250720607383672, -1.2300245151651303, -1.2214982316134828, -1.1686093491166583, -0.06492243647478636, -0.250766698957767, -2.5498435846129754, -0.2580889812147133, -1.2383344461418853, 0.131392618868235, -2.023840356745401, -0.03144872153226095, -1.0560493767101657, -0.4217969866876994, -0.4018373418144764, -1.1183563708668753, -1.2411244012158056, -2.072411795812033, -0.4260841318918555, -0.6100572253018425, 0.2197566910760488, -1.2968637715697486, -0.14559983010191968, -0.18221950771654197, -1.411935551533199, -0.49272557024372665},
    {-1.0301182662183614, -0.5681988940656957, 0.33309867703652146, -0.8735036061442482, -0.964791735099311, -0.7793817528210029, -0.7608923920701175, -0.3535336189108208, -0.7697977794882694, -1.0931216823923693, -0.5217425317492447, 1.059083310949209, -0.7676317231088553, 0.3893683223667184, -0.6278847760731082, 0.10771066435854047, -0.03436305425679038, -0.08370548365297133, -1.1223833143911819, -0.20585120112888158, -0.13431807277297922, -0.6007053237612958, -0.3850322746574314, -2.1395842165154213, 0.17214630437645315, -0.07964146165686395, 0.11136779588406942, -1.2370571896589349, -0.9347132337107382, 0.310936956775268, -1.1669787081496286, -0.21898980998107037},
    {-0.872375733663781, -0.020210107245299945, 0.7499809974193818, -0.09735624051831378, -0.5192018953420551, 0.7951600071087432, -0.483472877948787, 0.8025948146069207, 0.5470039176616949, -0.8270602706776456, 0.14494775035966764, 0.2387033832940917, -0.5306115478342827, 0.03459373282195619, 0.18020951075837818, 0.15447305174695192, -0.15311362485717622, 0.0404214034231013, 0.27125277228331696, 0.27016076999007643, -0.39955962453916344, -1.0665159933505415, -0.22100812706971099, -0.33581501817763154, 0.2027197754154841, 0.1739067526802358, -0.11904923903445594, -0.5802552318692797, 0.07579157849423226, -0.49939647837605733, 0.1873927422517945, 0.6951861054964588},
    {-0.18216284302954458, 1.1738247567798816, -0.19975793409507164, 0.14543933015124838, 0.004144449712888858, 1.369335334724162, 1.0254721098211657, 0.9362606932196648, 1.1942344969407444, 0.5793488356357691, 1.3104639732409122, 0.2826599586737846, -1.475693297682669, 0.17780666261505104, -0.947930748601374, 0.8280273592463926, -1.1771138469631448, -0.35403091854201596, 1.142929295143695, 0.13636368285426456, 0.6845785582375065, -0.9509063385211626, 0.08431378326910094, -0.424558372227264, -0.502411932903023, -0.33886621289695723, 0.6732920697155969, 0.48761896993956344, -0.1746961666570251, 0.7064387044872504, 0.13985911021530903, -0.34083782049034483},
    {0.2945057268954146, 0.5260985832642934, 0.7537273854289385, 0.012867368558007871, 1.0533570449814194, 2.170536766949612, 1.045091115775768, -0.11209829934367803, -0.5040397731323519, 0.7354842866833536, 0.797959925277256, 0.9438102123303038, -0.5117323486962532, 0.12608089577820547, -0.13083069233207248, 0.10297844804325004, -0.1419691154971328, -0.6040571652080852, 0.39740489790884215, 0.06594096141361247, 0.6444951509232623, -0.4385508960079911, -0.440533563991607, 0.8770707217058742, -0.7869099166981155, 0.08168221078197895, 0.7434142154429145, 1.3144044589830939, -0.36169118691503854, 1.2143797680160002, -0.043568875607715336, 0.41225075766743513},
    {0.009620497032486866, -0.420161266217288, 0.7503657986313657, 0.2910271831583723, 0.636756699379892, 0.7657657751329408, -1.3895776596182612, -0.3338415695240402, -0.7554407077912949, 0.043623883688482246, -1.589825913792214, -0.4160537862604058, 0.7588569092426857, -0.31771245364213424, 0.21681760505086517, -1.3764999394349324, 0.7293405616632426, -0.0543685137807781, -0.03344740154756685, -0.3351958280221461, -0.24288039068759087, 0.8578371808416331, -0.034827454903559686, -0.10053909516451584, 0.06809374483714183, 0.566687640372744, 0.06192837338267207, -0.05423041019923746, 0.5221422666386306, -0.820018750331034, 0.05939038246145365, 1.249876643313575},
    {0.09081881356426855, -0.19849750020930954, -0.19797893713334022, -0.35511332619707264, -0.4977276652283922, -0.1465523799281065, 0.044605202873027924, 0.4836207461442865, -0.29879818427069893, -1.099241545206489, -1.3673983164866577, 0.06995069647263742, 0.7796381503399074, -0.2221889200890342, 0.4225830294872061, -0.36569311370757257, 0.13110996160666283, -0.29012490114566797, 0.2851634947653679, -0.5132530062947628, 0.8241591037669083, 0.70390282642993, -0.4692285818369851, 0.17251864031802497, -0.8419404695086339, -0.12422112564197221, 0.2616459359435806, 0.047699264775946874, -0.2771714021864453, -1.4262522818843333, 0.0100612878392635, 0.09946995280230785},
    {1.4545227967060197, -0.49073584815604265, -0.3385030508565781, 0.44370634469398834, -0.6651270872311768, -1.3262749568671, 0.24130959859846168, -0.6535398151186019, -0.7422255979717614, 0.31034589848729105, 0.05625706554008791, -0.20618244459399335, 0.14951225266025314, 0.46310169729934675, -1.1933631207374698, -0.1848655355029522, 0.6261331092535352, 0.4252084384471514, -1.2180711200717997, 0.7461643267651041, -0.5301911157153538, 1.7541025077899575, 0.5500389094374666, 1.0121356903261218, 1.1905228041355, 0.70007920499337, 0.8916781458095572, -0.11016131987535618, 0.2999787394687724, 0.0055854228507977175, 1.5609644564446192, -1.7952231487204302},
    {-0.5100713651083926, -0.4322222240261234, -0.6467556369094356, 0.10503711581496883, -0.8022383606497289, 0.12854379199412422, -0.8650024662243272, -0.4575609918844158, 0.5413740164084165, 0.46775692279286263, 0.22595814875201606, 0.2847509650912166, 0.0194825621395324, 0.8094269842157291, -0.7206334784949245, -0.48986025706496406, 0.24040639879411202, 0.2953282761602564, 0.7542012887310955, 0.9719070683659852, -0.36651331063141224, 0.879067400144457, 0.658363603937256, 0.337757266818462, 0.5462863869930058, 1.0362402773390487, -0.2566354150417859, 0.051374832249407226, 0.7835563760632731, -0.493426852698079, 0.8059317027477888, -1.391882030112612},
    {-0.7354792661165411, 0.185565179333811, -0.7081766563962885, -0.40364587772278054, 0.4332471797367384, 0.1116982855482143, -0.09705684509062686, -0.06686713437479387, 1.0639742510554806, 0.12476094481307616, 0.9657262209818855, 0.3418619547025029, 0.5182811906969773, 0.657151738551528, 1.1809831680271132, -0.7198366306766049, 0.6102398796786912, 0.6597195183330286, 1.3525748054254227, 0.009958876561853363, 0.5409782206237232, 0.3833873936657593, 0.6022959938684442, 2.0629815315902476, -0.05421167981127704, -0.9139957138076189, -0.9244996910567552, 0.49662832314142075, 0.696146408949195, -0.08565761527490987, -0.024740468644598005, -0.08455042881656047},
    {-0.04457442671735075, 0.3108053166441608, -0.9621774302784298, 0.5922607965104743, 1.2735078802595685, -0.36252209223767795, 0.8383547916446862, 0.7950080814070976, 0.38623301829654166, 1.093186038080955, 0.9591147540203813, -0.27083680364093454, 0.21956977424869223, 0.2889440394079334, 1.278509968980152, 0.0050155533264150415, 0.2428149752495933, -1.0832035637485449, 1.3698454814215477, -0.5501000009376545, 0.10706781145254388, -0.19994808819283155, 0.036833906849883656, 0.6666717863800217, -0.5757042346179136, 0.25403798520166376, 0.06582866388990874, 1.1345715622708283, -0.3379731547933299, 0.8775420564971971, -0.48986884430812994, 0.2556143754019724},
    {0.02732931465453232, -0.08737016906272187, -0.5373915010593006, 1.4544442201774754, -0.09449692647456276, -0.3623036338211212, 1.187947404414009, -0.054304406826664334, 0.3182148086065627, 0.6794176306588176, -0.6773810691104318, -0.7302197903942955, 0.09591954167774068, -0.33836220962689334, 0.9037435479406523, -0.5160030304328508, 0.7830255288856998, -0.9235568387684333, 0.840213916654386, 0.3120639949096433, -0.4771118950864342, 0.718438424748291, 0.11552892699396354, -0.6759098336609428, 0.30719363181546944, -0.09704748614030023, 0.5854077912670308, 0.5056902161876795, 0.0890447766607805, 0.7643475205396371, 0.47227988065662335, 0.8049537051176681},
    {0.9000124784810852, 0.48487406185862303, -0.3528023243864005, 0.9221020223155603, -1.4088328974519337, -0.47167643946667404, 0.6736297678430269, -0.4513267175309023, 0.13142252337819624, -0.24742835543412584, -1.1737391727606856, 0.7349437922650122, 0.6507014823185125, -0.38856566920043223, 0.46227526918510825, -0.2776074157091309, -0.08074498530841458, -0.8440003326162935, -1.0249150493536938, -0.5504524267239113, 0.7452273403144878, 0.330277706496079, -0.5584305881854712, 0.150152726096916, -0.0800958556630881, -0.3208258392268333, -0.38439666014177637, -0.3117814188040984, -0.11762869840037193, 0.4596118576652569, -0.8792864424757204, -1.219128851664958},
    {-0.26102751397667806, -0.2470147545572476, -0.25596090035115887, -1.0300363795727059, -0.9373463852107978, -0.3878027142489872, -0.5123177276774746, -0.785670336747228, -0.6315840994868583, -1.0971876085754182, -1.2637246954650578, 0.3462583580768676, -0.08087394850018423, -0.31128214922468805, -0.9291021018742175, -0.9549781820233486, -1.4309545838887492, -0.8259318945172043, -1.6035178513784132, -0.24481960902880162, -0.4837552424948795, -0.596841325878466, -0.571215180232497, 0.03646949303293764, -0.8182374210827806, -0.9963169100628622, -0.6220171061909721, -1.2736777335807792, -0.820178988896802, -0.6312657750493963, -0.634048801027342, -0.9972201356362547},
    {0.5388223207122039, -0.00036648597101931893, 0.30990655635114683, 0.18855996316249643, -0.448316990770584, 0.010361950635957474, 1.0113034008888013, 0.4491640753844303, 0.9717495119443271, 0.044699557798286764, 0.5573105888252577, 0.462300847514043, -0.05636981990508748, -0.17984677167882862, -1.281899686092432, 0.4584595011007655, -0.48128788616640156, 0.3303728655757719, -0.9838845255685545, -0.17075424288387697, 0.18877990955877225, 0.796560726858933, -0.38647704473335037, -0.39731442549443735, 0.10632336266327766, -0.35062765520993844, 0.1886829665115422, -0.8482188749837444, -0.3120495207911741, 0.8447565544819879, -0.3606636068778613, -0.28637669647926783},
    {0.5109630656852604, 0.5539372823433634, 0.47462329998965613, -0.12066064149017479, -0.5052928412892934, 1.343226610537927, 0.4112524043100208, 0.8093753835831821, 1.3615156401375188, -0.49573911272118104, 0.7862453369082214, 0.2513605474360356, -0.14162816390286917, -0.6948182555208842, -0.3580932985157013, 0.9006661648586437, 0.42840652475805374, 0.7058113682717486, -0.2352633223880745, -0.2518798625973977, 0.9395782126956771, -0.6426991452313862, -0.03831133097534989, -0.3973126336912508, 0.347069215434353, 0.44418732318007864, -0.009901717872655598, 0.14160493712136543, -0.13392434117101085, 0.3943296674920821, 0.24784607163620287, 0.44344652448386374},
    {0.48121746965386125, -0.0434848619178953, -0.21920139425890162, -0.9635875307735021, 0.47954360630334575, -0.4239930149278343, 0.03978469084264378, -1.0318171140870307, -0.2939256072085827, 0.990384393037485, -0.03287406431319711, -0.16954753951817958, -0.49223659925930713, 0.9961370342083055, -0.2524850600974384, 0.31595180699745, 0.9312664770144291, 0.3994809923772969, 0.2799813696698199, 0.3491640592798775, 0.28498929173138676, 0.13376107079925478, 0.6279337328348509, -0.307234233689486, 0.2565282040924419, -0.349838679709411, -0.059563349770613006, 0.7097858034431442, 0.25668723608997585, 0.010414183840011366, -0.1319071876750315, 0.24536284412267734},
    {-0.3260282506656756, -0.03441358517435739, -0.0856588394858146, 0.07326054441251806, -0.3155718102306038, -0.19033337289576074, 0.11620401606495782, -0.6949546703016449, -0.4169999323943455, 0.9973111592895216, 0.14342291698016046, 0.021554156303695986, -0.687605777832463, -0.6689719988260382, -0.9947948213429982, -0.8206948522644685, -1.3564129314896989, 0.5132484095609138, 0.5414899955068195, 0.09714647601624356, -0.37856887343599077, -1.0489095320628778, -0.7641135184321313, -0.5213330659229836, -0.45688420056408613, -0.5253357302713111, 0.4213736267788956, 0.4727753137608206, -0.5799261246664179, -0.17216176085981577, -0.8916271199173658, 0.21883210317936042},
    {-0.8713700769330968, 1.4177614769697606, 1.304233978684914, -0.2194017965396096, 0.23781700556009527, 1.0484339107398737, 0.4692492282604522, 0.4484308922320737, 1.58662352539252, 0.9793522517394317, 0.07105873996831831, 0.2186149071243077, 0.329221519364201, -0.5318896673945304, 0.8434816082271067, 1.272158498801294, 0.336960870850348, -0.15775212675100428, -0.028139662733366783, 0.9393692145060394, 1.1559275519680983, -1.5164731657923587, -0.015711829232172153, -0.6007568674234769, 0.20473612724565995, -0.21603153295996796, 1.0791223089406894, 0.2557330551876217, 0.04168898558391517, 0.8239919675855438, -0.014673399860805793, 1.3464600221467664},
    {-0.6849937857704774, 0.46621324230890626, -0.17196282797527718, -0.03955171974313903, -0.1818784477438233, -0.32184352318322135, 0.7929079528130559, 0.46709364168341905, 0.884901185377343, -0.34150837851287175, 0.694284224893751, 1.6299596856054808, -0.72922169273356, -0.48510073828270006, -0.9174058994213576, 0.7698251917722622, 0.11333712000063417, -0.8383000955431655, -0.18274570283361427, -0.46988289495534685, -0.0490980846889867, -0.8056746236211698, -0.7043272557181204, -1.0605352197724627, -0.053266632587696226, -0.7233735873104061, -0.5941508445157418, 0.7456440052982002, -0.6628242180501331, -0.12876263795597218, -1.1404726378289318, -0.011207715942751481},
    {0.7772515653243889, -0.37631413290621124, -0.044313858655311386, 0.4502877342280875, 0.32457325072145593, -0.9812581007331964, -0.574652892163134, -0.2164877986652135, -0.060672535898882926, -0.1781669120996718, 0.1765013410637965, -0.04220639384020916, 0.7828626096815533, 0.3696328954798144, 0.12420467536645571, -0.736118733591697, 0.6406408653539056, 0.4258638632200391, 0.20916687854763158, -0.696045690748756, -0.4425490997165714, 1.3746288234535045, 0.46772652089010563, -0.10963673660639536, 1.0150550085225007, 0.2714438050241671, -0.016956391002003027, -0.5003713683429843, 0.8540510336850813, -0.8207260380672583, 1.1734833071583501, 0.8921713360649135},
    {-0.09489328949424092, 0.33964770527532034, 0.05476788912733549, 0.10239201346105613, -1.0885010513427367, 0.11035420540314061, 0.5622334699282334, -0.45753336764828917, -0.4488645765603662, 0.03312253626128778, 0.40018939568322465, -0.5554435658103574, -0.3430887545118723, 0.011031717533096055, -0.9855713329737193, 0.6006336238043827, -1.6842033488798924, -0.6401845154537535, -0.07052687746956328, -1.163059366607181, 0.3185080467624182, -0.006055033868572288, -1.0459032554473322, -0.8517816864020261, -1.0092968756553085, -1.0390445525645615, -0.35555060408381367, 0.4710674917256725, -1.249529113547059, -0.31210455061141656, 0.0070418292643834235, 0.35865265528778983},
    {0.4513054815807717, -0.09788966451874413, 1.0602953986229164, 0.6135555107576472, 0.2234512395886689, 1.1282215323584703, 0.3939089834459415, 0.8219683459269616, -0.20363869937848694, 0.06168220574464205, -0.7867623865963534, -0.9869371012413725, -0.3538371166998325, -0.2227115709498291, 0.7903032798252562, -0.3414820099738407, -0.39474085644188234, -0.16933484966240164, -0.39088885197734097, -0.8424109689539871, 0.3787408476832036, 0.05060425093154598, -0.35073064766117396, -0.06154194450031651, -0.46430791774070374, -0.7392878779293823, -0.43449845186502567, 0.6279214646017134, 0.5362985520293995, 0.8013096208779106, -0.7929753269821219, 0.16243494966281075},
    {-0.1576435279700874, 2.9255331958581814, 2.652794213189692, 2.611747107098858, 2.044465415590118, 2.7663386137847734, 3.3507658956273887, 3.3634237338749933, 2.8604159037545753, 2.0659447894892846, 2.5633215770528786, 3.1008223345291572, 1.1532390044012, -5.382592333439853, 1.766571869700504, 2.8862131604615464, -2.2275339439717396, -3.9919596492496034, 2.9117327683756375, -4.844481653350155, 2.6959355174891053, -0.7864260726367968, -4.743036867086865, -2.1231097122209492, -5.3902455099609305, -0.42877489469082053, 0.7581174775927367, 2.4245144457166616, -5.418333850170028, 2.6647076123131543, -3.8774390325006647, 2.7127000359717592},
    {0.7146594848185622, 3.8435305143212526, 3.3063863204102653, 2.326240753748224, 2.1135917587878295, 3.2687810813010483, 3.9332244354410433, 3.402806348433647, 3.147104054850881, 2.633399448167145, 3.0905057136160297, 3.5220825430548293, 1.5583151723902011, -4.971900993359519, 1.3748451269800317, 3.2593148977084243, -4.023886140812516, -4.085338156400651, 3.1498096127605426, -4.992332865768818, 3.341023993287145, -2.238284405556447, -4.390898183743663, -4.263107304820636, -4.8641669616861245, -0.7667051370502933, 1.668298786482224, 3.0539585751950544, -5.26353650088667, 4.02716850393029, -2.9739877095702636, 2.612461466057751},
    {-2.702745462593586, 3.125518748462857, 1.2802285159549003, 0.8420085154598455, 0.9394843893781555, 2.0657839254874246, 3.3203347676836037, 2.2585219028190266, 2.3598524684025812, -1.1526517442378323, 2.7717272698325757, 3.045096934861417, -1.3719814919161097, -3.659594118035056, -0.3260316754665266, 2.8037376651046215, -2.621620570503345, -2.628434151527794, 2.5021067146490052, -3.6336632895347334, 3.063686804758815, -0.5107000065695831, -3.923103000806954, -0.4882492017834482, -3.802922237389302, -1.0239978066448934, -0.8611844389021123, 2.915986244006927, -3.621260862463871, 2.248196231822122, -3.000910408821305, 1.4380951158406161},
    {-1.5772712155454327, 2.389808046201053, 1.7218053394189154, 0.9821516158320865, 0.626352363079916, 1.5819985983766796, 2.6121410128175824, 2.1172543348066704, 2.325185831915804, 0.910034367086625, 1.6760303369675127, 3.058573591618031, -1.8120641348769473, -1.6655365214363238, -0.7362219899946635, 2.371943042251263, -1.7741438943167538, -1.418756522606772, 1.5141656914397217, -1.2547256124999138, 1.7040078380233425, 0.49874776212353883, -2.531168904401594, 0.19087813777087503, -2.798217963071973, 0.23220419146154309, 0.7940677909926326, 1.955571685659145, -1.8662161385271574, 1.4626125754496033, -2.114303133694144, -0.05056585449826418},
    {-1.461077115314009, 2.9670110235068954, 1.4611548639897463, 0.7126706751853363, -0.08474367950131674, 2.116907986834529, 2.189305423529747, 2.054647050059052, 2.2144699788449467, -0.11652006232336733, 1.6258804885014095, 1.8253763164150258, -0.9490038348088047, -2.250184220090222, -0.6195973934830333, 1.6159446367238948, -1.8044202228874386, -1.4013939812170553, 1.6472711667156446, -1.885582165089725, 2.168944462703847, -0.4886888500856914, -2.9772524658325725, 0.3755116574175633, -3.057371870000515, -0.2069955292148284, 0.8700983589906918, 2.0862164615614893, -2.7623322243027024, 0.9792593724697044, -1.921658108119371, 0.07874610985884097},
    {-0.09715085050927061, 2.848584543074647, 1.957391227135943, 0.5824971019689364, 1.193380121842389, 2.071659184775004, 3.1098869854582745, 2.7697138987028063, 2.9313281570897165, 0.7287986411998314, 2.2184789123877175, 3.368500678874894, 0.05657980631278228, -2.0226532591331625, 0.4408013489011446, 3.398353539115905, -1.5739449363730835, -0.8174294592833957, 2.396263449116058, -1.107812960201086, 2.6116907361844146, -1.069506679389203, -2.3984280733743653, -0.9260095508093913, -2.068045779003938, -0.005610131093386864, -0.32493143050902545, 2.350257758973026, -3.0350866085731147, 1.9744163454083976, -2.198996589284096, 1.465818423856625},
    {-1.745450988182609, 0.9747797658797682, 0.8354539417507229, -1.3260003909051545, 1.5410218806593152, 1.306123749314982, -0.15116965823195902, 1.222841245849411, -0.2335908212823083, 0.062002369668474215, -0.3592876799865293, -0.49800606969615296, -0.4281100260916265, -2.728254939529271, 0.5227793886890784, 1.0988368562735527, -1.5472936579622063, -0.779263601617315, 1.4972887460346773, -1.6612927945549951, 1.5573740048752345, 0.030831640219329364, -1.1171117025046517, -0.40931345321711726, -1.2632133594130894, 1.0486155506489434, -0.7899186297660704, 0.9741417395853095, -1.4738971813163726, 0.5890905735208072, -1.7124225759398428, 1.2426916130859045},
    {-1.5509643142920422, -0.7963469390015335, 1.3188217930966408, 0.4882054707817359, -1.5108094230581375, -0.2829978325867456, -0.3809478598503977, 0.8284131634687996, 0.8657593735676886, -1.7800711841064725, -0.183374317774014, 0.1559494365924106, -1.2018207388033921, -1.308219360230423, 0.0060886702785786775, 0.04735762773416433, -1.3269489125705238, -0.9100445882024631, 0.5764132928990885, -1.5692295831863599, 0.13192001071344833, -0.13360294161702338, 0.0674605918918699, -2.518011450116092, -0.8890358270325877, -0.4110510405311929, -0.71057031972192, -0.29076770960474513, -0.5757643849281928, -0.36306549750439854, -0.05009479438179095, 0.1438240141071087},
    {-0.4895479016663375, 1.9886087483027404, 1.5814687313651616, 0.5634894098845388, 0.87101434597347, 1.4071751554948322, 1.2097489624390316, 1.0597635534887488, 0.8713592591287308, 1.4187450835037356, -0.24071051290296527, 1.4887990665130204, 1.5313369932372995, -2.046674570013732, 1.6783057893499862, 0.5902335912521165, -2.7081527832284853, -1.8458268331998127, 1.1057908265028709, -2.0873360940426116, 1.3093881658869937, -1.6059193795706652, -1.3337055760935805, -4.1100557498007735, -1.9135361782100857, -0.6832637721930762, -0.7021183004866401, 0.6032816607880396, -2.3121934390008096, 1.3107415231692834, -1.6635654309980938, 1.4766524186632586},
    {-0.2997514725829321, 0.7466070440961186, 0.9468100713508915, -0.6210334484570568, -0.4564935529870034, 0.649225584171654, 0.5654567001899526, 0.6641031049134608, 1.5220655418608202, 0.2542600601215422, 0.27345773367272375, 0.15593515987089654, -0.7210883578168419, 0.6058444503922601, 0.17430274613431704, 1.301720696356938, -0.29710234373449734, 0.2088089342560816, 0.19006182208930797, -0.3714439638258953, 1.2327310976410653, 0.22090039147365484, 0.005111191854923496, -1.5279221053792356, -0.5303651479220968, -0.37252495803326635, 1.4808209365767482, 0.7804457904729063, -1.0060203244771153, 0.903985828590142, 0.5864258046336235, 1.007361485454713},
    {0.4072282949614176, 2.639194548505684, 1.413754111203454, 0.6583380960590376, 1.4521752162644779, 2.58465625766365, 2.5957728787563195, 1.5698585065337922, 2.2315539543141485, 1.4451688580751372, 2.012704207635139, 2.0807020530169074, -0.10446766616400548, 0.6092935236986651, 0.29905512196944395, 2.112419476425082, -0.8179752557457978, 0.15282197167760478, 1.5090644083473395, 0.12010106465290844, 2.1879444008739437, -0.8313703547563507, -0.7076767080263997, -0.1563400826617355, -1.736314148628177, -0.8719042857184692, 1.7526287301755477, 1.9936832718684125, -0.7594978694760149, 2.513674481544808, -0.9313482184901974, 1.5257023575857807},
    {-0.034041414193181255, 1.5742133620645817, 0.5086626271641564, 0.09829507509588481, 0.7789345383574654, -0.35554905084657146, 1.0211137369580587, 1.5319314660263332, 1.5556532408505455, 1.4663539104729277, 1.6388837599870096, 1.5271242332722452, 0.6692185728202453, -0.1854496273243466, -0.16337966966885129, 1.4696233372258436, -1.4444840608447012, -1.4349228123768476, 0.7538511687605807, -1.5310556109109625, 1.2788872100969397, -1.716234537158357, -1.0053097909911695, -0.4060464118619849, -1.2953993016592233, -0.7047911881817115, 0.8615395101352196, 2.1373356370510406, -0.5059228986954419, 1.0087390253747954, -1.2809852103526522, -0.20471593855384668},
    {0.9014371766809277, 0.48563412262975697, 2.0543107738768476, 0.7842933815735472, -0.38433608327239444, 0.4253261480321085, 0.811563118790937, 1.5982793487084292, 1.273397357519234, 1.1720017443509847, -0.36684251730016454, 0.8873480429049087, 0.2216746910919522, -0.7397658087943851, 0.11182488401693778, 1.4354560789343858, -0.8434810990113124, -1.2321420129652019, 0.08570514194698105, -0.8759326839310208, 0.33126862999981865, 0.9010007821848218, 0.37815636932295443, -1.5448220664649406, 0.30298273740183346, 0.7065885613680386, 0.7625698956717676, -0.01886246129827377, -0.691371357610837, 1.1094665839694322, 0.7022016477484928, -0.11099738648719491},
    {-0.8901118851978634, -0.9087073052250821, -1.5761717081652944, 0.48718906683059704, -1.470042002171387, -0.10838268905338194, -0.5456948003858076, -1.589833223594357, -0.7671105631054717, -1.2503350504013395, -1.0345086380687285, 0.05191227333711755, -0.06413628639132873, -1.0947367445142704, -0.37953648587433897, -1.3816794139446982, -2.012298597477034, -1.1279074896765573, 1.0219607986126942, -1.8508077215130359, 0.4124744179109876, -0.5845038233963575, -0.7023412569441303, -2.4354774620795103, -1.3065177692254601, -0.8925437382165406, -1.0418342407470256, -0.38589035707642155, -0.8782415079301473, -1.0808695750192103, -0.8910355629139232, -0.9646237069726615},
    {-1.0958254918874906, -1.747016748052846, -0.1412791325057074, -0.48315233993333345, -0.9838854677284353, 0.5391402739929267, -0.2340654506655513, -0.290196628716006, -0.6672973635714939, 0.2600795183514512, -0.8598180748862588, 0.4067487785890153, 0.4397354742999032, 0.08284885245893642, -0.08755731987550779, -0.2989922622431129, -0.497032415487953, 0.14608477520180727, 0.43909736642841685, -0.6775888982728161, -0.7776125351797938, -0.026120170220486728, 0.10256915469866473, -1.5535433093707558, -0.421144626351717, -0.5719909305782799, -0.9514048956773541, 0.03194226882598278, -0.09908602688929935, 0.4332183360977145, -0.6464073851524368, 0.047680342957462846},
    {-0.13242693341114073, 0.8244369562231499, 0.2747320957860489, 1.0060825478023239, -0.07436685501091345, 1.3897939237094485, 2.363397691118429, 2.154821984470581, 1.653247210101251, 0.5762982276026286, 1.8648912079501434, 0.8849035760168112, 1.3681478970523882, -2.696742322874329, -0.04852807492995819, 0.8079628937577531, -2.0535048141618035, -1.9780562260043537, 2.215499029693145, -2.714666427444928, 1.1102418444613869, -0.46218923915006743, -0.5400059742230184, -2.582142975517905, -2.3829813931868333, -1.4114453037879107, 1.1522752363762776, 0.8032962358212616, -1.6098756230472595, 1.566455517073195, 0.1952823445247798, -0.19273722853562283},
    {-0.8216465280641674, 1.604939068947224, 0.9048008365746254, 0.5140965654434169, -1.5811221161765123, 1.1127962354894159, 0.8277839952265783, -0.11191864934081767, 1.298564546512025, -0.536816302518529, 1.4681696144933745, 1.267183422062117, -1.3129567929340977, -1.121080835819842, -2.349836737975626, 0.5763649913800287, -3.3723917584397003, 0.29710854516041696, 0.7200440982423217, -0.8490043839936521, 0.599806768320916, -2.6378144953270364, -1.2390468653896676, -0.5120131740687827, -1.2597255198683635, -0.5741837226070501, 2.2594031764662574, 1.1496187010469183, -1.228447570735528, 1.4260857351913898, -1.133215484699897, 0.3283249421652583},
    {-0.49585239006778364, 1.6057941140819487, -0.03803373008638562, -0.6085071431959571, -1.1894423408132124, 3.0138060910001006, 0.8287991587035396, -0.6491084176926162, 1.2241743626668256, 1.6772298559314345, -0.2026140992890674, 0.7861550744137501, -0.4755912614073007, 1.1567900957100965, 0.06964807798468522, 1.1793146095549354, -1.8714442276211487, -0.13102303460725806, -1.5311593230025624, 0.534979492439846, 0.30755819758617975, -2.5371795555839296, -0.3911562133206034, -0.6130527256367747, -0.9705371468874254, -0.09280245911093134, 0.7834719060528195, 1.2376761405016588, -0.7770471357642821, 0.6242422930817099, -1.6052875024365438, -0.5253682456379967},
    {1.5178548890275805, 0.918695403014951, 1.861674140671838, 1.5193831673855802, -0.47138193911570925, 1.9336064934658934, 1.5915006923254302, -1.0214253607892727, 1.9451083248246737, 0.6687682703150083, 1.0054246488615417, -0.6719345976662903, -0.8252089435309787, 0.9175337477142457, -0.8002100462202731, 1.3895498454141044, -0.8655403801592734, 2.0094705278556138, 0.872552157792577, 0.5530576659787461, 1.2180541147223722, -0.9806707897177898, 0.015520443482855745, 0.3541529464583354, -0.2203738509791379, 0.7217731373788551, 2.552348587958644, 2.2762180175590014, 0.48315007308761054, 1.6799275729992371, 0.08032389429629745, 0.10797044686169305},
    {1.6842253421723288, 1.6424041866517256, 0.8324066144151872, 0.23471078330872858, -0.5771765607624236, 1.5568005022230431, 2.4637432014309284, 0.222185468842812, 1.6467742380289707, 2.2136765590511627, 1.8028847794535157, 0.37743445668434145, -0.8812549945476923, 1.5901036717027273, -1.539380062866183, 1.6907829553281635, -1.9804368133255215, -0.2816988629236129, 0.12997970144460333, 0.7770823714645458, 2.0830408692113225, -0.8068039980324041, -0.661970955552764, -1.2504625919362187, -1.02719776785634, -0.6852278199212135, 2.506511813318149, 1.9938979204395453, -0.48615459834389363, 1.997010493993237, -0.4817158671648438, -1.7790296532167529},
    {1.7014591352872228, 2.140362583027135, 1.4145127695238253, 1.5006640124630937, 1.0402546822608016, 0.1641096978527827, 2.126138083352233, -0.11099081819455921, 1.3794532052284145, 1.5641755056154523, 2.3934919045741605, 1.46704692396493, 0.5552515448613078, 2.0122451280037255, -1.163491912465642, 2.283789332898107, -2.543240190172704, 0.33159471626736453, 0.8417424207675058, 0.3192222509163134, 0.9944249201228269, -1.4241369987010386, -0.7033197025652236, -0.1803306332460474, 0.21430315478778994, -1.884630172487239, 1.623693046545491, 1.9477054799949742, 0.4308735018330869, 2.633813959685093, 0.4591938492870469, -2.6934116552652645},
    {2.311915748012087, 1.7192576991217952, 1.9627645221130146, 1.673177726518642, 1.224290665551626, 2.9718932654354546, 2.403249382819936, 1.3889488299901958, 2.2201191994952687, 1.9534306847227487, 2.362962633606942, 1.2188654030770083, 1.5881840606367135, 1.306166878949349, 1.668306254553667, 2.7642717256252896, 1.1470031213180403, 1.6532150220565, 0.8532893208787107, 0.9665211662919371, 2.25559867661497, -0.2607335070696626, 0.19589058655003205, 0.8352125863527398, -0.6825789097760476, 0.25768450353550865, 2.6533152046127912, 2.7190080095010924, 0.025459200311469813, 3.1568929695948564, -0.28634367940392075, 0.9997440315997606},
    {0.5506499580920449, 0.8943054788960726, 1.361290903908566, 1.4936001057358672, -0.01311569591227373, 1.3672159045177132, 1.033388114367446, 0.5889093947412425, 0.5403246064192294, 1.737455097043423, 0.8291767487097408, 0.8419816673624877, -0.3868193373388224, 1.050340555714152, -0.8120847712121334, 2.2499225607768496, -1.1712137947404406, -0.213999257501754, 0.382686982000842, 0.1964741243092879, 0.4795299291484187, 0.7086697718463029, 0.29491738875850293, 0.7036433351090234, -0.7131526199042206, 0.7478926759570641, 1.590719082326396, 1.5981839344095172, 0.10135923377869357, 0.7362184026454174, 0.8908848017056091, 0.8333548313632896},
    {0.5176121334862029, 0.17381202471678067, 1.2666640044594502, 0.32177956097208127, 0.27729935219164187, 1.231366794604861, -0.09799598630465123, -1.101491496408447, -0.4037932782288415, 0.1988037332808717, -0.8102747008417662, -0.6456340052610768, 0.5941436473179095, 1.036500411625614, -0.7560883604294265, 0.4096234556886375, -1.7873083117045083, 0.3603146508516245, 0.8830042870558628, 0.4095025197277678, -0.09056900001594129, -1.7976320306009057, -0.30549208005887124, -0.9958785107856792, 0.13768745381300196, -0.7228962033528976, 0.8320844066722917, 0.6049268941807961, 0.17371847439602783, 0.9578998470157946, 0.3051824163553066, -0.03857112893572608},
    {-1.9956200444006695, -1.4651471570125343, -2.0305296570085036, 0.18566090898519902, -1.4378595511134773, -1.5693620290105421, -1.7024330295867582, -0.6620733588223006, -0.9237645834100611, -1.3887308901681148, -0.8310672973896187, -0.20370612727308943, 0.4019052873202298, -1.9689939764077415, -0.37994666638295593, -1.798084329135565, -1.5698232217053403, -1.993525364623479, 0.51582242559126, -1.8870489496914347, 0.09490629762981619, -0.4070197002523882, -1.292980250096028, -2.7163570748964023, -0.7613337519221774, -2.144106562085018, -1.6909654929549396, -1.487443149353587, -1.0478095003241994, 0.9890062001010838, -1.8030035220830396, -1.3228913128356061},
    {1.5952217999131473, 1.2039939731384497, 1.4580903896289716, 0.5102147136776852, 0.5371719754477736, 1.0082664296586876, 0.8747382367761789, 0.8585204520366053, 0.9391766657387265, 1.499957617607252, 0.23764385293117193, 1.4876711432463126, -0.511886795014609, 0.323454183990857, 0.44143634872164117, 1.8344969776316393, -0.16538768414185395, 0.6685065652342088, 2.0278019629390065, 1.1433838810276724, -0.22352380707435582, -0.9920349525218661, -0.877629781461445, -0.6974137351532846, -0.018405030177992953, -0.5045958446452667, 1.206255077648507, 1.0622801288264374, -0.651420711085082, 1.7375203528251768, 0.1106405870727529, 0.8313645620238246},
    {-0.9884098667079073, 0.6517511079993491, -0.9492147279453483, 0.6845793183124526, -0.7454747971276966, -0.4383336918932787, 0.9333563519084225, 0.8908548639886512, -0.40244650706093754, -0.5342983141981036, 0.024668743563323086, 1.820356437937514, -0.2385496995684661, -1.6948941202562424, -1.6461598503276482, 1.0710597534481388, -0.7586907363023255, -1.915712219382845, 1.0835617884375468, -2.02060999902943, 0.6389531100399871, -0.7116035595450095, -1.834063592279746, -1.2396193162853912, -1.1295936554258863, 0.6638883660703246, -1.214210628187955, -0.8279420761534497, -1.8119506938758985, 1.0685437938618867, -1.8489121668281912, -0.8073052487458243},
    {0.39511997627653234, 1.863267868364658, 0.663368294139233, 0.38154554248983363, 1.6099939920750665, 0.8419241477152936, 1.310940548972854, 0.12606581230916308, 1.3370144178914662, 1.0783668214343414, 1.3445929126531515, 1.610697825830844, 1.8272422602045406, 0.6356556211183366, -0.0918905937471739, 0.7206464609957233, -1.5578092248641053, -0.07560669247632165, 0.6452599316848867, -0.7936845453134606, 1.1732090515463212, -2.8995986678583723, -0.9451075137468948, -1.934694874020708, -0.6407418863790758, -2.2049169172584304, 0.8202985841318085, 0.9260456905989708, -0.5940349196383032, 1.6688941705619662, -1.475698648451328, -0.21160121999085404},
    {0.8670384597072778, 0.943737575628216, 1.4678677189275298, 1.6508132592630336, 1.100039810555746, 2.0706715721678526, 1.4865184743723328, 0.7911740383000114, 0.8161158564081793, 1.7430363648656917, 0.2513321764630495, 0.7866222957094502, 1.9178762448800344, 0.6095656413558984, 0.34406875257911407, 2.2393134274472657, -0.6009276769097128, 0.5884056857799639, 0.7341227620972973, 0.6483304423616967, 1.044927007521518, -0.4181966558982379, -0.6850391651728263, -0.3720220936703862, 0.44774403404500474, 1.8003699897176257, 0.6575789197415485, 1.412311308712034, -0.4611302516038585, 1.4051689664701847, 0.8478196211257392, 0.839923117219477},
    {-0.638332311669411, 0.9330464117698247, -0.24166213813791418, -0.7601480429655505, 0.6343034306377044, -1.8597876695065847, 1.3046733684937137, 0.8321432832263723, -0.12871991857627663, 0.8543814188130285, 0.04583687750675392, 1.742685209075927, -0.2446044060061264, -0.29655152464715195, -0.6257730885036257, 1.205915899838613, -0.4821185687162812, -0.1493794867614445, -0.9557912760652235, -0.5555369427906299, -0.2638183977830652, -0.12375937049102681, -0.1686218548755332, -0.6203268904339794, -0.7474286153204498, -0.004384416715048968, -0.35792685845970185, -0.4249270183032464, -0.22080191028776006, 0.9673846988413147, -0.736573833440595, -0.8792702345566}
};

static const float b1[32] = {8.45794068959135, 7.811634898407743, 8.455751700463997, 8.47054222990485, 8.529061992452108, 8.033321641373897, 8.032261409877915, 8.50099903904388, 7.965428786040383, 8.317456034665494, 7.94049501652837, 8.076655744736437, 8.440732156752265, 8.54066495144602, 8.671473211008262, 7.832355478795281, 8.754306452741424, 8.664094028775043, 8.335786616485967, 8.536265531046764, 7.63399605551447, 8.644764315921345, 8.654489605916671, 8.64098564154417, 8.693984626852398, 8.512552650652744, 8.52123825504617, 7.847060200221704, 8.622856801447403, 8.393621983686007, 8.709948137278843, 8.469962105940798};

static const float w2[32][16] = {
    {6.975346283217128, 6.057869428308706, 7.516514932877113, 7.691468210776562, 7.673147269474184, 7.369715380052695, 6.851478732216548, 7.657283865243472, 7.7630729938082546, 7.6006508729044375, 7.880720664147572, 7.117875329441882, 7.882172855598945, 5.172611997281682, 7.759799776397292, 7.378490406526813},
    {5.771395189568257, 4.756332079996461, 6.872477256188631, 6.515475941730138, 7.117944546707818, 6.322165208852387, 5.807687816263838, 6.9266099587581085, 6.852370561066929, 7.065991386845295, 6.527479575399905, 7.15881827038078, 6.778520113437934, 3.7724742778528846, 6.997444124688146, 6.728024878766122},
    {5.766754689086064, 4.770160205860496, 7.473750297932578, 7.465381805490436, 7.399398899678986, 6.949943135349981, 6.867931596871647, 7.346550739246402, 7.593316239122385, 6.996509705545158, 7.6836800587364715, 7.10727569152196, 7.125707205736091, 3.8730871822022976, 7.337385227051755, 6.7967995532114935},
    {6.307290319495722, 5.341151666014758, 7.5478922237465715, 7.919401184810372, 7.363689567394569, 7.639167035518072, 6.370016305586821, 7.257268585432505, 7.384523809013907, 7.980608805029548, 7.627619475309079, 7.647092703665353, 7.3576128604851485, 4.279458058113369, 7.414589906957769, 7.215794172857933},
    {6.054349107079268, 5.383504863089575, 7.319915189043785, 7.79254683844419, 6.894169072955866, 7.2026463035118145, 6.03345002767081, 7.347610425187993, 7.36903646989996, 7.710075705777098, 7.727606809743241, 7.557319836872514, 7.817861963278245, 4.214356566893167, 7.339098495829449, 7.183749481305261},
    {5.619641277359902, 5.153502641460282, 7.140422480207498, 6.617596209306819, 7.0025482603112605, 6.51348048209699, 6.496520755802028, 7.654021103936149, 7.019422760841277, 7.325700482630177, 7.278241654045758, 7.323035363506895, 7.03583480490167, 3.8498177653121015, 7.276411734431676, 6.561712414799333},
    {4.950807299603243, 4.412905702446451, 6.839653956746161, 6.515158868766567, 6.595451641769265, 6.60077082365599, 5.87691377978791, 6.5769565503160345, 6.601475572990976, 6.761910659548482, 7.068895746990602, 6.320447249953504, 6.582305120463277, 3.8628149219785053, 6.98925948036678, 6.727857632356987},
    {5.746925103595985, 4.898473345702543, 6.857906210514263, 7.094835813947301, 6.9800734782319855, 6.9292868165038755, 5.695645989222075, 6.899653182694778, 7.184259455768683, 7.320481149765084, 7.500526262191178, 6.628634555805976, 7.340915338666266, 4.057815874666749, 6.592952768582683, 7.074004447800868},
    {5.340353606542361, 5.181496898264377, 6.733535412342828, 6.716539571872692, 6.520331262224227, 6.1761008475221555, 5.8597921212970245, 6.6846600635905, 7.291725029807398, 6.880314937419319, 7.195004740240387, 6.989824594285599, 6.670799564235691, 4.019097409240432, 6.987253042533063, 6.860921975662572},
    {6.22555526613128, 5.28777197953289, 7.674587992498925, 7.280651500991398, 7.352423360245165, 7.182711190819939, 6.211187545434321, 7.772749566434826, 7.106091476123424, 7.158011300970778, 6.984204117091191, 7.090286853768584, 7.478710159199301, 4.179073106380847, 7.701022808260396, 7.21252426284592},
    {5.726817669106177, 5.16922039961533, 6.554053664076201, 6.913665027074663, 6.608779000118221, 6.353292988122868, 6.306887933496609, 6.81027614577244, 6.967252882536302, 6.969595465701333, 7.224987586465678, 7.168039589175239, 6.8197204735032235, 3.600285849091321, 6.872451769334418, 6.82258097568941},
    {5.52214708019555, 4.820411622208059, 6.279431566213895, 6.864782910348765, 6.831291628149072, 6.975282446453551, 5.616687133592888, 6.961062077162014, 6.448749261565321, 6.6184981037332165, 6.7832284493813315, 6.929444483315181, 6.813655012438173, 3.7586621964781517, 6.45398987987333, 6.719359779060758},
    {6.379129902167913, 5.655824862284199, 7.834080206947426, 7.923906309150025, 7.675569355624474, 7.6097259421679455, 6.724571316217361, 7.5648451721346985, 7.754385418625221, 8.181280070159925, 7.21061261502794, 7.3351838762563295, 7.849434606973691, 4.477408712559701, 7.73007146500448, 7.281717393974233},
    {6.4941014867337445, 5.5856535580487545, 8.105815739148573, 7.246383358767598, 8.037578045329283, 7.470192610346181, 6.454291674713933, 7.594868113795085, 7.603624550450983, 7.576776628125437, 7.256087903696132, 7.7811488169777, 7.4773524961118305, 4.8687828036340814, 7.324014739173356, 7.6359000069373675},
    {6.331889629715665, 5.475782111759404, 8.12239990891264, 7.60710165691964, 7.203947408014131, 7.282184799829411, 6.5933463534596894, 7.876454147994812, 7.55066076412659, 7.558387055393411, 7.678836681502116, 7.622492083697523, 7.888161099424192, 4.426315476993211, 7.2896476104999355, 7.618614889740797},
    {5.380768900563544, 5.237334949393867, 7.151266757531337, 7.022362812882093, 7.081885486022067, 6.966068397827109, 5.7273209693169305, 6.582795332528123, 6.724211171652515, 6.983530283247502, 6.608376456039472, 7.401449560733342, 6.951755669172613, 3.832951237944522, 6.9387466655299095, 6.51802595915367},
    {6.324392821797485, 5.563289314553984, 8.044389597242784, 7.57629618070502, 8.209368362299205, 7.411441535481626, 7.397232490433026, 7.832138891469641, 8.223340453449085, 7.746645412588146, 7.840200721471517, 7.840974653228967, 7.8804470320391475, 4.817744516913117, 7.687030646301239, 7.600383622394179},
    {6.569263127014766, 5.335899308799794, 7.598213457099905, 7.454153153154947, 7.603634422392741, 7.019354841878509, 6.661513731572499, 7.895214926705229, 7.540484185035052, 7.679188517545652, 7.504981694557024, 7.429889679350414, 7.858154835499594, 5.138367244721945, 7.675547704948402, 7.792612711863204},
    {5.8017416004484765, 5.210043923850083, 7.558821534618949, 7.11675765732889, 7.138656580989608, 7.234340905089133, 5.7379729546216485, 7.305344883680201, 7.2781851688979415, 6.757990949392541, 7.333315819882498, 6.656201946259534, 7.169678387493256, 3.970189613420168, 7.332844944300786, 6.353339951505902},
    {6.4735125195814724, 6.002980140433272, 7.731193410508406, 7.323255710892485, 8.04906702222628, 7.362044655728112, 6.888810789941049, 7.639844609370944, 7.02843128208168, 8.191976397998701, 7.766797838882485, 7.669294450629528, 7.773158085004111, 4.521638307296201, 7.705632685635106, 7.394751076198829},
    {5.2399717265503725, 4.554445542281497, 6.705945611009032, 6.791440680680909, 7.065818398556137, 6.3607780284760125, 5.531245472576989, 6.4224501924896185, 6.5520786331498995, 6.8297976380546945, 6.295802918469507, 6.861562753658774, 6.589700396152071, 3.641303093449556, 6.548293430043364, 6.728017388196423},
    {6.142307153378783, 5.3416376687390725, 7.9016018710976015, 7.127183721197377, 7.476723650252687, 7.258163042726006, 6.489797336608724, 7.787676120014846, 7.668361389035493, 7.9363842092930925, 7.310613336394389, 7.939220650272761, 7.707056639151709, 4.733685792198679, 7.510203383588632, 7.2457880988869245},
    {6.471616399724239, 5.529858393511967, 8.036269712428599, 8.10004489535692, 7.67422732705345, 7.819715614587931, 6.677574994369068, 7.844861941651953, 7.857938120795289, 7.8144416492032525, 7.961341173647124, 7.269879819149967, 7.979291846856427, 4.365063779308509, 8.139449358298187, 7.524980456322068},
    {6.585102812460717, 5.593965858963859, 7.514916252010037, 7.498477644727714, 8.121909430649227, 7.517224505987228, 6.699988420341991, 7.815153850185078, 7.879099605662769, 7.827972297324346, 7.941561547021033, 7.599416301382832, 7.657264430361484, 4.554882374442501, 7.775405075268665, 7.600568959408317},
    {5.8872747936896115, 5.561540003504271, 8.405625179924213, 7.454826535494651, 7.69787739834335, 7.564553543597002, 6.681444288912995, 7.904428236344967, 7.697050174677327, 7.721183597213473, 7.909828842273802, 7.710895439466514, 7.934041815913362, 4.90486932138745, 7.897068331531153, 7.642260633924767},
    {6.335688847126041, 5.642981561757769, 8.135495906089371, 7.96652784469853, 7.900304509115087, 7.712580639650292, 7.043092513809209, 7.3879264613756765, 7.949310389579861, 8.16962952811483, 7.766043492025355, 7.75156412366895, 7.918678653765168, 4.737840574198952, 8.342713035497807, 7.947540290659845},
    {6.257354679137579, 5.045250390047037, 7.024868890866809, 7.417851606249052, 7.250233824848017, 6.57570227547025, 6.5621659720318455, 7.138053543172708, 7.320535054976122, 7.892816081300215, 7.562870590439138, 7.445477691440455, 7.305589476656749, 4.476225821157156, 7.1919527342831175, 6.90481137418536},
    {5.42393893787064, 4.734246813243333, 6.808541547429813, 6.691775795422943, 6.780176414004658, 6.296272596849761, 6.0359172257676565, 6.758765019829095, 6.660604156994893, 6.841996245443549, 6.5073074584174435, 6.81039148181206, 7.0723053793920565, 3.968023066731253, 6.425784941822799, 6.456370486994131},
    {6.263482466286403, 5.698258290848924, 7.605233031739476, 7.245252748083632, 7.96463208610183, 7.563652228614235, 7.238876864308768, 7.695709266247342, 8.258422995148027, 7.774009960217621, 7.136047173831805, 7.885235618331095, 7.9088074324952204, 4.59387349604937, 7.702032548405314, 7.4235127952318924},
    {5.991616249167708, 4.8867361410410375, 7.2898449300481785, 6.624450434098607, 6.794277368802412, 6.877202463054679, 6.247048952261381, 7.318301287002744, 7.610739589776723, 6.99728584120254, 7.140745644506483, 6.767003202023124, 6.792619067736832, 3.697282567960898, 7.108434970160742, 7.0711471803023365},
    {6.373238033284065, 5.403415434434561, 7.715605303650309, 7.5380986831481716, 7.75493054390216, 7.62727718810862, 6.747679340513215, 7.889709895056313, 7.795765114394734, 8.15540169961892, 8.080717265866323, 7.511045783391131, 8.010399122750234, 5.0585803124906565, 7.915301595813106, 8.378299687724304},
    {6.0783969736804755, 5.511082423745454, 7.4754689205280105, 7.3075692895145465, 7.684161689526197, 7.9402681299261175, 6.227019934134248, 7.659692736985216, 7.473691233319727, 8.112323379970887, 7.613186894847724, 7.4361799786582985, 7.272396574120507, 4.578213355079161, 7.188623060042942, 7.33499356475459}
};

static const float b2[16] = {6.4257103890601, 5.887350737168345, 7.2377328164524455, 7.209336105943245, 7.288317707496335, 7.519294443927999, 6.999979450378996, 7.051077374822941, 7.234308639568505, 7.139085154398883, 7.1241638065784025, 7.077103948806157, 7.175859367320118, 4.995822651129005, 7.187172415428072, 7.162406130914254};

static const float w3[16][12] = {
    {-4.402525071730252, -3.9296865203627296, -3.5661435709164238, -3.479386236894773, -4.158691515951419, -4.079784897753011, -3.826110749798888, -4.1145007010092005, -4.361678507048906, -4.618360873020988, -3.962894692011907, -4.424358152671004},
    {-3.3784698416469103, -3.3811159426188326, -3.6575140448019505, -2.7359520593623983, -3.18278025385, -3.5909453718912356, -3.743945707247152, -3.5585688496892947, -3.623805478948179, -3.489689423329093, -3.2656897970457015, -3.5909419253572237},
    {-5.1502264182228945, -5.225395349538849, -4.945052485711286, -5.2611570424826, -5.396449022431487, -4.672848750844643, -5.367065165645282, -4.963313960132535, -5.7031803158678755, -4.91081240831224, -5.123095193929933, -4.942639316268301},
    {-5.369036071986492, -5.516451489654737, -4.52365367269811, -5.402622127116948, -5.2777538187789235, -4.784952213976412, -5.384072098916806, -5.451155680086707, -5.193727302897678, -5.410481466123853, -5.4485887423431425, -5.767550415188864},
    {-5.05279515341619, -5.3484295207222905, -5.025028267841029, -4.673098112763155, -5.042925843084299, -5.352885537130963, -6.223626556933772, -4.490274588026708, -5.328430900473481, -5.380269073985175, -5.422299573717668, -5.619925289749972},
    {-4.823892997412207, -4.932994555735925, -5.011150122715878, -5.064771605485121, -5.1672460578829, -5.493859226404336, -4.982155098798073, -5.031702304858764, -5.127679830141883, -5.164830489540988, -5.175711594430181, -4.462502962714474},
    {-3.844993446716413, -3.875927200330925, -4.467326164419859, -4.65238771840705, -4.1778111534493325, -4.199443062404231, -4.01699959410971, -4.255482554717313, -4.1030521287171915, -4.457536018626694, -4.6921645724675844, -3.744670895434681},
    {-5.178102221617741, -5.005818737217135, -5.475921587881332, -4.949434954140172, -5.559310418516437, -5.186524038452528, -5.077949812413662, -5.128093794891199, -4.63256786301393, -5.751340384797448, -4.873942275418806, -4.582019563416786},
    {-4.84116545072952, -6.141995789261827, -5.441182143331654, -5.490173301265698, -4.921429470508696, -5.185778772664974, -5.910771400452979, -5.18083410311458, -5.236871026327576, -4.933066098207214, -5.322664773065999, -5.4629120597967535},
    {-5.0736889920749295, -5.475828423632, -5.155503274012036, -5.670228739745581, -4.572186016522016, -5.322483592290483, -4.824979762114387, -4.95082203537291, -4.756781017814569, -5.729902714986837, -4.765087192461976, -5.4244454044782495},
    {-5.3777835370386, -4.69303016232661, -4.658789015132807, -4.8932308204763535, -5.567340913371734, -5.430520490507249, -4.890106405409927, -5.890280647092374, -5.491326081049757, -5.056050206215094, -4.706194057518268, -5.084861435123216},
    {-6.052332503592516, -4.9655245789571145, -4.883611656906787, -5.319396576096924, -5.077579772193718, -5.010996377489845, -4.39850579835681, -4.054551994368649, -4.920763950558236, -4.937833681549922, -5.125648604677605, -4.98706476900564},
    {-5.2073164193372, -4.83145132246565, -5.176485449445219, -5.595941922356022, -4.892350342342037, -5.481433695517149, -5.096619121203481, -5.492604018140596, -5.0921020222636155, -4.450586903742995, -5.0486759969722845, -5.153626071965534},
    {-2.6711954751870226, -2.965533347013268, -3.113436539297459, -2.8523935695892586, -2.577541439736107, -3.28369758618393, -2.613572303673684, -3.5595844085986137, -4.021242109809446, -2.5865995763563445, -3.444582899902988, -3.1275677824232266},
    {-5.346467448407202, -5.346348752986659, -5.601478512336189, -5.200625598832933, -4.986047353423789, -4.156376128716814, -4.860241217401231, -5.663784235112085, -4.992789233874002, -4.94094225589201, -5.380664189763948, -5.7006398636770665},
    {-4.695676066623235, -4.803698385876934, -5.982507764465335, -4.993908505454182, -5.812222293622503, -5.521911120694431, -5.195417741253624, -5.073661635289827, -4.458797389110701, -4.796292378092851, -5.041444712479181, -4.452049982571169}
};

static const float b3[12] = {-2.1734386116811297, -3.4180767881419665, -2.5673266247523774, -2.3571330165274875, -2.7059973981047243, -2.74651143537653, -2.8979479708768685, -1.2667367696441776, -3.3572820760221638, -3.3549772831436013, -3.2627571111191807, -3.5257356214255635};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
