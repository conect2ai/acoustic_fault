#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.7652284274431287, -0.3452211856405883, -0.012033630850251794, -0.681099466367535, 3.9245127564552362, -0.8850618733720255, -0.13836456108961884, -0.2946041369931574, 0.8969609954067147, -1.4114927297441893, 0.052317570672642366, -1.6753178421453732, 2.2653836246174217, 3.2958856460358867, 0.4483476113129833, 0.38365673128318706, 3.007132125815986, -1.2945008680374053, 0.10397376036172787, 1.0956036286764153, -1.143997279146312, 1.6123012139597406, 0.03460274863594751, -0.21993426064127936, -1.5652172649370781, -1.5656145491510065, -1.512206863133194, -1.2881776406611731, 3.185730108606058, -0.22638828476607376, -0.7301839390372077, 4.223020660274916},
    {-0.8803343929194757, -1.4232409614119634, -0.6156702620602791, -1.2896593368357923, 2.1873059932411447, -2.243571364213277, -1.3686353292788875, -0.6208177772582175, 1.2008406052705451, -3.2812887405123905, 0.6627530206719296, -1.425897579642016, -0.0036878903187532374, 2.0364280861438955, 1.2063102450644148, 1.3707484187489678, 1.7107026269223868, -2.9544149439784433, -1.4839010322036292, 0.7921351501074727, -2.976973975146157, 2.1552089181364407, 0.049916125074758094, 0.2606056287601783, -3.5477809404379888, -3.662252620809992, -2.9674315146049977, -2.898145357054957, 3.0812104904662343, -0.4069362683165372, -0.26768916831988465, 3.469376553237031},
    {-2.1515247430409254, -1.8811665446672408, -1.0238205834947085, -2.0098547377255307, 4.082469067510768, -1.9704270065438287, -1.6865883153916978, -1.0837033927696815, -0.46139789158053107, -2.4636229339631686, -0.5322122638905447, -2.0305266843530343, 2.0442110680723116, 3.4755943086546504, -0.5072709599784321, 0.7860703698095812, 3.481068234287201, -2.2009599211233963, -1.5850060760477342, -0.7506842406163285, -2.446942597134043, 1.3148441969914368, -0.7973841717515033, -0.5252012798200699, -2.4116614720323484, -2.425072118138959, -1.867785434982137, -2.0535103376154265, 3.6338217438382436, -2.050657745845827, -1.2391881725037954, 4.753952148668803},
    {-3.5314727455108756, -2.6537451452804146, -2.61083456059232, -3.023966535174045, 4.143690084859121, -2.8890272658875866, -2.5808111476676245, -2.854295730230455, -1.549131475813721, -3.6201804151075074, -2.133431208879282, -3.3295485197878625, 1.6657352504664105, 3.3048878566603777, -1.6142963963802748, -0.7393283685642139, 3.267898033627484, -3.1413694437909756, -2.8749972513494266, -1.4919699468921346, -3.5105782357604887, 0.42041189047016786, -2.132421755489169, -2.3251111866145076, -3.4629802557503297, -3.5528315424088883, -3.351005061205707, -3.3184714329924887, 3.4043224258063836, -3.068871113000041, -2.423103379063269, 4.166682968515373},
    {-4.023895258510973, -3.4242277629107325, -3.051058942261336, -3.4692426111950976, 3.4218360285554037, -3.253641406649488, -3.0384268305275306, -3.3684687573851235, -2.5230917926521745, -3.0360274614830454, -2.534498036016436, -3.6179307415097046, 1.154934600276409, 2.61363941977288, -2.845909322600347, -1.376220192748857, 2.74930439634421, -3.2376483863502363, -3.2800566521213876, -2.766270230656502, -3.082058082036341, -1.2078779664224628, -2.8937709008298946, -2.681938347575505, -3.1881793506991496, -3.0827798703317484, -3.2037099413444134, -2.9548793683636285, 3.0530323446197403, -3.812636458118683, -2.933242685021583, 3.315490825138271},
    {-3.8312774931437596, -3.4031411430762906, -3.0311494972828155, -3.876870626232679, 2.4514566381301788, -3.4860588828685053, -3.127331303300046, -3.6187892734223905, -2.741411447660371, -3.2355801558335915, -2.1657617693213007, -3.8005726886193623, 0.4194779041627363, 1.5979264598982295, -3.0248309255970804, -1.6506294687626337, 2.448771244503331, -3.258097654866561, -3.262896612984685, -3.1935785454699754, -3.1043177232037418, -1.8347195906831093, -2.696956127751268, -2.7520262714468626, -2.8383660524778604, -3.058436297421124, -3.0090899731230185, -2.9503439508940663, 2.533241713566563, -4.256522176212092, -3.16474435652141, 2.321047665938674},
    {-3.84520722075215, -3.3894541331329133, -2.5669777181201288, -3.5295488140214037, 1.702755667148935, -3.724486828187976, -3.503579891227228, -3.4207340347894712, -2.655277923268765, -3.657425884758741, -2.5297564453692645, -3.645133250136641, 0.20070015252815143, 1.20916049360781, -2.7138176076021927, -1.3035258929583173, 2.178575483191007, -3.5855613971565132, -3.254613886646683, -3.0280109963200736, -3.531324735829867, -1.6532357653666465, -2.5480583426064323, -2.806622694513118, -3.696721411020103, -3.4100937971567507, -3.3627720094574256, -3.0072365737624946, 2.554159244709651, -3.29497949585512, -3.270612585726629, 1.3301447854828696},
    {-4.336302875188406, -3.7112173135034494, -3.2898000595049655, -3.6541832199178446, 2.3028942515087363, -3.7977025804018743, -3.4984499549116093, -3.5743578060918733, -2.914468857530345, -3.6286311528857964, -2.9958602454255, -3.986732691446322, 0.899545438492691, 1.6723195791530254, -2.8163886466657075, -1.7259673499342243, 2.5496459249517143, -3.7916929335303253, -3.330873512524425, -2.8458601096444154, -3.6077225430117155, -1.8754969585805947, -3.437538108642459, -3.3664802483905403, -3.7286066231662467, -3.5491907358344936, -3.907012980046694, -3.5275815181422505, 2.432750025464329, -3.8565218366269827, -3.46429742189604, 1.4788638770530165},
    {-3.9681069705769993, -2.8518872342711763, -3.5106378203353543, -3.3009906772732296, 2.7318484379270407, -3.4755539759841465, -3.3592624423683515, -4.061102972911456, -2.839188274663796, -3.714490900214402, -3.3036948759180897, -3.902319723545287, 1.6039728900771462, 2.1756784039094366, -2.4308587246209776, -1.6805913811891624, 2.833098809324951, -3.5817804164677054, -3.206647139606526, -2.584417169504361, -3.8124867446934423, -1.0212918942661662, -3.4072626859105646, -3.2179182202583996, -3.912097658860548, -3.7011301335539795, -3.687068727969913, -3.6236413441338575, 2.5075441390587114, -3.889268355173661, -3.5732095165629807, 2.611997593360993},
    {-3.6382744482593106, -2.8587133399065396, -2.982606899779877, -3.1250207481279744, 2.929694328836861, -3.5895350785178244, -2.9634670794966578, -3.271727329829945, -1.6714776829006057, -3.9550504621211156, -2.2860197621978253, -3.3957590910888396, 1.2279120859436634, 2.467630159136567, -1.7902367135832027, -0.5667144168014634, 2.721977899795515, -3.9081489045424695, -3.2253095771462283, -1.9088210348797219, -4.093609470360975, 0.09132037978040151, -2.5399682503647285, -2.4325448719066647, -4.252445380129869, -4.242850676519065, -4.1239967988351705, -4.114050758016517, 3.297573360542671, -3.4881295409542403, -2.975317292703378, 3.3842993809400292},
    {-3.397259370709382, -3.1020311388998865, -2.6863366954196772, -2.801067893452753, 1.6604377101418313, -3.6761200157280123, -2.7937923838853185, -2.7041321355141186, -1.060290000070834, -4.356292663953421, -2.322720729744451, -3.2223362284315873, -0.10711131417411823, 1.6498694011872663, -1.4385569413112975, 0.024595794894077518, 1.4931934181854527, -4.201408334486661, -3.3905141081425456, -1.7147496789479901, -4.296084703284594, 0.5647982977254647, -2.332138694972872, -2.236328474265191, -4.489456359982192, -4.379329782450811, -4.012958272482627, -4.224066879117984, 2.3896549730279957, -3.0004320466137444, -2.5281681765502166, 3.042489115420342},
    {-3.5023466597160375, -3.2253398294502373, -3.5162019920299845, -3.0709539680024727, 1.8638325541482352, -3.724937544086901, -3.2728792134787463, -3.0900862228425394, -1.8651374211896765, -4.222823784967394, -2.6089434182683435, -3.353614415941736, 0.522692746731912, 1.7169667389864107, -2.003121915908367, -0.7744994132164087, 2.059551763042406, -4.055146848667887, -3.3039907135107844, -2.1678077096112376, -3.847545348957798, -0.5954771830952993, -2.9327418900797784, -2.5096875058884835, -4.413716820970324, -4.269049984483617, -4.003060603191113, -4.1149600183737265, 2.197562285664753, -3.013248870306941, -2.975958641244408, 2.446659985625847},
    {-3.45310734531991, -3.32663486586687, -3.1332491179717032, -3.4347253814653396, 1.4479093187768275, -3.559340312949105, -3.3882494206306264, -3.004432788111988, -1.9916555842493024, -3.9422472723182103, -2.8794969877193397, -3.7261308236291635, 0.7241402419387251, 1.3807521216524425, -1.9256572786885173, -0.7898811755157136, 1.8439988870610273, -3.967414854130547, -3.437624542008929, -2.306009131400642, -4.285986080215144, -0.5277092367095151, -2.954968916403857, -2.7042241712798756, -4.240207549534238, -4.47891095213545, -4.000569744215715, -4.023323981411162, 2.06535733408243, -3.3807896723008333, -2.823601061165283, 2.412152075581595},
    {-3.6939026788511296, -3.569364015527142, -3.1807660200190484, -3.2767342562645423, 1.5506411031017437, -3.672851280650732, -3.4914420237860115, -3.3681875248035436, -2.4546614500093495, -4.008813408681775, -3.0953481239329887, -3.8178630890083873, 0.42927496474464477, 1.244866018257383, -2.249166892956929, -1.2123788458222604, 1.862238437192351, -4.120338709297753, -3.4645131037627674, -2.5615373250358657, -4.337368492708544, -0.7881387459237831, -3.103679688242901, -2.749635652131551, -4.372394737310366, -4.336724693265477, -4.177493865980915, -4.035885070108505, 1.7748858390130027, -3.285623713105958, -3.1560398407844934, 2.502414905193539},
    {-3.6501697298261755, -3.6056281999985775, -3.357483769156469, -2.9705985695785873, 1.8936579185538074, -3.9373716351541206, -3.410894696115624, -3.3138825439296835, -2.3227278669180667, -4.039876486139595, -2.972128949816646, -3.5789243937972466, 0.7511937170303222, 1.8617052160681165, -2.297002450969396, -0.7903235044258999, 2.3440907598573926, -3.878664934706187, -3.667157616654903, -2.4816585657372174, -3.922368948121858, -0.6474541209798657, -2.907902120251841, -2.8699204687085205, -4.379191013447567, -4.263135180189261, -3.9710501638141302, -3.8900564223652325, 2.2924697803232275, -3.22799455716003, -2.93136209496428, 2.920252478179354},
    {-3.8590321864725854, -3.36329171383786, -3.4398083741748846, -3.64334747673425, 3.0251313662920305, -3.710300796822073, -3.431005303973343, -3.4067306955678665, -2.600256098065361, -4.066393337447116, -2.942599384544083, -4.004820593108064, 1.3636803585702537, 2.4234220132277167, -2.0276911293826827, -0.9131808889295603, 3.172511316095881, -3.658861327071209, -3.5233563521640754, -2.635996804090612, -4.081823493534667, -0.43188522283607267, -2.997980022425239, -2.8038813190836267, -4.171351403038727, -4.08611206776719, -4.1391658972201695, -3.9293495441782236, 2.654572764819427, -3.3511125290742085, -3.0322213702311784, 3.249196269539567},
    {-3.4695424090743665, -2.8155659802880586, -3.0718338680929977, -3.0554678483816677, 3.769458439671448, -2.9584607090174377, -2.9556771505747537, -3.161364450876592, -2.2852226628610808, -3.6732069107910625, -2.770815744599312, -3.632026603369086, 2.1005680627616425, 3.3349897044182395, -1.8342043180333083, -0.625203978010959, 3.506199101022466, -3.417861534490259, -2.817727167980817, -1.7301169478621456, -3.7154183478436207, -0.15863918470479849, -2.8020341478975603, -2.768204456293373, -3.8695337547438746, -3.624028259508502, -3.318626175944504, -3.5794218966196443, 3.245978614504966, -3.0381216801459816, -2.8411903883644887, 3.7171210330383104},
    {-2.906401395770381, -2.1719749432674913, -2.527416402482482, -2.201164655932944, 4.352061990338835, -2.212136262433335, -2.025483455591488, -2.4235292500487553, -1.4393079511944549, -2.7887529500272694, -2.265896667236587, -2.9534250671050546, 2.8824665649787726, 3.7411938895695407, -1.3522299941300568, -0.011806890794680613, 3.8028934017928555, -2.8141581292105986, -2.3422350897080517, -1.2912101970298304, -3.083463605124186, 0.3954183124009647, -2.4645312755399207, -1.8844083923433739, -3.2151415061500903, -3.057958968794324, -2.559245499019978, -2.6732030531862105, 3.5938562161709324, -2.4423443317129148, -2.0647839331469027, 4.503790538577829},
    {-2.866084544974264, -2.513697261695905, -2.321062569621359, -2.41246983966663, 4.124363186624066, -2.3480949948210705, -1.8502869312619064, -2.3640314496382335, -1.7319419997904508, -2.6298061426800627, -2.164138828215066, -2.8773904547476055, 2.7034538636100436, 3.4458302645608643, -1.8500051143368952, -0.4079911640875243, 3.713698316862318, -2.5180586316809537, -2.1102496210269286, -1.5234421800607878, -2.6131689407421934, -0.11133753519760987, -2.292364494483897, -2.0050021196796433, -2.8730162956911047, -2.7034806911328153, -2.349477351740244, -2.375176724675044, 3.759098185408074, -2.3944678260590777, -2.5549690027077787, 4.10242658180707},
    {-3.0913428310604583, -2.934054586547498, -2.7143480556365716, -3.150722040397877, 3.871982275321561, -3.0421613941777097, -2.8547548123471818, -2.6360257516774968, -1.4384969239862728, -3.7897028357271223, -1.8058282574660813, -3.1824108130666438, 2.047275896261141, 2.9533754647828805, -2.0994266614323434, -0.27254093540466884, 3.4545294331136303, -2.957416478988665, -2.9579595959147373, -1.8862609927439062, -3.3409816128254386, 0.016338051346805802, -1.8779231952231137, -2.152560878883518, -3.5580182353575958, -3.3981901754043213, -3.227974489199352, -3.222534535201231, 3.1521129016098537, -3.039072655617114, -2.52324131844521, 4.2160500547450885},
    {-3.067042672199239, -2.8655267410186025, -2.8388215275295936, -2.7685278205808808, 3.459483702546417, -3.3621793498169743, -2.8638766400355578, -2.6821594313996346, -1.2795626848370172, -4.054647027904953, -1.9632620162627055, -3.2821244409005987, 1.9374721951387557, 3.1067755443414495, -1.5418540984418552, 0.26628431886001297, 3.2605853792245005, -3.6627162935047433, -2.8292621381916137, -1.593914187173594, -3.8746218843901654, 0.7168402131342334, -2.077218283631264, -2.0341920161551337, -3.9206456132227183, -3.9521525717153656, -3.9347788219996587, -3.6941990441099306, 3.295829968374335, -2.8591701054274754, -2.3085079343733668, 4.3962946083034495},
    {-2.4697505451688446, -2.0017405416094527, -2.2174616047789395, -2.189059897013542, 4.516424551984173, -2.253455937046897, -1.89671522830079, -1.5248753552101226, -0.6432887541727231, -3.111409541286305, -1.2847992296921846, -2.4282505184009504, 2.770112946058011, 4.287912121565554, -0.39782408505724065, 0.9237079695801844, 3.9123671595669136, -2.908740739089797, -1.9325721357323888, -0.2601335268499801, -3.2054077198245916, 1.5937163804568184, -1.3218670836214634, -1.1475628487264624, -3.3422341037835737, -3.1118511704247873, -3.014116867102749, -2.8855861194656147, 4.000410829183553, -1.6204588562052382, -1.8817070018048285, 4.934590316746963},
    {-1.9707750117862588, -1.329386873500643, -1.671363790766785, -1.6981560762672117, 4.745187350624356, -1.7050582779924832, -1.3006806789142404, -1.5611363197407293, -0.14725256608596132, -2.8795064151242076, -1.1515921815402275, -2.1809174378547125, 3.2444652599003967, 4.253107186744107, -0.1767858219732778, 0.978028132683738, 3.989915546062676, -2.35028734947404, -1.3652890479052424, 0.1769381245681115, -2.426474612622991, 1.8112859061773894, -1.1381566398628191, -0.7516121086243215, -3.1310963713196007, -2.682778780339616, -2.337451508015033, -2.465257903442145, 4.050190614450117, -1.1597160833240274, -1.255990720367637, 5.158084748398786},
    {-2.4395253530987886, -1.9963948655751569, -2.3769238966999464, -2.120749051588166, 4.138983111133367, -2.1855163573462817, -1.8848607987711046, -2.1866300930455487, -0.84677479121985, -3.203933013485008, -2.008315928210777, -2.6682656832744276, 2.4253724422149845, 3.5128016047489927, -0.5692350472782353, 0.4690608544116269, 3.557660936144323, -3.051180562968919, -2.017379853289446, -0.4322973092320764, -3.2640177872735303, 1.3767778722121922, -2.106367060349811, -1.5783499466933157, -3.345443521284758, -3.6057256507063085, -3.205817715825185, -2.829222391785371, 3.4770780176713214, -2.178322273625723, -1.851430359295652, 4.688361725435015},
    {-2.70420635712304, -2.498994616352385, -2.531326850391432, -2.3195081264865247, 3.5325573366488876, -2.5606783917862703, -2.17550086473121, -2.3297430626570317, -0.6745760254211707, -3.739905284437254, -2.0332537886493633, -2.937422290642046, 1.7553330556968472, 3.1152230258403373, -0.5436783602285227, 0.5775000720533249, 2.666350451112229, -3.168017304307896, -2.3143257879337966, -0.6202543257575964, -3.755790186042681, 1.5790595557860696, -1.8883979331264953, -1.5138011841061025, -4.05092765773616, -3.8146851196134235, -3.454713795182447, -3.3002808269293573, 3.3697666599936253, -2.0633650188627435, -1.9643869321636156, 4.457251428629666},
    {-2.5328500915255012, -2.1838192026764176, -2.1500018119716957, -1.9595128478762824, 3.723561522172252, -2.3821989858849366, -2.014156996962239, -2.0593492133071125, -0.6406357428404877, -3.145469373455064, -1.9837133830410032, -2.537027610449058, 2.2353141415952655, 3.1267411748685907, -0.8043873424378543, 0.8729653540687946, 3.2362412417135205, -2.8588269879948234, -2.5063699167524573, -0.8199364370663713, -3.2175576073917793, 1.043764823006833, -1.689318982950676, -1.2156512743947434, -3.2893708065139777, -3.3950613261017386, -2.7520843101048014, -2.986461926233424, 3.571415126819362, -1.9090599939623236, -1.8100972807335296, 4.273888544912654},
    {-2.6687829226636737, -1.8142905034521313, -2.2422056280513716, -2.1993660682526, 4.266651161731402, -2.5061618618586277, -2.0883070169493867, -2.017084584033647, -0.9397501155678499, -3.450864999360288, -1.634832439342442, -2.861702144952998, 2.287176966256126, 3.5842730270829355, -0.47834111170693694, 0.7983096496462964, 3.577772637547886, -2.994327671542001, -2.085783611174232, -0.7010933415226639, -3.3914218254185924, 1.347483984552637, -1.5982550311491237, -1.2420489784935143, -3.329237084538401, -3.554371546651176, -3.025162777921658, -3.15006964823723, 3.5919747636462924, -2.047833816636531, -1.6696546510266643, 4.736828771281531},
    {-2.7761919195332134, -2.6890099866086183, -2.384133944824063, -2.3863084089642337, 3.907581240151357, -2.622776314258064, -2.616249024204536, -2.29614369020233, -1.0690067280905173, -3.7562401079453673, -1.662554771073573, -2.8995155424093206, 2.0960148032498003, 3.630763130356293, -1.1380886032768351, 0.5174578291087104, 3.4808627929998197, -3.4315727891361387, -2.0585388138934353, -1.0827371303212474, -3.6291433872144734, 1.1926703508639882, -1.9255304932788015, -1.535796696411566, -3.778424696487363, -3.815328126954912, -3.367156186332119, -3.438636648194594, 3.6949461708376212, -2.2102340729351297, -2.2169860283780767, 4.746063764895558},
    {-2.515771834911037, -2.428212778657288, -2.0879173457871576, -2.3154431606047625, 3.655971768001649, -2.769219229152776, -2.4320345644948254, -2.114118393882833, -0.9749565549947784, -3.5266552059375873, -1.3888210179478473, -2.916761321098693, 1.9407390999454288, 3.2400645622250863, -0.5184650285318232, 0.5911501507158822, 2.910771466860229, -3.3955192230332116, -2.3563477732875215, -0.9943754553560382, -3.525458353352316, 1.3554888100541709, -1.9271543184744837, -1.31154811464686, -3.9494027951338024, -3.8051235954005413, -3.3705488624363507, -3.3235281098017104, 3.2352089281693055, -2.100628955811805, -1.7712284696545357, 4.508590136115559},
    {-2.4386478704874945, -2.4283845448092163, -2.077158553049332, -2.300181917939991, 3.8503547730387706, -2.671207408104241, -1.847192561287602, -1.7440905793830703, -0.15111637504600817, -3.772205619367013, -1.5574840460233323, -2.7374689269075496, 1.8203790925579475, 3.3492668745972716, -0.14764725650668, 0.858380960382775, 2.9286229191000914, -3.4349203953349003, -2.0704135603496647, -0.19922128089806473, -3.442301314780635, 1.607725926237948, -1.559370453570358, -1.0685611378987359, -3.8392926673551577, -4.001414955419816, -3.366649263612461, -3.3849687098128105, 3.5614133646824855, -1.6374516076475971, -1.524083835216732, 4.205869438924972},
    {1.7239527029236983, 0.7720455385612566, 1.8050570480078063, 0.9989330954037581, -1.8178360349949438, 0.8607310743515426, 0.5816511474941143, 1.4463630991004977, 1.1441350650322093, 1.9227804096570125, 1.5768540004070477, 1.6627306954485341, 0.018911905805815424, -1.5969738161118634, 0.12821365391910494, 0.925549942732766, 0.16765779107929243, 1.5202806278838685, 0.475920755943225, -0.12405665157748867, 1.266375585282693, -0.9819978988670715, 1.3550894498663522, 1.6718726201820553, 1.272174937021307, 1.3511308052564084, 1.3941076172529727, 1.2933930442176043, 0.4538862795688004, 0.8349809397416109, 1.3943676301160812, -0.9733523753847565},
    {-2.07289905956319, -1.9140967449709743, -1.196533360220144, -1.73916410277282, 1.0982644882865915, -1.9432919148370678, -1.4481691121289628, -1.6250801474504475, -0.7899662870689009, -2.723758634715358, -1.0029105525150623, -2.2241470067660414, -0.9574239821961243, 1.0890019674696905, -0.8008926643564427, -1.2151558853044249, 0.20732580455776195, -2.5974433480594574, -1.5571300995298367, -1.052028084671733, -3.143260853718899, -0.5426859134369487, -1.2978225516772361, -1.1515627334065694, -2.9037204507254923, -3.06131526656366, -3.0210560722196385, -2.7029793534499134, 0.40664609270632934, -1.4171154062114286, -1.4202054905949062, 1.8888358987380833},
    {-2.2367558516129153, -1.894797696544019, -1.993517922416581, -2.291445628142494, 0.09840649761484843, -1.5371582256527947, -1.7018702386190272, -2.2353756584042666, -2.6203859843109734, -1.0294952339151584, -2.3363670465102686, -2.00673977444401, 0.2545840704867654, -0.5115761421169932, -3.026730470140094, -2.4557665690193877, 0.4325960890238196, -0.8567707981153158, -2.100114703522844, -2.9551808714601346, -0.7665184831886306, -3.182508694181592, -2.0832324590265623, -2.3453557849552373, -0.5531730597126796, -1.0190346650967603, -1.2295184470802547, -0.9974509352509549, -0.15618956080998642, -2.5968701768353064, -2.198708903967493, -1.2878857851372043},
    {-1.9224203426119333, -1.5997456759265039, -2.728800134290006, -2.1294741136101303, -0.21672514798632445, -2.068628914468268, -1.8849034597200318, -2.3162192301729627, -2.4197950734822875, -2.0119361427529356, -2.7894033622466057, -2.1467776740436686, -0.28117544799655547, -0.283152654272867, -2.5274509583136187, -2.3871390454545294, 0.1433239249303628, -1.9979607561963448, -1.9480294584514017, -2.159079077631142, -1.6660346985361343, -2.2459891847787645, -2.4662135677692874, -2.6627638860409926, -1.5058729171809888, -1.7631195029243785, -2.248956557749005, -1.898514842433818, -0.6640450115966476, -1.7674237074043597, -2.1702680647584836, -1.505768584444437},
    {-2.6181633057889946, -2.4731877574240144, -2.2467192791428126, -2.774156736237139, 0.15129517093231962, -2.6560886438068327, -2.212358222406445, -2.040405118936414, -2.268434265947008, -2.523557056868112, -2.264202297160337, -2.373364634413071, -0.41833809799714367, -0.32104569248587544, -2.5493606807959197, -2.046517663784089, 0.3119097916738364, -2.458664338520127, -2.6923987929036057, -2.2949113989985177, -2.4891280822415554, -1.8114586399980093, -2.203077981551218, -2.3088539096080716, -2.5905182985372694, -2.6129441408640477, -2.6730249589391435, -2.5113221432566863, 0.34819371577665525, -2.539643768533587, -1.9739457430504954, 0.13561482288631566},
    {-2.428400916692138, -2.6267820007148828, -2.591979437007405, -3.0295992849062605, 0.3040292431271442, -2.807526846406667, -2.802740655601057, -2.9066441589010243, -2.9275450322275836, -2.3971050532340636, -2.656391784755987, -2.6297863131444847, -0.3719530424006881, -0.2683614808572573, -3.211912124848685, -2.9806458783458716, 0.4726361450375292, -2.1136618755739716, -2.780133917873549, -2.6419348967008287, -1.958118618239101, -2.606514884001198, -2.875298703088623, -3.078571646166657, -2.4964667667864835, -2.3446241692640926, -2.5778686022916513, -2.009973849003278, 0.37003817017152507, -2.884013190815314, -2.5931094279665072, -0.5513557135347534},
    {-2.209476059119124, -2.155787732638905, -2.2386340801991818, -2.811716287336164, -0.4427104993535502, -2.4513163279214543, -2.456821333796784, -2.4881766629940003, -2.1190771492263134, -2.6076308755361706, -2.315713600095581, -2.180820317021788, -1.114386365110704, -0.9456919897236072, -2.5066945580221582, -1.8322579025682733, -0.13387668896650518, -2.2761988866157297, -2.438735123021247, -2.4964269536664565, -1.9060158729419698, -2.414684684339801, -2.281666050318762, -2.3943280748811944, -2.4914377444601548, -2.6749900867587395, -2.8457399499134723, -2.4665294051513413, 0.04991620504635036, -2.732907232309927, -2.0612299956921794, -0.6399313445886217},
    {-2.236380221955736, -2.2717317026429305, -2.06469210255561, -2.6026511271821966, -0.6441664298228063, -2.200015473177518, -2.0158953425287724, -1.9763865671796141, -2.389597241003735, -2.4586571107832698, -1.895052034962163, -2.342415118114382, -1.3627835339396517, -0.791727645518888, -2.564317142761544, -2.0597524070845847, 0.001450416654553065, -2.5387312971156364, -2.168891471823972, -2.4674403111134904, -2.565650661417488, -2.4040780042920047, -1.9955215042654022, -2.2774728922152474, -2.414787758498979, -2.2247898794153764, -2.367461345934634, -2.591707922844542, 0.05924625080128068, -2.355211738719251, -2.2044350834723367, -0.5410122945429865},
    {-3.406184629075503, -2.4977740389104417, -2.1226134856187713, -3.0394576911317595, -0.2347066695976588, -2.6619254912773047, -2.7227914861778455, -2.673574706266741, -2.734529472127039, -2.9941245422561718, -2.216491673919815, -2.6751475313600306, -0.9303070866898177, -0.3415730372775781, -3.1023850320528634, -2.501657613631347, 0.49538201641823393, -2.725841667593662, -2.809644587913493, -3.013241296411676, -2.794498098050865, -2.6322473034221985, -2.235542812296055, -2.6797743534134826, -2.637543234844284, -2.709513820568653, -2.588002404308324, -2.7826438700847933, 0.3134084940009961, -3.013781963454412, -2.7627202485402838, -0.4926464058020896},
    {-2.2855374102968993, -2.4392126020313705, -2.0747117249336484, -3.197091179939628, 0.7363985424513523, -2.4700285890128764, -2.9166636701333566, -2.5196463108927256, -2.551396911027718, -2.3883191539925233, -2.3611291996722463, -2.410749130181283, -0.49658623634980986, 0.2838091622709074, -2.75106238904059, -2.23080029524377, 1.0849201432553648, -2.2623138739080315, -2.4051485206356653, -2.7674480145143847, -2.012324731134368, -2.721265134493042, -1.8395191049160864, -2.196753223021452, -2.1634875132580356, -2.3897384051521366, -2.549137822927025, -2.2827450083154486, 0.9535991041282031, -2.5392066767376598, -2.5777105970217806, 0.1842661587843158},
    {-1.6767941417576842, -2.252883585575436, -1.766773352750997, -2.072541795692797, -0.51311962846759, -2.3467776858610105, -2.3153229590388733, -2.148703005174464, -2.259597118586626, -2.1117485670030565, -1.9634971970682928, -1.705376202597706, -1.2343340313909024, -0.8061695989024513, -2.6740317304041312, -2.37486754853156, 0.24801086374526388, -2.4696442789279023, -2.602661057713263, -2.728579319755507, -2.1717342720279764, -2.523437322314607, -2.124364762240535, -2.272924774936345, -2.2170369702791146, -2.499370357611652, -1.925401669621359, -2.388497335978484, 0.4014369521789535, -2.0810748674989124, -1.9503954349551753, -0.8227803215831121},
    {-2.435127526618549, -2.7176039668559975, -2.567696083266554, -2.849944110560374, 0.03644595619052077, -2.4764898368576755, -2.8191602480316202, -2.5883734198537653, -2.6269781480100924, -2.5225337712242566, -2.5699468089390285, -2.518309587192705, -0.5342372139432902, -0.6206605097754907, -2.7404007092307126, -2.6690756455806888, 1.1465229313509282, -2.355989058703331, -2.9664171751723805, -3.0301499633273847, -2.6541574140555664, -2.7876637164196962, -2.8737274668302515, -2.854075164458639, -2.2903181674856183, -2.349258334080716, -2.9389209574871327, -2.336983054256789, 0.8247057057839798, -2.831666321088977, -2.675384385907545, -0.7075804952385715},
    {-2.75934265126461, -3.03218581057288, -2.0106792619686216, -3.0214508551184807, -0.4876181306511414, -2.9700515534565373, -2.9406953436738528, -2.6118151966382577, -2.724313239306555, -2.7645519973490367, -2.5369102774887518, -2.5731185086171866, -1.103980914713236, -1.2804993875775714, -2.956400146967365, -2.6195356806985997, 0.17512498566086848, -2.965400005228155, -3.056832705516357, -2.8017320697134602, -2.4535374932731044, -2.820606973398404, -2.5343167713050976, -2.7793969366270392, -2.863928971947874, -2.7305138030796816, -2.6196180772188318, -2.5863839139605673, 0.7384159493216188, -2.7115357505567887, -2.65216049070803, -0.7440898834545052},
    {-3.2240037508069412, -3.1894680470908736, -1.9193179114795496, -3.206449681089423, -0.5200624943212426, -2.987833070013711, -2.8138226002688644, -2.9226519654888614, -3.137676643833325, -2.7749744700148, -2.7226919300040966, -2.4631679547112357, -1.3964550977812633, -1.6187332240491172, -3.0643204066631764, -2.6889569771478232, -0.1676223054043189, -2.638701001557129, -2.9403229667655695, -3.1262118368304304, -2.571448019881058, -3.234627910695964, -2.4763011893654814, -2.8597495468387693, -2.345219130707679, -2.4695177081651947, -2.4108887793185527, -2.5323817630070233, 0.03540077582566751, -3.031299476254213, -2.7639740728158033, -0.8698407236188784},
    {-2.625490187412677, -2.7222377844732444, -1.817799197689592, -3.1736644556801923, -0.4026021902870843, -2.632685614810301, -2.9826032592488336, -2.5501152383736763, -2.5014410813233634, -2.1817655590861036, -2.241943912766615, -2.5043740097535125, -0.7692162673970607, -0.9930042069320238, -3.364741234353923, -2.4465464408773556, 0.1528487560516999, -2.348591425980598, -2.898478655462624, -3.224155663475683, -1.8282917492708033, -3.154627509582322, -2.466803261573318, -2.5727254175955614, -1.916725560064306, -2.3982696991700587, -2.088895961186037, -1.8766960610357604, 0.429607796782653, -2.905210053458686, -2.4007180202800744, -0.5818227560363044},
    {-2.472995938143874, -2.4022781463831984, -2.140741383012834, -2.921444563459834, -0.30067399204720985, -2.167118495660431, -2.51384071510279, -2.723232931945877, -3.125294172871815, -2.2303546263235314, -2.6719120661930478, -2.7226512566786467, -0.4666290328524438, -0.8677313689183479, -3.1043165268843333, -2.8038684970629717, 0.267955708519389, -2.0469322291075382, -2.2057618871244187, -2.987136576048616, -1.9962278901737542, -3.9070030124956077, -2.5861632658992346, -2.981492093981166, -1.8310209566988405, -1.8614578076839714, -1.7418258875748465, -1.7770511079000924, -0.20694158857768324, -2.8900638579707176, -2.9329125984452293, -0.8569938525591977},
    {-2.694877240299548, -2.0816398932438, -2.12198767166173, -2.5685322358664906, 0.2662334384832486, -2.064870756304898, -2.1798485485631525, -2.477369714081894, -3.080381474601551, -1.9465808104400695, -2.68368483081439, -2.485576146003428, -0.5307695736597201, -0.33944175186594777, -2.865668299857787, -2.738183707035097, 0.328388550383988, -2.1171511461842942, -1.8365331744889741, -2.63757935172207, -2.1091503514917904, -3.054821095114158, -2.835140754458501, -2.9777372770138335, -1.8286027179492763, -1.8901567552415948, -1.802924249290341, -2.168823662700362, 0.2238634077820375, -2.905517581868011, -2.792423341404124, -0.6390186532165386},
    {-2.5017933269902337, -1.957855683818237, -2.267230503416107, -2.514528328138474, 0.9489010300440744, -1.8757641315498352, -1.995099058198779, -2.4538096929103954, -3.0968906624413646, -1.6934775568317066, -2.340021493736986, -2.3880018522404747, 0.4386741049510817, 0.24862922670221163, -2.572161470639864, -2.6725648673737448, 1.2758007183980136, -1.5410502751802302, -1.797684934209497, -2.0581558239863265, -1.7170593594596681, -2.6592458579505664, -2.552287458294732, -2.6568533833854677, -1.4114460585625617, -1.372356623936251, -1.5002282514359424, -1.3004700335822494, 0.10888360925600704, -2.301991813972223, -2.686908863434254, -0.058168774008549834},
    {-3.0639773200269964, -2.633890440861983, -2.356401686715851, -3.225289665236071, -0.4555406828082091, -2.4866089309795645, -2.7726345005919897, -2.725968774378196, -3.1477065579470107, -1.661873576724928, -2.596756773995098, -2.7143406091972064, -0.43240183587346, -1.0828151229196228, -3.3710446731806503, -3.408909045320999, 0.054918394846612935, -1.797729155817428, -2.4558434447793323, -3.238345041277431, -1.5152224308364945, -3.4134219054522257, -2.9699447315827356, -3.231847491922747, -1.5244470307555096, -1.5701337529141668, -1.8000130496492104, -1.4904889883828891, -0.43593096816610544, -3.0802544091703608, -2.82662405974831, -1.2459403954691293},
    {-3.2881367082981, -3.3338480780378323, -2.14626176755538, -3.799670616385796, -0.37571775797155327, -3.1299967531266946, -3.183608005017125, -2.7915776273135866, -3.1707355510413637, -2.613895181140585, -2.5836355589377478, -2.9179103679137333, -0.8344882072382449, -1.1490961999890847, -3.637490119227826, -3.0364325771196246, 0.14689293333351516, -2.3179989274281056, -3.192142602961434, -3.9771952178325516, -2.312850678876958, -3.420782720806589, -2.616555799232866, -3.0000963479974905, -2.156487307099634, -2.4186526911679707, -2.6356335276484275, -2.363366031802178, 0.14270022493431597, -3.775540115129901, -2.85937747696319, -0.933129809508363},
    {-3.2006153315228336, -3.4536948562348697, -2.2654787561463734, -3.458223649652224, -0.2093621144950355, -3.1225289671651235, -3.308645104760413, -3.132255592963366, -3.1139606026725457, -2.5093377362265277, -2.7785265152639704, -2.7562597726368527, -0.30663639878045956, -0.7675123981927124, -3.4381525456364534, -2.8845847393302675, 0.3032855743760655, -2.843243047394686, -3.108762392541482, -3.543794382024457, -2.379712726073364, -3.1124026064534385, -3.1439445644291006, -3.1355150870066058, -2.3747834582611427, -2.4729027743153975, -2.7438717899924407, -2.6691138421469534, 1.0348872370812312, -3.63192073299106, -3.319566669456948, -0.6098090764017383},
    {-2.5328360402430303, -2.53341088368374, -1.4586147465706607, -2.5870198395001727, 2.076970758639176, -1.7416924970339362, -1.8142740377990525, -2.5355347194951716, -2.5856795315489793, -1.045993149661722, -1.6237949868870436, -2.5244644006301153, 1.054694446384553, 1.4157349265012773, -2.8519407797795946, -2.2495363450515002, 1.8908404661201035, -1.7156336762091422, -1.7570252675053148, -2.5865320950196704, -0.9452385779102019, -2.5652613709561094, -2.084369457257588, -2.353936338298362, -1.2445292253661915, -1.0487678173257502, -1.297902442739252, -1.1845742512535729, 1.7758022311998902, -2.641582491503267, -2.36750576038666, 1.5684299211844097},
    {-1.6614063588604722, -1.1266086914470013, -0.2255070651844647, -1.966334309047417, 2.071810675107137, -0.7361395960085829, -1.171538505868785, -1.5117940435460002, -2.223408421906941, 0.719797206515034, -1.262227373532777, -1.3297939034749844, 1.8945828349172984, 0.9881736690818818, -2.8253630851212375, -2.163301821667804, 1.9508736185082312, 0.16160486290537573, -1.0684653250988154, -2.747612743364593, 1.1334645279390054, -3.462678342990535, -1.4462299648155492, -1.6306200754952176, 1.0150820599413217, 1.2045165417238124, 0.4646975497378869, 0.586501807556314, 1.6619741740690759, -2.3153320604594105, -1.7579530728996908, 0.2570104466098976},
    {-2.82826151557929, -2.5198088241951715, -2.0704464526032407, -2.9558799212867783, 0.3035995434802762, -1.9102198575379734, -2.4759553527763534, -2.76053871001391, -3.536242604058073, -0.7406704346852354, -2.5544952233123084, -2.4024133144819286, 0.3344852928558793, -0.9336392114081843, -3.8055070801970423, -2.931818599743558, 0.829167580813388, -0.9322132171147057, -2.1575371971802224, -3.5843350079209757, -0.6633313634917537, -4.155449918392941, -2.696337991574398, -3.2540102095483907, -0.2627721986189809, -0.0595149830200903, -0.8192885833713524, -0.7116094543578402, 0.5341882699816309, -3.2100369313475956, -2.8850122409338375, -1.3825060918941305},
    {-3.464234801580383, -2.854283352800624, -2.7834489173312407, -3.5343952227508137, -0.303721537643492, -2.992047446905253, -3.106448683801411, -3.2108338367498432, -3.418479987616032, -2.193810756833878, -2.9350033354497866, -3.472923529795783, -0.7129757892153333, -1.1309872771385685, -3.7098437779111584, -3.316566616967457, -0.0454327402520349, -2.551155073776079, -3.0315613166249293, -3.751188003660839, -2.2120854156882954, -3.8576229492775824, -3.1495262148046796, -3.5597681637199208, -2.138101588693445, -2.4350556935585512, -2.3264116510725783, -2.298753977753687, 0.18027411906083854, -3.8356215144437256, -3.2898252199519047, -1.2026324992722406},
    {-2.566707230358042, -1.9746209897319196, -1.3499058244165227, -2.593581955387977, 1.0448799371272186, -1.7674266213489462, -1.961862933687127, -2.301896942474766, -3.304105037903809, 0.14874097312112966, -2.449514121899166, -1.898692336442464, 0.8773309396231792, -0.2818023518389375, -3.635266904589948, -2.8546311385260785, 0.8094613902440351, -0.8151663298493312, -1.8784162421520767, -3.3351415490864036, 0.4545605144487926, -4.097785964267652, -2.6250595532642995, -2.578232784907977, 0.5584060228221056, 0.5156979299498077, -0.21286519972783113, -0.054605881742450145, 0.31812193734222943, -3.05730464392199, -2.315979154324783, -1.6926553107261555},
    {-1.9956904658346684, -2.0920588858512534, -1.0584476199684065, -2.4243553341517745, 0.7680993422124626, -1.55000212898713, -1.7808733176695102, -1.9174377562975418, -2.8216323698364056, 0.17193918745377101, -1.7810438611695607, -1.7684006040790161, 0.49248162114829097, 0.10293009504204796, -3.556397280243171, -2.5007624543582896, 1.2632706706029955, -0.5442236337815072, -1.6697669523176402, -3.100561002122189, 0.28249471899369255, -3.536324402930633, -1.8364784908808514, -1.8494547721645416, 0.0998876151503993, 0.1985453632396338, -0.43540375686654226, -0.31891245521018263, 1.0130842009625811, -2.50129201215371, -2.1249544005970904, -0.7193154428605862},
    {-2.531473196323936, -2.326103473022877, -2.2476512993840663, -2.8253324637592487, 0.5872637740369283, -1.745248867838561, -2.2973437795825036, -3.0859721988927644, -3.5148598747653668, -1.098077232180075, -2.43225597003338, -2.610216114809561, 0.18506068493008887, -0.42812302334363944, -3.7009221526498157, -3.2519345898116123, 0.9494189624091085, -1.288011390825784, -2.126410043635675, -3.5452034092559837, -0.9188190031122495, -3.9713274019744573, -2.7983386499164027, -2.9307483211640974, -1.029010901047989, -0.8911280190001561, -0.9533151769143573, -1.013580487302033, 0.4956093550897347, -3.0860649137553042, -2.761974811491484, -0.9601767057057478},
    {-2.6057144710649998, -2.103348094735387, -1.8194022423970917, -2.607076327021352, 0.4981723813811304, -1.7095891505102376, -1.9462342732999751, -2.3375660357024994, -3.3256133880871506, -0.21510322920219715, -2.3460828461982937, -2.5162746843191086, 0.4244193463894455, -0.4535112004767177, -3.868877003185244, -3.0919812699740583, 0.9104868833980483, -0.8712824198484361, -2.0449703374344823, -3.392076647799178, -0.13367971868335915, -4.0681545824337055, -2.534647631617489, -2.5901978353120185, -0.3015358646477444, -0.26541861186103216, -0.35198770697115167, -0.518824064820481, 0.2657695386563996, -2.9807837857351873, -2.710989464731813, -1.1101669979277085},
    {-1.4350219277108665, -1.5165396781933849, -0.8538770915901747, -2.184536961792874, 1.6010202110242937, -1.0722508037703777, -1.6225970646407386, -2.2011737812519003, -3.0248223084829333, 0.3120416453818904, -1.6600429025029924, -1.688013664647846, 1.3818458900269384, 0.00021276933616479624, -3.2554641971864977, -2.5619752842301726, 1.6452999547425684, -0.3999522175875625, -1.1376753471510619, -2.7384572487886514, 0.2137883776924361, -3.895164827334462, -1.9609265499989053, -2.1239213924494442, 0.39516243783846877, 0.23577822482508917, 0.14671562854122844, -0.0581206946156671, 1.2472859288136946, -1.926118782359164, -2.1269017859204693, -0.49221200143938454},
    {0.07288529681865907, 1.4621914550783626, -2.3804593526651443, 0.8859997805717823, 1.2415167684598327, 1.05608420997095, 1.406126753874137, -1.3194358371681472, -1.4981813269976658, 0.7973491497378032, -2.299211704204243, -1.3408732153785554, 1.9871783516042376, 1.9340064751926624, 0.6632539086775109, -2.153860969393582, 1.3970762507557142, 1.0399350064983486, 1.3497158592053877, 0.8563902930184519, -0.9669013282874536, -0.19344518595100546, -2.2803930507370573, -1.4914585933587852, -0.2857159430896094, -0.17624090908346815, 0.5473159470967491, 0.6276334184865738, -1.9322103244564055, 0.19862992425178613, -1.401776495855487, -0.43692294861572584},
    {-0.6423136827805316, 1.3337943119406084, -2.2637759557592765, 0.9153163976400503, 1.344362223488772, 1.6782264339321613, 1.6492206829367908, -1.4667514585013262, -1.4799174819879886, 0.27304329442298103, -2.2223348913398304, -1.2878687228392505, 2.8586500483553636, 2.817063583305576, 0.5523841617166367, -1.8088474872430174, 2.320727542550497, 1.0439846571342826, 1.463571915888539, 0.8917688664414921, -0.2553609017309131, 0.4139199910195621, -1.9599457115374836, -1.7714118322434302, 0.4487670822912703, 0.014708351414229895, 0.5697187007091674, 1.1018834120951506, -1.5287128422758405, 0.021840482939407175, -1.532952044497397, 0.3186820346036174},
    {-0.438321134036445, 1.964631416355148, -2.893229807639806, 0.9701141580441793, 1.3563836223371104, 1.9865785437230616, 2.271650137363093, -1.8584842306422968, -2.3451078447624325, 0.8429268725560589, -2.8553323165321727, -1.5016770521828584, 3.3741629023727495, 2.559568911047939, 0.22012118964452246, -3.0677343958636336, 2.3576387276255653, 1.866685812554498, 2.0091554553578104, 0.8845955784975335, 0.11441075386422193, -0.477809598498175, -2.7092441588611105, -2.6286801381330127, 0.6234816574882168, 0.4648714883824641, 1.4782474359443272, 1.8382706036974887, -2.377451508085019, 0.5549468698300067, -2.0511200790395305, -0.6625269596550288},
    {-0.5254753898110494, 2.0285868329175334, -2.8650421847845853, 0.885963669314594, 1.7405444382850466, 2.1991979098700085, 2.1808053923590887, -1.6040533980690856, -2.174618605223757, 0.7931547764976693, -2.982496247077511, -1.439919802179156, 3.312847974369764, 2.629776583378968, 0.740908634867072, -2.728136818134633, 2.8746563160315266, 1.5803129525262634, 2.283773784727014, 1.5908836407701998, -0.2927525458574104, 0.2853223465279464, -2.786626386080835, -2.9500042436923115, 0.7533001553268681, 0.37571179902437396, 1.571779720287778, 1.659786536528099, -2.130093721667637, 0.13854866178340938, -2.003231526948845, -0.17900337827842785},
    {0.44782158009528433, 2.1135040259775506, -2.7560107097612967, 1.5176776302877792, 1.6474296181776644, 2.031088176476089, 1.988281259787896, -1.5159836195312424, -1.5907954256031933, 0.8535248523642568, -2.7871637777003277, -0.744560339317932, 3.242218732973507, 2.936258662014679, 1.154712308625536, -1.7658166399642234, 2.2206668721404195, 1.5546310793244453, 1.8739527872909343, 2.1401690184891398, 0.29054852548644605, 0.3186882409912155, -2.4135162839620263, -2.2279481790930853, 0.7338747863729171, 0.34984124980892833, 1.0670786659399707, 1.3487789597061866, -1.890139555021268, 0.3443016538144414, -1.9211703117480554, -0.022350381975107927},
    {0.4460333937660003, 1.963786998234033, -3.1601215276625405, 1.5261631996833938, 1.4324251490002402, 2.05637768845016, 2.164651303535043, -1.7842512882810664, -1.7428144058342239, 1.2000697910942164, -2.670282331391524, -0.9015005625308007, 3.2723833380305964, 2.2821323012402486, 1.202976594639364, -2.4593734220181567, 2.1913096269411505, 1.809550737704249, 1.6328484336181275, 1.748971756400618, 0.16043257489475005, -0.08991981149347279, -2.3367251328969005, -1.9921769669720837, 0.680897521813258, 0.7923658988048632, 1.6280091190427934, 1.7537976747747483, -2.4294499647324654, -0.23829052592688962, -1.7093409929845487, -1.0767832742009018},
    {-0.7170727933340147, 1.9395772459794691, -3.198704222881827, 1.2844729937017072, 1.5213021463680636, 1.7468932506560584, 2.055575789377996, -1.75911782656641, -2.2611003791360407, 0.9051052732322779, -3.011162559893576, -1.3179618235080568, 3.051091942293103, 2.576162510647324, 0.4558002650593841, -2.7215886124374196, 2.0801419547732287, 1.8327114095279367, 1.5613345096544893, 1.3329241991410907, -0.4828771418535399, -0.8482516455073585, -2.5074828314210857, -2.2358267564956247, 0.7467246268569878, 0.5229535811309004, 1.5199235454989601, 1.9571814934570892, -2.4541075035742166, -0.13860098835014173, -2.2792302669979945, -1.5731699082134785},
    {-0.34707079096261484, 2.0316126708044404, -2.88382781224937, 1.8019984166705523, 1.4839288570695133, 2.124000193463899, 2.236963487393326, -1.4107829866496693, -1.6269886769251505, 1.058850793657882, -2.595056211667375, -1.147450584227198, 3.0347077421993345, 2.8435577115670823, 0.9247066226559104, -2.307710573472234, 2.132668012029621, 2.066285990691493, 1.807051661457383, 1.3501147269346618, -0.6864949759456711, -0.08242269073173684, -2.1603404957630703, -2.057301303468109, 1.0705199720060437, 0.5221251263919541, 1.703521498172542, 1.8554249705754724, -2.51969617843318, 0.7405626306824558, -1.5684891118639175, -1.0917046683916067},
    {-0.04452518493020694, 2.2487116204386246, -2.9826300322851855, 1.7186005716818344, 1.5011371173945058, 2.9669354398743915, 2.6675805626143845, -1.907596928540159, -1.5713842732676773, 1.3126442880506446, -2.8816437688186327, -1.7931389591474622, 3.3446804270405175, 2.5091200694175497, 0.7542856635046267, -2.3141217349110685, 2.425112532770451, 2.2604553507018252, 2.4545716272315192, 1.506578861625961, 0.07231486654476825, -0.029938326016139834, -2.595462052161663, -1.9447874382249797, 1.122613286590746, 0.560055939041442, 1.8751242378225421, 2.3161244428075483, -2.528361088757083, 0.6557937032174421, -2.0552046928191845, -0.641597682478573},
    {-0.11846735213908753, 2.7684887337135042, -2.9501034521821006, 1.5902288578309387, 1.5919410561699792, 2.7953722027381125, 2.553006269178668, -1.9552567235401814, -1.6396470128739236, 1.1162664937342759, -3.1076958470178226, -1.5440454613031556, 3.1576640628490837, 2.599573757760839, 0.5043017320823557, -2.7059405700589503, 2.4113111076927756, 2.2134618606249385, 2.558318263207935, 1.4339337272909736, -0.40158039392476896, -0.0845960834994302, -2.7056251669409077, -2.0006090471442186, 0.6257861637974296, 0.49800604903678675, 2.204177416611632, 2.213749282753656, -2.5866871306134285, 0.6824861354778446, -1.9442040188191865, -0.43706597538969433},
    {-0.15240791010655172, 2.088721213627308, -3.0546158156741656, 1.7445226632665325, 1.380314377618891, 2.21774663140527, 2.3809704811399097, -1.5752594867178953, -1.7313367982411922, 0.8048649115138637, -2.7130800388516985, -1.6175701920046366, 3.0896860876017676, 2.6470467373504047, 0.4556882338500068, -2.759320277901135, 2.501993828825629, 1.7631872030475717, 2.411991191019948, 1.6137967670144426, -0.638397707414369, -0.24732542847687747, -2.894894166570607, -2.0924200345055564, 0.4387340372472538, 0.6284373498948873, 1.4167326967643945, 1.8278477545904808, -2.6814834887540324, 0.6517791035862366, -1.999729837078198, -0.7787506823278347},
    {0.1424077496267053, 2.4681655892580765, -3.5052895922972422, 1.8750394272963096, 2.11111187959784, 1.8837163712427865, 2.6132520592855375, -1.860899799510287, -1.6853278137748393, 1.2721981050266156, -3.136757596055146, -1.3281233337865934, 3.4063481594546117, 2.3941188085855627, 0.9896930401875931, -2.6621499615896047, 2.60016036060012, 2.194881884805015, 2.2707726792185747, 1.6030126518296266, -0.6377887366167877, -0.0442642146917787, -3.3726605442566315, -2.2105437326455335, 0.6397108274187427, 0.9876217049635109, 1.8892871090757166, 2.0631842955682944, -2.8888394453404103, 0.43170492776115166, -1.9461140346770005, -0.2224002916947478},
    {-0.3887002598280753, 2.5530710823225786, -3.164536676843712, 1.601614510867438, 1.92687668763107, 2.4821957472881717, 2.566256396685709, -1.7399329978049074, -1.9596403227965302, 1.480364097537354, -3.3053370533444046, -1.155233348207447, 3.269640028203604, 2.70692979488206, 1.1995664473546028, -2.842359676941893, 2.92776628360751, 2.4532977974960724, 2.285624671201572, 1.7741758414290918, -0.8113930821995928, -0.08183032286131035, -3.1523074496788213, -2.166963675780963, 1.2453388080653611, 0.6286846722393208, 2.288280000948361, 2.0833837484415128, -2.6641999979109254, 0.6751799779606543, -2.2627671212037583, -0.8445191058262145},
    {-0.21083336899726057, 2.0046075082222328, -2.9281480650475613, 1.2328896278212333, 1.8398440644598093, 2.2016473942824453, 2.321647814141467, -1.4605630924507893, -1.8945943816398456, 1.1384111081658905, -3.0871227915190036, -1.5243243442375929, 3.2866113924983975, 2.6745202433349564, 1.0097124988661859, -2.740809051170922, 2.6514781177098348, 1.7941461889173769, 1.9662700853569164, 1.3380749747404461, -0.7485171078946302, -0.6114068784325315, -2.8072660527917095, -2.387625588112848, 0.8002720695464961, -0.022642029081582648, 1.5469824701245043, 2.2781485437458078, -2.727564254731565, 0.9913798369184861, -2.2164170957687, -0.42730103254721435},
    {-0.5075608505415932, 2.1776705933888496, -2.781655269590359, 1.1315235032097486, 1.5282346525275745, 2.4796236329877517, 2.409872961774027, -1.8004739783632464, -1.9106552581828962, 1.4889743231145651, -2.8599564337294474, -1.904947296716449, 3.0592067986378533, 2.6582231590472123, 0.6868978607651952, -2.4019759393310185, 1.924464043393615, 2.283344615530018, 1.8402670078755872, 1.5941368134122358, -0.9194772639606679, -0.7953816329271025, -2.9453262028015823, -2.4906538123093864, 0.6936416921386885, 0.6800895141389843, 2.1060683544092913, 2.141246184647784, -2.414505970625038, 0.23465203406336255, -2.31050091320593, -0.9425711519729395},
    {-0.6647668855535256, 1.9080004712052756, -3.262047285900917, 1.4514582183875362, 2.121302832782589, 2.2453790723089453, 2.2167552878438195, -2.153968310713824, -2.2385288006258737, 1.1419537906075317, -3.2780248591025916, -2.2159963507909652, 3.190026127909487, 3.1473823557643446, 0.7406356718949403, -2.4561511835649052, 2.2351676920376593, 2.1814863399130924, 2.15699564826351, 1.740518974656924, -1.2007935182669665, -0.6088008423210421, -3.280698855622888, -2.45482170685636, 0.26951704300728824, 0.07455055650584001, 1.7817691583436364, 1.9602445811222489, -2.8005475404219187, 0.07185334778966943, -2.766683337100309, -0.8207165450431471},
    {-0.3077235432661847, 2.265460094237601, -3.252816840596787, 2.2091600947162466, 1.9917441282110697, 2.456968139666715, 2.6194842996521466, -1.957572038644269, -2.2925570918385874, 1.1605023066168705, -3.1991060111637335, -1.6624496164300195, 3.7110153345419206, 3.2829151094599265, 0.6812014388400428, -2.6074735413213634, 2.899153170452987, 1.9823215469388695, 2.5166466422586637, 1.2669768962405639, -0.788596747928881, -0.23674068542754295, -3.1429361869986354, -2.3847482246405605, 0.1329815436245709, 0.12525005904133876, 1.9540842384567707, 2.2298413468727207, -2.6106618206108503, 1.0802597210378158, -2.3654935054794177, -0.10349010702760715},
    {-0.30441841795386526, 2.871354669266197, -2.934140566165112, 1.9626104747079762, 1.858639411645824, 2.4721450336753157, 2.6376436229029845, -2.031832337207759, -2.4095383407997386, 1.2415067105983495, -3.3230854648423143, -1.6559168178570864, 3.4160332434707588, 2.803647997434065, 0.9378559976391194, -2.713290879546308, 2.551581940325952, 2.013187022281442, 2.759249039803469, 1.7358232580375434, -0.2115257225876704, -0.5399268197355904, -3.248063484731824, -2.422195119188308, 0.49716806637412253, 0.5909286327684345, 1.9353880611687782, 2.0882284837239995, -2.8296078974666865, 1.3598266722176573, -2.1668333058127955, -0.6785386490674556},
    {-0.6886198468401213, 2.6798205375910804, -3.0728192266517764, 1.7212470985807093, 1.6307931410411507, 2.4707891326938967, 2.8352324120387795, -2.1169805553957834, -2.204692653090756, 0.9611694496512851, -3.406885812507635, -1.9732556708348956, 3.2971802134724046, 2.825986689067198, 0.7950452258461512, -2.9523639409375773, 2.3529939478359587, 2.071502744765401, 2.2784427058773913, 1.7581071053758812, -0.6225640806339853, -0.3297579396895483, -3.4017189745091474, -2.683101183053897, 0.520966827246377, 0.6175745965605892, 1.6586312122269498, 1.6045864533775438, -3.006374309028293, 1.0731005840735863, -2.5363743324082324, -0.4827243716030724},
    {-0.3480763238847615, 2.537252202352523, -3.1683484894118643, 2.0986127648775508, 2.1274877412980255, 2.3625653989262503, 2.561138277713202, -1.922939101571457, -1.7259298361536692, 1.2203069997084866, -3.2984721546840716, -1.6053291122896318, 3.604904868699975, 3.311813846023565, 1.582769351104427, -2.9224185353201855, 2.971021897871768, 2.189099793465065, 2.4283571005339772, 2.065714275901104, -0.5999635349658275, -0.042848310611713465, -3.1188143124449295, -2.1404579285330523, 0.6057944308215957, 0.8732841207254393, 2.1193909404547995, 2.27662399451944, -2.4447915250971617, 0.703495283428685, -2.1586307778356786, -0.3274623734499926},
    {-0.13830788829378785, 2.4446216136361163, -3.1468151142437804, 2.1022734884020027, 2.260776287386221, 2.3087950001167825, 2.68534221394983, -1.6445190999470771, -1.8853787487548963, 1.227916274790285, -3.26787966440366, -1.4099343177469685, 3.4415420894703264, 3.1061928028699635, 1.6207449266980938, -2.39711823419387, 2.6950235882656886, 2.360573768207132, 2.514334150871495, 2.2966598334419346, -0.5165936998636614, -0.032887395723222586, -3.0807547831920843, -2.051282252916078, 0.383051592874943, 0.28252969476605116, 2.243630122149456, 2.1595309920100143, -2.8919091346603802, 1.2471280514816392, -2.0587511239434817, -0.5372376013815986},
    {0.5942987417663679, 2.8919951807814677, -2.812624659340397, 2.2890825107433534, 2.49950221863752, 2.6499017802328764, 2.981681568706183, -1.50859640104991, -1.8048820370663214, 1.5198864745988137, -3.2147219013833226, -1.4855125501047286, 3.9848938627263957, 3.408166504428148, 1.6380429180529639, -2.7932298816986996, 2.9565226475558024, 2.6954329678657336, 2.864194402032652, 2.418009878613499, -0.4308539653111271, 0.15350103443394228, -3.2265518532148185, -1.8161703569361212, 0.5309801433561241, 1.04305956339444, 2.300996129566467, 2.003579836671601, -2.846157642726416, 1.9624787297579775, -2.1746654542385553, 0.09044398533063616},
    {0.07491772276187061, 2.650724539674237, -3.026413602645148, 2.319518125488949, 2.5754561258411774, 2.7178638953748124, 3.192598000607742, -2.1880849579777384, -2.607875911811832, 1.6943605969120357, -3.4649520074328266, -1.7187389760559804, 3.5760746554125467, 3.422512937274145, 1.6215297309060464, -3.414456645402844, 2.69612110120419, 2.7578460110792307, 2.8158429711188564, 1.880206131583083, -0.8025947321404434, 0.03128664589230787, -3.079871883757823, -2.601177423209841, 0.3820308363736962, 0.7529070633755971, 2.2158014236090042, 2.1944964288773128, -3.134100862060282, 1.4660892420794862, -2.230101652234822, -0.4990142272259059},
    {-0.4065140098164441, 2.8333293527821404, -3.2980309530982392, 2.213896180818217, 2.280166421879853, 2.6673605744366746, 2.614881783448667, -2.0171629041387096, -2.5018971082324493, 1.429193410207814, -3.299396423785633, -1.9634390535929704, 3.781880105758409, 3.115446308326045, 1.414531147070064, -3.258369963786302, 2.8479898455001567, 2.3370670497575383, 2.547232833405424, 2.3598549847513266, -0.9155503657544969, -0.33098602918706665, -3.4521141430822153, -2.85758343452707, 0.37059379873719406, 0.5665639356150092, 2.2213660342733945, 2.031233993415752, -3.224633309657455, 1.2708867506798764, -2.69215759426654, -0.18522921120244734},
    {-0.4192811320725079, 2.731737726921699, -3.4172307747268174, 1.958342983531465, 2.205684722525711, 2.3698151760608606, 2.5752900014429403, -2.069207458292155, -2.3398979920694023, 1.0611674129295003, -3.346947683022508, -2.073534655449617, 4.103307641577011, 3.3810895130395866, 1.4910290551608072, -3.2099867802682014, 2.882346641119906, 2.393090508483262, 2.4137806512500948, 2.1369567982465956, -1.165642798189967, 0.026959386954511125, -3.166032765835603, -2.726238340186156, 0.28002012911818236, 0.4040990625806406, 2.1216248048661854, 1.9913000295484007, -2.7243523926798097, 1.1013665544487485, -2.601974082728205, -0.13889478128883312},
    {-0.6375584972559508, 2.6737995994212915, -3.578659598383848, 1.8946798318137592, 2.2374654523582436, 2.772795264201082, 2.9547199799021295, -2.3340458882792303, -2.8965822368152887, 1.1299887508313449, -3.7667148759720845, -2.149140393372153, 3.663221916399108, 3.585299553744655, 1.2715597345263658, -3.1913343540183194, 2.8512730449137105, 2.2766626884650027, 2.850637336166339, 2.208387173159819, -0.9218330175360897, -0.4664233006938279, -3.7354431799216927, -3.0373401463517435, 0.2761211461972622, 0.23367576158238712, 2.077016292705207, 2.011926063809065, -2.9697066674872583, 1.2706535813761712, -2.878977492769456, -0.9255293886993377},
    {-0.31680253969915034, 2.9632948062518687, -3.573888838523634, 2.0254705055202797, 2.6826863823586122, 2.682099986088725, 3.085552787412125, -2.3189880819470328, -2.6432406565914497, 1.195158419529412, -3.6097643587397186, -2.340602756903819, 3.709434433344062, 3.575072243802945, 1.2445315519636653, -2.9599699236486923, 3.218523177720378, 2.6105748988689506, 2.7350661709874116, 2.1955709632140405, -1.098336019717123, -0.12492692628259186, -3.5097187873024835, -2.9245308874901483, 0.37788870570866495, 0.23546049026739688, 1.862786112036103, 2.1199190238794174, -2.966592038298256, 1.6389066897487687, -2.905096619122553, -0.8974144382356949},
    {-0.6845808570639326, 3.1430367364809424, -3.6470963609767626, 1.6803225525476233, 2.4334942353882214, 2.806464855099615, 2.8327173248735518, -2.3522910290907872, -2.9067452537711183, 1.4062278900210492, -3.1292559097876547, -2.1440225789987046, 3.9291219434491103, 3.546651865804857, 0.8625074142809427, -3.0709073331034817, 3.1732511669663843, 2.6615239475920487, 2.746821271476973, 1.9577045910022095, -1.0507203751737284, -0.42861522197649177, -3.4484862315955302, -2.9558722725234903, 0.49542737543895565, 0.896023739598909, 2.4344248693549075, 2.1739819725924527, -2.6656953890963844, 1.4068150534683004, -2.942131431885741, -0.5325429498297837},
    {-0.6672644753806447, 2.7792475674749095, -3.6319320258579886, 1.9212368644537237, 2.319989627047686, 2.663371849809839, 2.832634744843787, -2.479584608582963, -2.7766592861033548, 1.2157264127936824, -3.4302056293686385, -2.429664369068665, 3.6933849343120766, 3.343849387611331, 1.0390332363843469, -3.3688741695496605, 3.1360802566266917, 1.8213200109122052, 2.5190901457461057, 2.0245901985636263, -1.094642169432094, -0.6924049472912562, -3.6279513177465232, -2.758104510205941, 0.2915843627576566, 0.7703767185402202, 2.030951204922557, 1.980453336370712, -2.8406554570477356, 1.1081693869934657, -3.0561259532360374, -0.7586542800661571},
    {0.004737886124652635, 2.700337350626887, -3.529957059859631, 2.1631330978973486, 2.1766694743398305, 2.8362106264778535, 2.8438626783119205, -2.652473440973023, -2.7385078600710084, 1.3161376253979604, -3.5813226012896666, -2.2853463722878438, 3.330636873515033, 3.1828513774021547, 1.2316608714584085, -2.981408535686398, 3.092138925900075, 2.2271240496606186, 2.684410331533667, 2.1184074341958357, -1.271479461002032, -0.4317553961241726, -3.353722605151101, -2.725426252629551, 0.28802320144545673, 0.8228941241313553, 2.143917324163945, 2.224435079051596, -2.996795284024669, 1.3217508590728513, -2.8935889604872282, -0.6288287239057869},
    {1.8218372450678348, 1.098586170067904, 1.7219905651024348, 0.9304418584790463, -1.861910115163141, 1.459918879876856, 0.8704762315874336, 1.2461327759931418, 0.28281077964799484, 2.59959107041766, 1.1758505791085456, 1.78315008059191, 1.1079056511280203, -1.559041552117862, -0.4977915593051607, 0.5906160659973702, 0.2748829524626186, 2.4490049484775307, 0.9237182829000751, -0.2939807192643606, 2.2294753461067107, -2.04905748614619, 0.9540267396372377, 1.3182210746875809, 2.602590933857258, 2.672508771561054, 2.184307899294275, 2.2606033940835397, 0.11702819364637573, 0.6771725540703448, 0.9626799220248543, -2.2826788912954346},
    {-1.861150516388862, -0.9883355657861655, -1.5217820985601855, -1.0544851370239476, -0.04181881603862469, -0.5271137797033376, -1.03618334016794, -1.0473225300814495, -1.6430483491315584, -0.8285182910032823, -1.470048452005072, -1.640884717365638, -0.21370850536343075, 0.1318701916659324, -1.687925405787271, -1.446516826615534, 0.17861395310952577, -0.9507192400216835, -1.134168430136043, -1.4517697752857661, -0.8758514904615823, -1.6610462138645443, -1.3372697812242862, -1.5373888973032834, -0.3275621036982987, -0.6216578398364678, -0.3428416326116727, -0.12188664840260933, -0.6826286315644984, -1.5801897740687534, -1.3118381799425025, -0.31388153414054537},
    {-1.6152976896405347, -1.5959643069469869, -1.311266002261615, -2.154267997212868, -0.08476722812873086, -1.6068881601809002, -1.9573922740419418, -1.866273338917304, -1.8363344138732591, -0.5642116773275277, -1.6989305888640944, -1.4358461403739964, 0.03146757071247485, -0.49854589052732357, -2.3636083339779215, -1.8126489372260284, 0.28473897211143606, -1.229883676562202, -2.002332208706418, -2.577511227754124, -0.7009086144013406, -2.9211252227539, -1.1065180331119064, -1.6873350570083854, -0.3458638508798545, -0.6349133504777649, -1.1465728852821546, -0.673959335882733, 0.9696177981666827, -2.243802963793122, -1.8179732048480048, -1.4096103578772055},
    {-1.7414267749810282, -1.2056454876104137, -1.6173941570513815, -1.8039312457042247, -0.09840530973014058, -1.2185621807348932, -1.4234706109107376, -1.8449503324916245, -2.276653217284963, -0.552091274127137, -1.6443897853585592, -1.3013140810399462, -0.25260529101786816, -0.6334280550129814, -2.006645531747131, -1.7353801899200947, 0.1018425748149155, -0.8547895779206276, -1.4286253960515445, -2.191462761850888, -0.7909634016098435, -1.7385113899050475, -1.0783103000402319, -2.1253548758860874, -0.3951183343369278, -0.47474989622253116, -1.0152127535457807, -1.0828482805937218, -0.2723187600186515, -1.677427077512552, -1.9116398659798193, -1.9970930612401327},
    {-2.122710325390354, -1.7926171894607348, -1.8475964355016794, -1.784417123087682, 0.6058767243446037, -1.6816371173097133, -1.6730569696483362, -2.154765709733441, -2.206890332724997, -0.799115986621433, -2.0142732905409146, -2.1531367562781645, 0.18059993654694279, 0.5892306249760655, -1.9644457687682897, -1.9673800295425743, 0.8049167225387309, -1.1865368932377494, -1.8322303110505669, -1.7882869475204108, -1.1976178108500921, -2.026790483956475, -2.03526241577898, -2.3751921315080615, -1.3212164609637056, -1.189771982646451, -1.1867252931243193, -1.4812643673564818, 0.24107791501528397, -2.4428836938527843, -2.0135706818251045, -0.6445078928667962},
    {-1.9224113524589728, -1.7678990457516766, -2.1090073492566943, -2.098466050078686, 0.12813297299951584, -2.062035586507205, -1.8541645381092728, -1.965864665395425, -2.1408367180701506, -1.639954234147341, -2.6519250722966823, -2.0553928133911934, -0.33011746913096907, -0.2828486465771708, -2.188360023462253, -1.8187327020112944, 0.6439052273922484, -1.1144986451603744, -1.9227090936514564, -1.7499754155839167, -1.552982935864351, -1.7839166570008969, -1.9096500650009764, -2.337294505065796, -1.7403792178060866, -1.443056696091199, -1.8105986802182463, -1.427698200232272, -0.11332430532948094, -2.3395599287050834, -1.8249820160905879, -0.8356374169847981},
    {-1.1433239300427922, -1.332006090397259, -1.7077952432884973, -1.6153087526537042, -0.3943106148647841, -1.8523118991670555, -1.6664944050616988, -1.7572022627298727, -1.5568139280372812, -1.1996468052245086, -1.9190603011732807, -1.2397001003108536, -0.4680918318153919, -0.0018685182068134767, -1.682715725352421, -1.2979971754265085, -0.07782737166402395, -1.0502025248951259, -1.8533664876025464, -1.4415293892469696, -1.580105301655868, -2.1106688695204925, -1.7500230709236475, -1.5821489091840713, -1.1742078890544736, -1.0836598020004056, -1.6963424701052061, -1.0680112012218936, -0.03212520541683917, -1.9134166427790764, -1.5378474963662359, -0.5880400740669705},
    {-1.4534725641271324, -0.9328183828671018, -1.4962918170534043, -1.2221946223880045, 0.03333166429543995, -1.2966381356260785, -1.0294005304807816, -1.4775704273899835, -1.4725732466254022, -1.1675895699351546, -1.5570355794170059, -1.405620988640293, -1.0444467710263574, -0.027181992796012112, -1.4724586993999507, -1.5937451384692731, 0.6156722266127531, -1.2022180711276897, -1.2139788953593817, -1.37666584935639, -1.6543825726317456, -1.6811219900024963, -1.4448929238009027, -1.533980462883747, -0.8406778365447168, -1.064264477239267, -1.4905035002003213, -1.1458762099381103, 0.5299509488182454, -1.621408364614134, -1.6533414036516771, -0.26218686860503576},
    {-2.295165811608965, -1.526953672276328, -1.558137672697218, -2.2114874888181446, -0.37247244968270676, -1.5292119548961904, -1.6920304587885155, -1.8222895824921017, -2.040103014736265, -2.0152003271448238, -1.9803647753016662, -2.115791140116977, -0.4564356373772455, -0.36159687100859733, -2.3216210945617397, -2.1069882913541393, 0.5487183115869437, -1.7111099051958705, -1.796528549165565, -2.0161069175026527, -1.5743661364238586, -1.9037374948661567, -1.7226924839589013, -2.083720977437731, -1.3779329428296159, -1.4929486393352684, -1.555297800434732, -1.572507460615945, 0.3327279622850384, -2.1213136222366633, -2.0155048339719546, -0.5521793660749094},
    {-1.3614021376565755, -1.4301930316506994, -1.1171120037603888, -1.9077980819600775, 1.277988707352529, -1.3331086627776034, -1.8026928550038275, -1.4472906507094572, -2.0152468078717134, -1.2049809470365376, -1.4851475696728558, -1.36907375651483, 0.5297783531877698, 0.5924230205497584, -2.4770516310795143, -1.4913558734342238, 1.6173823188027006, -1.339820706013401, -1.145706329591003, -2.139249595681551, -0.08438980911840918, -2.0994527347455083, -1.1357281732985685, -1.3525923049566848, -0.7353064383531553, -0.8907841665236533, -1.462731949695157, -1.0921212365897346, 1.2477202286120423, -1.8497183509058062, -1.8772781286738405, -0.010656036876356557},
    {-1.0922286264959398, -1.0994758935901778, -1.1479145530102715, -1.1740379499281994, -0.46447411702673735, -1.0333415452915047, -1.3839195934042465, -1.01256575509853, -1.8468247044212203, -0.19565459531942994, -0.9102583424442532, -0.4566511631280855, -0.7543984596248838, -0.6927117548330287, -1.9091632334385682, -1.293656878357226, 0.16278644745930052, -0.755127814975803, -1.5121742630334427, -2.0504461840178236, -0.7230185773478672, -1.9542285341823404, -0.9558136239930174, -1.4441538252967419, -0.4933767881676431, -0.4415959077179827, -0.7159303021053922, -1.0683960893387294, 0.5390950264884247, -1.506469502377069, -1.1246109794206554, -1.1139013321552673},
    {-1.3793782436200253, -1.4195960103219796, -1.5105883587719708, -1.695204753717421, -0.11665961750866623, -1.2093597600827182, -1.48744817719545, -1.3126087006388103, -1.9690543288853222, -0.7726013395348483, -1.5083763479446837, -0.9487227897686531, 0.10557238394936644, -0.3838512862680374, -1.8986473961019406, -1.8719435071123731, 1.1013604798780994, -0.8550985430401293, -1.721549049828382, -1.7771235361059727, -0.9867709360266952, -2.292010141905796, -1.5780017917134197, -1.755451992542111, -0.44870393813889164, -0.41952200384075483, -0.815314304183801, -0.8073367639738634, 0.9926842171893607, -1.3827587124467389, -1.4797384499744455, -0.8711993076294898},
    {-1.3370966060211775, -1.3635713604593926, -1.0001089717127556, -1.7404942769869258, -0.37122845968895674, -1.2529875771752228, -1.4420706673204569, -1.0398441625736967, -2.039492067553177, -1.137929677102217, -1.2180416224415846, -0.7079458553059097, -0.20716349508881005, -0.8293363561771218, -1.9369557868456375, -1.5869047597461587, 0.931576863752013, -0.6435079830205767, -1.4910645296464298, -1.9681069986751796, -0.7453336470113082, -2.1848222687493957, -0.8486680992160806, -1.6261358127645644, -0.799732319560202, -0.72264974088444, -0.776286243232713, -0.81499717943376, 0.9381216862249377, -1.3524868774563081, -1.3762519401476456, -0.9432202770812602},
    {-1.9449788747711085, -1.704963855530401, -0.9660638216954085, -1.7422943085983007, -0.5384166894407225, -1.7162750315669557, -1.714754403248733, -1.7833152147581877, -2.226467998829087, -1.0131867054052441, -1.4256133221392286, -1.3807954024411406, -0.655597566200961, -1.4630579651518154, -2.6010479273771923, -1.6391604296254176, 0.2760948710186871, -0.9478668159227125, -1.7025973585292338, -2.4644657860594066, -0.5139079010735715, -3.0838621146680247, -1.1677434139128844, -1.8417224441492015, -0.40187697425544516, -0.3455626543399498, -0.655865648916876, -0.6019989825743625, 0.17102859088314312, -1.7290247815233946, -1.6320995056274277, -0.831104282061593},
    {-1.6048703861148537, -1.6460617612399377, -0.6958628517031519, -2.484380576485178, -0.2674047484891431, -1.3857617363899974, -1.9916076135315084, -1.3170172000795368, -1.6857998984124658, -0.5533899799626518, -1.1189054408859802, -0.9527051618040641, -0.1843523461645027, -0.3477472499553813, -2.7269508226011827, -1.4965787628471514, 0.730455721583371, -0.5783098126829619, -1.6501778299903125, -2.397734888157768, 0.23336038318667665, -2.900701519330915, -1.1337810672408057, -1.6011367688940372, -0.05306700745623274, -0.5322552245642418, -0.8699342284140436, -0.16299157935369799, 0.5112284460143819, -2.0711116027378695, -1.7704129243667404, -0.4395782430100354},
    {-1.4828075315162836, -0.6836354312966776, -1.137389547322087, -1.459533265513968, 0.1817224213517611, -0.9045719779037693, -1.3999565787189674, -1.6108025565294783, -2.2033068970047207, -0.7125312306413809, -1.5735583595737916, -1.5162273529321846, 0.024810967982720044, -0.1696419466849855, -2.545491720703276, -2.314407734181092, 0.4658966292047345, -0.2677018944686544, -0.8874436861786852, -2.2303507193725007, -0.7085145486505735, -2.92684814365933, -1.7132249161785167, -2.155657123179527, -0.2394477315648473, -0.2183596486966814, -0.28548888485037954, -0.12095120971668542, 0.05686828783943784, -1.7571011531570362, -2.185125706526394, -1.4236667898228794},
    {-1.0780736236276451, -0.7731005232375039, -0.990295227634463, -1.237392406999758, -0.005091701623749937, -0.894311255916563, -1.277945434116994, -1.3794919880882837, -2.2981148748603037, -0.06229405252143984, -1.5271844489375435, -1.0015103105986043, -0.09853603317855397, -0.3744586092752066, -2.478680077252137, -2.091404639755008, 0.2905181736104469, -0.3712206619457605, -0.8358529439668673, -1.5943877055797053, -0.12398813823840361, -3.16283888143509, -1.2275818427985916, -1.970362625296774, 0.4050278780074037, 0.3366239985893828, -0.03801582322082821, -0.2328360131005377, 0.2521496702341191, -1.6944718967745558, -1.7335738683470496, -1.0283320049663447},
    {-1.8899094812494683, -1.3983493658219572, -1.2834818409895012, -1.745532166244383, 0.7961266225541981, -0.8513561586321886, -1.0751514783610554, -1.7823819560858225, -2.7253039267457617, 0.4586370809400579, -2.0731055300609555, -1.3045541389108275, 0.5515472087690884, -0.1227579841940591, -2.6563806981298623, -2.389772552316716, 1.316636012771805, 0.10208614673012936, -1.4404598055486146, -2.2827859018523293, 0.4319504334242241, -3.5133291919021428, -1.9679570031466997, -2.6119594021835373, 0.9677440564474326, 0.9093586507168544, 0.24569466585375413, 0.3102565597041501, 0.24945231091867293, -2.232371420356774, -2.2375851201932027, -1.2886540666019788},
    {-2.058094346821104, -1.3527982042917766, -1.2653284522954171, -1.957489048892617, 0.2124137658623446, -1.1680388776437742, -1.2343950119863223, -1.7436152931816402, -2.8317284684495183, 0.23900461441037155, -1.9406871753423074, -1.3848606535657335, 0.6527582708059849, -0.5170655208569879, -2.916385540589863, -2.4460039563487497, 0.7399864095208224, -0.08510473340914353, -1.7114407505497393, -2.953245410035532, -0.3728955913455424, -3.302698754639342, -2.2562236603000883, -2.3277241905293318, 0.7682008152292686, 0.2626698044343568, 0.17999756226731434, 0.2868766019888923, 0.023127041727779036, -2.473575119659008, -2.046768435054072, -1.6565704986173375},
    {-1.9687361630416889, -1.7777403006252208, -1.4493891879901588, -2.3468737384241076, -0.6064296064264412, -1.5317609630290718, -1.9918713300884963, -2.123486707100842, -2.474386533852129, -0.509407852336136, -1.5688416009198969, -1.6651167817572248, -0.4197651298650943, -0.9436499119490653, -3.4141841986380514, -2.4130215611024353, 0.18823692424406904, -0.7331831792170915, -1.9946095595593722, -2.973228147561699, -0.3400831150151807, -3.259260943248122, -1.789569053401436, -1.943213373397389, -0.17427083210184952, -0.01227219966142737, -0.36753630782921354, -0.6773183857009067, 0.2841960251785993, -2.4126402046732514, -2.0723429381760052, -1.4881822906594164},
    {-1.823875141171309, -1.4492332169975157, -0.8741143630966597, -2.027133576975708, -0.1214568790657236, -1.3133424652218613, -1.6008130825027376, -2.1429885817880923, -3.1065556830950474, 0.4920821846436664, -2.158911040438281, -1.2212198872283264, 0.9853582461047768, -0.3223218614229642, -3.0017838664929792, -2.2088679903375263, 1.192646795231933, -0.25135469761961327, -1.2913087710865763, -2.85655218720786, 0.647588052460502, -3.579217254390014, -1.643101040619637, -2.744322661870057, 0.7024972357300513, 1.1366087728113652, 0.09329620705495709, -0.06271604769283329, 0.5823324928163753, -2.151696619065788, -2.3035020026226203, -1.7404555125289494},
    {-1.5869789659083084, -0.6486759293353994, -0.34551644401893583, -1.4875235492230037, 1.3982358766290877, 0.06415212645609905, -0.482767866199602, -2.0503282732593444, -3.1545797339044954, 1.7350714779827878, -1.3866282221184274, -1.2981732217052466, 1.7716935107142546, 0.4602480738401137, -3.1174348783163017, -2.709196478817857, 1.7194762085841853, 0.78680449193058, -0.5297905162182527, -2.8997757310677463, 1.63902242488857, -4.124454728828353, -1.5056618643237594, -2.427958681694072, 2.092688766040625, 2.138587640815871, 1.3079466202723726, 1.550838073180398, 1.1293601941824503, -2.3078258522206467, -2.1150407081620104, -1.8378566651641668},
    {-0.12657359771128784, -0.039730217982458016, 0.8813714425003865, -0.9230546271864424, 1.5109097394971465, 0.8420638318085919, 0.07245681668224503, -0.856770538123501, -2.1627113951658288, 2.953860979394331, -0.3974466445837804, 0.45924304875098404, 2.270308705213417, 0.36130697698359265, -3.2245962532244756, -1.9319889546688849, 1.6077058840431802, 1.9064359179904005, 0.21987162963673795, -2.46777513022311, 3.013527229410122, -4.341413936478316, -0.4042108598888898, -1.2913244106438402, 3.229717053857432, 3.395415787570962, 2.3208417908579, 2.539177053546308, 1.0384244712548754, -1.0316430509250334, -1.062649888487345, -2.347006767375573},
    {-0.9505408956032237, -0.9994783320889083, -0.3384688958770279, -1.8099767972986596, 0.40843282061718245, -0.1001453591985958, -1.0748213232620047, -1.543940023529504, -2.7672893247420385, 2.133695271247689, -1.258528868163402, -0.7671623395111842, 1.1358563266203663, -0.49316511846683847, -3.536363094571538, -2.5290934936696257, 1.3803992687424032, 1.275354504615813, -0.9543304730860486, -3.3445574307363826, 2.201089980161991, -4.70322475291445, -1.4067896886151874, -1.95313615185011, 2.3842486063677377, 2.6169374685739113, 1.3993037726878181, 1.6744192948794934, 0.8306513436727319, -2.159321959873928, -1.8597417350091918, -2.895875487003677},
    {-2.2199326863384745, -1.7723279010193986, -1.4737457783815189, -2.4223247730200175, 0.013273539971819811, -1.3276277414421178, -1.5089468789994749, -2.514400858911651, -3.335338943919923, 0.5487062519169813, -2.112607844750052, -2.1301819376034112, 0.32005767360254134, -0.9042676578739497, -3.620982014633289, -3.2380408722597447, 0.8482745432598162, -0.20752567475295144, -1.8339126883664647, -3.0641473144584883, 0.18331050060513904, -4.099571244418748, -2.4440206094872683, -2.965265542934534, 0.3842362886982963, 0.3448257603844409, -0.08556759430764548, -0.1633429453814597, 0.3417965904192461, -2.889160825663406, -2.7140011781843163, -2.083938094695267},
    {-0.8235810942715521, -0.5040315629772321, -0.2706212137790563, -1.2487524394514475, 0.9742488995212024, 0.0708585488423365, -0.8598439868075929, -1.2149651466211548, -2.8052300006653597, 1.961717481510524, -1.2331580607636814, -0.3322055995059386, 1.6414389716011812, -0.16452380369500647, -3.428300064980979, -2.81257466135975, 1.462958300774883, 0.9198681939570006, -0.5536139778583095, -2.687476652421787, 2.2893904189252456, -4.352757975484169, -1.0912204680377944, -1.8215240376199153, 2.2518909539139065, 2.304193748345444, 1.4980945568845718, 1.5782972203373797, 0.6163381631844929, -1.7140028458001766, -1.7216224435322085, -2.6957653362300205},
    {-0.48912605161084066, -0.7287670418711099, 0.6407954901035504, -1.5198377480042273, 0.23585704482083092, -0.12499209788997719, -0.6447920496412811, -1.134646274151853, -2.3294541214485682, 2.3743983426779587, -0.8254922341045724, 0.1018009848513431, 1.167934245157025, -0.6902285020780725, -3.932414143854639, -2.2560122368221514, 1.2045788682419165, 1.6174777124186888, -0.7080597396955288, -3.1057945008710033, 2.6654822983726736, -4.555940146591191, -0.6550285816696183, -1.3301181129307051, 2.6409523436941154, 2.7149625225567413, 2.0392155274616264, 2.067160599621278, 1.1243871084821737, -1.987069393984137, -1.5089241999892928, -2.988156681252748},
    {-0.8079009832093889, -0.8688157012620811, -0.24080108749512427, -1.368876773316572, 0.3685332601764056, -0.0393515311571638, -0.8611813467629863, -1.767688661468438, -3.0147557986846993, 2.071403550258052, -0.9504954878561493, -0.44202067045494114, 1.0379059905776167, -0.6801119013142439, -3.3290452378697957, -2.4052080265628355, 1.2808791907449368, 1.4422110620286601, -0.6459392859044207, -3.0950578300955933, 1.9670832113701335, -4.824967545267671, -1.2229290381921563, -1.765411142423858, 2.4537566360309326, 2.368822176754173, 1.4773362160295316, 1.6638811500850412, 0.6533770788705364, -2.2530290579464194, -1.7533538382093892, -2.561634799311804},
    {-0.5995482088947333, -0.8218027879322247, 0.05376593349287759, -1.3727889641964806, 0.8006291836452751, -0.0020166047302375275, -0.6458061815797939, -1.2837406195371848, -2.6807267164430826, 2.2953293964724035, -1.1486195967845287, -0.26006587435034295, 1.4346800896216054, -0.5138516151565283, -3.510099700181259, -2.4537478245543785, 1.0760050164792951, 1.6268435295877952, -0.5287457241537056, -2.9134203506663563, 2.4267026873876185, -4.72745696315704, -1.3728182289264024, -1.7355197765682897, 2.535576783082973, 2.4681543862941675, 1.7808094551879734, 1.8480004344472374, 0.3103800361001105, -1.8551224716918056, -1.6504910743863876, -3.0449975873535893},
    {0.5006202055420405, -0.06690817049338237, 0.6181962833536495, -0.6264088590041044, 0.6455721294401995, 0.8110793953176574, -0.36037412681508324, -0.7501961072664382, -2.3353779748788854, 2.7689521275834217, -0.6134801826774098, 0.37943932483165194, 1.773581040978276, -0.14312649192445684, -3.133034549898517, -2.2012831658045666, 1.5585198476625755, 2.1354729763291713, 0.09381983259667334, -2.621621187986781, 2.857897978069688, -4.80678471334153, -0.7052893827650347, -1.2425633889441827, 2.8664109913196207, 2.8954653356091224, 2.2914810445550535, 2.6518799902857655, 0.5049995677662954, -1.0360264090689724, -1.2963017606976874, -3.088426720188314}
};

static const float b1[32] = {5.352210862357252, 5.321530321467144, 5.526818412643307, 5.301823372613305, 5.877573023026904, 5.327172909493792, 5.3842387031282275, 5.232312203196734, 5.483619010655187, 5.32803900081698, 5.447033161907731, 5.350407514326959, 5.692958630493539, 5.843314062016185, 5.48605001524941, 5.464495875992402, 5.756172600523023, 5.393534456056981, 5.2283708335247345, 5.446752580394413, 5.276235497354358, 5.652031163589444, 5.421954599497164, 5.397822514920671, 5.359858740866716, 5.364698494429754, 5.370905695701057, 5.362755539643869, 5.742851127846968, 5.41608071664263, 5.369933403785531, 5.859008517564069};

static const float w2[32][16] = {
    {4.072964936201613, -0.1576315426721977, 4.4977824416296315, 4.204456013911657, 4.428601012777129, 4.4584502924470195, 3.6546795405221704, 4.704569892375844, 3.1612739555123515, 4.227661909791779, 4.395244820314476, 4.218786302319855, 4.831010885425302, 4.272503769489161, 3.900572835244994, 4.081676413541925},
    {4.480966865794557, 0.13545181290203392, 4.1895491784728085, 4.311206661062742, 4.814909769837862, 4.5222594299315695, 4.46102154844163, 4.961774011837518, 3.8038472218906163, 4.612711333542849, 4.449522708658736, 4.216384109431872, 4.334813202924545, 4.250880033099651, 3.8733116092134154, 4.3496499040896515},
    {4.621838841499366, -0.25371338075565786, 4.597216921914617, 4.649239037402655, 4.805454604161759, 4.555410699122844, 4.561145505311099, 4.686094366092336, 3.7993319023919265, 4.732654751449645, 4.6813013758553925, 4.301574134020434, 4.732170254083553, 4.833305556491814, 4.619036262196074, 4.400950601294673},
    {5.008356209223963, -0.33258868272953107, 4.388287851661493, 4.359081063921141, 4.287744838831123, 4.290143085055051, 4.149950367973481, 4.30875666127512, 3.5478692582751874, 4.553182187061623, 4.195182302275659, 4.2911032439348595, 4.317512459916045, 4.696227047849262, 4.134239875278547, 4.62716104785363},
    {4.7598710215741855, -0.4116343510220344, 5.014913507785853, 4.984648643113695, 4.9214870457477025, 5.407663790839673, 4.913783977990497, 4.185012704204037, 3.6128690628451516, 4.944765027579152, 4.799282552965324, 4.990697608595703, 4.800405900772858, 4.2814098354643235, 4.3700997992870665, 4.9701279076205305},
    {4.816660712195984, -0.002639208580916959, 4.643312963639849, 4.362878799581161, 4.379920808237407, 4.7412336459095865, 3.9577884352288386, 4.682367971753927, 3.5284736674166677, 4.46250581172745, 4.478743297304599, 4.328092060070936, 4.151403091943338, 4.4820817635580745, 4.0798539766135, 4.5700318100916535},
    {4.174572132472789, -0.3187197162531762, 4.506177569038348, 4.48792128406151, 4.371131968626713, 4.971000258499333, 4.516304968989549, 4.502692339411997, 3.8718689837230125, 4.305066149514944, 4.409208031837421, 4.645888242857414, 4.733858240259118, 4.775671923859934, 4.1101206268929245, 4.52454441743414},
    {4.517553041570637, -0.0979787434293015, 4.90478315123084, 4.562046043220057, 4.578695888912008, 4.363414322683998, 4.45702516324231, 5.003157498852531, 4.057750659618952, 4.521623278831766, 3.787287627863128, 4.417803338703312, 4.5946284059861835, 4.533975257099603, 4.550973124418672, 4.254176201960761},
    {5.14505053334918, 0.1661953486967853, 5.102352766502941, 4.880679321350718, 4.546552601992068, 5.106831790015224, 4.450699305414028, 4.730720115070318, 3.879272337173113, 4.446278903902522, 5.12509109419437, 4.445624814518811, 4.620934547357759, 4.773478653858082, 4.546538847697389, 4.551526803213081},
    {4.729379402285387, -0.1971224146646279, 4.190135929720052, 4.370387267050357, 4.627370179329038, 4.693511201108729, 4.648108350919188, 4.496940739392503, 3.565939128091651, 4.930204695911359, 4.995999761591317, 4.486314102503143, 4.038094682327534, 4.617793612367753, 4.1068686070815295, 4.469414824038021},
    {4.581406205544173, 0.11868977193710988, 4.676703536949016, 5.047099524100051, 4.761519000738969, 4.831279512866096, 5.054045900292991, 4.7603470450569585, 4.070608543736841, 4.5156861882774315, 4.700216987845998, 4.7084861138975835, 5.122405413655762, 4.736503009032509, 4.271335697271699, 4.411785408607985},
    {4.514582547494847, 0.35535785516673113, 4.650111448172117, 4.4632580183621515, 4.330776416685294, 4.664956143873901, 4.3498927329088435, 4.213690026586054, 3.6626997423673187, 4.23069801768965, 4.765860744125382, 4.129825430639257, 4.137675544151012, 4.183102331713011, 4.190431060704058, 4.419080866421188},
    {5.027583064282925, 0.37829770304118593, 4.481439401231319, 5.15246910287864, 4.893681390040961, 4.945240232568253, 4.929130416520608, 5.305163999643803, 4.533672370868977, 5.216950843069121, 5.205369948444359, 5.001491467099284, 4.777237914600273, 4.870081262678684, 4.460522521477739, 5.200118431579072},
    {4.983297306841733, -0.35971034494556553, 5.050545409359361, 5.0120882269408265, 4.944703370565866, 4.8614914184460005, 5.567343514678087, 5.052187426517913, 4.105957639972605, 4.938979737485266, 5.230520606133214, 5.418883982294141, 4.86497076927858, 4.405367797155012, 4.3901873991083304, 5.2221589458575135},
    {4.562837231458766, -0.1418588222015547, 4.478784408243701, 4.560576131718311, 5.308278226063472, 4.455305103061826, 4.394908467388736, 4.644351002575506, 3.8761452646534598, 4.257855569252572, 4.926462151770745, 4.600351458312872, 4.933182525365596, 4.335455466470489, 4.068619666339765, 4.804829528207528},
    {4.902318208592545, -0.22826173335741945, 5.210491593878994, 5.334687358086765, 5.204932721631902, 4.34387074256438, 5.322754245711282, 5.142673865818183, 4.216643979185596, 4.922261938542399, 5.22382326589024, 5.3321996346091085, 4.994054271008656, 5.145377825801026, 5.059482310920032, 4.618169966178949},
    {4.6786216576639745, -0.31987289079593595, 4.797120459598141, 4.942077751048847, 4.33597060517591, 4.4002612329648905, 4.8696214207413, 4.263597191654669, 3.3368428376029007, 4.804833226781906, 4.809884534761932, 5.199529797692468, 4.952085400031102, 4.329540658811901, 4.242361891743463, 4.480112002170624},
    {4.518129196768357, -0.25580553254288807, 4.513151938853453, 4.2518715180862765, 4.369923840183421, 4.293318529415338, 4.486541627307552, 4.636774679121896, 3.8992684123007164, 4.385974578978978, 4.727995291264516, 4.48069632704981, 4.347275514419933, 4.43197579390288, 3.5535384813328603, 4.443757500589569},
    {4.820005768141859, 0.3368140403553781, 4.412570916384989, 4.351477181037764, 4.363036023448625, 4.9702964042685815, 4.504762670141074, 4.643486905477711, 3.8323120332659597, 4.228314650347651, 4.362898517522997, 4.87208954568656, 4.556108417711878, 4.820778295139612, 4.521987815406196, 4.762971197466574},
    {4.242698015192558, -0.17259684751600782, 4.633467296181789, 4.493147583925318, 4.254446526791493, 4.671998716408643, 4.417090634756855, 5.124711270947808, 3.652754932131468, 4.563325169414991, 4.675932418708637, 4.980786081834482, 4.836213578519225, 4.796303851709386, 4.504767287945301, 4.718748902880605},
    {5.18720109069826, -0.19269480691703939, 4.691206981499961, 4.618439982228818, 4.934662950027195, 4.777489011520253, 4.990257826704219, 4.266869729388861, 3.843401387454676, 4.677231176606543, 4.215647663768809, 4.746161258163563, 4.85856856210818, 4.820081429928111, 4.708014500928339, 4.855744827775016},
    {4.694098989442856, -0.04550064017719364, 5.270999673514109, 5.282737300283455, 5.247787174529021, 4.519933730566666, 5.101974871278761, 5.355246178369743, 4.306301631094138, 4.9680797849411915, 5.169753824029371, 4.783710879034172, 5.3830230427108, 4.927155936167389, 4.683306564174873, 5.541645114826256},
    {4.557615140327091, -0.3768126829604518, 4.701315948944531, 4.874486377480257, 4.637778339270643, 4.904916158262838, 4.425198434832656, 4.811906880308529, 4.075736216896776, 4.891160807158643, 4.99122711093343, 4.752956102271821, 4.617557287978812, 4.828571279617846, 4.40285427017157, 4.645352914080122},
    {4.4515434329629775, -0.1344351991591838, 5.278658913855336, 5.370857865571494, 4.624138590037705, 4.47524575874903, 4.438065751584973, 4.948502160724478, 3.605211122473216, 4.828453408278398, 4.894023072164479, 4.857799852884355, 4.877454180448085, 4.4782305853558135, 4.451624979625143, 4.651566663757414},
    {4.441725732281537, -0.02140030623451265, 4.897749106172036, 4.159490735378119, 4.794717639757394, 4.191887687374571, 4.088494163401346, 4.649968299781404, 4.21642100147424, 4.538235308829664, 4.914754066083236, 4.418130392741276, 4.389160776662437, 4.654961941123086, 4.094566651636757, 4.948951147418033},
    {4.737693023968937, 0.09436520741255054, 4.691945884795431, 4.172051186492245, 4.88299986251703, 4.616205687209356, 4.617054195595399, 4.494726119820083, 3.7727575357539482, 4.953186938885567, 4.635222282154733, 4.075157494420413, 4.87306925711861, 4.842176933571906, 4.242591157851997, 4.637393880770505},
    {4.793202847100212, -0.22759805021617804, 4.720455220674957, 4.055389944136221, 4.648425778201952, 4.619465518666192, 4.747921251343285, 4.623993427231867, 3.9001869437884995, 4.674573571412078, 4.285419733848965, 4.207351969208492, 4.136488505129296, 4.51082137326192, 3.9536906051961775, 4.883347558487807},
    {4.322148371643874, 0.036033025258796106, 4.384318577547799, 4.522556259450736, 4.557697183051332, 4.803718712251021, 4.979923081927357, 4.2181240422175525, 3.289677038309151, 4.551446638552466, 4.378500410299985, 4.812204216133264, 4.4284359958950645, 4.7411576649634455, 4.3530061785396725, 4.77306412587935},
    {4.804432485553669, -0.016487163706582524, 4.653118158984218, 5.170977477036522, 4.738032756364989, 4.311262333151767, 5.252406501013816, 4.361651870210172, 4.129859262105594, 4.726640946297648, 4.54351272124346, 4.972611510693317, 4.604808862929409, 4.243680043852746, 4.684534088043239, 4.489175524721745},
    {4.437432557871573, -0.1547877651816213, 4.437796140169388, 4.434620641972428, 4.143055927668916, 4.363378069568559, 4.086679719937781, 4.358022853862271, 3.294970233404384, 4.360058912463311, 4.697280453872577, 4.0976643378519615, 4.677344086093653, 4.291252038630497, 3.7712632824899046, 4.621346112767967},
    {4.405305940198572, 0.16545543449167815, 4.461590412056182, 4.361219463087898, 4.621643880259737, 4.386154404086495, 4.956800582653167, 4.8070378055794265, 3.973250722058406, 4.315611665976507, 4.062597246482042, 4.491408247665638, 4.2640139284460545, 4.685126069139203, 3.754086028672733, 4.991564148889154},
    {4.67057592786652, 0.05896281639545397, 5.082443100600841, 4.978957854428039, 5.075102008817922, 5.111757261968009, 4.838295570266802, 4.880859806042365, 3.64033977364802, 5.376353910386036, 4.95928804698452, 5.05290244545097, 5.551540549614564, 4.425253952030411, 4.825147895368459, 4.785276043526805}
};

static const float b2[16] = {4.693455970077978, -0.08194119267544978, 4.620035653873316, 4.582977394122912, 4.5330118489791795, 4.626532445676844, 4.673856815802542, 4.524525244225901, 4.629915339546878, 4.523227649974917, 4.5980805732271195, 4.75756410183808, 4.753020096164026, 4.527397648699021, 4.843624551169717, 4.606122798020394};

static const float w3[16][12] = {
    {-3.1090238858447923, -2.8968413148589427, -3.6571762822877885, -3.221860496591363, -2.6966547639145317, -4.0343275053887835, -2.6877563211870377, -2.474218647065268, -3.6240590372908277, -2.745987485668938, -3.695936770570258, -2.7115044193831435},
    {-0.1299160052477085, -0.6742714710134309, 0.2844656599595042, 0.4579782650935275, -0.05290120702916812, -0.52792991641415, 0.09220688188332157, 0.5735022490726208, -0.11618678836047791, -0.022933517187503697, 0.28819404765667966, 0.09347741963593931},
    {-3.163411694071222, -3.2218944065333863, -2.693997208693089, -3.202753345160895, -3.2032601830824343, -3.010995874402172, -3.345256904478499, -3.366171623301883, -3.6268906168960617, -3.3019393347151498, -3.5751768885603923, -3.431696679438262},
    {-3.0794516849922333, -4.204819353624993, -3.3853020418034485, -3.4816528423341313, -3.1990494913792267, -3.5239255547312096, -3.6185410406536316, -2.788195750211093, -2.9187388906199967, -3.4685255764503573, -3.2835838978891596, -3.3705070833006308},
    {-3.9467285130741336, -3.6046424898433, -3.0166256153693207, -2.697110508312746, -3.22709175970325, -3.3799969426306995, -3.0678625890408977, -3.006416791906833, -2.759068206311769, -3.632450304940646, -3.1354825400200443, -3.310382160174724},
    {-2.922768342935798, -3.2616505155696074, -3.7373808947286427, -2.739104231688107, -2.979393495395552, -3.612297902234803, -3.4367831217881633, -4.106285590753702, -2.6228506535782854, -3.100197054617622, -3.4428498119812923, -2.923233272501039},
    {-3.7890188445932327, -3.2718624916135464, -3.191326200101797, -3.419766916116616, -2.808094372291396, -3.2798417288378037, -3.9213454685976767, -3.2693654322047663, -3.0208373616552993, -3.4230442006180484, -3.6557626213887953, -3.0765400002935888},
    {-3.4125428018256745, -2.8798329799841604, -2.882005654579303, -2.8355885240288363, -3.126458071607728, -3.065626403435948, -2.9854077077314503, -2.8637460931885097, -3.7681454578529308, -2.962560285244337, -3.396915821738812, -3.3995985457581512},
    {-2.626046892097794, -2.660700332162891, -2.8041331927858666, -2.7794503536934987, -3.237528870446142, -2.7013067137635502, -2.249507613768767, -3.1193502642087303, -2.306437191076473, -2.9806782780700436, -2.2185994621176386, -3.4175922720085414},
    {-3.2460042993382583, -3.64569781457097, -3.1566877166125433, -4.093778231381896, -3.36572818320216, -3.2216507234094762, -3.110511442603843, -3.0759955869433253, -3.1153341096481366, -3.446679370752263, -2.7779726340339526, -3.4970083467909463},
    {-2.620810226145905, -2.9341625344704148, -3.809617314366681, -3.663271951131995, -3.3260505617371177, -2.8980112544226864, -3.2446375380347345, -3.258166750666777, -3.487160971452194, -3.3458650831279915, -3.012602452681359, -2.9270153668808554},
    {-3.4268763380630998, -3.5765322890890454, -3.3779753064455433, -3.443258330680586, -3.297888734863809, -3.49094237157507, -2.9688324988707446, -3.043867801428222, -3.1606026866299217, -3.377161157853178, -2.7022734073100185, -3.173928710878833},
    {-3.4286852467287723, -3.0355057910954395, -3.316166204474602, -3.6690782244790165, -2.963416864544688, -3.194498796987377, -2.7809643435875073, -3.3148241601395476, -3.3917882078226995, -2.8838245989174314, -3.353102624576736, -2.8227736357556914},
    {-2.960039349158309, -2.9737175990941482, -2.889279912406917, -3.0147777121052446, -2.450976559699229, -2.4874030683958863, -3.8381307906620847, -3.933177114733225, -3.609517711440247, -3.2861055381618622, -2.8516790433808614, -3.4576262481385625},
    {-2.9782933119038226, -2.6098426953843736, -3.1895384800621813, -2.6341460011026214, -3.83874373899873, -2.710129345555202, -3.014471235659193, -3.23906019809443, -2.901153108795359, -2.9769049148581006, -3.5459832390698316, -3.293983069637},
    {-3.153740346425383, -3.196837521723487, -2.940239990611818, -3.0369270388473986, -4.1149587447018705, -3.5380003458142095, -3.5054389481578228, -3.182000988572688, -3.6319345732921113, -3.022290354689635, -3.2701966169244394, -3.220521150491007}
};

static const float b3[12] = {-1.6493716633587905, -1.958143113726311, -1.1622686480236517, -2.009799622665045, -1.8819671750755154, -1.508552173969283, -1.995591283675606, -1.7992651081349051, -1.2457392735021622, -2.222473505168031, -1.8757953901372904, -1.557857675637765};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
