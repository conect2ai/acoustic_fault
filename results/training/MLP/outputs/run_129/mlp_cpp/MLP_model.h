#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.2518126571897767, 0.6409824233687594, 0.8235567868338571, -1.1007179955986324, 0.514802484319005, 0.9617067995549525, -1.2723458899651048, -1.1338502712669465, -0.921929023772594, -2.6151679970167105, 0.9543478112574203, -0.02662231247183518, 0.23139880951975875, -1.7572378638851185, 0.2689966018793869, 0.6395072498206029},
    {0.26090309116706895, 1.3059432205533923, -0.5226604072541694, 0.7264122846162727, -0.16982018825525969, -0.7375366892983386, 0.7478579175477984, 0.5229204085876723, 0.8105892298015038, 1.0078948163709855, 0.30969541317649135, -0.4136997943722315, -1.1086180816093494, -0.18935551128145628, -0.30411562859686236, -0.7861113744202359},
    {0.8562262402453826, 1.2302293323340558, -0.16416990808031587, 0.29547127077439944, -0.8415851930031958, -0.20564670260793216, 0.39748301460353613, 0.8333538572881571, -1.2887709536786751, 0.11505931856334084, -0.5372285780755439, 0.5129250523712008, -0.5727156074555844, -0.43093803741280134, -0.21360470441748222, 0.03046361011385569},
    {1.5435592161643503, 1.1200362279732943, -0.38501052711649764, 0.4697566283054212, -1.5393150721686, 1.049035052372665, -1.3596564157943716, -0.13273522652820943, 0.22817694277056255, -0.8114080169045175, -0.8528278855371216, -0.16671960400273944, 0.465362792106784, -0.7272542532115475, -0.30133141919714895, 0.7446062145734395},
    {-1.1264240607107059, 0.6052350933470299, -0.5376880908396245, 0.6808574286205678, -1.0644733514999893, -0.13489964333777563, 0.7051491673276546, 0.11409008464939327, -0.2630813918349707, -0.14089135298924915, -1.5366410963849657, -0.6722513499854809, 1.0866904847490184, 0.072623230792329, -0.07028591089316386, 1.0482277257554862},
    {0.1655044784270082, 0.22786096809093073, 0.3555637652654109, 1.5170567727426032, -1.1196847950968436, -0.210386763244062, 0.37656935842270545, 0.9029800019172541, 1.049756170437719, 0.25144986232389605, -1.1612667105869985, 0.6442936507318865, 1.4124179332371776, 1.124243452426513, 0.5941159456098012, 0.9533877424864072},
    {0.35141350759390483, 0.3325238316149568, 0.30193991819788796, 1.0604087579916048, -0.7140122168292757, 0.21483574769510386, -0.4834885754165058, 1.1969948016345227, 1.1117364742740985, 0.17544938812816674, -1.4746111949742071, 0.7289502818631944, 1.1089088984879916, 0.4328507913528336, 0.47616945855326415, 1.4249461926030764},
    {-1.2843500147404407, 0.7519376530062095, -0.3639558434979957, 0.4012321031516236, -0.7281045142682654, 0.274683396273972, -0.03636804712383731, 0.007086837964513968, -0.12506268328961945, 0.14291797226810932, -0.3247538535323912, -0.6560551902835348, -0.8069230604267604, -0.5765380702079999, -0.2570849842245597, 0.5776830576873373},
    {-0.21424285111716002, 1.6877845050216913, -0.36408093696538574, 0.4249494521373635, 0.2091541803178824, 0.42991920889641944, -0.6940684992328893, 0.35226274239027655, 0.3093549161635983, 0.602356049760586, -0.5301831084811951, 0.2611716425743195, -0.5873666761312366, -1.1534349748002233, 0.2165717139434624, 1.3290305774067805},
    {-0.053476960136736425, -0.13594138521663307, 0.8088610054371876, -0.17411009556851523, 1.2839147682575212, -0.7649228092315629, 0.1120852133061519, 0.48820974082042595, 1.6812335488466383, 0.9550675535865841, -0.02158640138183066, -0.39246743442503007, 0.09184427923710488, 0.7571223017203681, 0.521152599184301, -0.4296027539643175},
    {-0.818235292398615, -0.3289709829847327, 0.3289900637029064, -0.5116585537817118, -0.14061551495761238, 0.2081207488838939, -0.33681350867420745, 0.3265296881648069, 0.3756386229274587, 0.21960311187037257, -0.6782640802082189, -0.5688283797705499, 1.1462540295491206, -0.058563841198705696, 0.13588164563553648, -0.42533384105837796},
    {0.9002473454214206, 0.5799418724606419, -0.11241859531093867, 0.5719288814617937, 0.10010547498612227, -0.7458204254208337, -0.3510678734508855, 0.48408413086101537, -0.23058697101402584, -0.5286612784594255, 0.3330337287217809, 0.26369646546513414, -0.07682280294656872, -1.035923485385974, 0.7138168784193825, -0.936441252556788},
    {-0.8983849592139613, -0.5278223555280483, -0.6825079447487671, -0.08661787041160582, 0.8384563818349949, -0.6738910576014951, 0.6822786941946074, 0.7240884819359517, 0.12745028678346765, 1.0804762175085467, 0.6636517512938022, 1.0949582734075607, 0.10100896922417454, -0.18206841133421717, -0.5795497580834996, -0.39210738948173024},
    {1.057430050085376, 0.47253119264099086, 0.026022831765381702, 0.5512614232168564, -0.7681898976300385, 1.2872805744538744, -1.5488585460987558, 0.8529935202755796, 1.139195651201014, 0.39995001027927907, 0.24443804501089483, -0.1626735776505111, 0.7808925854335201, 0.6349158053187467, 0.6377574676385209, 0.48842789376669027},
    {0.5300155965756054, -0.6996821930166964, -0.013534736671593323, 0.8888209566005482, -0.6005071264016023, 1.41901905026741, -1.0949497947806526, 1.1421444267396614, -0.08710149753153336, -0.7879470293000127, 0.4849268562017287, 1.4420953108336465, 0.6705885438905721, -0.10555194654676125, 0.24129609149263662, 1.024852328645315},
    {-0.05376844800453231, -0.3862592325971986, -0.47647762394275045, 0.7718375714054586, 0.35750760908277096, 0.32355438832594424, -0.5546007995787943, 0.8652406684707242, 0.4952753897063242, 0.7575401137498415, 1.3105088244609915, 1.2526812044569648, -0.23044560203942213, 0.36459185240572656, -0.3631156310350919, 0.25617717516997945},
    {0.8625238075687465, 0.6189400261654919, 0.7752146728863213, 0.867506391347612, -0.8208116981134613, 1.5291743812849077, -1.1004500958977135, 0.7563032859799235, 1.3300299021770434, -0.14957320800056872, 0.2541663129265761, 0.11217284157840353, 0.8213307834640846, 1.3541277742013165, 0.7421889317554228, 1.2179731649116627},
    {0.5198520821201924, 0.6581393360238005, 0.3117220264499264, 0.5664017243012753, -0.4439483910214141, 0.44727009648225885, -0.4937720306062992, 0.7594931924109392, 0.9619445608796443, -0.04044455384600092, 0.18255269128265164, 0.2524239274339987, 0.6652970372748611, 0.7146500690622077, 0.4804760630578047, 0.8736848389838813},
    {0.22907129140944268, 0.8731476012591048, -0.5730016806180416, 0.7064837875888238, -0.30088215244627886, 0.6800769003074499, -0.48174122931655783, 0.33566787339645815, -0.22589295626082662, 0.33322524958287664, 0.6840680720495038, 0.037882916148846216, -0.2742378187860109, -0.13714753549257563, -0.07547533930649863, 0.6986391708679948},
    {-0.019230313484879254, 0.6426829244567575, 0.6235974943982859, 0.0887258496885068, -0.020819566280663553, 0.4631692708364228, -0.3266158980324975, -0.02271699441488783, 0.6825580509180622, -0.273591971182495, 0.2482313294803213, -0.9676863324214808, 0.7060699162196933, -0.272745244193368, -0.4697544298350699, -0.06545354304922124},
    {0.33430732932016016, 0.07404394790941449, -0.16859097066243306, 0.2759410768126712, -0.8760876020424025, 1.2273744371359163, -0.7111483343913516, -0.12171681664664247, -0.3949039360374719, -0.4265447549147942, 0.555121742208202, -0.5290944337206822, 0.24434601728501426, -0.21601138546358759, -0.5711880020354143, 0.4326439967324054},
    {-0.19624747117333377, -0.5815384122454849, 0.4024613900706147, -0.05995640555211747, -0.36067433937732357, 1.2924480994327154, -1.084350907547772, -0.11306846852305212, 0.84160237017215, 0.017175024709317203, 0.281174913245316, -1.168078313129272, 0.22229304987998288, 0.7850232926773772, 0.11739122080815037, 0.3946374864987421},
    {0.2531826058724, -0.46865573095833735, -0.22136105576373025, -0.3251814887468702, -0.6363299430387473, 0.8097111650626295, -0.6158728798526207, 0.5783910894205981, -0.7675338027298851, 0.10919917655098126, 0.8577248328825735, 0.4481130700145693, -0.4180116739284987, 0.4689789746718163, -0.31122251325541805, -0.309064231343132},
    {0.06156923252597488, -0.7238204108176708, 0.2938485463679065, -0.4153482566119664, -0.10609298359349692, 0.44904115673641215, 0.37690817883074373, -0.65218114295041, -0.26366866161308466, 0.38821074824986446, 0.835972861891609, -1.6177045981991913, -0.5743506255626302, 0.7229137609738873, -0.023302004534973254, -0.8847772557930714},
    {0.12179194650823658, 0.2624563854665731, 0.6630329479150342, -0.1743293554701051, -0.4884448734983466, 0.887133089873759, -0.3988597899283754, -0.156368682693502, -0.3601336779697696, -0.5474720394127607, -0.03342824978179169, -0.8113433116999672, 0.5592392944977816, 0.22606007602942613, 0.376077127421274, -0.12908903996250892},
    {0.5670564223415012, 0.32862197307811164, 0.4602032143391959, -0.90423479753219, 0.18637505674641863, 0.3666396588823696, -0.04377655163095199, -0.8006996025767273, -0.7933900881605305, -0.26861018953906673, 0.7111852410833007, -0.9529687923314902, -0.00750846778285674, -0.2213015557524144, 0.28132622294961196, -0.11466370467716437},
    {0.3803207607396603, -1.3628992552676067, 0.48895431966693786, -1.0768797995963313, 0.24862216093651238, 0.07467182196306753, -0.34232680841772484, -0.7406850785875335, 0.19654502901717502, -0.6477942259755187, 0.3134907598757796, -0.8340415049981506, 0.39593326400899004, -0.028128625375645255, -0.5485671380701654, -0.8034470620853075},
    {0.06375496500184577, 0.09510897370754846, -0.3591377362844792, -0.5546856900517714, 0.3202844796949998, -0.1633942391990098, 0.48131029352079013, 0.10901735028082302, -0.756249726106659, 0.7460731451454675, 0.32365739328756943, -0.32401390447922523, 0.5593609574267898, -0.0035690842081087483, -0.06408151777330895, -0.4543704014479602},
    {1.0875229489105882, -0.3903329960113829, 0.6838706584390484, 0.1556574271290185, -0.7954395514660597, 0.5777969652514133, -0.30837028607492584, 0.33660933309926644, 0.32989847483559986, -0.4098331708921153, -0.26939697768750165, -1.1430418412565055, 0.6793531466839914, 0.8248566077753993, 0.455057984701355, -0.6530573398928259},
    {0.18916553074054074, -0.4402818838770329, -0.11202627187240535, 0.21083494176409856, -0.8074657850441157, -0.05151839073653711, -0.1890013600463477, 0.17710551026993013, -0.2558770973287679, -0.169341286520279, -0.3556839700727621, -0.6923184644566164, 0.36656393200146, 0.04184036836684922, 0.38259960502703705, -0.10101853955711303},
    {-0.16626499725102295, 0.12359109929801876, 0.9025939763461596, -0.9587465444911483, 0.8259090991433468, 0.674242911877713, -0.9163782995968913, -0.030415029934811585, 0.15770670066516884, -0.045928053902297046, 0.5274672584383254, 0.0536530523506147, 0.444221575394266, -0.02822861929064587, 0.17950447828760513, 0.40807888264369757},
    {0.10107668290056561, 0.6000407313852469, 1.0956967690267452, -0.901199995944377, 0.7057133205017823, 0.6594296643138435, -0.5769268544926812, 0.6542929848599932, -0.37769763640155896, 0.4437586977292853, 0.8696100040408343, -0.5021244626623454, -0.14665841291323015, -0.8500924201550147, 0.6869027072333682, 0.4454454990159809},
    {0.07785268834029961, 0.3966269216912251, 1.501436189718228, -0.7957946187646419, 0.9403524915215711, 0.6634114988807109, -0.17643368113210126, 0.8207648987678475, -0.28075186777838695, 0.6693567628156983, 0.6419007445255447, 0.36036181037251164, -0.037424949845125594, 0.6175914532218306, 0.9571319788306468, 0.3881048042577431},
    {-0.1252979672729953, -0.1792693587442058, 0.9069577141401481, -0.8351570423124473, 0.6992176889787817, 0.14086793124683417, -0.08051932453421175, -0.02146940701531474, -0.16128189645134933, 0.3372497630255131, 0.4806415405987893, 0.3249448550423566, -0.4948512364012261, -0.0866752221267543, 1.0983738381963435, -0.019740700409454835},
    {-0.008212140314571742, 0.19133808947651265, 0.7648936643612032, -0.27480575355501213, 0.5596219282785121, 0.19627862709140298, -0.20897494628557328, 0.5254858552814671, -0.140632958205605, 0.10988102411319817, 0.17873500820239746, 0.08059024208995123, 0.631589014145158, 0.30772672578666604, 0.6080746920611635, 0.6126505447249361},
    {-0.004232427245178759, 0.028524094567466997, 0.98492919325981, -0.27337288421620926, 0.369526111626043, -0.012935468156674537, 0.11454294107098505, 0.5546851960041298, -0.056892709903104494, 0.05704207327238352, 0.13931192577425588, 0.12103965009974958, 0.13604719889791375, 0.2667204890429999, 0.6354429516628086, 0.16058233299624605},
    {0.03780929664264932, -0.12727856869453394, 0.9677863609315299, -0.25762404336587114, 0.5811982779721045, 0.21359458587440894, -0.015370866077165521, 0.6283099445788767, 0.0930511840149995, 0.06422055087602037, 0.37781123543608475, 0.4190678439976333, 0.2670025803592744, 0.47322690919368426, 0.870438070007792, 0.014704288339295919},
    {0.1889481223447123, -0.3342548206981961, 0.233044843987458, -0.07267744443456434, 0.2603679819436658, 0.23651443579682196, 0.12033767814848625, 0.6073099440160976, 0.07617653599750482, 0.03260106331199531, 0.234474901336459, 0.49079410504703885, 0.06050380399964664, 0.3637677932822326, 0.7515969246926242, 0.4886044856900034},
    {-0.030523671476436386, 0.1385037034631577, 0.504924906211486, -0.1200602303282421, -0.07006010392904446, 0.11465056042016407, -0.06553897192733159, 0.3369247994481895, -0.5323277297623161, 0.2561578185511119, 0.0011851964279492061, -0.19784925003301015, 0.31149878374225154, -0.08932674602705568, 0.5109781191959166, 0.43774174674480754},
    {-0.22530009371335769, 0.0420793670816954, 0.3017623863050679, 0.003237998144005181, -0.024752237761891168, -0.19437763527984658, -0.26942009572085346, -0.01845533788833492, -0.17532218983431042, -0.002132601138406803, -0.18503033603094093, -0.11905623165818505, -0.5414634599121485, 0.07071171405443599, -0.016134088822092177, -0.004145739630445877},
    {-0.18107036451890654, -0.019513575958997904, -0.10034691803754545, -0.24892031099489373, -0.28928168155219763, -0.4369989731802404, 0.10265509861360901, -0.24786815027540163, 0.15668051015072723, -0.17899773520625012, -0.28185215298859595, 0.21048275512902043, -0.06237357493832506, -0.40408341912322915, -0.024010568851357165, -0.6072160523338382},
    {-0.007940253605824031, -0.1590524318343806, 0.052955791610919296, -0.3224328915758135, 0.6262399487860185, 0.24841369426007767, 0.012576726004571314, -0.2392535393489324, -0.14301435281971384, -0.07785189149869742, 0.7196939728978116, 0.2755480044205271, -0.24048634965650167, 0.4040596577343163, 0.0249811962752531, -0.06652699747294327},
    {0.15740107376425924, 0.1517838230572181, 0.04455172709294316, -0.1028944128244872, -0.42388004262274137, 0.0893937092958206, -0.33155868430425195, -0.3107566900197139, 0.28369417342603365, -0.35187576250585284, -0.34639448590428623, -0.03536901769459502, -0.5260425646013172, -0.3548275272521498, 0.3550604114619031, -0.3964143745816987},
    {-0.2763041406876225, -0.3440337451435236, -0.26228461342934806, -0.4187319635779774, 0.14612556761059758, -0.13438436329565806, -0.2952933653750793, 0.07598374247157297, -0.44339687394388533, -0.020149526677718077, -0.44307671927513537, -0.10655319716336936, -0.6273238062092024, -0.3296512416207011, -0.033321948481705166, -0.03487746047991889},
    {-0.12427511107455859, 0.3058676704138401, 0.2234204914945314, -0.028151402324889673, 0.5826849395468406, 0.24546712617982874, -0.1513069836706745, 0.19177239986403855, -0.45232259604882386, 0.20079485993438723, 0.0022140519535860373, -0.28224809278195795, -0.5039166478179771, 0.1013440616002226, 0.3634659264560261, 0.422324990308121},
    {0.3026060377323445, 0.09099824339778105, 0.4579416518608231, -0.08161061089495344, 0.1800418658674771, 0.225985537917596, 0.10227857198057412, 0.15398754144962343, -0.20002617764838257, 0.17534825358564926, 0.1888541222256844, -0.0497494906202312, -0.22601724543357252, 0.36863255112232945, 0.4716504227282602, 0.4060213400511753},
    {0.01223050769131057, 0.01487795676302683, 0.07620326201591958, 0.11121929143359328, -0.441970436864865, -0.08726628017654148, -0.09628792713617682, -0.20833334668177825, -0.6435264348243885, -0.07974107008614234, -0.26372670781786495, -0.01997631003382247, -0.21232173477621574, 0.00048459586292510864, -0.3634748530607184, 0.0023038891060047006},
    {-0.44013606494934465, 0.00917432995595336, -0.011348860753668463, -0.31518346157955474, -0.4239162816229814, -0.16200271166436975, -0.09512425834769324, -0.352859900131863, -0.15925005203221632, 0.10329171833751505, -0.09290199636068101, 0.24052633610300755, 0.004628822650932619, 0.006552868484827387, -0.032550843981747964, -0.04417598250698586},
    {0.11217578817995545, 0.36915934065969896, 0.15026990470946122, -0.20361653748087902, -0.12938096531118856, -0.12739352263707351, 0.1174442702181422, 0.0019457940583357792, 0.03949663606432035, 0.28486777993940454, 0.23871363445511082, 0.03381706028185196, -0.32194314759895387, -0.042206466456745674, 0.3515954407263064, -0.14274033324297342},
    {-0.26313974410401986, 0.04752328398899983, -0.14450198531372924, 0.27417035941141843, -0.35143443242336864, -0.13102204086127042, 0.2681287384414734, -0.3734158223222933, -0.36042219157849287, -0.10706274295446376, 0.2047169944243995, 0.541418716091418, 0.09162107122639894, 0.36967398726082107, -0.22052837723982804, 0.08569322352221956},
    {0.1269564555046656, 0.2720488171457353, -0.23507363994847047, 0.5569850998137326, 0.035637142429341094, 0.19862706375167907, 0.07481103011687897, 0.0007266365639532471, -0.17056582866077064, 0.15036268179030968, 0.38467818607953236, 0.6467326243466455, 0.1804726398522767, 0.3073412594854039, 0.30356775871740754, 0.026932830308222865},
    {0.15203781006347175, 0.45817989534299974, 0.23794098559162455, 0.24198013962667259, -0.1481942678172719, 0.1764126174290285, 0.5359115361290142, 0.3517474262251857, 0.22621804848172306, 0.20363959926643999, 0.46997739289582147, 0.3481748474356596, 0.07590543593350746, 0.6909680885250682, 0.4398663882298565, 0.7328735784914225},
    {0.04667407677765296, 0.11637217640243361, 0.2531632408153855, -0.12446389559060046, 0.10093499115364582, 0.2505128459112719, -0.2058513599814653, 0.3406967753069368, 0.04754759234137598, -0.03353705114370444, -0.3823554297714812, 0.033226659564314795, 0.10637340044801076, 0.14382513522413082, 0.14973701412246318, -0.06592998660548773},
    {0.09186207747602734, 0.03508556895464384, 0.10378968742717266, -0.020670027232946475, -0.06135586987184266, -0.003020718635610892, -0.0027388641910253363, 0.24913103670289774, 0.3789223777532634, 0.08808297575309906, 0.0025687815947114806, 0.29189641163364466, -0.20436725235969933, 0.42787463925421265, 0.5695134424984417, -0.14709819553501696},
    {0.2056054070245549, 0.17846440123646187, -0.6068816177187331, 0.12833468479028415, -0.44834573922801146, 0.06809990368112995, 0.03544071675691824, 0.10321805427520456, -0.15756288166158097, -0.07710865233248479, 0.03284026619588583, -0.012975196854124092, 0.31365123329969263, -0.02919560946105002, -0.30545507756963547, -0.06106713652011413},
    {-0.1808523279328184, 0.4968664214945973, 0.12980558182719687, -0.23639466318740562, 0.17927809303996328, 0.11404478492859152, -0.054411658059007606, -0.04062406724717408, 0.13603885333038065, 0.37987422279891153, -0.13333205635228748, -0.15598921626811288, 0.01621161416615989, 0.1553208071314286, 0.09377195348010221, 0.2468392829058294},
    {0.25347709819330205, 0.013132710665371434, 0.3029590046690565, 0.16308415428752573, 0.0031312277781455366, -0.020049379542520073, -0.3983772656200059, -0.10753918290676895, 0.1690665920132456, 0.03896197032916309, 0.2140465270181399, 0.29990439282368486, -0.08066303843602839, 0.26541252531406734, 0.625951262703891, -0.08412090426109785},
    {0.19336758236940513, 0.04291862131369698, -0.35394932755301367, 0.23485051136563936, -0.3118032709043388, -0.32827036719040925, 0.23058278659943196, 0.023158619180943682, 0.06376228109208369, -0.10746437482809264, -0.19580845389038035, -0.11111251084876436, 0.7384705110337872, -0.27453247492562316, -0.18615632552711958, -0.45051998846906083},
    {0.34810765142175903, 0.07211555682816934, 0.7174189391279643, 0.6469336575870152, -0.05709491956682021, 0.24195556167743942, 0.27856549959674276, 0.34105990794490165, 0.40185957275850037, -0.29946689953515365, -0.09984319377380492, 0.07171565832163104, 0.0917512162423618, 0.237445107176811, 0.5158680521055417, 0.17171414706909252},
    {0.2950880820459227, 0.30445530459659903, 0.17563648999883305, 0.23717160365989143, -0.5172519804734453, 0.16917917595040216, 0.29960438241518167, 0.15038694084265455, 0.4152043851246876, -0.0810976200400416, 0.097357772921232, -0.012233401158705881, 0.08983713333081148, 0.2124366805188766, 0.3978191464575593, 0.5103836786032196},
    {-0.2589748475636818, -0.06593636763737981, -0.307388674495095, 0.2716218470268144, -0.4043966624014999, -0.1915658000517212, -0.3509894560186284, 0.3978264194839645, 0.06718374457641041, 0.030656514607826226, 0.19429732599291863, -0.3978932042925748, 0.022344830081447047, -0.36951584111917823, 0.30299888096517114, 0.2620743165665021},
    {-0.02871208269600782, 0.0605523961871557, -0.31413476397142936, 0.2653715975681144, -0.19819762315534592, -0.19755997861512262, 0.2927070139265884, -0.007717093132548278, 0.06036842672841745, 0.09635771690846, -0.3111165079907432, -0.0122243139207158, 0.37598226593366085, -0.24944492912037047, -0.1403681398287367, 0.26695196554284817},
    {0.40361989306604845, 0.0059067727252774755, -0.2274263699406809, 0.29730153370189294, -0.053844921263595656, 0.0005840013595464855, 0.367738141938617, 0.11854958757960615, 0.03552969023091307, -0.10635866366147724, 0.00993352093676426, 0.02734498200470399, 0.6375488465626049, -0.023362511144622334, -0.17060755553341142, -0.1450273872001192},
    {-0.18031413208682787, 0.006934087345781144, 0.20405811606803248, -0.05115722763987978, 0.19667921436516386, 0.0053737467945409, 0.23987399827702321, -0.18161323518558692, -0.13385744778531736, 0.13426526524044213, -0.10820975080544096, -0.19085597977268326, -0.010264358691782141, 0.013072373798234381, -0.5532764423075274, -0.11012510529017193},
    {0.04148800879836124, -0.19662623207704114, 0.5221721523404944, 0.1933770837188928, -0.20889254863404347, 0.21342534622453452, -0.20367504533914635, -0.18548018531406543, -0.1519061219974349, -0.23225482156028715, 0.15913108271656629, 0.12898529637833273, -0.2724932797705886, 0.01054274276542197, 0.2529352147837495, -0.1361473024003923},
    {-0.10210738811215563, -0.05967347425429632, 0.08778312567634208, -0.22235850643927846, 0.04419340248091572, -0.19947979937852567, -0.0673950441270948, 0.04525602481846482, -0.313205617122391, -0.10774562060638097, -0.5085658884415629, -0.33788443954650105, -0.48629657294590345, -0.07729917902166962, -0.24953254780269954, 0.14697826335857198},
    {-0.008078516562030146, 0.054236535142861815, 0.27830089211522596, 0.0803752825901971, 0.4927536493172511, 0.1877279941224448, 0.1187531916913187, 0.19396638201160887, 0.06954428070589659, -0.047706390453742586, -0.1253444257363983, -0.03719995774833782, -0.37040366527826946, 0.09470151117297707, -0.032428672516065474, -0.1749213007463105},
    {-0.2876335961398893, -0.2568898079434436, -0.33392997870395413, -0.4809376545914494, -0.04269034750832131, -0.35847894344010833, -0.31189602271349165, -0.5886419554378355, -0.1891760297167178, -0.278635573442078, -0.3928266901506897, 0.17133506274397697, -0.6418157587062524, -0.2748426574509687, -0.14827704906456118, -0.28037655991383537},
    {-0.0689005702415213, 0.052398322372406554, -0.25484929148456026, -0.3368376768729096, -0.25411593814111194, -0.018500308622410467, -0.0030220226277298035, -0.06416629135589003, -0.1874025181273803, -0.24484843692747965, -0.1470326849875392, 0.055714275484313916, -0.4783191124092915, -0.11843723321411495, -0.38899589819501373, -0.07552340866532654},
    {-0.32397461843858055, -0.05707610685971098, 0.3693933059310561, -0.36630702278836524, -0.023964160312038317, 0.19510481920990866, 0.20225589448081402, -0.10970983905889183, 0.17019109437948773, 0.10691083739481862, 0.17254596827372717, 0.30766986778608385, -0.28088831507581996, 0.1431151835220284, 0.0667503598239686, 0.3442626680577633},
    {0.18685047161789442, 0.07277799050927813, 0.2617781287543047, -0.21293948343739366, 0.051966388451381254, 0.21390751946399858, 0.1805677120379702, -0.2672226552929984, 0.08615474095278018, -0.08602790988234364, -0.3157529967395223, 0.21336678217574942, -0.09791161425907594, -0.0023762249869777726, -0.04133759103093441, -0.04193117316580926},
    {0.03393027264923199, 0.25661885194054385, 0.3237144544862471, -0.17798303580640895, 0.31685715484307747, 0.16513493144441058, 0.022715990655899784, 0.37599599097481, -0.1215736151260149, 0.09388143813578684, -0.15222355491394743, -0.07874306463914651, 0.21080189584680364, -0.16841755991812687, -0.2752296644266054, 0.04712072527690339},
    {-0.21353317590491588, 0.13704011616401054, -0.40445926680972977, -0.21940121137772306, -0.0335540818612783, -0.015161700438899845, 0.03599617260485884, 0.15570071808656347, -0.1791144215947327, -0.015895417561307242, -0.3248216387355657, -0.29070064277840374, -0.29875645935603706, -0.10887738290347004, -0.3344660489239604, 0.061448210059735116},
    {0.03609714930943881, 0.12951896644943667, 0.449557925839347, -0.11903729263062343, 0.534513096032965, 0.20032180852302894, -0.05090227134682895, 0.40392927076529794, 0.052756025199122855, -0.11817082425894276, 0.14491906277604372, 0.2788486826471342, -0.3004598532643986, 0.3928974042325124, 0.37183123559443815, 0.5166052424375501},
    {0.022592593195610768, 0.1203389715712427, -0.21443945303887102, -0.08297739251947954, -0.2224099430410519, 0.2608462781469725, -0.3151862777300541, -0.09852491487527064, 0.30699722179984934, -0.24963201054862055, -0.3948357068091329, -0.28057517071306803, -0.18070548688353585, -0.28731335346350506, -0.2630057548242371, -0.23053040541326544},
    {-0.14492807522661708, 0.054761385041763436, 0.13104518066933124, -0.005409464150580319, 0.5589177309966081, 0.05980680792149497, -0.3310122113025229, 0.023985746270839353, -0.037750366342293604, 0.12299960561549202, 0.15989547939477236, 0.22137950456066402, 0.17288758078577013, 0.1279156759022958, -0.010122541155164822, -0.19329237605559663},
    {0.14186989499524938, -0.0811170518214933, 0.31139865971800784, -0.09408147335413489, 0.063710433803911, 0.11672201661803987, -0.2202538522901876, -0.11237407544599837, 0.026102406282326428, -0.07470278811008238, 0.1908657785305487, 0.20881054789692766, -0.12908866813440234, 0.19764026289450526, 0.5762745753755119, 0.21477437499084512},
    {0.28644253330486674, -0.14312245389383657, 0.05735751069300591, -0.0701446812454512, 0.03728922180345838, 0.06257952759359761, -0.2246454150478462, 0.0887724858146468, 0.10212130858750894, -0.11612758834173142, -0.0868213169474552, -0.2734474546124269, 0.12219813295663357, 0.14518741922602624, 0.38737859882424774, 0.02708580154447721},
    {0.3076459482379556, -0.14807129713389305, -0.04092369727289601, 0.12947472655271328, 0.08342825042132417, -0.049308503078885436, -0.1758113085027459, -0.40769432911439923, -0.10932057611858342, -0.13141106526524202, 0.027712629831557877, 0.030890618604898286, 0.16749239789282513, 0.04896351044834751, -0.39883765503183033, 0.13045288830700744},
    {0.4218524109010853, 0.07211306262533926, 0.09882950348028863, 0.43327920563693134, 0.6967359183887664, 0.17521645010439058, 0.16239075459382185, -0.016815140808732486, -0.1436864460799964, 0.2847736539000878, 0.6581680016609731, 0.255292109386214, 0.3553792691947362, 0.21409862637513252, 0.09941258733493005, 0.16181679597251564},
    {-0.2094143213888014, 0.074631529169644, -0.0054055875486314735, -0.346530096902834, 0.12831816944298863, -0.10212419365999849, -0.3862823112062858, 0.26806388024379824, -0.17198417019913656, 0.25690764173222014, -0.07456437597931559, -0.06416735814618789, -0.21314108228002088, -0.07207860590811152, 0.31633159911118186, -0.27257161985569706},
    {-0.24827511906815586, -0.2794615971445748, 0.051354932750514795, -0.3399626131507957, -0.33959063854554083, -0.11492868105129532, -0.05798852009387389, 0.2094872230987897, -0.15500952024229026, -0.27987872081089243, -0.05315494716207862, 0.21280322683068298, -0.36853748066753794, -0.1923784009986319, -0.18030367428053276, -0.006843886970164817},
    {-0.11772671899014896, -0.09754299877297876, 0.10625139411322314, -0.10251198611765987, 0.17130556038228692, 0.3126979035685789, 0.11943324588188274, 0.668202812551551, 0.12635803077131713, -0.028692778545742547, 0.18856222327498312, -0.05984481643344648, -0.4543497147772131, -0.0007301603494678473, 0.04832441093703349, 0.3416232133483114},
    {-0.05264171563793885, -0.18084279365201839, 0.05067116120750544, -0.05567372667036758, 0.0013612648613127948, 0.05831343903295524, 0.049158550398876205, -0.3887733204886333, 0.07882627847120757, -0.1027934348382354, -0.15042637465776101, -0.04670481260770208, 0.13707054098823201, -0.09535206699149366, 0.05743184351768662, -0.17333337995440873},
    {0.06900223461317903, -0.1571626947695588, 0.2958807313118879, 0.3100611740610178, 0.11378280948095101, 0.22694224216183395, 0.09801502306582942, -0.11020227790957525, 0.15480587361485457, 0.2893641764710055, 0.19066734857219544, 0.05933016229170531, 0.0653937819326471, 0.0696340729062314, 0.5519807001107127, -0.05517905566046213},
    {-0.41453729267412803, 0.018628141853982493, 0.09972392327920732, -0.12005628200131184, 0.3125143599903714, 0.06989513226309232, 0.019373219967226837, 0.014547792168458187, -0.2718584602447795, -0.01197697662560878, -0.054372497907270494, 0.15025254355388754, -0.4887836701436585, 0.12270647234767093, 0.36340608693636434, 0.30237093760455824},
    {-0.41199078102002834, -0.055334401905407414, -0.343160886082313, -0.5394931050464329, -0.20889873709820106, -0.15682805467846983, 0.2083357527699432, -0.4148305533554044, -0.026522402883633077, -0.19945543009179836, -0.2754964207531273, -0.017532803568519457, -0.35863093345225916, 0.05364546429776137, -0.3419488167924117, -0.26696802276932063},
    {-0.2121910744375649, -0.084443595359634, 0.08681399199279374, 0.27019846340860204, 0.16276804706374623, 0.19896101581436604, -0.0775686760624856, -0.14699694935820107, -0.3303990952173315, 0.018800066767330155, -0.07050075311507766, 0.09923679403298133, -0.4721346505962331, -0.04594525596149628, -0.15643416349757308, -0.5493763768788109},
    {-0.15913050220250105, 0.000600372250287508, 0.1879152521615689, -0.360310648725991, 0.13347640756528503, 0.009244750739388031, 0.20252736972664578, 0.19569874340314639, -0.04208538041966457, 0.10206593578574166, -0.12183609361593828, 0.25740643489679804, -0.3879094095397943, 0.11762264157566904, -0.42976330312453925, 0.06091051991735281},
    {-0.3858071812202669, -0.2850790012997976, -0.5098525301946013, -0.3681288702847631, -0.46470400001266166, -0.35058595049505664, -0.017271164086904465, 0.047341139808710624, -0.20458813199204198, -0.19744510336838655, -0.32897518619570254, -0.22890942911190246, -0.17925042107867992, -0.00936578531597175, -0.39618022597990643, 0.053422000621130374},
    {-0.5226531218894837, 0.3859494814560622, 1.1385888421654717, -0.058296562554927496, 0.6238969604006537, 0.4874448966404683, -0.4943337259103408, 0.28494013114091404, 1.1410305779391592, -0.15621041345195674, 0.668083898473607, -0.25409259571789305, 0.599417587852809, 0.473015379575069, 0.291696977688058, 0.3866182030350284},
    {0.5940404924634959, 0.2114573811136372, 1.1238596884476342, -0.0030294027180934476, 0.2724349494153927, 0.3522207151085491, -0.6171951969421859, 0.5902147925575277, 1.2672578260076668, -0.018908472737437086, 0.8282285430854388, -0.7324454622499624, -0.14752166029896324, -0.05016600549254207, 0.22484647576448838, 0.3784620261018816},
    {0.07624327161230016, 0.322185849736451, 1.1585032038975935, -0.16041320973970194, 1.0175905045908296, 0.5404836978836248, -0.4398308932386842, 0.25251164293821404, 0.1575067492923533, 0.5368338693141945, 0.7830363442318554, 0.12258147644609385, 0.3081463132051505, 0.45029711576529696, 0.9422915488471849, 0.5140399140100282},
    {-0.7269017399357164, 0.25707311794686033, 0.9534854801267657, -0.5534811890839257, 0.740648141447063, 0.3585131415358125, -0.307516604985773, -0.027073177416309737, 0.1531136245747701, 0.1673502668671449, 0.3135703821487683, 0.30054660085681245, -0.30498847098700116, 0.3320538957624896, 0.9745844713947971, -0.007581305050812956},
    {0.5005215775109851, 0.2880156057720124, 0.47722804034110355, 0.06989121641229128, 0.5915839783174494, 0.20928569946820333, -0.16635920348083433, 0.3299087091519058, 0.047410827273791915, 0.16945021708646368, 0.4828608589071477, -0.1042761117215821, 0.10296569795442595, 0.047329150936218575, 0.3538404382612965, 0.0175969954603473},
    {-0.14435913111635154, -0.00543631798496017, 0.5953997236362091, -0.28691836552656763, 0.3302031123085345, 0.31499270440565896, -0.05141237107231543, 0.4376386691531343, 0.19105690833643188, 0.0764700962482176, 0.38245303089174415, 0.15816729961220655, 0.11570538073081968, 0.4248125800117888, 0.8762586505974893, 0.39438748646642013},
    {0.0032929561483470244, 0.03415898517246922, 0.36503387760744693, 0.01863580890870428, -0.0911555177096997, 0.0706184084616594, -0.17800427209259162, 0.5034078241567055, 0.2961051293203914, 0.07416298729321456, -0.33896453019817463, -0.11334609408794867, -0.40321051291517074, -0.43287930467929003, 0.5466144139033042, -0.20293360465443439},
    {-0.05483648055573801, 0.05619576876459136, 0.46008967691156794, -0.006677929162341272, 0.060051924942640555, 0.356344778047145, 0.020160934923544708, 0.22505216067495704, 0.08148013822355304, -0.12395549355361851, -0.05249808271023811, -0.11398365033659369, -0.3550580418684849, 0.10019351783429467, 0.526082722966104, 0.3128241473261057},
    {0.061055726223184045, 0.14267738631414967, 0.5388150324959723, -0.22072137234468722, -0.39723392314140443, -0.028591953688756652, 0.05712056848742098, 0.564391300719008, 0.18912244395890318, 0.133891159353757, 0.3111474771782585, 0.09442076978657203, -0.005366711411356113, -0.09376669198581222, 0.28599110076073103, 0.4678580930515767},
    {0.03225293625102541, -0.12014016698677273, 0.8271149915850284, -0.11411442834604327, 0.4305267953586748, 0.22782371254294714, -0.1651276990044672, 0.35203230309308364, 0.0596479997282586, -0.2057613378284443, 0.23350726798241356, 0.10736033099793459, -0.6862502045964614, 0.24313668845802378, 0.34702765870907915, 0.30398886755787874},
    {-0.3145618350647549, 0.020515337364974996, 0.37035742421094137, -0.13028797716905946, -0.5158068348902646, -0.2995587612507566, 0.0009228189269931963, -0.5675633585196628, 0.16142616339088953, -0.31079546065666963, -0.5045816497971174, 0.0025016411738284384, 0.054403825111314065, -0.25003286870116703, -0.1080001652115227, -0.43797190195026964},
    {0.09301699441288658, 0.14681017482973047, -0.11069458829256731, -0.24170580058262608, 0.5038994068115984, 0.09124760787374508, -0.49834485282946034, -0.4189077678918641, -0.224976095720976, -0.21542443896199354, 0.29798849027108076, -0.07639286331425284, 0.1517015100664429, 0.05505878632927688, -0.12415186605976893, -0.4512936412706729},
    {-0.2061714724691188, -0.03493063542406612, 0.42006690974450306, -0.22225457899696138, -0.17710517111046586, 0.2242042188563732, 0.20075403989413523, -0.49923014515407166, 0.19791840776917194, -0.3865443126911633, -0.10329166698249743, 0.3537128805270294, -0.17821426486232816, 0.3158744033141259, 0.3128765886219664, 0.10498270553809846},
    {-0.06311767024206534, -0.3387383583815684, 0.4661371342473924, -0.27189006001308597, 0.16107493987731591, 0.08170651899767019, 0.03637698611365064, 0.37765443109139346, -0.023137833560468373, -0.07616425617792466, -0.09974428767584949, -0.4931492696799073, -0.3750435434933755, 0.09620165313618867, 0.030109686137317265, 0.09167048245660347},
    {-0.08723613072899465, -0.4450139198516043, 0.2712154473804494, 0.1416512166404254, 0.21089961902852591, 0.06954157892856726, -0.40642281517104845, 0.3470025758344749, 0.14798825611249875, -0.2632132674151437, -0.2248168456968766, -0.182910972040958, -0.25832606159206883, 0.02918187013604625, 0.3480152206790656, 0.14011392550762305},
    {-0.18889938952225074, -0.006367114524335619, 0.6499636520425257, 0.31256697580131687, 0.3342419573885835, 0.3856001857560743, 0.10046628726364153, 0.355733158084078, 0.35102885553457314, -0.0652799848755105, 0.23823684662655784, -0.1501289964605347, -0.337212780434626, -0.13945009594337435, 0.602940159701961, 0.3432673317365973},
    {0.11453274507853296, -0.011430535881174009, 0.13254016643883673, -0.4341888802774714, -0.5244048236787798, -0.40624812422268103, -0.27465495593504347, -0.0059784328036214945, 0.13379800644295953, -0.4762894550761008, -0.2122380889782228, -0.1891220247776717, -0.43094462082599416, -0.06023620788883445, -0.38938681488620186, -0.33008097543023557},
    {-0.16064892606562178, 0.021010996066416657, -0.24190904491694673, -0.25786043860907215, -0.40423068738258977, -0.3473264697872448, 0.09824601829234893, -0.4841150009478042, -0.05404641354271349, -0.2233795639283746, -0.49335093462956875, -0.12249260385780948, -0.09106691752939491, -0.22686529303477462, -0.4346452805137688, -0.5886433586368973},
    {0.22520181650202156, 0.04737829473817793, 1.0032234395877533, 0.07859319237268603, 0.2840118752803093, 0.5626286959700298, -0.08339808882406238, 0.384442191602651, 0.4629170901082664, -0.07430407608287148, -0.01080163084003245, 0.1337485512017415, -0.20989472026234893, 0.21027113877168796, 0.48412519945057314, 0.4275413660511038},
    {0.05744860513944419, 0.03294337330002705, 0.28359108648962267, -0.30588027379489574, -0.0722816868370647, -0.09981049353243997, 0.1551800970984461, -0.07282356555353779, -0.033502479903200454, -0.05499565917638655, 0.18845422468465767, -0.06736991670356852, -0.3414302082023562, 0.22055106002907776, -0.3408442865980167, -0.2883649419391042},
    {-0.0220944739549487, 0.15790698332998188, 0.3292171560630874, -0.028834946742472264, 0.3950763217306017, 0.12463778598349533, 0.6378377431452703, -0.19398796885676833, 0.22312379847570712, 0.11073646932606751, 0.16685888324560055, 0.2304843557426595, 0.18641893514176833, 0.33123664116039003, -0.052902682146482076, -0.09046347239202049},
    {-0.2420411935383068, 0.14793756713574635, 0.46291979991311455, 0.23425923209794833, 0.19284715454990636, 0.09115305695848683, 0.19058457142026095, 0.24614036090989116, 0.2942317563216191, 0.05263884066154913, 0.22877129837533516, 0.19914663534047086, 0.16759702957442, 0.33795242495985256, 0.4242722102398018, 0.5620123039630917},
    {-0.19054314203793846, 0.12125587384831228, 0.20496604107715174, -0.3741872246075046, 0.09646519819717449, 0.1565614636194831, -0.05648641884288182, -0.04520041988507032, 0.1488767998182816, -0.07950369172516894, 0.24637763498237872, 0.1542202142067864, -0.07411232125397549, 0.08158988013476663, 0.3916776403900904, -0.13656007165781364},
    {0.20530271587959067, 0.1719483561981457, 0.5657859728089901, -0.2554877732949276, 0.8710715672697277, 0.27070265060540577, -0.24063428326137637, -0.021285825622942584, 0.05803147792408556, 0.10005239083443049, 0.23587642527408673, 0.14776452178889257, -0.0973515947853125, 0.3944613178233544, 0.2234117417976907, 0.330665766527538},
    {-0.16160854214378523, 0.0647668657339019, -0.21474500487666898, -0.08688743171710198, -0.11821929349563938, -0.013055982244523012, -0.041823932054863025, -0.17402487602957067, 0.4294125829084108, 0.05840359593750642, -0.1155221425262809, -0.06132358484173564, 0.12457497019700933, -0.04005431449101196, -0.0349551057285385, -0.028000348124925422},
    {0.026904933457227786, 0.24830140115194965, -0.015580705820366827, -0.4372122458448464, 0.12487241094680483, -0.15881238024330363, 0.09100737145976055, 0.12867072093141926, -0.08294307206269058, -0.06462930428208762, -0.3081890618055856, 0.032777969293067075, 0.20713285378101326, 0.3940141566864459, -0.32219387911734526, -0.18277628781636435},
    {0.3062809741665923, 0.03470708315224728, 0.8712937858280396, -0.07818611958268724, 0.341063024609832, 0.06416959339878732, -0.24242334419729, -0.1492748387139498, 0.006344810925929263, -0.23831026137335654, 0.3646647453653128, 0.016621697396368526, 0.173777704187785, -0.22284060009304174, 0.5507668265681843, 0.0691284383073161},
    {0.1358669712699154, 0.021106998425110903, -0.327223970147491, 0.17109304592734292, -0.031195616750768637, -0.15019223132372816, -0.054294095786241704, 0.17112223943384056, 0.037821045750680723, 0.2855218974847628, -0.016239055462485687, -0.16642795171835315, 0.4400581998102475, -0.37365998907483994, 0.2607292322737331, -0.3189325238276466},
    {0.19319036909504464, -0.3198534284746894, 0.15750462033948046, 0.2143483368330996, -0.3953275126436669, -0.1562674693608086, 0.2591174902060803, -0.05158410664474696, 0.14985587755157936, -0.3089465475859307, -0.3616160727240254, -0.012208171693605552, -0.18984873852995354, 0.20593970835476008, -0.08493498773014926, 0.013421458585558533},
    {0.43780686183095846, -0.018042796735545097, -0.01468710601352546, 0.24159862660464648, -0.008799734281456834, 0.03717592132566694, 0.19549445816683314, 0.49206335098989323, 0.18141504330160899, 0.11678196298811437, -0.031019171062910304, 0.20139465698693296, -0.10428089339911943, -0.03415742006294341, 0.05116533142906762, 0.5042568008358974}
};

static const float b1[16] = {1.085807494297087, 1.2955497094495079, 1.6451631742271378, 1.2162485787805288, 1.7802083513540885, 1.4794404415839282, 1.4957641081409654, 1.4051663986124516, 1.4253859243948517, 1.1556641754323989, 1.6640338631809601, 1.6291489700062582, 1.4856239870991124, 1.5745574051209081, 1.483047158674213, 1.4659900989877077};

static const float w2[16][12] = {
    {-0.5637568103060162, -1.7898992119429067, 0.06535359869010055, -0.7283181272252038, -0.9275705151687539, -0.3759273662796108, -1.1473054369812044, -0.7752384859082392, -0.29765159090357446, -0.8346515885495398, -1.452228817182527, -0.011410472731472152},
    {-1.7956311991845686, -0.9798553244218231, -1.5314305498602763, -0.8128055564196138, -0.8967281314253632, -0.10981786945445499, 0.21237720751311182, -1.3250768143434348, -0.34352720680760285, -1.4635726402562412, -1.079703319797578, 0.8867788400485094},
    {-1.5337754041846587, -0.8311922591756438, -1.2113994029321464, -1.5749720628160204, -1.391799565475521, -1.0107911662244553, -0.8419305489415735, -1.9509290149631253, -0.7655274216750322, -1.3538460908194596, -0.5900734748946044, -1.095107221538351},
    {-0.9387495152357891, -0.6210225583781216, -1.1191839659489509, -1.0792461129559516, -0.16828868345944092, -0.4777338166315845, -0.7001998268020163, -1.0593511026193791, -1.460225125650445, -0.7964263187504899, -1.5826943688504953, -0.9378052778149847},
    {-0.9952899545744958, -1.2725114710810344, -1.4366871204358114, -0.5714353623686317, -1.3911951918807524, -1.047714809305436, -1.0830543601536746, -0.5905390655152573, -1.8317599376071598, -1.1430591237305772, -0.6959119766745302, -1.0296447364218617},
    {-1.065600025164662, -0.5748870241158411, -0.08557779053893487, -0.9790357581779862, -0.9084321753444199, -1.144831998643634, -0.07985211939207004, -1.5100936435897434, -0.12716298608931248, -1.090201493499091, -1.8031890647790951, -1.9061414613951952},
    {-1.604631800421801, -1.0739955085062458, -1.1823310201434747, -0.20196940033868369, -0.5499745991245109, -1.5435730821316889, -1.391778942580209, -0.3422146210593002, -0.8261682804808959, -1.1950431433808082, -0.22613682251145376, -0.5266156228212318},
    {-0.6975114616156505, -1.1062176281247005, -1.3450573910831716, -1.3291994643834983, -0.6760512762380558, -0.7413825622041238, -1.5653061868874207, -0.865772387023867, -0.727686310820037, -0.2361934843529435, -1.7780192103615111, -1.0092925344831662},
    {0.16212680972528956, 0.28144268188528065, -1.3595325473941269, -0.8816336474277088, -1.843011942555217, -0.24245072253305552, -1.8910031505274083, -1.1527698654602225, -0.7413825499736687, -2.0722858178170926, -0.19326507476943477, -1.6423162285119501},
    {0.10580057998530357, -1.8833746098058275, -0.7589577089181518, 0.4585904303789477, 0.03594485506302497, -0.7112029139412974, -0.945171319910721, -1.4649156627164395, -0.9975465267881625, -1.9038180833842597, -1.1691071167773877, -1.4684136723750185},
    {-1.5723592360522498, -0.6161320588514041, -1.784307911020688, -1.0195715959819123, -0.6308007828344989, -0.9710165216490184, -1.4929499314427646, -0.2713062837230214, -0.4052520826079394, -1.0825692964872724, -1.3979306663754087, -0.878264013970738},
    {-0.47582102345290717, -1.5284098124075396, -1.3769589447401493, -1.837436886673036, -0.4867245737109536, -0.4376268839745987, -0.5543458171564964, -0.039825492705510696, -1.0532897993920283, 0.4019400435777059, -1.6737744538088284, -0.9627765222725334},
    {-1.0434018257568487, -0.3960788482995317, -0.4717891205710025, -1.6271113711108216, -1.1533630458174076, -1.3030114902004957, -0.6864580497354924, -1.2391253487595961, -1.0826906007150168, -0.08124917980851985, -0.0452911359797446, -1.0891214945500718},
    {-0.08004411286718811, -0.5184508397503276, -0.3612579512448768, -1.0821076771588434, -0.26427319600761817, -1.3783988950076398, -1.8357711660541933, -1.7906329039941347, -1.3532535439074131, -0.7374157312825415, -0.077190127774048, -0.8881534121316403},
    {-1.3866034024120295, -1.2053372261669673, -0.4495508884065794, -0.7672312313201305, -0.8398098032022234, -1.161841621679952, -1.400884174278832, -1.2165238242690781, -1.5296903253870668, -0.9777469571299942, -0.9035538240875701, -0.43542245513594435},
    {-1.3567940050665788, -0.7128897395224939, -0.9338011485110285, -1.0041750885794563, -1.1570367483705863, -0.703453354680555, 0.028955727332707685, -0.9270904843200246, -1.2862223580656007, -0.7799731021262101, -0.8666953510291003, -1.6974258578421593}
};

static const float b2[12] = {-0.8441167720536638, -0.9064052788151566, -0.5787077825416597, -0.701697324105258, -0.6125947855818155, -0.6901523121528705, -0.5768866388328455, -0.6448478266365577, -0.6561509189742266, -0.4344923045868458, -0.1565669541195396, -0.570448945459082};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
