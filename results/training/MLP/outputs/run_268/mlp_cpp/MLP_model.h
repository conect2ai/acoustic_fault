#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-2.0182694472559777, -1.3721874237165144, 2.776983348602783, -2.422775628799447, -1.2630659090482927, -2.040078787028861, -1.0527194483311382, 2.020526576791978, -1.838921744487272, -2.0326955218662945, 3.256221474374084, -2.0943993840366275, 2.676618606838121, -1.7745150494486077, -2.1110485502929737, -1.6227487690557687, -1.5352013179079371, -1.858820549091841, 1.5232238618670229, -2.04664536243608, -1.6721965859062766, -2.3097240646361583, -1.5977434832787774, 2.6804515715310715, -1.8604371829905317, -1.713492750741764, 2.5441605977027857, -1.940531305132008, -1.0335904706983612, 2.0281002315037315, 3.3466556165357995, -2.4177505682818796},
    {-1.8118098802890037, -1.4198720819309874, 3.0339099077981264, -1.6426054972281074, -0.6543522513469162, -1.834943674883311, -0.6757931446353045, 3.060040327939995, -1.7581578110620475, -1.9850637239065858, 2.9600947799589425, -1.9437151167035427, 2.3243169270746886, -1.9335408931157745, -2.255448711024243, -0.8057733420217319, -2.747638852028294, -1.8069008127238488, 1.513713468156744, -2.1500597714212257, -1.6341802524681228, -2.1019197448626366, -1.7997033841063177, 1.6922968979853104, -1.634068438190082, -1.5932863016270937, 3.4253443892069297, -1.6791691107313036, 0.06121473593115025, 3.3297511976682403, 2.799073356436174, -2.939411092847571},
    {-2.3377957703434307, -2.0257698522130774, 4.00783379597787, -2.3422246118912486, -0.9960425874599478, -2.307115545873441, -0.3650114665553217, 3.347723935421671, -2.5465924541090135, -2.757648310977085, 4.280088377214993, -2.544399587082956, 3.7052792836676245, -2.2849597405316513, -2.7484265084222583, -1.1921923787293032, -2.28094761840605, -1.9820985349799667, 2.648422862665109, -2.211633320270918, -2.0034447633872805, -2.546221617323097, -2.459751509215821, 3.2311120305284335, -2.5255863279382766, -1.8535450036784324, 4.110080552316598, -2.3172753969145146, -0.2811133586566153, 3.7982251613117857, 4.474391438201138, -2.8417700836933792},
    {-3.0809631118274146, -3.068011068505566, 3.694861974614562, -3.672223793334775, -2.3913661014045062, -3.302430299438358, -1.2060883803704079, 2.981291106517369, -3.375216030809985, -3.287921705677992, 4.038406497085417, -3.576508283632588, 3.8584931476313127, -3.041345547591371, -3.335959672812058, -2.2831208219619397, -3.3455762328416396, -3.3170468868255987, 1.9770047153389343, -3.231269594656502, -2.5357675789256184, -3.330525297847053, -3.3322583263124987, 3.3720868073239316, -3.7207334743824827, -2.8754548502069355, 3.4805287016480206, -3.0426413279729445, -0.877529282185195, 2.6474923051136594, 4.180525182701843, -3.5076688121380672},
    {-3.449970640008207, -3.4587171882563963, 3.0928571525999717, -3.535426640466145, -2.4950555290731895, -3.4734778825684445, -1.2166721660695092, 2.407150617073305, -3.785116593541335, -3.886398978927427, 3.407770468800782, -3.952702757842739, 3.6217710789909225, -3.3048207951079287, -3.532300140905189, -2.6249649355351425, -3.409032740417787, -3.513841536379152, 2.4666179414112293, -3.6221434244602984, -3.4379417274842297, -3.7267880456347315, -3.459180110978848, 3.3714138663173894, -3.610615070960799, -3.2556442538193555, 2.9725444120169517, -3.6442594303115023, -1.5169188644982468, 2.532977885031826, 3.752180102863436, -3.969391684067634},
    {-3.7073561320038286, -3.252564367913062, 2.5478305151816367, -4.000661835900195, -2.507054043376255, -3.694323199349923, -1.1780001633647392, 1.9694713151183736, -3.7502631027127356, -3.694799526484781, 2.6034644565148457, -3.810273438903544, 3.06437313810923, -3.2574823856212305, -3.8457588343617695, -2.9956517166496917, -3.35873534725952, -3.581086491575515, 2.292992806276321, -3.560004935229132, -3.4369393574881437, -3.8237849368432775, -3.452684379022962, 3.1182778727218796, -3.7195719747953833, -3.60651527585725, 2.2269572873511483, -3.421438700039213, -1.7430145703590687, 1.8599427939467885, 3.204814347382831, -3.793402237333609},
    {-3.3105943286802115, -3.410656354311073, 1.9328642496288782, -3.4982899778277323, -2.587163500642932, -3.2672070658076238, -1.5855712119344834, 2.069292191493061, -3.4121786123931717, -3.572994406203818, 1.8009964127933518, -3.3499233645760036, 2.967707479180853, -3.1947847551696458, -3.7628516083906582, -2.6117476359924443, -3.1544578784473587, -3.273123027587318, 2.1778807080797375, -3.2461388162256126, -3.140219818962387, -3.5733220208308505, -3.0525173336008966, 2.904104651818318, -3.6954553522322375, -3.472377677344487, 1.9557857289596103, -3.061702723560664, -1.8259713552854442, 1.3794007777782873, 2.505301327761928, -3.857847549552558},
    {-3.877161583771916, -3.40345304477354, 1.871268913181483, -3.705064499147438, -2.8887352222069755, -3.568249169374485, -1.7799804740766192, 1.9506249934106215, -3.4880368293916435, -3.634949665165922, 2.1233535328699307, -3.7975793581262534, 2.821689322056484, -3.5180513745309283, -3.9440004485072437, -2.681995208033001, -3.519269220931467, -3.7703827247875803, 2.199497106117838, -3.7142408210157343, -3.466241899958204, -3.8057356773602704, -3.5796975768833628, 2.9525253117449908, -3.5184345294846646, -3.5028450901843735, 1.8082291056911974, -3.2470896266985902, -1.8932385969095735, 1.7382077636513018, 2.524896742483489, -3.8315178471913254},
    {-3.6221399857395524, -3.5266897891319613, 2.54529884887853, -3.819783317180383, -2.490357586175622, -3.486469648995118, -1.9759840707110328, 2.261893809935393, -3.4439646024219854, -3.525136251693134, 2.6779662817546566, -3.870968549764217, 3.20734495562099, -3.072966151287652, -4.066996383308905, -2.4711257749705866, -3.3666630666489654, -3.54446405580803, 1.618892422384394, -3.414093098417864, -3.151074109817564, -3.8208938484980437, -3.5927466247777176, 2.8242605246601333, -3.4394983361300775, -3.6642368130482876, 2.4912174528828244, -3.175761496654452, -1.6768734373563317, 1.772013086144136, 3.1263697892703286, -3.966572058942558},
    {-3.5354258815290884, -3.280097814913823, 2.9398667180459017, -3.367766722233975, -2.3819642242103414, -3.1985230412146675, -2.257061506909184, 2.8629765719018363, -3.227316812847805, -3.068169261672083, 2.940770807572758, -3.5332089298142386, 2.845106868864557, -3.1634619877150456, -3.511153154199868, -2.317442477205777, -3.489117789301171, -3.116313090848413, 1.7682826259965603, -3.560502058486799, -3.216194324974443, -3.4156974495183112, -3.1859245860905347, 2.59157516433622, -3.2862017925451252, -3.444483372481153, 3.274545024705368, -3.0374438182184544, -1.2639673668124631, 2.8152114883290094, 3.149640071407693, -4.003930547272556},
    {-3.385998731130268, -3.058140994081116, 2.3503088417116293, -3.104933313585888, -2.509095453655743, -3.3292843426325858, -2.225626868215724, 2.369149110056796, -3.3349888047387877, -3.2072251324336944, 2.4279803195405365, -3.267531026955052, 1.760369134981344, -2.981589911875793, -3.697595656828312, -2.4765452376865884, -3.549701864301696, -3.0308885244201056, 0.6973582387598286, -3.4969391847318714, -2.9329002377120026, -3.176715867305107, -3.264525843763782, 1.684326433669141, -3.261483774086611, -3.424062060445417, 3.1349394649500186, -2.9114237439987387, -1.0678504521230467, 2.7907792654091748, 2.263902052251023, -3.9345596059651418},
    {-3.531355730810264, -3.286356697163782, 2.0702210811482935, -2.9711034768769236, -2.719706178137449, -3.3369785051351144, -2.223992936248538, 2.1606249637116814, -3.4855821674066534, -3.2620421893004723, 2.5330678741194634, -3.301179310313591, 2.067706820907292, -3.320784571831688, -3.303275298523376, -2.18187669224633, -3.26922164706628, -3.123043380158596, 1.141962294839836, -3.4558239050096264, -3.1464510449583205, -3.1835472376223373, -3.3571958473303094, 1.8145337520490477, -3.3630552282465325, -3.252981551306069, 2.7199690432851265, -3.1412237736893744, -1.3030696966617368, 2.254165484854467, 1.7588467429703485, -3.732174100288999},
    {-3.531740343816278, -3.036336808675305, 2.450330961617289, -3.1495677209752326, -2.6803292901393783, -3.139857448233779, -2.300137764272553, 2.2970051304792842, -3.5580374425309325, -3.2805083773948707, 2.697650233473911, -3.5579104203010767, 2.383462199434875, -3.088246801316772, -3.1212170448477354, -1.8691075060560203, -3.2604439414974538, -2.9520390740245253, 1.3898982698677094, -3.1097120733503836, -3.1143212178927944, -3.212123840794268, -3.533728971381551, 2.0215933606880108, -2.9316203502778513, -3.09367345815805, 2.80406552966348, -3.307757414883695, -0.8494049058451068, 2.3855410210414387, 2.2089565241941793, -3.669708127550875},
    {-3.4606462844730825, -3.470751960012346, 2.5178808317044976, -3.1673705575272306, -2.7426497970138404, -3.3870238757967766, -2.044105836719864, 2.0732923677346187, -3.4130942696719373, -3.3320380644494554, 2.5313274725537083, -3.361276522837723, 2.323676651420642, -3.174224255795387, -3.5696379005638312, -2.1827856058020747, -3.505227407775114, -3.442626762415444, 0.8617867886245617, -3.3464388953848796, -2.9369239564227643, -3.2274180974534237, -3.49131335134147, 2.0214666176096094, -3.5555829084675445, -3.444728723602027, 2.8732139192150057, -3.4268916981614965, -1.2350788872149148, 2.6613988685300165, 2.403400491065857, -3.750031253564777},
    {-3.114874984291223, -3.3482513577423028, 2.777149820821041, -3.0183201845001904, -2.0701919299565605, -3.056090491745452, -1.6676136089321572, 2.520786597112107, -3.551622070628267, -3.1394190695419315, 2.80657828483731, -3.3361802444721715, 2.598261783376267, -2.8151340714306805, -3.4394133601832673, -2.042180104884105, -3.4975643714227753, -3.321276633862219, 1.4759658094482018, -3.2129183366109446, -2.923240218117503, -3.2558207744360375, -3.235682068071894, 2.538965793444739, -3.311421104724741, -3.1802353805119252, 3.1157989140479434, -3.1332580965278676, -1.0717070891160747, 2.7377533683246953, 2.5699915827526834, -3.907738450795214},
    {-3.187547413221861, -2.9405060342433194, 3.016112281131782, -3.461695647747437, -2.1431519551843414, -3.3084650618831204, -1.1760816773370613, 2.76629604720025, -3.4767617254575396, -3.606166144609671, 3.2083003588940757, -3.206618484335472, 3.1448992709949075, -3.0895777780040783, -3.531814087362399, -1.9515141989258589, -3.4973806669066327, -3.2081213148428285, 1.887081701760188, -3.4683003794759886, -2.962317315099296, -3.4255061786742957, -3.514078314092803, 3.1310965391347407, -3.2010242834666602, -3.2197775901880967, 2.948835564048906, -3.2810498887242003, -0.6247408920657279, 2.8161627172152865, 3.243048163301271, -3.9380914247369736},
    {-2.984033803657986, -2.874910045762098, 3.9620821000971156, -3.376795194724838, -1.8470353469357106, -3.0016450641171213, -0.9319116408688033, 3.3141980105936404, -3.376537432376292, -3.1357599067679818, 3.8676381518396465, -3.438583305893884, 3.7688954724747257, -2.7360701194308428, -3.3862801675923393, -1.733927958046955, -3.3478002046180664, -2.8037169275977245, 2.292104305297959, -2.965933451732723, -2.572109620832397, -3.372509997668926, -3.1548586029038077, 3.506841811205834, -3.2001479008818263, -2.7180470213301637, 3.6973509629042938, -2.428306729662392, -0.38813684856408887, 3.194316851029505, 3.775260067024692, -3.9250730630601405},
    {-2.7365694528901088, -2.327580319236404, 4.167109594579323, -2.588870215245949, -1.4958098103770692, -2.6317644811488448, -0.8141153977251276, 3.5674223255928803, -2.7779107614661056, -2.639683162118367, 4.205083574980768, -3.0804058113815147, 3.9416423568513226, -2.2412038232286493, -2.8110880821199586, -1.6888383541286496, -2.9982877071716856, -2.6115199981814827, 2.869672024254444, -2.6767956334857828, -2.393499448857913, -2.840320754453604, -2.790850400444512, 3.8102312318667146, -2.7023525927500383, -2.3657751117432144, 4.13128564230467, -2.471042112123105, -0.33148316996123034, 3.7494090663954767, 4.426291227639226, -3.404831158185551},
    {-2.6212882194189384, -2.623565143130765, 4.037517336702607, -2.716636137624234, -1.4892714002546528, -2.6418510936628214, -1.0311912355237438, 2.714201657836523, -2.912743016039259, -2.595325587234236, 4.053944223320534, -2.8744454713793406, 3.9871708109314286, -2.344906632964263, -2.813596138451114, -1.722532084709978, -2.546622016529147, -2.749598966972602, 2.9061394862305243, -2.717015867077008, -2.5898653741471955, -2.6439776132497115, -2.9522590856497333, 3.7045127545230594, -2.6925574912127197, -2.73860648154322, 3.545317131061797, -2.7491478970336676, -0.8365413921059376, 3.227732533182899, 4.122291969791163, -3.0883915912451174},
    {-3.1648318625159537, -2.8742560854540997, 3.570803306397078, -2.9872118717130687, -1.8571257150989837, -3.081049711468406, -1.149960207556075, 2.763937550687147, -3.2089858738845263, -3.1101297458195747, 3.9050223435472096, -3.301169374948616, 3.611868974918848, -3.091336327157242, -3.639578280134704, -1.8799481130133842, -2.9170792008346247, -2.696341821510317, 2.2049755977769725, -2.923806508447159, -2.89789715926574, -3.280859236330468, -3.0704336774575562, 3.2610028206279718, -3.060191657769611, -2.835338168981552, 3.61815170499853, -3.0438506380193275, -0.8541874707932642, 3.2825413075871426, 4.078911173221274, -3.647043601079208},
    {-3.1559797384955783, -2.769101572772048, 3.804334341876151, -3.0041341184681998, -1.5704250268598619, -3.166995463088451, -0.8741588882837699, 3.2437129573213515, -3.3172896691147558, -3.0260176193561805, 3.929149753938005, -3.0026012624031106, 3.613851707927995, -2.8849106616148665, -3.3165632722609937, -1.8362002245322293, -3.3382052202404195, -3.1027281230695647, 2.02044067379625, -2.953488153577174, -2.559393729378574, -3.325664617600535, -3.1035143137931347, 3.23044087665113, -3.1233903712336364, -2.9104009161938404, 3.7721530083793273, -2.9258588658834097, -0.049676970642219084, 3.5057069286077223, 4.074534648044867, -4.029126545110208},
    {-2.483818768271496, -2.2097211740458618, 4.169819759606911, -2.4456232948740038, -1.3582263595380555, -2.40083849558738, -0.741329714559227, 3.8553481199747734, -2.8335296105264485, -2.69591399390176, 4.487725254674185, -2.590728956005643, 4.074143865659759, -2.5425935592095796, -2.7561495342315148, -1.420042783123513, -2.8483208347218323, -2.6126594435711303, 2.998822898742841, -2.357553309285763, -2.278929744501509, -2.6819192137705516, -2.7390533389038763, 3.778406514035331, -2.8365493703106752, -2.470254545488414, 4.280432138865891, -2.7646080633852037, -0.06975026644413794, 3.922310748192859, 4.399794897244301, -3.3941762106441424},
    {-2.411651570092755, -1.7919723428223282, 4.405974606827576, -2.0102950428931003, -1.0896930158993416, -2.1564185449880258, -0.688117134682426, 4.075607271985828, -2.149942988910151, -2.277947498230442, 4.591757049411585, -2.0336395723737417, 4.285740866448059, -2.124541297089739, -2.2984526056717893, -1.160483588736467, -2.69255861401231, -2.008792052399041, 2.912415684925046, -2.16865467287781, -2.127625774163447, -2.560056497599395, -2.4517872830991174, 3.865866808796055, -2.332567722219961, -1.8366265816282847, 4.236746235177788, -2.288952640417771, 0.12402548656332184, 4.034961187503129, 4.627441545073889, -3.2318756903425574},
    {-2.656685411329023, -2.4732586604025655, 4.295771156053291, -2.4386821229404716, -1.800497124467391, -2.4029059311439074, -1.085743977440701, 3.729883346970908, -2.6808034274870964, -2.6808770502150505, 4.508349005875376, -2.7158393526437283, 3.937657872601503, -2.41277378389197, -2.710722404369241, -1.2873941371512583, -3.050696399896174, -2.686388792277034, 2.4620579709447963, -2.5200436847485586, -2.2992522111832843, -2.497946725113394, -2.963326349791019, 3.4225685931731844, -2.6666192425313175, -2.4067233169529594, 4.325012122508152, -2.6555369207035735, -0.08770140500296054, 3.9447449038718316, 4.210657391099852, -2.991839326313286},
    {-3.03793690168377, -2.310111886421296, 4.0480135238447765, -2.5503032516128328, -1.442767794078269, -3.0434939615379166, -0.7339439376286273, 3.2584364250910576, -2.8783351220259297, -2.777926711822753, 4.051675685453072, -2.887953039458972, 3.1580510794890673, -2.707962084430518, -2.925884191737294, -1.254219109446101, -2.990570921489858, -2.6367491383919948, 1.6757007774805797, -2.5923292170610077, -2.1250607115404603, -3.000779287696436, -2.860763018321213, 2.993126390461379, -2.8716778073160745, -2.363026488838097, 3.8668375821733156, -2.44180435028914, 0.2600755905988252, 3.871200397778286, 3.8775582563643223, -3.487689912376863},
    {-2.802364534189663, -2.3548449933284186, 3.9863952112735124, -2.375137991337251, -1.646122777800887, -2.4443522256355417, -0.9819272334821629, 3.1595562896822784, -2.601100911282234, -2.6882685131505197, 4.326027263257097, -2.4527323371361027, 3.830941230015325, -2.6307995112103955, -2.7760574268233755, -1.645321570144468, -2.8998233335005845, -2.4029716717188108, 2.145181918183842, -2.4012777711323574, -2.3579970171293554, -2.5655467347308396, -2.573350685486505, 3.242689190012712, -2.808964957320879, -2.39096449287629, 3.893268426855422, -2.803480169231356, -0.04364337846651928, 3.5905260690283884, 4.016061898006751, -3.5013226777252777},
    {-2.5750907797359717, -2.512468048428374, 4.130340829106131, -2.236665352630444, -1.448596354887403, -2.4073255552967856, -0.7794844975930705, 3.4791291518175433, -2.6748239278915844, -2.736025074947171, 4.310976782130176, -2.8524376492716663, 3.7816438667979524, -2.4877253432563577, -2.9176035740016943, -1.3719280673952183, -2.629308264972165, -2.468778666696528, 2.688419535864645, -2.4402586603518817, -2.211558884233002, -2.8557530262236503, -2.793505942542829, 3.5708134176207222, -2.7531615182332665, -2.102799919727071, 4.072151735389438, -2.476867519358939, -0.13094292630053392, 4.287105526295656, 4.018422405784853, -3.4195931902054286},
    {-2.9969430273807998, -2.5122976841828604, 3.9141075671400998, -2.437759853868039, -1.6920806594712499, -2.789272233701113, -0.8375198876767435, 3.6740688898896168, -2.990344702631404, -2.8726063826652677, 4.147739759957042, -2.6426488229226943, 3.905755427857635, -2.6181402211265667, -2.95663785828794, -1.4550466157590498, -3.190145200988717, -2.6859367075949696, 2.7061375088933755, -2.82329004024042, -2.5287032478705447, -2.7700111046668137, -2.972200078687697, 3.7631828505724347, -2.9882394452669603, -2.6274236147898806, 4.208708166174433, -2.8575450617099043, -0.10121017249563509, 3.708922110409584, 4.198114774992335, -3.3920500553109822},
    {-2.720117789673711, -2.176872760539857, 4.157158723205841, -2.219013273741231, -1.4574645474987122, -2.2973114422440255, -0.860433857345871, 3.701352041630168, -2.7568689154245423, -2.6510425343668698, 4.24567483706402, -2.561277947991203, 3.5113171675291324, -2.5122529309679655, -2.7156481624636677, -1.3784688523317514, -3.1332733303144087, -2.583471172851131, 2.294408740971815, -2.597682903503441, -2.1753646081224387, -2.543305509359106, -2.696725090376337, 3.053515238686051, -2.5850501942409148, -2.494929602545011, 4.112272310991743, -2.39906680069438, 0.11468098269964526, 3.9153158041947558, 4.061203929039688, -3.423227528696438},
    {-2.538521026293833, -2.0759341111603713, 4.050350467515632, -2.1398550334631654, -1.5276572356218376, -2.7101105574180813, -0.9414319664483233, 3.4375827560719556, -2.7065366982897703, -2.707814499558674, 4.21613001429639, -2.6770941255923972, 3.6562248340417556, -2.3715878530388346, -2.620305306401505, -1.1401681759017588, -3.2351220996311127, -2.3236383271271324, 2.1260387332802644, -2.4765014823861353, -2.0393465672787214, -2.6918813518942484, -2.910378723139041, 3.157764503325382, -2.6179134202415715, -2.1221557898187764, 4.015528515949661, -2.663464209403859, -0.0037632334048527992, 3.7110928636174405, 4.052911369697623, -3.232756066903204},
    {1.2184672625618462, 0.6606327478981889, -2.6528215958557513, 1.5939552353153654, 0.9082908515452331, 1.0053791656663045, -0.6467684850179666, -1.6758015898890442, 1.3476793365866087, 1.4605993603952998, -2.39953873392083, 1.3908758533127932, -1.6922360953876316, 1.4572254962853037, 1.1797122908417388, 0.5335630966807928, 2.1066438217316947, 0.6211544705180264, 0.8936545209419233, 1.312818877543273, 0.9384902412600105, 1.3674409013205537, 1.5481512098526746, -0.9071359374282943, 1.5409850304242683, 0.6075938700671593, -2.5647762872599453, 1.0289262317334984, -1.587087667506896, -1.8710295111871529, -1.6931067250716298, 1.5833637391319428},
    {-1.7695499943738509, -1.3661442949799756, 1.1728630209913922, -2.1116891790236694, -1.7398148920701235, -1.694261134266542, -1.227359129412182, 1.034628959615368, -1.7286111417839893, -1.8317981285941816, 1.0471782374512577, -2.182473848072972, 0.9003336168605721, -2.0556205514881802, -1.8569524406363016, -1.612033822759885, -2.0091253395862143, -2.0606232230195225, 0.36485868343860556, -1.9210850928366483, -2.0656234235359854, -2.1797550551857543, -1.3699426882346393, 0.9690623286239735, -2.021052265427714, -1.5537361852124991, 1.198916708460429, -1.3340058763439655, -1.441174532574796, 0.6431070781056601, 1.3691615653841491, -2.7710156675261404},
    {-1.6932962481976876, -2.1456354464037783, -1.6783422608377851, -2.341846425070377, -2.4636322000724378, -1.9532143807302116, -1.6459532936878423, -1.723313906516203, -1.7857315657710209, -2.208965131802096, -1.415712071152107, -2.557792862796408, -0.3153400137289164, -1.9127820230767767, -1.737199181794747, -2.2135837187463996, -0.8044678048931867, -2.015005164072007, -0.2781132084392733, -1.9854364550268555, -2.5319964120435476, -2.259023808145899, -1.3555487260176464, 0.30568772393256, -2.1601818949659837, -2.2360907635178093, -2.1599359152666, -2.2991343565975604, -2.798495448084844, -2.7538964655388205, -0.9912287283667605, -1.244303893000789},
    {-2.2026734606910177, -2.0127129837462725, -1.1745295304023575, -2.176325164571445, -2.293247896320908, -2.081613839398137, -2.1544330099901163, -1.0612970051768256, -1.705775929622605, -1.564939123299199, -0.4003296030436129, -2.080494445758108, -0.37867125830850323, -2.1914840988172464, -1.5795906680761955, -1.9318326877998184, -1.3450060713614564, -2.492265425416331, -0.3106619761043353, -1.8158744289081374, -2.0542978620852943, -1.8321212545549481, -1.8443251754521508, -0.13658091329232983, -1.9173636129560134, -2.2214544216818672, -1.3781920994354901, -2.0345662716205184, -2.471688758766671, -1.7944077511498098, -1.4093699353231062, -1.9101579772108142},
    {-3.0397445921111568, -2.5801316721768064, 0.43193782690968613, -2.9052839109531967, -2.516956491404325, -2.873761385629127, -1.8480647103681447, -0.2559491802790821, -2.422059384165579, -2.6607189181396755, 0.7891771592087987, -2.7487819284182824, 0.7977935268495376, -2.853110228156387, -2.453845362683871, -2.3279399175327273, -2.1583242951704, -2.6521456386821725, 0.5376536610068008, -2.581945709712994, -2.9234642517799103, -2.190627880726454, -2.3318436005145586, 0.8923876519424867, -2.344460790462918, -2.6332166678842355, -0.16862607550604952, -2.548030371598085, -2.065735890793053, -0.22547397996328325, 0.09594578256919022, -2.5523344518050375},
    {-2.6720117631833804, -2.9812542495706205, -0.8697717711173404, -3.0758650651421098, -2.806705847819473, -2.503488111086994, -2.1637681751614752, -1.1050362362585089, -2.325488725403217, -2.68239915689141, -1.1360950824020803, -2.9088453566446577, -0.33055646935539496, -2.79216196061317, -2.4241464585946932, -2.533615635555299, -1.7223414046125853, -2.6585438817044786, -0.12901963446523884, -2.312800807149685, -2.980255466191509, -2.231290741007532, -2.292702587484313, 0.548645296090976, -2.547495595688794, -2.826603565081869, -1.469710384561993, -2.5046946235223895, -2.6933476943182733, -1.483468578397896, -0.667147202974081, -2.4555597528685467},
    {-2.4608758424955406, -2.6673019130287288, -1.1379773179532748, -2.60396286945178, -2.717712916523166, -2.603407687971438, -2.0235223368620114, -0.8101038060918676, -2.3803369909997714, -2.7907807947287204, -0.9879219547130826, -2.3961276796919657, -0.15700483991480166, -2.862103253873058, -2.1257342179599377, -2.407194194846282, -1.4878948595808779, -2.7813401942869467, 0.0906902635101563, -2.4826382551409205, -2.7799377132682292, -2.3227707794149195, -2.036147263631465, 0.3674407312868503, -2.7063866703679498, -2.5560254445072044, -1.3456796809935134, -2.663341306668429, -2.7029509589675995, -1.281541299448032, -0.5650631170901658, -2.1448980994534272},
    {-2.341113759577117, -2.2287905124399305, -0.458561683743257, -2.4310146651235525, -2.8627529452826024, -2.7612851402253304, -1.870087657160715, -0.6676693564733427, -2.523282457061146, -2.6801938202188897, -0.4998110779231158, -2.4129247630851927, 0.09297229562923633, -2.743837163399349, -2.129507859923259, -2.663248991528218, -1.6356005165907304, -2.553677734604688, -0.3084565575294725, -2.6671548186896126, -2.675356834925799, -1.9191546124555745, -2.3333894206342194, 0.3102531322885002, -2.38191946510385, -2.561442124172056, -1.072973521891799, -2.6910289403733483, -2.7722644092804978, -1.2217902077475953, -0.6860008242830419, -2.158063359532056},
    {-2.578581669902763, -2.8274340589308373, -0.36157512802942865, -2.6159505734103625, -2.7076067056668784, -2.7062194899439174, -2.1130945398598877, -0.4081292231844879, -2.660256583817376, -2.741516435496313, -0.29589267051314055, -2.8612156166348455, 0.4084345366758886, -2.5322718840559904, -2.332608282927166, -3.220502608189931, -1.540905441404112, -2.610479454925124, 0.42581374533934624, -2.8570216499989614, -3.1427949843690093, -2.7755497836672176, -2.113855745321035, 1.1495997657403405, -2.605018986118742, -3.216712499765941, -0.5523343260198688, -2.4535666517463297, -2.699316260817421, -1.1374237111375438, -0.5383280944067843, -2.1892263415235873},
    {-2.9528294181075436, -2.6956131439085342, -0.793346251495854, -3.0380540657658432, -2.5085334400583013, -2.6081949866946292, -2.170362885816085, -0.3201510145144403, -2.3528794977021215, -2.5531011876784433, -0.619667105628596, -3.108650795997901, 0.8239220143753238, -2.7749987848678286, -2.611331038536538, -2.8825484510088804, -1.7130527925626482, -2.9615862539108395, 0.9085344021945374, -2.442769856404566, -3.069090858468575, -2.67241289837732, -2.136021672486637, 1.1466558430145788, -2.7385018719627627, -2.7388909829536714, -0.8742420504211693, -2.4638389243620447, -2.7685096207909092, -1.5160648985645657, -0.1419117927700964, -2.365117378701148},
    {-2.2383314320031307, -2.7608148722258177, -1.687022349960614, -2.3928333177934786, -2.9060204346646534, -2.3828293267788743, -2.4324146539038143, -0.9471679952969023, -2.170668244846892, -2.16952509609859, -0.9827811911701018, -2.5899884365820185, -1.065580611298417, -2.326713130028056, -1.9167128386109284, -2.4826184246769953, -1.4728396353759294, -2.373139418325003, -0.14217035066140993, -1.9551865057145317, -2.539311106637721, -2.174832409054888, -1.9954677316435856, -0.2057676354749574, -2.014617271326423, -2.654231202593097, -1.4939050688804003, -2.4010045259501394, -2.66858683425729, -1.7378989357524568, -1.3978173601263084, -2.2287666382849878},
    {-2.804835822943741, -2.75058568724279, -1.1473408463182346, -2.770323517492217, -2.909167358210177, -2.7649652334449693, -2.529239098670963, -0.8089084793969156, -2.4834841204962497, -2.676236679402044, -0.8369007166664852, -2.7953523921660426, -0.18678448487591595, -2.8468207451649032, -2.4358031079987437, -2.770232363262713, -1.518120534497492, -2.7987623753140287, 0.34559501406663745, -2.69582450144962, -2.9884128001516643, -2.691920299159104, -1.936992235331013, 0.5028591745328305, -2.4791792596134865, -2.741536272779965, -1.2978242147905084, -2.6003028775373003, -3.207015525818934, -1.8675451686083093, -0.9664694443981489, -2.3256825113305504},
    {-2.996308675047193, -3.073643059580724, -1.187893906680841, -3.0318648878318326, -2.9500445496993253, -3.319817161608405, -2.2364318191599963, -0.5685351967975376, -2.8228187257501154, -2.786134177237416, -0.7565974999369675, -2.6068033659536325, 0.22910697242827505, -3.0549176769352546, -2.8852990126753975, -2.866042169924888, -1.5323695079896802, -2.769672292121973, 0.505844183069176, -2.709363144270683, -3.1135647011274044, -2.77715323609989, -2.52992304358659, 0.9112490766471675, -2.6781453885597535, -3.0268108169289376, -1.3031821172112246, -3.239476194517195, -3.3475887220154275, -1.8042369636345927, -0.3833897002318259, -2.458315478396837},
    {-3.119192958199991, -3.175307924589813, -1.6521227065615764, -3.1015394879467326, -2.9306239440284654, -3.211233113548183, -2.907856877923437, -1.656144103210501, -2.978065066532861, -2.968878823956984, -1.589866345914578, -3.194407393989406, -0.5165251331079896, -3.105296317537205, -2.746196808596114, -3.1599806898449914, -1.7960930842412683, -3.1897175581434047, -0.14304944206047532, -3.1929356893074035, -3.163567871688149, -3.028470673445737, -2.759338561291499, -0.037733987562089254, -3.023678356849112, -3.163600474361792, -2.209437261869191, -3.177020199219297, -3.3310530676082046, -2.3218715815578617, -0.8672629483402293, -2.5240263431556786},
    {-3.083181032847607, -3.0405659770983595, -1.2951934136855368, -3.2905017467066524, -3.204526233148369, -2.7993076748623698, -2.414405007054085, -1.2206767213851282, -2.8607898658871935, -2.956593095227511, -0.7450290965006434, -2.8010132973674287, 0.19338944458711205, -2.8263354107179905, -2.5242071053024806, -3.230078603595667, -1.7533426944607455, -2.8473857806041636, 0.14608606092602383, -2.8605375911996367, -2.884674436283259, -2.92931660131675, -2.415318165624572, 0.6970381018446761, -2.769174392703958, -3.1625649283604877, -1.9697180954851332, -2.9334685546938584, -2.955033294090733, -2.0400285018674373, -0.3775596473185949, -2.599378305675587},
    {-2.8766317542176174, -3.0104102871597433, -2.3673877344926004, -3.383474828660889, -2.8819804029444263, -2.709902581098742, -2.9170867537910095, -1.1534789859393344, -2.6191618830571692, -2.5867301172613995, -1.4976920684354913, -3.0258799566851224, -0.9123945247458219, -2.9199768768985193, -2.539213790215031, -3.0854448410951747, -1.2643065224279142, -2.947375634248811, 0.16962319949782342, -2.817606536601005, -3.12377906397841, -3.0919358325880193, -2.289952536364478, -0.4688960736405307, -2.8517749649728703, -2.9311210222413884, -2.35566947939628, -2.877277791579362, -3.6189240226582595, -3.0135402763847567, -1.0235852840920323, -2.4408109857007174},
    {-2.619515547955658, -2.8868780289988933, -1.3831377303963104, -3.004575694877598, -2.9706196559850664, -2.658812294251459, -2.2847500536723255, -0.6419099111972587, -2.3925213454063448, -2.74103082514727, -0.8604895862966621, -3.205894219218812, -0.014511714058913239, -2.786244199381067, -2.4186148932368585, -3.0342371339904006, -2.047007945643769, -3.023308164567146, -0.621716738073586, -2.7051253610252997, -2.8414467171934485, -3.103015638844762, -2.162893723221115, 0.17937023945687303, -2.831168193656957, -2.6113218177915343, -1.8154770487010627, -2.9186931360313704, -3.1292365328402756, -2.0865695343658848, -1.1914382046688936, -2.3698540151961187},
    {-2.2681914608076252, -2.259779573788985, -0.28217490147964, -2.409712809823326, -2.348472140594897, -2.189331205068022, -2.1941346125651653, -0.3008444700912537, -1.876784825873792, -2.422947947466123, 0.23603490038236766, -2.5317335349009085, 0.41634629687160046, -2.3291841290260553, -2.3472714281562905, -2.441433406293343, -1.3777775092980613, -2.9358932261971713, 0.7260316093954586, -2.4438668643924446, -2.420090594542436, -2.6480918293421607, -2.1874747544553537, 0.9499521483549241, -2.3873096985048625, -2.4968714035280946, -0.8426525832613055, -2.2005027970532476, -2.6976586492790107, -1.4467881481469047, -0.08803037742156504, -1.9313456031146539},
    {-2.3571111966160716, -2.551506268293347, -1.7180389627711252, -2.8882333009080936, -2.979103199822396, -2.6760546046926064, -2.4026615994213554, -1.5400327868818886, -2.4236997787972387, -2.599284537737653, -1.2791253704355576, -2.752551466749745, -0.4964635740929406, -2.9079334910515278, -2.0157705381598916, -2.9805036011157076, -0.9613078076404767, -2.773624441036301, 0.26911816341656764, -2.530432592524087, -3.1443057253765483, -2.527262179703512, -2.032294619270464, 0.453119674031297, -2.72199820699628, -2.6518232305789646, -2.369002542803062, -2.4374327157313727, -3.1653537081382863, -2.715779910931257, -1.1736508573130413, -1.8900717925508594},
    {-2.9830518996191575, -3.2439233723990086, -2.105600215396, -3.5333610879881157, -3.330375956238087, -3.1082230907729707, -2.4601065941274425, -1.556300187699345, -2.4722280534404852, -2.8864840941434613, -1.6934059413632248, -3.051353638422278, -0.3398730373471807, -3.340696457172167, -2.340238405269374, -3.2266353179458247, -1.0699643267092045, -3.2434589434076813, 0.1859442703510664, -3.290702880033817, -3.308449173776515, -3.1590955138805024, -2.21065012880159, 0.425258758716608, -3.145295683095582, -3.2464041717491345, -2.3981431091749887, -3.216596213276649, -3.3942411956350025, -2.921539000881048, -1.391741465758291, -2.3987027196493673},
    {-3.370923935809822, -3.324566100858837, -0.9073629266106823, -3.189206039866265, -3.3559508810347523, -3.2700201030345566, -2.6265678830243915, -0.5443992514823285, -3.112783518546053, -3.39823616361073, -0.6376234747960218, -3.7255044324682616, 0.48402534617249765, -3.724253560805556, -2.9136424353047046, -3.0641728200389777, -1.7695761463206765, -3.443105987470392, 0.36379740846967057, -3.1812802468262045, -3.320722651285868, -3.3505220518310828, -3.192412281679538, 0.9068856192310939, -3.335106871039081, -3.2127628606206393, -1.1611523439788687, -3.257434196455449, -2.8879353195303574, -1.7515399928945152, -0.45362657059266764, -2.8714660289751532},
    {-2.9482610825793083, -2.834318604698417, 0.27806469213393065, -3.1672133215890534, -2.6802052306239315, -2.721761141179644, -2.12929308011919, 0.49365057491906866, -2.3616693422502033, -2.7103613911961117, 1.1329934556255037, -3.027375542173449, 1.8552290916035215, -3.1111361634335215, -2.407676843424379, -2.8178829476925715, -0.5332891379764408, -2.790787798967753, 2.247116768210854, -2.6265840232089857, -2.8298205192721135, -3.0132888469030013, -2.018092685991422, 2.230600345779482, -2.8990117064596115, -2.638798861805059, -0.14680550112770907, -2.817957253370407, -3.193611089653208, -1.132080669901417, 1.9287454023778847, -2.1882711401157784},
    {-2.1983713513693486, -2.1642250377081718, -1.1287068120615025, -2.7624985114070815, -2.4059893674836275, -2.0209147172012973, -1.6471294622277695, -0.32945981035092625, -1.6175662499027912, -1.982668183662894, 0.20424987464037475, -2.6193092324740492, 1.290264019457269, -2.2303981746470565, -1.4811827734843002, -2.901418760034365, 0.6903425337126676, -2.460091811340386, 2.833104395978758, -2.041544268944071, -2.542269166984147, -2.373229625837132, -1.3072915581735944, 2.4248910971435067, -2.2449411951819727, -2.4426548672416155, -1.9048737051925475, -2.1464391150998465, -3.7741596892994966, -2.7690107334566787, 1.207229495796538, -1.221820761225823},
    {-2.6004866191251756, -2.955496230831023, -2.109969700858041, -3.2239083499229224, -3.0986148910313625, -2.8053996215525006, -2.6078208808655927, -1.4035191643192104, -2.4640597439264784, -2.9155037138886897, -1.2915562875543194, -3.2556226218804163, 0.3144759300027236, -2.823372585211885, -2.30504742060568, -3.151706405257497, -0.6640138999911532, -3.1293920287708197, 1.2825541248779642, -2.7751905573692177, -3.2155343004186934, -2.957976825595148, -2.237743197951284, 1.005503404117968, -2.6568037442707992, -3.0865069594851593, -2.830798428236117, -2.769424759015516, -3.7819592201370944, -3.628692308579266, -0.6575860537369875, -1.7874384882713623},
    {-3.517339087190681, -3.07050967733465, -2.1361619464253394, -3.5897359871378836, -3.3027340654621873, -3.2373561710410588, -2.98164315442851, -1.768795564346633, -2.851300571261184, -3.2880485263869015, -1.7637324287920508, -3.652700809438226, -0.39472628039763735, -3.446372633065445, -2.6812266125586484, -3.3960375638825613, -1.8597279582972106, -3.3491417426715624, 0.13104663956548368, -3.058894218906986, -3.4510011920300094, -3.326999909696481, -2.8514033951629925, 0.5712422522312653, -3.249004423512117, -3.367267177896127, -2.672192223493151, -3.176219718696839, -3.625466925649578, -2.792660954281133, -1.293539576100054, -2.5541291425617216},
    {-2.74031183982625, -2.913469912674407, -2.530628011441227, -2.857593730047236, -3.012731228775699, -2.614520714410683, -2.462680799561836, -1.986425622716707, -1.9849466545767147, -2.457329457199341, -1.5454568009626566, -2.7640980150774315, 0.20007940834386367, -2.6795269703101328, -1.8864877812441525, -3.154416009350547, 0.24905986255986823, -2.65194035157478, 1.6230791288715327, -2.4740163867816904, -3.278863253938742, -2.425618580226746, -1.7848961005826463, 1.4163982637857566, -2.6009991124856207, -2.815161215020405, -2.894410435128536, -2.6767194949626347, -3.990904287248473, -3.4610668064815355, -0.45072024419082274, -1.64654820969527},
    {-2.273466006923503, -2.2741838916114125, -1.5904697849402336, -2.6348027126802274, -2.458342847735058, -2.2395632018988203, -2.392501398117015, -0.9251561608851557, -1.8651648956821631, -2.4470150319508455, -1.0144252572419195, -2.7142181796063714, 0.49665586394393113, -2.3162696551169257, -1.879062406381312, -2.7181464676627636, 0.285660057091859, -2.958411668207532, 2.098738473720585, -2.397643751642414, -2.7907481622275574, -2.7638373501593, -1.5903926118304388, 1.657039580740915, -2.6163366595063517, -2.6826123953025434, -2.2780323902789856, -2.3867297555888216, -3.700454173662733, -2.703809259601898, -0.10276233121085304, -1.59999290794542},
    {-2.98968597983211, -2.9465473972859497, -2.2577649924563614, -2.8465778290437957, -3.2729672219190533, -2.873634437749951, -2.499260531962258, -1.3373811761991696, -2.1257181504401848, -2.7325310888881944, -1.170973242432753, -2.9705985248693034, 0.1568060345852462, -2.859320860025937, -2.343473666350751, -3.28407484427472, -0.057857817093203034, -2.8375361040151814, 1.4347578676317785, -2.6680458793149393, -3.0751723594195077, -2.62337489057798, -1.9490230496468888, 1.3072587188294171, -3.0463387383366944, -2.9679313766429725, -2.7286177000442913, -2.8491614445091735, -3.5458816498729258, -3.3731124637869736, -0.08113956428205907, -2.1001274821774563},
    {-2.4734901733358923, -2.9842150381456327, -2.3604271184145187, -3.152687142432806, -3.2448841222809546, -2.7964428471250753, -2.6876090136736157, -1.4531804858081971, -2.4056023660426744, -2.5714341214014533, -1.5041688112331617, -2.990800135875913, 0.1292912789365177, -2.7770181451237086, -2.4033547390109327, -3.0265410193154683, -0.12225143393289752, -3.1731822322475915, 1.3864615682612442, -2.4111944904143043, -2.901926628149748, -2.728890302932862, -1.898581022264827, 0.8173044157836113, -2.8108504933489185, -3.151173890352464, -2.9145559385656896, -2.89263571962202, -3.749770859808994, -3.220348120250621, -0.02919066451115542, -1.8379065293804386},
    {-2.050581516958382, -2.516826919076938, -2.1448360416342256, -2.8356803132128015, -2.6162439861596667, -2.498903242463326, -2.757210408465163, -1.1046140405318243, -1.7421658915611258, -2.079529145752809, -1.45305935814414, -3.028699001015633, 0.05693392159520064, -2.474017709792508, -1.8726006755164748, -2.5600315909462696, 0.30806423622138907, -2.8100681429876153, 2.0886638501208514, -2.115760195473327, -2.5830734513052365, -2.6344068138084102, -1.49408460190053, 1.0973085046162638, -2.0483722872252574, -2.623492986690266, -2.50549220381313, -2.3213515215489786, -3.816867745411533, -3.0895065552201535, -0.06784829492540065, -1.1782239311181135},
    {1.371338144091616, 1.4409548057558372, -1.2189227883240454, -0.048320071035605455, 1.7880978282279016, 1.314422869834968, -2.6300256897361756, 1.6300169107487752, 1.8163718692577602, 1.3459559352192663, -0.9414735005349583, -0.029022666660296063, -1.875170690269501, 1.7894560973210512, 1.3023186084471605, 1.3403748094105787, 1.5903281446756825, -1.4110355761699034, 2.0102861982598834, 1.261567840222846, 1.1343251166197281, -0.29205373501236176, 1.8576396017765688, -2.0628772844325307, 1.468280065039571, 1.2367651585010895, 0.23093650493803689, 1.564258415297011, -0.522657005293571, -0.14997912867764432, -1.484492570042167, 0.6283856860016749},
    {1.5462062270764279, 1.363654765582625, -1.0457433120273558, -0.09235174658781473, 1.877810323436726, 1.4616727679352415, -2.3327581678931004, 1.6023895410568658, 2.0128440704487613, 1.2550337535031024, -0.20885424868206232, -0.5507899215942842, -1.470353481724968, 1.802480115853095, 1.306218037904756, 1.6971474725645337, 2.206273578494089, -1.7502261843714484, 2.3728762294820767, 1.3618157697586608, 1.0619336750847974, -0.2547849467087307, 1.8290377913225062, -1.2877456944725587, 1.2973304720922003, 1.1767078104983706, 0.5681287551899105, 1.5046805137939085, -0.8250751814003456, 0.14934384196557035, -0.27420776516222034, 0.6357716570309961},
    {1.992093682947299, 1.9954586912439145, -1.4134457291222815, 0.2448075073856259, 2.20784413074156, 2.22553040568931, -2.716876106641448, 1.591253308662002, 2.2390175124362197, 1.7201288930107281, -0.3645680696484076, -0.48937095000215525, -2.000641123342604, 2.350577671386362, 1.7785385833062837, 1.7090089437966565, 2.229825212235267, -1.3269094806190416, 2.6785154117537813, 1.3476343963672301, 1.440657155120122, -0.2122312594251959, 2.2726037458898913, -1.804910744700581, 1.5792183168477671, 1.8097375815717704, 0.13234428814033836, 1.9652570368154536, -1.254396606187008, -0.12417094779042956, -0.786774899955249, 0.9941187702807576},
    {1.781440276271332, 1.9665306894041494, -1.0263103360282773, 0.41080883297794574, 2.0240186832494467, 2.012194269430168, -2.7988066734782464, 2.3485854340662278, 2.2367585069153257, 1.764649159165336, -0.022480718984199993, -0.05719623219608689, -1.5947462712310925, 1.96269628441236, 1.444361095188469, 2.0546723289245334, 1.7502540985121675, -1.420912673216682, 2.8008767080403083, 1.3164341409481464, 1.371139477284048, 0.1796040755765901, 2.130973009475775, -1.3549892847133294, 1.380741006469343, 1.513837370873181, 0.8470609734505786, 2.048040607897649, -0.5437967819832443, 0.8378367158062221, -0.490315907201845, 1.1113141045324628},
    {1.6767473820148806, 1.4193275998165535, -0.7445090470624615, 0.5201761529721018, 2.0445876317733402, 1.5898201800751923, -2.3454207773298, 2.1132380819348717, 1.8921708725036537, 1.730649193451621, 0.05767868585115719, 0.26003593215305915, -1.5490903588971747, 1.57133837641306, 0.8797822343910621, 2.168130169361858, 1.6472561893117106, -1.674738997946354, 2.178654920601009, 1.2701155258969976, 1.4674964117777758, -0.029303849881112086, 1.8417161430511575, -1.8427011910875621, 1.2279365636933297, 1.488486382414215, 0.6715936855783822, 1.6006056738241834, -0.5699136891339462, 0.2038775009691324, -0.11519450245772814, 0.5257270201477205},
    {2.2910600308516993, 1.478069775755221, -1.1508511047524208, 0.16142486332248496, 2.262396721016576, 2.060608505334247, -2.988188226215013, 2.1409047008539086, 1.9648783137796086, 1.507113669355877, -0.38051702584441427, 0.009442731067802372, -2.019411156173765, 2.081904670985306, 1.158652446271449, 2.1870584432997457, 2.090244401359655, -1.4627996911712164, 2.54678178367089, 1.5166945442733308, 1.5054437788178088, -0.2903798294772166, 1.8644115725185375, -1.9215476179200681, 1.311012896583014, 1.389557249616221, 0.37321262771211244, 1.9428995327196832, -0.7603594225629245, 0.25739699908839647, -0.5718012418647366, 1.1475140813415672},
    {1.876229698154166, 1.9571655393931695, -1.8368875363416917, 0.0659179386256021, 2.039617042851648, 2.1161561935689925, -2.968509622101613, 1.944732047359019, 2.1953368569781975, 1.8634827205794158, -1.4750250878795341, -0.02580439306138657, -1.8840764950375326, 2.129389092511205, 1.3442077908721863, 2.0332374597147767, 2.104562667613216, -2.121116967917543, 2.196792704687607, 1.6437075727786614, 1.5195782364386443, -0.49841544124102166, 2.109219643739024, -2.161438905173702, 1.6352722763079046, 1.418748869424813, -0.06789314973237597, 1.7877979618008304, -1.2818257851428025, -0.4005885594340356, -1.2015108195112982, 1.0741442819777633},
    {2.190262166691634, 1.9932643914225523, -1.6552886925076307, 0.3532835810379139, 2.286759448269366, 2.329145676815022, -2.8297395418411737, 2.0725232781226253, 2.510144772461627, 2.108710109442932, -0.8138809437679156, 0.24263316105427082, -2.2053271435524713, 2.165770294634479, 1.6677415083370022, 1.9594635338256494, 2.2348194115371443, -1.8706192884283226, 2.358409292688863, 1.669776335458249, 1.2875529642489358, -0.1044899458871408, 2.161945058602893, -2.505506597803762, 1.7456269139494927, 1.1520053032134532, 0.23883914034495288, 1.9060987077501308, -0.5916425780739559, -0.3088901243930224, -1.1808496594392641, 1.3651511972820032},
    {2.3291980755850115, 2.0978494935491514, -1.5351881007526396, -0.02662221570770435, 2.3466237503840093, 2.4218534653968034, -2.8201769355444615, 2.440087316503114, 2.6066156856439555, 2.2825800380888577, -0.7146632757595031, 0.3888729349444862, -2.224946991195726, 2.1732267856498355, 1.7819789977789688, 2.3086544940545926, 2.3281657757818954, -2.035595861978732, 2.958673964967538, 2.0156902793604177, 1.4238581133977215, -0.11888686999375969, 2.3838107172922514, -2.4625649655538004, 2.0092321466030367, 1.4955896908671173, 0.37007204875946537, 1.7297521188864264, -0.583849924277677, -0.004305787031533166, -1.1093551051911281, 1.4461216887073678},
    {2.1560998013646175, 2.1939791483089564, -1.5479807755484525, 0.05913329987832813, 2.226578938567552, 2.4362615076002125, -3.2065352053340384, 2.668677371560439, 2.6257428695280662, 1.905020521135939, 0.05201755085128859, 0.2634694502775863, -2.1155442159215303, 2.255111362855682, 1.7512075544249592, 2.090176440959392, 2.273623371919553, -1.879707303465489, 3.068640543419665, 1.838309672624764, 1.4127939326108414, -0.35684843190682647, 2.795255914968351, -2.123314796283778, 1.7022630553903337, 1.4794087110012546, 0.45002732607601814, 1.8310663848106512, -0.7462885754077033, -0.2276712191911394, -1.2346847008800828, 1.5628552647384248},
    {1.9477630286170806, 1.8213790349004608, -1.1282857207095547, -0.05850743518988873, 2.4762660191838575, 2.1716665676441207, -3.0203562219726376, 2.42433371975476, 2.6448423866948425, 1.9771858766287205, -0.21055922770629082, 0.14299362519822045, -2.4030958478406155, 2.315248739666563, 1.7921906896579582, 2.057573007801072, 1.9424808089175092, -1.8563375009356236, 2.7093978169116775, 1.4854623862206773, 0.8862660824622471, -0.4442110673017993, 2.393307130719094, -2.2517217587957123, 1.6188112151922822, 1.667694445835326, 0.3400107813810836, 1.732829130748206, -0.7954279162599284, 0.16331778632244964, -0.8417326227697901, 1.3311181979362832},
    {2.354034630302592, 2.1444360414151507, -1.4596639448352904, 0.11690068052521847, 2.448294420780729, 2.1001290727119537, -2.8557321217770673, 2.5518214160899104, 2.642107912752725, 2.414754290668764, -0.030378824057501107, 0.12777137043190562, -2.0860811224606346, 2.384535467875163, 1.7890639595820126, 2.0669223486937667, 2.7161531549032234, -1.837692163666493, 2.760637988732249, 1.5532175934076433, 1.6828353700403942, -0.3080936549555603, 2.7522028379174754, -2.4020396823813375, 1.709323575038009, 1.8861345811936368, 0.9273917943199612, 2.1309241020160377, -1.2497668240506408, 0.3140723352434944, -1.125687122034576, 1.2296185230294365},
    {2.375726132769045, 1.731725661537928, -1.528567867296983, 0.18596461557460017, 2.4391414020994437, 2.312647733418963, -3.2338011692061714, 2.0702159789177714, 2.6336220239010215, 2.6722416776954234, -0.4057245997185633, 0.147140334730738, -2.377966186944651, 2.578840658967757, 1.9509862016040562, 2.1734101001531188, 2.420880950998229, -1.9458579027549703, 2.995901544539783, 1.8936466296284091, 1.8149031305092904, -0.3483933107177154, 2.293890796875885, -2.4469107732138022, 2.1949179492473334, 1.8503871801314435, 0.7276526204009935, 2.2191483378703714, -1.0980380115390156, 0.22764619302827688, -1.2286836271988444, 1.5385870178348395},
    {2.3900539865330206, 1.7121401991588352, -1.4170086562094424, 0.28060893064844494, 2.2862910462405948, 2.406546644806195, -2.7719155036073095, 2.2330427721224746, 2.2722787439567105, 2.1343258298269268, -0.6564067810327691, 0.34379314158733554, -2.4302675748027287, 2.178917267877598, 2.0670196276752635, 2.062404570877328, 2.329531885604976, -2.0373370600468457, 2.8706958578022426, 1.825671115551058, 1.8111857770069115, -0.3229362669464246, 2.59258462080334, -2.648337062907507, 1.957972261922746, 1.799747713649532, 0.24633526262767375, 2.1608178353740137, -1.0130815944165872, -0.045143372799643665, -1.4654312396912805, 1.1239680422649732},
    {2.401809110312084, 2.04380375963543, -1.7190470306340466, 0.27989483466912923, 2.003308311564578, 2.0812140959787997, -3.1182458494445426, 2.248541918391395, 2.344614681842451, 2.1100264764166807, -1.3147528607941261, 0.3005999300482426, -2.4544812928543016, 1.9729865099581647, 1.7816781971758031, 1.8318659591753494, 2.738708851585242, -1.8378578533714287, 2.506738414951841, 1.1393132050353505, 1.5409055982151951, -0.3227332583995402, 2.1465868216533504, -2.8512042919481133, 1.8646063569852156, 1.6012008089795235, -0.17850579154803514, 2.228609104019786, -0.916067057871688, -0.6595388646277169, -1.9136101983114575, 1.3909476328281691},
    {2.033930188494302, 1.7495081257390714, -2.0428426387810474, -0.34301841328706634, 2.0124910492244794, 1.8992312631779302, -3.222518656094676, 2.629388354289722, 2.2417131884797388, 2.193743802096397, -0.9794057743841214, -0.28702892066923386, -2.636391268806383, 1.9557148771981314, 1.541306577688917, 1.9957933784646478, 2.194683295197348, -1.8289664418820675, 2.639268948259167, 1.1604940301480238, 1.350411519166529, -1.107502398652834, 2.186881269353267, -2.8058045375902343, 1.9489606354159321, 1.6729241274455566, 0.31248683097562546, 2.367637663638891, -1.2605916873516751, -0.9210972577001981, -1.9646548906008585, 0.6818382472158624},
    {2.1591515960206427, 2.0649947932654737, -1.8305436573617204, -0.20812887023852, 2.451538945631727, 2.09705298078856, -3.008100247684683, 2.7530032831338507, 2.4811053327599857, 2.4829262404123185, 0.007815843008395483, -0.31723374687094896, -2.2189528042610664, 2.1261862530954554, 1.5594805941388967, 2.289375805896256, 2.4254774874405736, -2.005683658660659, 2.5060048359467935, 1.4380996716886687, 1.2979923681229233, -0.5152044790921139, 2.414525839156872, -2.4206028709437386, 2.0260526498886713, 1.8648520280058136, 1.3347984081786262, 2.195911691732353, -1.2801425413322602, 0.2824273183811965, -0.8769831682731629, 1.1054379098793676},
    {2.6366784337331723, 1.8657716098224433, -1.9040068756192072, 0.05516898799588762, 2.8670724420352798, 2.267512970391968, -3.116938961247544, 2.6689029623713267, 2.4631020095703917, 2.5724210361169235, -0.4430864640777986, -0.35436599399539986, -2.328149963935367, 2.168200796818893, 2.0049019791675624, 2.6273640717532403, 2.534693326729114, -1.8226287389054558, 3.1752240170779356, 1.559401334226536, 1.9529191896990088, -0.9609486343423306, 2.53069039471125, -2.6056397839674044, 2.2566610667663265, 2.121181105010717, 1.0039608325661515, 2.3088492898290696, -1.4105624426564252, -0.4774742476342792, -1.0851961563016899, 1.066180993741702},
    {2.6684504275224605, 2.200357839310602, -1.7051385973071165, 0.46706815309428046, 3.2200449996463103, 2.594422454452953, -3.218501982666712, 2.3257329096116504, 2.7282750198175245, 2.5755646528721914, -0.5889869070897734, -0.03838504061962102, -2.5224882306254366, 2.5746159109212607, 1.8024040632923048, 2.663475745171741, 2.5068483020037036, -1.9669225520552938, 3.0699204036753422, 1.797755611441145, 1.974351769234479, -0.7815105849102968, 2.9766675240309355, -2.329707459196439, 1.8845588272028189, 1.9939779874377765, 0.5385938055979679, 2.394647841760999, -1.3346933602600137, -0.08026304128775398, -1.093749898056516, 1.4739206949877797},
    {2.2827038905039787, 2.1406590507401146, -1.7194131271104702, 0.10068383607220967, 2.8188616077577113, 2.353562967825436, -3.5204277150814494, 2.546122193611828, 2.8040846200713485, 2.244538687201381, -0.7635873208183003, 0.10000276943755809, -2.5013028287412453, 2.33485077225494, 1.9104761123084666, 2.493178560161076, 2.68491864596169, -1.6518955589244326, 3.015784718264963, 1.7456725506750232, 1.677246410777804, -0.00103777555575666, 2.5201549285547813, -2.465152188282531, 2.081685867876981, 2.0344010334896687, 0.5470551710725661, 2.3250954918582036, -0.8288583355390979, 0.08288924728299599, -1.2862147176691006, 1.4644214563497684},
    {2.64280620537349, 1.824835382330741, -1.4823869337638815, 0.456906917516936, 2.7211171056372576, 2.4681930850862828, -2.970288530133957, 2.887162194023927, 2.900942573482369, 2.6691368070626322, -0.586309041841236, 0.4844156517576705, -2.190985575440122, 2.4532827181480643, 1.9140159288077772, 2.2144390021003093, 2.6673118901749655, -1.4358038424652595, 2.9348539905755335, 1.8426934270075848, 1.526097813847258, 0.12411410530806527, 2.7315382420720162, -2.3574134203798, 2.451902425316247, 2.106969729595172, 1.2247320613379842, 2.61688648071533, -0.7174085246248673, 0.13361150383368708, -1.6136098751298569, 1.6216680603992557},
    {2.964420272072136, 2.1738915918428376, -1.9234503588605159, 0.3444318838034951, 2.939445094654009, 2.5769284060896487, -3.1471879117317, 3.1862711995067388, 3.170202198129457, 2.725364058898368, -0.4555196183984014, 0.17803592707609248, -2.7251689067681633, 2.879063909405677, 2.449538660722365, 2.2907260914602277, 3.131159194318218, -1.8979469909665825, 3.421035513762209, 1.9646623943913673, 2.4287606264516546, -0.07016069488172968, 3.130116889774572, -2.341472146047851, 2.445078649278626, 2.363115715591607, 1.620061121097925, 2.421689654767948, -0.723113459632875, 0.6788950712825292, -1.4771168293318484, 1.7544686718698614},
    {2.9756983907000025, 2.332208836990291, -2.3078596158146882, 0.21579723140867038, 2.618255016706309, 2.6278534016232435, -3.570419948740227, 3.0465042101749176, 2.846492184006751, 2.94970274525517, -1.0242043066898348, 0.3990584712450078, -2.836947706087693, 2.6263820152069024, 2.4454629666381624, 2.6020235697056155, 2.914998420043925, -1.7001348115320418, 3.0191017579269244, 2.133351671566518, 2.286285852079898, -0.11335154803623204, 3.014480753354419, -2.9508575251268816, 2.2433997514106525, 2.7219919111937863, 1.299154839045206, 2.7047015625613278, -1.242970398120605, -0.32669034988147877, -1.7097087354772371, 1.5400195219382382},
    {2.79451685799766, 2.5814528843924553, -2.2916449448443927, 0.0059960856158071145, 3.1231079610395476, 2.6635242058928874, -3.484820554799078, 2.8078507361745326, 2.5698262560234357, 2.731441266539125, -1.290049013336299, -0.1510662315264136, -3.1911274246186347, 2.8834775509527475, 2.449706010931664, 2.7927752428620627, 2.657275282895496, -2.4633870440819443, 3.2544033121189884, 2.061308635687172, 2.215867861192863, -0.7176488638547618, 2.9247396923579805, -2.9101044570843175, 2.620257597564099, 2.692896816202558, 0.7380848910556138, 2.7980782973783853, -1.1635944798142006, -0.2284652064793691, -1.7481003413146272, 1.4467026850294586},
    {2.6239099122829748, 2.3946262690958893, -1.8374421304114974, 0.10084533058742295, 2.9124739722476964, 2.340213594685338, -3.5792553220047663, 3.0395273730549603, 2.562186035334278, 2.472075774964333, -0.3275480359553564, -0.1620851448177871, -2.6578795283236345, 2.8158676423151596, 1.973770454516747, 2.301336698491241, 2.6270905453569426, -2.0617265820603032, 3.174959867653755, 1.6248724280071793, 2.361851055364423, -0.7955506841568333, 2.9279841154474897, -2.431211285296032, 2.2827246556615433, 2.349269255952524, 1.2903445691852, 2.266627136550239, -0.626292024726463, 0.3597274136354667, -1.5820864698104415, 1.0350130077899002},
    {2.7310220350807324, 2.2334630575229406, -2.1063808144917884, -0.02526558377051641, 2.825303704645871, 2.504238373628818, -4.027346282128403, 2.830648613576298, 2.704087581245412, 2.7986598270944234, -1.139956767308591, -0.2785267098403689, -3.078753028504463, 2.812941995765245, 1.9478451611921994, 2.546786489970505, 2.8176343800685606, -2.2824201775021744, 2.973180999349985, 1.7557317443272529, 2.165840027260436, -0.7409078206099662, 2.8406849498608455, -3.1044930366749504, 2.3743009283266034, 2.1772463557438733, 0.9712014914621487, 2.7328239835509813, -1.3689562263049528, -0.5868165578704728, -1.9592058684701243, 1.1840123398361628},
    {3.1400320591495725, 2.3242915782743383, -2.2540784531272493, 0.3559315198435349, 2.8856618283135074, 2.833645425853945, -3.394015473809625, 3.0118553548249243, 2.865916600614365, 2.9161452168006265, -1.1267416311033769, 0.5594149133269894, -2.7281267031954184, 2.758157233048196, 2.4094536337463848, 2.8053812149328063, 2.954348383257802, -2.172584212150644, 3.064214356375804, 1.7488786531169722, 2.190414608837706, -0.42870431790344016, 3.065797576577621, -3.037567007578469, 2.5388596643252668, 2.5539427749986223, 0.7175570715634025, 2.7149806248001696, -1.0917492543102603, -0.2774405835362747, -2.029592877872683, 1.2082388594804916},
    {2.487604465361467, 2.2921925415441193, -2.4245102775360796, -0.179553691483925, 3.0396838927820293, 2.177656422210095, -3.5745244601042736, 2.648895242434769, 2.836960721430926, 2.3044232309184136, -1.4281100967774776, -0.21223335641086175, -2.7244893969642603, 2.592359743909299, 2.0078393735324935, 2.3317795125500997, 2.8679661519101405, -2.0015488191685145, 3.3120750475799516, 1.5111528828120495, 1.649180575180488, -0.8108673677824351, 2.8466187231411904, -2.64520371710124, 2.397578400795601, 2.1790944194345783, 0.9244638870137878, 2.5608916788085323, -1.6924072236750902, -0.38171940029263357, -1.9497231446540508, 1.2311130437336302},
    {2.5423469119701245, 2.170494671825606, -2.3140144273648806, -0.13343248953763304, 2.975026243348198, 2.451521501646206, -3.4773783978708104, 3.0841648842901277, 2.580939216241147, 2.7606126439497394, -1.4012934865596998, -0.48996975908598867, -2.7030097866116294, 2.5501780761183404, 2.2324642218419837, 2.3530071609242835, 3.0264218544893087, -2.4324402030492176, 3.438501503903002, 1.7413005256279797, 1.8554228978201726, -0.778338102425846, 2.9240312818163736, -2.7129891294033315, 2.426100207156004, 1.8827196186198667, 0.9480286328579607, 2.5021055356281816, -1.721769443039396, -0.4472362175472235, -2.097365357757607, 1.1454280153298482},
    {2.7116917368852844, 2.48173483958342, -2.6677783421465118, 0.24206904142113508, 2.959663227241095, 2.39633425961968, -3.87646033355795, 2.853090506390026, 2.6364436646656757, 2.3997828940970716, -1.307557903667634, -0.17929311339001255, -2.916315477739051, 2.8210287757215826, 2.4080895345249433, 2.597509652602877, 2.8125058095692568, -2.1720409909456713, 3.1898292975158062, 2.125506897140815, 2.049681873618065, -0.3174497384401839, 2.930343108565982, -2.6530365800754767, 2.19144955891933, 2.268551670448634, 0.7645468025262091, 2.7143126272603686, -1.6776313821539637, -0.3897304841478298, -2.2659800181504255, 1.3021230257144083},
    {1.1507276733575786, 0.2110368605891678, -2.7966728585873084, 1.128158938332026, 0.587097452286812, 1.1377439580168907, -0.9287462784078496, -2.0271620431369706, 1.2362757905835797, 1.2147614889547595, -2.65978421022241, 1.2398302803968106, -1.5097167673839658, 1.020000281225995, 1.2192559132137606, 0.03263147748003908, 2.222498137795809, 0.8054691832830173, 1.2057081939034768, 0.8299161488020734, 0.32421333961639753, 1.3671247771008228, 1.421114453331474, -0.9166999363913931, 1.6523665529554639, 0.37050140158623235, -2.630753361166085, 0.3106177689564688, -2.0525618574082225, -2.9222884786543446, -2.1076509191605224, 2.0060481668528976},
    {0.27114165943492485, -0.4653270204263856, 0.1918096049344166, -0.4134531486386621, -0.6846927001238177, -0.04393230016000688, -0.24126769878170226, -0.1864505618601502, -0.22259269790668076, -0.7104587888785568, 0.9367354739972495, -0.6079373439817968, 0.5671680229680784, -0.7407949018304715, -0.06634465309782067, -0.9693090653933262, -0.6098167143824857, -0.5573670793807397, -0.4394313439378264, -0.46675539753541817, -0.5501838173517415, 0.028942567080947782, -0.44394173585788826, 0.6459551509373732, -0.3128465008111477, -0.32410508393978404, 0.6348138460037993, -0.3608566834644939, -0.9876290497252985, 0.015129849940557903, 0.1549873505800905, -0.15547389538300457},
    {-1.3991594970637968, -2.4933349732145955, -1.798078240341247, -2.3950915007029554, -2.149934112750451, -1.3927687649987075, -1.5928960522284654, -1.3693752191747823, -1.4823267482875275, -1.7009061999032047, -1.7934921540383488, -1.9540820671845598, -0.41343500166102437, -1.8642161349872188, -1.7119390385173137, -2.0662555597511254, -0.3155206657545603, -1.702656878188346, -0.07335678602479616, -1.5364664037596503, -2.0943725481795914, -1.7315949364927552, -1.3938342480398795, 0.3876188050081142, -1.8914653914335813, -2.2721329682966065, -2.528089603861512, -1.8339645944911243, -2.343597519540998, -2.9048949833695006, -1.3850096903978681, -1.2169132908965128},
    {-1.6506833979474747, -1.7437681912019314, -1.4417496217223853, -2.115974966704378, -1.917210854226455, -1.5166069190149334, -1.6293272843520472, -1.189105525449538, -1.1366200083016773, -1.1000716302052729, -1.0165250391164045, -1.9884362749077549, -0.15800005047613588, -1.6986071812130261, -1.1968238818222057, -1.6509313582577207, -0.22458771344583672, -2.1056825775941346, 0.8643854479944818, -1.6452417015124257, -1.5639265940940899, -1.9805813140409605, -0.9610865603975748, 0.3275765018410379, -1.6620311608098655, -1.959171891641141, -1.8314742672955002, -1.8068581075059318, -2.081172319512315, -2.112765822085387, -1.5487585803970656, -1.4187123976318678},
    {-2.129088815393366, -2.172347667214969, -0.2429471510691917, -2.6754625300651376, -1.9742027147907184, -2.2067097334678785, -1.3844127106250588, -0.38425839965027336, -1.8913107733289416, -2.4031916839803955, -0.22328857165410318, -2.556635796750401, 0.9810449875766974, -2.1006483896392334, -2.3424069616669785, -2.281784927602908, -1.2060718321962414, -2.7051060815880863, 1.5944880097496497, -2.320726466589087, -2.3678577386350455, -2.433935806008607, -1.7132735793764045, 0.927239758270491, -2.3593699090425515, -2.6047900282538303, -0.6598114030929415, -2.058802216118455, -1.797495952158111, -0.872688951014632, 0.4679928519212089, -2.049813204204775},
    {-2.0216482513136786, -2.140414519676325, -0.03910889955019752, -2.2476639144383266, -2.4485539425448333, -1.7085368231960587, -1.6812373104195442, -0.5532694304837729, -1.763811887575012, -2.0459650403884075, -0.4684127276183396, -2.3087624835201743, 0.0009632790010485341, -2.032492712547055, -1.736422455565015, -2.047993615185555, -1.2242611714572813, -2.251723677863224, 0.35003944624224453, -2.1024492486768187, -2.0586528173090612, -1.9221346879760022, -1.6559425171144522, 0.9577949203722459, -1.781120701780086, -2.1679796198816796, -1.263422789684715, -1.8917231200773168, -1.800612567963424, -0.7376294291352887, -0.20594471662761604, -1.6809556427879089},
    {-1.7306365340465366, -1.8417534646122524, -0.8072694618014954, -2.283141266533748, -2.2143363278202357, -1.7677785232046532, -1.9402003043286236, -0.9027981621326171, -2.1383031066095275, -1.830286469159516, -1.115194377884609, -1.9943176240865124, -0.34575282261085377, -2.1740660857319987, -1.5694598276552942, -1.9888189674415035, -0.6812456218407223, -2.2108741166121546, 0.6816161476957492, -2.118431612398829, -2.003566600890845, -1.527516278325964, -1.5872323630575942, 0.3395668835099751, -1.8642645293058469, -1.9736679404485922, -1.2313583050927854, -2.1904809041898554, -2.723727411663394, -1.4689053736386655, -0.7740868266734392, -1.0648100154471205},
    {-1.6157866421098845, -1.8608720226512108, -0.2605184736083543, -1.9096035520559533, -1.8735348350445944, -1.5593740307547437, -1.0226330366236336, -0.35984640719770633, -1.4786015495925313, -1.7010960183646036, -0.45841499805297214, -1.6101175640216452, 0.34803245925896104, -1.6295488039220092, -1.423921598575172, -1.9150685572025894, -1.2209716574229144, -2.3105020019282927, 0.14841068674398478, -1.7803779441925318, -1.9466279676643026, -1.6922092245482794, -1.4471324229866154, 0.5409571821697776, -1.6426653869530177, -1.8702723624591289, -1.1904023875400322, -2.10072303760405, -2.087424709678275, -1.2732620438852629, -0.3425699790639733, -1.1945484207986106},
    {-1.7610376784663089, -1.9853590867369457, -0.40001431224538614, -2.248881152635854, -2.197740817553016, -1.7772782023685685, -1.3516456910851842, -0.5884257349365768, -1.8753994648347678, -1.849385224547618, -0.16841234871268174, -2.474994373511885, 0.7298857067515202, -2.019570737814578, -1.7166791707683997, -2.1665964317796567, -1.0663951195371564, -2.2556771103857303, 0.6629290214959658, -2.2037024271255095, -2.5772097717442244, -1.918199945661417, -1.4397699695903086, 1.2738484475737286, -1.8859850712551742, -2.1862946193648356, -0.9137102563492276, -2.0740259586616645, -2.431409112936549, -1.2051274801785217, -0.6597748246633669, -1.6741062833319549},
    {-2.169104273842002, -2.2595772721533853, -0.8277837654181615, -2.530247958294086, -2.064922869664476, -2.0765493122151284, -1.5185970315195798, -0.41944968956501955, -1.9390274078988508, -1.85178423836878, -0.5128580444400351, -2.3637010410140373, 1.032688520994507, -1.8730947401505609, -1.8179055358676026, -2.1372914042463513, -0.6102328601335067, -2.203826065590643, 1.3891138997247996, -2.103809321255066, -2.6856684891589984, -2.21028925125496, -1.4450938036683023, 1.8839839128812632, -1.7723716026206355, -2.2496611160723314, -1.1251605851302227, -2.3359180081743762, -2.3543099174515496, -1.6838224518635259, 0.27589632247496193, -1.7447704206173333},
    {-1.1253619387752403, -1.5861453946151178, -1.6855000131570133, -1.8569020896651591, -1.7350054597698537, -1.0364753088969574, -1.3625408502164529, -0.6739892519756886, -0.9492566667417832, -0.7220956378170391, -0.7319884750544858, -1.9292217216899605, -0.685040222277205, -1.0930721887365267, -0.6140172315058896, -1.5227982076959956, 0.04246625592009299, -1.562886571434943, 0.49316807330078705, -1.137691787461869, -1.7772573956445203, -1.2293438384825977, -0.7568293543305094, 0.39758490442374184, -0.8293911795224108, -1.9314081674835637, -1.8053365346952932, -1.0757802360791064, -2.349368983691507, -1.4692105581625037, -1.1478750356844, -0.9115527413038995},
    {-1.8164123807788355, -1.9871822113453965, -1.2127497790292225, -1.6929485333504177, -1.7939697313541707, -1.569229727496926, -1.9008320527838363, -0.7839768767356972, -1.5736408437254032, -1.422035923210306, -1.2675533907566872, -2.064795422806946, 0.04758926177390515, -1.9347606260383838, -1.4057810354451716, -1.9580983139748256, -0.24003567606382503, -1.9427761049325785, 0.9615149405261386, -1.6931369114292116, -2.096735676566085, -1.640833632800691, -0.5343483276525974, 0.9676568031753163, -1.807572065552579, -2.212145189780256, -1.6036911284946744, -1.5534279133566022, -2.804559679193868, -2.077475920798134, -0.9937922325077698, -0.99737640850102},
    {-1.7951387179014842, -2.00966289372788, -0.9039386328233192, -1.7868715372568982, -1.5797351799360815, -1.9094863332505325, -1.8107171279745258, -0.20969307931782383, -1.3981570238670011, -1.528819585943644, -0.9226752349298922, -1.5979257187777913, 0.44065023931858605, -1.8898048322722762, -1.362005493628414, -1.9864203135661678, 0.16878415536804964, -1.778688783047527, 1.3879437500753609, -1.6949026331100665, -2.0566848405438054, -2.048301408078627, -1.1118308826772412, 1.2141333426060146, -1.4855331717210192, -2.121505012033588, -1.4904427518268912, -1.9316748526554872, -2.7587016484317104, -1.266291954594901, -0.7506862108117508, -1.1908995424319644},
    {-2.1549453889755004, -2.0717781566383335, -1.6388317509247496, -2.4423802538393233, -2.0893166561428482, -2.3097434182011156, -1.8034469316759576, -1.1455822979189685, -1.884887866953018, -1.8913354599030279, -1.2894236322994872, -2.1744313604365413, -0.1118459077727268, -2.0991312641130797, -1.3868219868391398, -2.560326960750762, -0.39242176214579216, -2.2332190138350136, 0.9361424931156794, -2.174172076073828, -2.274480631860511, -2.239546525402178, -1.4507121718429423, 1.0343806472487314, -1.8057172521092415, -2.0273847755723624, -1.75935497809596, -2.0465260695007714, -2.6700545852234523, -2.137148790588614, -0.7459493160751469, -1.177758709826553},
    {-2.0533359634845905, -2.654881780055491, -0.8633696862127682, -2.4121550020947327, -2.199024884221702, -1.9529866768419561, -1.218019810890467, -1.2679800690236782, -2.0918283413672003, -2.128414602989779, -0.6209976556080316, -2.3492104969027037, 0.5056207276466904, -1.9860793175724891, -1.5256520366732762, -2.6454005061036527, -0.4040074400356002, -1.9763141488536333, 1.1011389156029066, -2.140774882195819, -2.2042205685412677, -2.0269564138794216, -1.3989739373489016, 1.4838148455204494, -2.2106995018299447, -2.037692540060792, -1.9067292665484963, -2.2442057493049576, -2.7764171082781433, -2.5388145381251146, -0.11196724200567383, -1.450943985331586},
    {-1.6604044715199113, -2.0415364868896444, -1.8383753676393073, -2.5717956260079156, -1.8462921958011835, -1.6376114946540499, -1.961075096782289, -0.7509239540859207, -1.3979575878725925, -1.5588721209910907, -1.3234603885555405, -2.170404871611426, -0.6438074483794333, -1.6325858373241677, -1.3219343429481765, -2.241648298075584, -0.33220992841290886, -2.036379515872919, 1.091150727443094, -1.8920494119214575, -2.221550881161394, -2.39302330646078, -1.0303457174623927, 0.14511890153805693, -1.4920426513184035, -1.9524392864581777, -2.4398288481803045, -1.5124209712663248, -3.0125731955440775, -2.6600004925889515, -1.2388139798006117, -1.2130675357962122},
    {-1.9409444421638231, -2.8098513799789457, -1.647849947494451, -2.9479552216192078, -2.11289015534529, -2.00618373452681, -1.7185676908831888, -0.31352061698464445, -1.7208821936446237, -2.1388170860123576, -1.0236500125914265, -2.6500155979311244, -0.30769987738077453, -2.173363445918942, -1.6486721436925746, -2.594898607528763, -0.5577064731474878, -2.4208933618493766, 0.251629866674845, -2.413951850954058, -2.213024798961094, -2.450985979140679, -1.4641324009622216, 0.16273688707346867, -2.115215555935229, -2.3142311980929455, -2.173669046290196, -1.9123396748589678, -2.935543549513247, -2.7407296570412365, -1.57896595197704, -1.4290878810561023},
    {-1.8383952464511952, -2.289349238703372, -1.2182492667139926, -2.348593705786536, -2.1515089237397698, -1.6864853587097286, -1.6674777112971797, -0.5816594615692459, -1.579264646370522, -1.6727884497644137, -1.0070460066207065, -2.3032391724712795, 0.41693356912286145, -2.2784702838768034, -1.5678887971907447, -2.2466525241325965, 0.31857636794344246, -2.2739271760236375, 1.5107751523283601, -2.134451913782, -2.1497917238363944, -2.323110624806643, -1.2818808416574503, 1.554812277615309, -2.034347950555948, -1.8881396442031912, -2.129374879221716, -1.8832711658847219, -3.3703561591953295, -2.909826429765987, -0.8120013199080098, -0.8582070998369243},
    {-1.2239102412214136, -1.7316754334579172, -1.4575763682908345, -2.372827689705769, -2.0116366891369886, -1.6122962458294103, -1.45775301568854, -0.8964450947839716, -1.2578594573009148, -1.3278963836092788, -1.1980300815374332, -1.8054859306405786, 0.16773396490166512, -1.6478788333036676, -1.0703941743920813, -1.905450410860864, 0.6555911916986302, -2.0566921495767865, 1.4414231078449355, -1.5370621184597886, -2.046611701989094, -1.919070610406388, -0.785325111229324, 1.3706791505396372, -1.573968994271129, -1.9398924059067115, -2.4241009780484917, -1.785915390334439, -2.895892563951026, -2.8209755886273373, -0.7318726252802307, -0.45385886068374304},
    {-2.4503485255120827, -2.2744415706546457, -1.9231936536637284, -2.8986493176432875, -2.790349651187141, -2.3051013481463523, -1.93531840995517, -1.339174744278402, -1.3747537023926453, -2.001860077448187, -1.9674858396354993, -2.6859648847578215, -0.09238819328335814, -2.4190846291712083, -1.792873041771088, -2.8533726919254643, 0.08510261521528739, -2.5277364433348812, 1.0641918534907144, -2.469423572242058, -2.698028567949706, -2.7279852452666535, -1.338404885120027, 0.5740933805293593, -2.3555757266045387, -2.35301034841865, -2.5717789795585424, -2.3554437397409944, -3.1135784101643478, -3.118671102163322, -0.8369875747887778, -1.3277757710563842},
    {-2.050736403611676, -2.375527883913354, -2.150410364034852, -2.9395603644218027, -2.5374097464024077, -1.826011060853679, -2.078671037180266, -0.752504665557873, -1.6511706635105805, -2.0224878128779245, -1.3742857289797166, -2.705339893495366, 0.44236028023109, -2.356474687934296, -1.455288054923283, -2.40838840618033, 0.31047920745863494, -2.7336891741978677, 1.894460896370158, -2.301824046056432, -2.409067313178037, -2.5414473496008694, -1.1114677504203911, 1.3082961531300494, -2.2175037712360766, -2.54376871992247, -2.3556263423597765, -2.441559897129599, -3.2397631430879987, -2.8271772502749526, -0.5970281868524386, -0.679740443662051},
    {-2.042588147814253, -2.3630573701906625, -2.340604694634396, -2.9261211571870853, -2.2743885227707428, -1.7153335194890211, -1.8422893336883257, -1.3577467926807067, -1.3265494191202971, -1.8470898153208863, -1.6801924450835846, -2.785697852231471, 0.7966852936179384, -2.141294019323575, -1.628190187094257, -2.442955489657658, 1.818571707718515, -2.51275727000996, 2.8608245010113897, -2.0050537033900477, -2.22484179357918, -2.481673374204076, -0.844391586226884, 2.1834639681339607, -1.947286448862096, -2.326758709033999, -3.350561751430484, -2.027501527521471, -4.097945288097337, -3.847511154336154, -0.22302941465971135, -0.7075205255043959},
    {-1.023233589111333, -1.515367935220199, -2.935639305120537, -2.704518077757528, -1.772458196187723, -0.9043918893003842, -1.7196815803364789, -1.64103375120386, -0.687730182049493, -0.6423709769577307, -2.3728593049278532, -1.7833595592302571, 0.4639797125429811, -1.4625087108061081, -0.3420617000656801, -2.0202097053686763, 2.476383945389763, -1.4934783126915443, 2.860526516870135, -1.1094234065674144, -1.7853507963134623, -1.9382944198238243, 0.02650225833878656, 2.2089927365484585, -1.151540483736133, -1.4587936295632773, -4.0645463463792755, -1.3536110422429368, -3.9341570061849502, -4.527019482395772, -0.4906620793353476, 0.632584290247728},
    {-1.7117752431398174, -2.1278895105448226, -3.067101234178007, -2.66316654708029, -2.1779489139767523, -1.6219617256520567, -1.375211877453117, -2.1047786067154477, -1.3588254029270779, -1.3480153059986717, -2.6275747536275897, -2.1678796850117625, 0.22134827822841185, -1.8842632113482207, -0.899200688055604, -2.4322163374837085, 1.4475799021159264, -2.161387020813038, 2.0723541267112613, -1.904975930299187, -2.0617905902178184, -2.344679699033348, -0.7537618097517013, 1.5693977100453629, -1.85807941969933, -2.258620482366268, -3.722882869512777, -1.9920116940111292, -3.925486274795698, -4.183600626365848, -0.8265214910908216, 0.31170533954171903},
    {-2.2046731148581165, -2.5128408729342198, -2.940927910952581, -3.0373095129013463, -2.6158799906542454, -2.396450214831873, -2.1342367917446574, -1.979111121914731, -1.936835036153597, -2.132509585445455, -2.3752010055457293, -3.127690100560725, -0.3733843712408221, -2.661215538551576, -1.7750602703417295, -2.7624662187550957, 0.49167324575300503, -2.74060630299692, 1.4047265343402902, -2.4141349648439334, -3.1137883646467777, -2.8165414372263533, -1.646978385285503, 1.153608600560345, -2.5545059568967896, -2.7924608912540636, -3.395387567133698, -2.585159787078093, -4.033331846093109, -3.5461993224554367, -1.552359172821692, -1.0934518726479192},
    {-1.5902686440877407, -1.9009118992023726, -3.134515669345838, -2.5188952303707666, -2.2973834664410986, -1.6512115878346274, -1.8986957546198486, -2.1326649927806587, -1.2684229642136704, -1.3693913244088933, -2.627501815647615, -2.517846101553134, 0.06774323882523467, -1.9981370225221433, -1.1612247203513324, -2.3900121559233547, 1.7313641057140268, -2.14526988058394, 2.390064626288133, -1.8690705877829163, -2.433582918241054, -2.23632305806917, -0.8352171679595102, 1.715348741003036, -1.784354738036193, -2.1831305122996896, -3.8891261566553625, -1.959687294079338, -4.0077699291152085, -4.233798259643414, -1.2186758740292958, -0.12601940077721951},
    {-1.3984482528046824, -2.073579772639027, -3.168201163415571, -2.2942013046435665, -2.0718427074215935, -0.8888293515794472, -1.871587745479524, -2.1677886270687545, -1.0837852604756446, -1.0957933616862539, -2.4459651325057545, -2.101183717274138, 0.26488604362088275, -1.7373215504662363, -0.6597759949847645, -2.469261456122634, 1.788875524889387, -1.810843993247998, 2.5540057467001995, -1.5352678248809377, -2.2107489272472507, -1.9863814542594478, -0.40316596544370875, 1.8518866292941574, -1.402585166959324, -2.0477073038543505, -4.212393676979755, -1.5897309178122039, -4.100934066574328, -3.9713741178011945, -0.7163135539731864, 0.12160131470934481},
    {-1.659267945043464, -2.1438605239979096, -3.3186837658367074, -2.223704223374023, -2.4393443178557495, -1.6705409979746029, -1.7548611491619814, -2.0182447124968266, -0.8265102228662486, -1.2702132711202363, -2.7244242676774597, -2.300997236839029, 0.01509461571725558, -1.8416940998494815, -0.8240519785179862, -2.6127055157606014, 1.9448984772880928, -1.7862936320645604, 2.465045573718013, -1.4463470771005016, -2.1600779716974756, -2.0767646158676305, -0.5151988658283606, 1.6698601456582127, -1.4766170416017577, -2.4359136736496994, -3.812826174276653, -1.955161626083874, -3.9276210852824396, -4.193874009496536, -1.0693763421001288, 0.10928381295848723},
    {-1.6567792902392693, -2.123918250325444, -3.2820782474508814, -2.445690511490557, -2.2678945335505385, -1.4596926615028212, -1.6284851830415212, -1.8286161966575258, -0.8619833354774349, -1.3660605646272956, -2.6215771562573362, -2.4490460480471854, -0.13411980270618826, -1.7016482087159348, -0.9519767183349626, -2.457939141164079, 2.2495190430076724, -1.9512140597878278, 2.3839516616266603, -1.8429288757906588, -2.4535590232631894, -2.108460024629178, -0.6890487752961557, 1.768778782286512, -1.4871704456254153, -2.170519782340296, -4.03116840076074, -1.862644614171156, -3.9549546574202545, -4.169850179484837, -1.1170196887090227, 0.1671968459622764},
    {-0.8488656950489956, -1.7675646793370523, -3.5956833037418434, -2.1219102086342305, -1.7557646461611827, -1.012114631599317, -1.9487876856156188, -1.9521444729293884, -0.9553294522211951, -0.7634860540151631, -3.016088891716455, -2.1785174992694687, -0.22654524547193117, -1.261880796427551, -0.5333012269999887, -1.8077645863976035, 2.344357449963324, -1.8583402287500128, 2.48480644989878, -1.2286107070016834, -1.5830473812281405, -2.0235955344088854, -0.11441682773987992, 1.408375367617054, -1.0841303642251232, -1.7309039188486466, -4.054753378728691, -1.2283760928447602, -4.081335809877147, -4.481426744331929, -1.4045976018445456, 0.6931237080049973}
};

static const float b1[32] = {4.695011349076748, 4.648210981716653, 5.014291219785323, 4.7312530486903315, 4.797951344191721, 4.604998497359064, 5.062199821080964, 4.942913978538502, 4.765469599125513, 4.669572958852119, 5.077800685319957, 4.699665553745055, 4.950707662869234, 4.64762438009266, 4.43623638357089, 4.62569904522915, 4.69568006668008, 4.80694288069055, 5.214448200424662, 4.571365736238504, 4.63545776836756, 4.630362835710567, 4.630798591128095, 5.135065993489974, 4.578719237440065, 4.6267343502174825, 5.074893567505435, 4.568228395736254, 4.879933071438242, 4.911257629307875, 5.002043277131343, 4.739628353217373};

static const float w2[32][16] = {
    {3.0188687669332324, 3.6923196355820544, 4.0096815306270654, 3.5236463075665756, 3.9203092143991602, 3.3147460014228685, 3.4086328795073313, 3.877594597349545, 3.379889695420177, 3.5142856302305714, 3.121074264955124, 3.5152465555071037, 4.010713822354482, 3.9285540562421786, 1.719841265590166, 3.552682581812918},
    {3.1712613797953573, 3.26632602572001, 3.847596730305563, 4.2352321687387775, 3.734823911245363, 3.9129459508909394, 3.7209057692462295, 3.80318916632535, 3.230966434962904, 3.853179400001365, 3.411996382602241, 3.83637050350308, 4.005023665669456, 3.7948734908454367, 2.1301026807612318, 3.598085365233638},
    {4.143146215914541, 4.41499689279152, 4.678611236114884, 5.104154049473251, 4.380042404367365, 4.385270284659759, 4.705957475320535, 4.516931029511877, 4.096046081422763, 4.237006987846675, 3.851760039437922, 4.305207993339585, 4.747482868612753, 4.53280490917218, 1.7470914870441503, 4.846159278652731},
    {3.5434370863438174, 3.909522148369136, 4.114200699322467, 3.767677337545734, 3.913217895943127, 4.013903488407636, 3.891175624594276, 3.221343944241363, 3.6860649347030456, 3.7765735130174773, 2.962880815161295, 4.042361699349345, 3.656577061967742, 3.4921795335688564, 1.7925432513048811, 3.41333844241069},
    {3.849200106653932, 3.7273236806985808, 4.192787610905947, 3.889194435980188, 4.071664201696439, 3.896963680575046, 3.9617083886694595, 3.400767903219208, 3.633128768236621, 3.848691046791452, 3.2288502228435676, 3.849287989590738, 3.899213803373473, 3.9271313392009914, 1.7378565021233785, 3.9230914624462407},
    {3.3268669497686956, 4.083048250883665, 4.253572306563117, 3.9582368557610366, 3.568711676771298, 3.5587615366446226, 4.296126311570222, 3.159750427895589, 3.405254629442004, 3.600520081900074, 3.5207689678665326, 3.821989621863142, 3.782466399265604, 4.1325193646506655, 2.346441408802374, 3.0536383002373273},
    {3.9398870550931107, 4.772184557877109, 4.38991611729431, 4.621872297365005, 4.582059664977908, 5.163654937282303, 5.01340181720393, 3.955827253152844, 4.491558984231612, 4.485062317375189, 3.935481046396622, 4.4649425932366595, 4.820612678147969, 4.530237674802929, 2.406684111151177, 4.320650804781538},
    {3.6580245744543425, 4.322480258018332, 4.743357687399494, 4.415637937608559, 4.612471078536479, 4.663498333307595, 4.813467496092489, 4.3329147876407, 3.9823909009753566, 4.151866578343463, 4.272433046161469, 4.460651004003708, 4.1814521057593845, 4.45216047657941, 2.0313679077997207, 4.6841921568141105},
    {3.3419165740276804, 3.675849823492443, 3.8404300500172805, 3.3599003866996395, 3.6542913320390014, 3.49176259348862, 3.8193774031523215, 3.64190057992639, 3.6754834172007893, 3.7178549605107385, 3.315595145886128, 3.6438203023921276, 3.983332986497867, 4.083862853489275, 1.7105863336527558, 3.7255687395665302},
    {3.2430749887243007, 3.920532942676173, 3.8069917129625344, 3.7957061479363845, 3.850219844417087, 3.893673606934603, 4.058703884459586, 3.2454339628939177, 3.5814206518156118, 3.6501375509529224, 3.682550281720714, 3.5784744167673455, 3.758054392230007, 3.9183780263332704, 2.182607348598879, 3.3277316841561544},
    {3.561871577550765, 4.589631519453615, 5.017841288628224, 4.460328286807094, 4.502257928806709, 4.831602358254073, 4.091287000152259, 4.287141237564503, 4.525550563041922, 4.771491237368925, 3.422556626795109, 4.3812121991383925, 4.390546339711838, 5.0901086006799545, 2.4650334826094937, 4.042349280818746},
    {3.5282185370405843, 3.8930260071727836, 3.891858425771652, 3.7824632712802613, 4.026199270211672, 3.775801670274349, 4.016782989224118, 3.5973876484694287, 3.2133078967364836, 3.8625488681803035, 3.3796973283451517, 3.5005560843969556, 3.9105563762901943, 4.098212658562406, 1.7842716805362393, 3.323791969011022},
    {4.267228526828263, 4.716516563518912, 4.148727097817904, 4.505904443239758, 4.462377066050916, 3.940658204751569, 4.514466370771131, 4.305215067299019, 4.21236767736906, 4.711999350417214, 3.7239721488875643, 4.816138063748688, 4.1959614589187435, 4.519066018654384, 2.1916964694371375, 3.8821542435139036},
    {3.0756623255034943, 3.8813037960996595, 3.667973738362502, 3.9444052998309758, 3.6054038759406306, 3.8716868447064825, 4.036101072999124, 3.545196350002232, 3.1906704861701076, 3.7583582594421285, 3.2021147997540136, 3.557682210806571, 4.038775741052784, 3.8973469466134354, 2.2588366597401826, 3.381919551358104},
    {2.956022630828464, 3.9703199311360224, 3.38775948881165, 3.882178364356742, 4.1918874728740825, 3.5535517264571963, 4.026940954258434, 3.5778694238896773, 3.4371601111972376, 3.8014283874705663, 2.7071636224535474, 3.724794779775393, 3.6919120380528354, 3.882096219559996, 2.254348883167586, 3.2676951328287505},
    {3.1009391061040827, 4.101535396195494, 3.9921909971461083, 4.017368288559557, 4.383937500206002, 3.7410783811732498, 4.488064757458382, 3.7137914095546507, 3.226805261359386, 4.379841418494448, 3.3905991046998163, 3.959995991774696, 4.129610144055635, 4.001420386818364, 1.8680743351965818, 3.7823499270688514},
    {3.463074271631924, 4.411215490727388, 4.138909508351388, 3.9060165751241573, 3.9981534242270165, 4.147840081434972, 4.297521227289804, 4.153300323491499, 3.5318759120970205, 4.0096563500651605, 3.743908766286533, 4.140060224196645, 4.1392897585538435, 4.242972711922777, 2.4154690086169426, 4.097279453445532},
    {3.1988873962120974, 4.1076137904881005, 3.737162685151377, 4.007224365139308, 4.4125018896621455, 4.380099861742154, 3.949977730089712, 3.821396275635475, 3.8963920487832358, 4.169155890649109, 3.3493023332011065, 4.076140820432536, 3.800942707881144, 4.422687324413477, 1.780590057056639, 3.4733031997084223},
    {3.958403694150436, 4.240335954724816, 4.775779906486546, 4.302176925647799, 3.988381692277234, 4.3259979793339856, 4.195262765134149, 4.389263704371272, 3.855322477228406, 4.3085043089943404, 3.6849149837397346, 4.558192097686, 4.4300508690069735, 4.033736025205053, 2.259865280997183, 3.901649958934276},
    {3.1009881876557532, 3.678714942940039, 3.7535702435431877, 4.068335041977376, 3.80761436496432, 3.981243515889851, 3.719914253311319, 3.216080302997996, 3.6889892970794533, 3.777171034215101, 3.2236329914126958, 3.607096741120609, 3.8296857631466774, 3.8848889700812475, 2.1393672902266148, 4.037316078545052},
    {3.357718606988206, 4.0651780541349, 3.49007050094076, 4.055892582650105, 3.7079778068888483, 4.068842029368109, 3.7012596151652737, 3.7256234889752466, 3.7191657866268666, 3.962914691386489, 3.1731190030924865, 3.597873177440092, 4.1762581103956675, 3.976512141370888, 2.205432922884271, 3.7481776869729173},
    {3.4615933868506352, 3.8357706206429794, 3.6701411548009104, 4.309629402264833, 3.7260881202697274, 3.5365383498630316, 3.7176658257671975, 3.269279283832286, 3.4685219767360147, 4.158098779163654, 3.543540203390675, 3.878542436777262, 3.4381413430741725, 4.25991836953849, 2.3381530340230094, 3.6631842863269046},
    {3.4663486196507964, 4.003951291345771, 3.788528578680503, 3.9001832921486685, 3.9401606722668467, 4.075296926628643, 4.0970349988415915, 3.5422482378177693, 3.4834743622758446, 3.6648126386137827, 3.1840101110063666, 3.981885122305535, 4.2174111305720645, 4.241803889722605, 1.9420928659109866, 3.6718584937422554},
    {3.8603491991192143, 4.768561138899089, 4.132083630879238, 4.3546092340014395, 4.455456077740577, 4.115157999480748, 4.504999499062563, 3.9284130943180737, 4.138703414978266, 4.056802525022621, 4.027078710307656, 4.117113176754519, 4.32846393433865, 4.783975982090244, 2.1159830192915874, 4.015473612083062},
    {3.294649608519678, 3.762334296636283, 4.084124255086864, 4.135650524017838, 3.8978210163060534, 3.7461956578719957, 3.693764401045074, 3.8568518355135155, 3.6452302781991612, 3.440842366417131, 2.8350510996600606, 4.326619454934145, 3.931694765753287, 3.3298145757270143, 1.8117841618830846, 3.8334312887211333},
    {3.85242678769649, 3.7166020544703224, 4.1496412339912165, 3.7747971584118107, 3.807713607918877, 3.979755525230105, 3.863690508733836, 3.3086777357036183, 3.2920715213312044, 3.967236770663761, 3.6081422989342298, 3.86198364574036, 3.7234729257974024, 3.5527429194415063, 2.1460494837571584, 3.8176055300448777},
    {3.7025421790727604, 4.55802903253491, 4.264417618698388, 4.629922427344015, 4.378678243159592, 4.647347426205934, 4.762312234143295, 4.625466177425678, 3.8700280618660483, 4.617259954629696, 3.732169449616727, 4.613276150523825, 4.382611958362791, 4.6677896636303995, 1.9892530836651505, 3.909669426139199},
    {2.872823072369024, 3.237822738590269, 3.8237410485072734, 4.175766599389749, 4.071463441848145, 3.6999442559856868, 4.042851121531609, 3.797029725938449, 3.61262227680392, 3.9896142107226065, 3.4004325240680373, 4.026139491922663, 3.8449969746591703, 3.7323561916634, 2.449488105148163, 3.3182453765248234},
    {4.031360701589982, 4.490503041130735, 4.412520926158836, 4.291786478933893, 3.92236233975441, 4.416907413509081, 4.723456446432726, 4.134920321455693, 4.399399128053602, 4.7778069610397225, 3.569097706951565, 4.3230240535601, 3.9231167720363564, 4.542022761046779, 2.4489057743738383, 4.047243849651676},
    {4.594412833550335, 4.637604305684079, 4.1968633566356, 4.994214996251691, 4.7590024176673165, 4.784775388566693, 4.830595940027206, 4.72805556228145, 4.031685726698643, 4.509116324870962, 4.040954976030486, 4.3750841900795585, 4.494991141073021, 4.634037211624465, 2.2761811625927684, 4.281556600010355},
    {3.925991050568276, 4.604052031720944, 4.422503289818613, 5.200785633892214, 4.194579546271106, 4.858739438014655, 4.54545737638506, 4.402489319139745, 4.704725026255693, 4.180175373656836, 3.9107015192611057, 4.729794389000556, 4.453749558018402, 4.6303516321133955, 1.8228170822268395, 4.6853520257375125},
    {3.3158406667161087, 4.038139140070278, 3.733629793252726, 3.9850015199186877, 3.707118065497507, 4.204501556794738, 3.7093045671326585, 3.8721903730269607, 3.62255903804393, 3.885309602468101, 3.0559186089041863, 3.609332029577871, 4.109005496185855, 3.9155304940454805, 2.0560312951381294, 3.3524949472541983}
};

static const float b2[16] = {4.003476947563475, 3.955934891573156, 3.641971098850964, 3.848842537238324, 3.8303347229089906, 3.902469940210699, 3.9701994433954435, 4.1545569306585275, 4.285353523139994, 3.7191908632989663, 3.854745659025465, 3.851097074894907, 3.7264001781734137, 3.896420454981054, 2.7000054700340104, 3.99358926569487};

static const float w3[16][12] = {
    {-2.774803736483623, -3.057555700625831, -2.751375903494416, -2.4433003580797146, -3.3484267978384246, -2.764847877174011, -2.7621241625152115, -2.473303899799991, -3.191751123653176, -3.139851048176294, -2.8881845049176316, -2.5344328339040483},
    {-3.0288599990556655, -2.9707724051755626, -2.6838941839584445, -3.418907398263027, -3.05147687951943, -2.805390081649315, -3.2199095760608776, -2.9360682065877968, -3.4619630104524086, -3.1740019414332337, -2.6881890162881916, -3.4846696915231874},
    {-3.1333471278916494, -3.3914739454464318, -2.361781034626132, -3.077841708907246, -2.9800013349325942, -3.0425039216041547, -3.2686094268839287, -3.2942932370559475, -2.7377345470316987, -3.275367215484511, -3.0930063893854354, -2.763944613258809},
    {-3.376214169488552, -3.10297184339907, -2.8518605891702307, -3.129520318695446, -2.8194674324151774, -3.1364570653156454, -2.941129354186031, -3.200921569831881, -2.8295080665834638, -3.2240735376400416, -2.7484644119033312, -2.5209698973661827},
    {-2.7758242474569523, -2.941113314359823, -2.7028700366496134, -3.696249292960218, -3.5388811930055306, -2.80516497697021, -3.2339370792461977, -2.842730009714246, -3.87007452030133, -2.7700380160223497, -3.1113097682044963, -2.8496876635117476},
    {-3.1605757964915497, -3.303462202540047, -3.3390173119945095, -2.8321305852589416, -3.3364979761420557, -2.816847348022379, -2.960363000675979, -3.2249007690626503, -2.6298178265626397, -3.0826119167555044, -2.854094952064732, -3.1970652907326875},
    {-2.95640290560422, -2.831052943469303, -2.6566480144318882, -3.05468693404969, -3.5697908366038775, -3.21494451994067, -2.573925060347273, -2.7876341395549975, -3.78408458028501, -3.267180549685518, -3.524762896250964, -2.9633187340476517},
    {-2.9369367402121433, -2.9571280207439616, -3.042216699299387, -2.9465085031486833, -2.666793557096097, -2.8138013895009517, -2.9617462773248073, -2.555113267280088, -2.8079434832835464, -2.7280609812589205, -3.0163951403872717, -2.8578848499024168},
    {-2.6857857591053342, -3.4576339133129217, -3.0656385589640265, -3.0594594684317253, -3.1955374854388063, -3.1256124583442544, -3.037874030332795, -4.037973101030043, -2.2303945308808024, -3.079452494628706, -2.6685703313360425, -3.1474538636931557},
    {-2.7309342027133474, -3.110236428833595, -3.197871705592568, -3.156940817105163, -2.6300503411787544, -3.000634846330776, -3.367315741081044, -2.668377472457862, -3.5386413057178547, -2.658700333682951, -3.1842440617641343, -3.2549587119126437},
    {-1.9679251623576999, -2.6398809951141993, -2.792402088392044, -2.628683304805871, -2.50421511885072, -2.5072224038214883, -2.9624257208317144, -2.806535893453822, -2.4601348148945066, -2.7780118679472885, -2.4886065310926804, -2.2761813486715523},
    {-2.7755512602054004, -2.6757630060065316, -3.247189299472019, -2.71434227581398, -3.09042609123434, -3.8557505284813685, -2.646213671404238, -3.1405944012224447, -2.785951824578413, -2.619595048485259, -2.514328116756507, -3.112075028185429},
    {-2.703533090079282, -3.1167261938850483, -3.5321416299429265, -2.8966838824256667, -3.054508938245371, -2.91678147445081, -3.093599291870137, -2.8537936665493926, -3.0981567485179986, -3.38163138149524, -3.220151062395622, -3.099470312027735},
    {-3.949348086104851, -2.4661946084286055, -3.3687309943742845, -3.073174745557608, -2.6361957765008883, -3.0271991951780093, -3.181429694889576, -2.917619845496562, -2.9552919429624507, -3.2483979950942494, -3.2440958928974517, -3.017868706009153},
    {-2.617334802099276, -1.4324071819023956, -1.5041927638055559, -1.6297424740863704, -1.602541849153356, -1.4092898462243701, -1.2444480907676845, -2.108416649222571, -0.9214559148603194, -1.7410006987793076, -1.492224852999892, -2.2668913582937718},
    {-3.2543099701922906, -2.8294407190809117, -3.058674962041173, -2.593096155470956, -2.3360399628931474, -2.9063886371808096, -2.6904524669165117, -2.87363719194633, -2.5956016965404034, -2.3343480680751334, -3.5160694658552205, -3.224178587130627}
};

static const float b3[12] = {-2.3510798100963917, -1.4965596788567765, -1.7024298280196446, -1.9267841295545436, -1.6587407210602647, -1.2467485209070417, -1.3833335805783336, -1.3170759543165205, -1.4669095775075243, -2.048566466181272, -1.7697400441900326, -1.5463514448822735};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
