#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-0.9569500798233396, -0.5691219863547541, -3.334005260857575, -0.9467162196751563, -2.2126615135008474, -0.24290476822332177, -3.156550765704817, -4.194650883046466, -1.9368304830195668, -1.3720293654791706, -0.9737411792696876, -3.3553058775132643, -1.8332006394796578, -1.4908857177409096, 1.1869885483849203, -0.9599089101227092, -2.5144065225204897, 0.6575976038543373, -1.7613049963434821, -1.4715714950561924, -2.663285710798227, 0.1698587135582569, -5.79230855629043, -2.9527178182498948, -2.09497330807366, 0.04701478823088223, 1.267047730911318, -1.9899761412196793, -0.12724867158515038, -0.6082335799862864, -0.797937457206182, -2.1799296772276047},
    {0.8855608219587737, -0.19031517295808206, 0.43840394983543685, -0.6839889726624521, 0.3330818838627189, -0.16762468049478962, 1.6014759322823457, 1.623614680620978, 1.2438781475819276, 1.5340186962369244, -2.143326841257911, 0.7213322808351624, 0.7066379759535666, 2.7058109446729013, -0.7034726967244181, -1.16774312515504, -0.47436954563588213, 0.9440864762153441, 1.1056160548019318, 0.5156743122485254, 1.3270929139349943, -0.9583343928816216, 2.911571061872892, 2.882541674882742, 2.508006651255168, 1.5069933714778994, -1.2350194660018792, 1.3062534863205475, -1.4493193489527083, -0.9225142421518557, 2.2638150332374907, -0.26787600877815243},
    {1.0797305277223603, -0.31502237433251845, 0.9551415919785354, -1.1321514825804597, 0.8610314002550933, -1.5141770691779024, 0.9326504620013034, 2.618393684894085, -1.1201069431568251, -0.08212121852715143, 0.8607927498730561, -4.631206126605389, 0.09427412314528215, 0.8497894559380803, 1.1758174382366864, -0.49994302541386926, -0.1602949272120603, -0.7288024038626294, 0.2483212887805766, -1.9953396688351122, 0.9784180391137446, -1.5411260001805358, -0.647644845575061, -0.06147280846475266, -1.133653138757319, 1.0196941154601589, -2.853335452268062, -0.42181071945582904, -1.1695838524376523, 1.5929532156818544, -0.23619233047909852, -1.270885364494891},
    {1.6365437862320407, 0.8483860409372909, -0.266414546830003, -0.4988171397005898, -1.6864363910426496, 1.9446136217766832, -1.9495347086251993, 0.26129259911578795, -1.0195910701296362, 0.4454189061707509, 1.765427471816563, -1.936614263943679, 0.40828577727607135, -0.8232253220507417, 1.0057914952906815, 0.3031341209448369, 0.791739970412857, -0.8224331083117227, -0.8465236286934588, -1.8377907171023746, -0.7213909766047959, -1.6638558274610915, -2.7480968517059288, -1.239371956216732, -0.7926349082253751, -2.9318682859790823, -1.1456532404151323, -1.3706022234066146, -1.0238321679325069, 1.6154419115958365, -2.5596498468064035, -3.1773553425515892},
    {-0.673043875553621, 1.3184948980228415, 0.20886362341082704, -0.5613038991205481, 1.8228592818253218, 2.521351130622747, -2.218875086559715, 0.4806223405125947, 1.9972625113827072, -0.1569650114746887, 5.128968958906792, 0.16601685614441822, -0.18539717244900727, 0.835089468787875, -1.9491517564601726, -0.802465114429096, 2.4541878399729606, -0.39911434665283846, 1.159556662393713, -2.0320391911661035, 1.3765294009507192, 0.9461171024287428, 0.5245006381244035, 1.1384733591051852, 0.5769579766318662, 0.6423482195598942, 0.34578214804706486, -2.8374515295158, -1.6042950698356964, 0.18162558704863446, -0.7554677101265405, -1.8973941325613297},
    {2.5229232467867346, -0.5230257035700223, 4.167637581659566, 0.9489026633376204, 2.780961623135611, 1.4777441385656405, 0.8593047270380804, 2.4530762972418336, 1.3122834837045394, -3.1296668170325797, 1.1468965814557568, 0.1494598433181228, -0.9074049155223438, 3.5228916611968275, -1.7983186346393931, 0.7634165092628307, -0.14653242713508838, -1.0166285467220766, 0.18222574071965503, -1.3587481283064953, 2.6408316629827278, 4.421660934434037, 1.9122941998520961, -0.3897380062212491, 0.9837040835928323, -0.4786982896466317, -0.5883898410638516, -1.240640768333758, -2.856188595837688, 0.7071783805686412, -1.0012438640077905, -0.9134510016655761},
    {1.843195288496356, -2.258461098069537, 4.893798821678596, -0.7376152199046967, 1.764338137414185, 0.008416893563731568, -0.12059490305616978, 0.8775874252287467, 1.4340020774365294, -1.4805650714364564, -1.1647546744392319, -2.1363505931102216, -0.09872948128927352, 2.1127917082668386, -0.5373238244991964, 0.8492651040677535, 0.6124364711469791, 0.38526737366096997, 2.8246213758549366, 0.9022133007930988, 0.4931785173998395, 0.7222370682530405, 3.7998163520751755, 0.9970174842631764, -0.05910632465457547, -1.1052480099917128, -0.7091056966947188, 0.8647947846255528, 2.32834670053376, -0.012333607027976293, -0.04075007815786989, 0.0037621904082521117},
    {0.9900329395968858, -0.3068435184739423, 0.7989562175347478, -0.9011822114293524, 0.2677228557436235, -1.9879959482291654, -0.012754769671092412, 0.5002252804387844, -1.093119685214885, -1.4758643984486695, 1.1325601849545552, -2.938649035487136, 0.532565605219018, 2.5545239329327942, -1.8901289933372114, -1.3465434017053404, -1.5057255786413635, 0.4666564178887565, 2.445224007780753, -0.7598703077112576, 0.09572087626890272, -2.074277348628192, -0.13830249070839806, 0.5664238871216125, -0.21824763205853812, 1.1080281848182902, -2.2772439720436863, -1.0018900422755541, -2.8340214157430133, 0.03105381110637899, -0.30580661808059245, -1.5614144000870627},
    {1.795010291738464, 5.613390213165411, 0.7767883305535144, 2.605963162431901, 2.692121908076357, 3.0329487117994915, 0.9955329674873936, -0.3693925137335543, -1.284791495487639, 0.5818900126261797, 0.32121148036303987, -1.6926871375444126, 0.6481936959289124, 2.0540612251602477, 0.05610470037043314, -1.630363798834852, 1.811154906428979, 0.7721272210072428, -1.3610517559880333, 2.1845980084413297, -0.11028935478163636, -3.1029039533639082, -2.07033714900383, 1.301125398667087, -0.9006539829737567, 2.69965090746916, -1.6570216567413834, 1.6000995936431137, 0.8586793381527136, 0.9937264160209048, 2.724357749770633, 0.4782152032355103},
    {-0.08929108417045103, -0.572220452890141, 2.988667213842493, -0.4565496593142079, 2.3271786663422795, 0.012156624192798433, 0.24640832642453417, 0.8056600415147426, 2.364390109320553, -0.5008787863462989, -0.25289001457335264, 0.48725661681451576, -2.5519364252255343, 3.655547227238417, 0.8297322635082834, -0.6964950805968276, 2.9862996071838284, 1.0591984572793849, -0.1400841607135074, 1.1213308609151116, 1.0001321712914102, 2.8395125987285725, 4.189388152164429, 0.9976579356365273, 0.021066447739966566, 1.5907809875480747, -0.34246593630097055, 1.3992651179490767, 1.13336819956067, -0.8042820007347811, 0.9590354251245078, 0.3647424811358178},
    {2.0463206550415505, -0.9484272272348357, 1.698473379461521, -0.5627151672782301, -0.1380078719148561, 0.2012923002232776, -2.0386994959790643, -1.2543093463034476, 0.33041428346893426, -0.012643610508075854, 2.9642177828283076, 2.085259546245488, -0.6763134980233105, 1.358622914707577, -1.530266028911909, 0.16484301028464585, 2.290069673087288, 0.5431421323515595, -1.2584157109989873, 0.7632416848978064, 3.170339527846289, 2.7047400160694015, 2.4157206297667115, -0.13169820042364294, -1.5558538663074903, 0.7801268906089615, -1.6193396170282779, 1.336755569542418, -0.14195404002558545, -0.5895850016343953, 0.5693414369679319, -0.3930795577235039},
    {-1.315929527119357, 0.6367295215348808, -0.6880272287216629, 0.128810014480017, -0.1291668920699874, 2.979550665842446, -1.0741864718282175, 0.36649729700670686, -2.170593650224722, 1.9034678500910622, -1.7915294739529413, 0.1752837187541292, 1.934431375300432, -0.026141006686447543, 1.8027042273765437, 0.611738116433424, 2.6061004230840616, 4.746122793440276, 0.5961375703235949, 3.6540809154293283, 0.4766857045719633, 0.6988645963563338, 2.182399968566846, 1.1937657595539484, 1.7579815531843788, 1.9560816381989694, 0.7283825806138562, 0.8335836458504827, -0.806126787593209, 1.1669748667033844, 1.9400839373655219, -1.0933461845056043},
    {-0.524230685726537, -1.08599765695527, -0.5147944900422783, -0.8782456636156942, 0.6344402159839931, -1.559393061864733, 0.47997575929074415, 1.090455129865408, 2.161032529799932, -1.6497100732849126, -0.4202653141329934, -1.6630963878178548, -1.6501387184788971, 4.354524959483373, -1.0639817061708956, -1.3436921455504465, -0.6451724412412884, 1.1106019239581624, -1.1671143206800403, -0.8356518768262811, 1.3308087943159883, -2.3807384268366487, 3.679900703060426, 1.9921031342000168, -1.6840609608050905, -0.11554262846506155, -0.3977056816796707, 1.8281384449485336, 1.8404978891522692, 1.313270546026141, 3.5960020834421673, 1.9960942346816393},
    {0.6683094893147143, -0.32447364225865644, 0.9541149985401443, 2.213964427178741, 0.8723172591335542, 1.9671739953560685, 2.589863470982478, 0.5037655946780847, -2.1536367809286525, -0.12717082671987354, -0.6232796249504332, -0.7694290102518073, 2.624560641553354, 1.8631075837058606, 0.21029018368116334, 0.4343693697421222, 2.1586238519797663, 0.46849687579305876, -3.0387697966860276, 3.872558332265433, 0.40066673234870337, 1.6854099353338199, 1.122826407799751, 0.6101396718346164, -0.35007261514774474, 0.03920640568115934, 2.005631718470374, -0.8122740418040733, 0.9202893268607001, -0.007456153379018361, -2.1001436039947237, -2.6473405718213434},
    {-3.2440051861101136, -2.6417152396515697, -0.7989343941967638, 2.648987954697076, -1.5713810278574656, 1.4296992894820504, -1.3408231952640504, -3.247375311489013, -2.255375837348681, -0.6549269775922276, -1.1991061245041965, -4.240957628426687, 0.5843746561715232, -3.271958642830383, -2.8107819832489844, 3.7014876854034844, -0.8454148917966232, -0.8623707223606327, 0.8911734465318516, -2.09161406247546, -1.6271518066282944, -0.053800296976205225, 1.1112524704728572, -0.9645253197214075, -1.4569901670524434, -1.2240243909844206, 2.630364348127093, 0.7295533603710915, -0.21421987721156563, -0.9317468369490345, -0.7715992367013772, -1.931296590007507},
    {-0.3929241576482019, 0.8520543169452152, -0.8941340869932594, 2.499467112705845, -1.978163676473551, 3.208168249491162, 0.03130815044294465, 0.25464923999062755, -0.45600859096283763, 1.2984911468953608, -0.12251583408441048, 0.9514061886938991, 0.5927040395919637, 0.28431255129136807, -0.7727481520264503, 0.9056701033067154, -0.5348284248412488, -1.1651181384856946, -1.7857649130201096, 1.672332378202871, -1.3066367408634187, -2.2765475826365558, -1.372797534821724, 0.6767706297936319, 0.2974814267284218, 1.5444234599477804, 2.9335798065473204, 0.9870901022051943, 2.4940940453884375, 1.7186997470996033, 3.22784795298753, 2.8049813048264034},
    {-0.4727381765087431, -3.6911824138372156, 1.598264079647344, 1.827025292933068, -0.5239589278758642, 2.7279554407037074, 0.453610376898962, -0.8547209010948092, -0.004551118342268586, -0.5113141597633016, -1.2742873824651566, -0.9988910164275056, 0.6448998564559397, -1.3170390583941871, -1.3583766687229382, 3.0189551690879854, -1.6274713694265763, -0.644936667171992, -1.2779356565096454, -0.047506631017842804, -0.12850255705141722, 3.3484717666429145, 1.4369595193496856, -0.2031867684146137, 0.09369745901924453, -0.4708296307107906, 1.5199555777997509, 1.6785882954895872, -0.9126259148390174, 0.12457067905539777, 0.7387868535003709, 0.18683553443130613},
    {4.273220145304855, -1.8500055795262145, 4.257613821602657, 2.366765888074872, 0.27091164705925, 2.765634217346855, -1.1320660820380435, -0.5899007830875118, 2.8587983946085913, 1.4483987053755936, -1.6469898105950753, 2.2569082985858264, 3.3011762111723284, 1.2483800968552536, -0.8314227752697562, 0.7259026964561428, 0.18898426103687554, 2.2458947278100068, 0.989404485058225, 3.561416279312435, -0.9896665273855378, 3.0330676581925693, 3.0475625932203343, 0.24571150245670548, -0.2591384510120026, -0.2283449760041096, 1.7759568795124114, -0.17657421050134856, 2.8580237882332473, 0.40697069088460747, 1.339931721134248, -1.0727846238574859},
    {1.26324577380015, -1.981304016803818, 0.8143508318847062, -0.3895911316305608, -0.05240909615593969, 2.0951536441237413, 1.4642059926314437, -2.6650239997872958, 0.07090672434070092, -0.8556845320818587, -1.2674900689429753, -0.5310616004321951, 2.0349892683989657, -0.046428996539380346, 1.3157461957359595, 0.9969636190006732, -0.8421118716656746, -0.04996000703016768, -0.29860325547605476, 1.1062223530383384, -0.3527627638186633, 1.893851058828809, -1.1794057271467335, 0.00453060470710492, 2.2837474870109262, -1.6073698273818362, 0.6662299466471385, -0.8375342363738862, -0.6070749312705546, -0.716103838091018, 0.4111973549813768, -1.517612437489139},
    {-1.4377829079563238, -1.626013687746, -0.19484786604400509, -0.08563999321297908, -0.24258361514225238, -1.1154052260087484, -2.8210349187538606, -0.47745699959363236, 0.6315780877363195, -1.8031585667158063, -0.07225810609650943, -0.27638480426480744, 0.08084488603853665, -0.45178056897733554, 0.10684400281807786, 0.3493020919818893, -1.6979503565431897, 1.0916274462281832, -2.075726235941385, -3.2805341965115, 0.33222989322923785, -0.8711669274676049, 1.9867240899987353, -0.5866357084204853, 0.47047673272647517, -2.6630122398760685, -1.8613619941719415, -0.32258247537578855, -1.6077961731225459, -1.9558462618055905, -0.5526892954038759, -2.6185647951556135},
    {-1.9402792950313081, 1.1305422095574416, -3.5690135634775144, -0.7755073122327947, 0.002526865311979648, 1.9499484340313644, -1.588947909921241, -1.569925170122507, -1.015118542340112, -1.1977728201470672, -1.710494157882456, 2.3686848700196816, 2.104123365208127, -2.303690968328314, -0.786720306029718, 2.1871894731199766, -1.693208825854752, -0.5619238815934562, -1.0920490513863346, -4.106539192423899, -1.4044620730786679, 0.8804520838738948, 0.67333932765229, -3.3888149888408217, -1.070635940006376, -2.3215324820458645, 1.6190672376921282, -0.7814996638346564, -0.6402133321127038, -1.2700783929636494, -1.8573578624459115, -0.9613998076593385},
    {-0.6320267606368406, 0.938187624577923, 2.1951208165605354, -1.0510285765332041, -1.8330565011797435, 1.6332756725976458, 1.2627678151192765, -0.9233640258070748, 0.4963570681388574, 0.04130417340348323, -0.224995261161361, -0.25062728425476277, -1.2458334330195404, -0.29005670706228226, -1.094990612542035, 2.4019378543163636, -1.442212323284426, 0.33643817688268507, -0.7769896130468501, -2.273361160121731, -2.330255168383184, -0.5596706158662168, 1.0345390072171106, 0.8647607044668039, -3.0729991802195964, -0.36917093141495144, 1.2189957459495468, 1.2588071079047642, -0.2367748352227122, -2.5354320016973393, -2.0246443776550564, -3.1049685454604137},
    {-1.8873491596611995, -0.7348566712870643, 1.205936702534598, -0.14655830424500307, -0.5668113659726965, -0.14876974303325222, -3.054884111166865, 0.23304180298643148, 0.2653857811011136, 0.9195441874863436, -0.13335875858372376, -0.07173569423238446, 2.3999623752594066, -2.34962454694737, 1.9214283014408031, 0.16987916489597243, 1.3988291002959694, -0.6107107094978949, -2.460853255893696, -2.0991134715508295, -1.8972479673777816, -0.307365944015692, 1.3679872683819985, -1.2318401319708205, -0.031391352733517945, 0.006116592761947184, -0.6963266559670781, 0.08287692471845977, -0.03899278622685176, -1.942149114024629, -0.41898043434674426, -0.9754077904453402},
    {-2.5435270339857623, -0.6047078023597474, 1.116044737771216, -1.8152855252999158, -1.8120074066894516, -2.5983531344684776, 2.281055659402907, -1.1496124239127932, 1.0501250804086308, 1.0215334096006337, 0.4755452782615938, 0.2955475806782803, -0.022194198100290375, -0.5520985663718615, 2.3746104704834847, -1.9068831372334976, -0.6535365369743433, -0.4383704694523897, -0.900291033222373, 0.3666760256477626, -1.1663141993632475, 2.862720423883923, 0.1833114505859423, -0.656059842647273, -0.8624872167099982, -0.5014713565843129, -2.7399459028954807, -2.880480737362589, -2.527383959998203, -2.8669834690186597, 1.1093691873411589, -1.0277330589533387},
    {1.7259872774008003, 1.1615022457186182, 2.6419584800157594, -1.2848534936508267, 2.0090376934089202, 0.5645465964358539, -0.3037218882032521, 0.8546806431723809, 0.48712323142054237, 0.47184132833381337, -1.2427982930194512, 0.36719288233866626, 0.7171126357756877, -1.2529416016933677, 1.6391852846201018, 1.0147768565150932, -0.9504688604748068, -0.5282911909419531, 0.9854871042890515, 2.1420874352895174, -1.0260348657208, 2.5793486430033115, -0.49997474120319374, -0.691767590342405, 0.2845166854390879, -1.5788767709217535, -2.3000023427173217, -0.9421475406979691, -3.5088096286493893, 0.8016824105752625, -2.3388949236181187, -2.9515874700833735},
    {-1.8396664129640894, 2.2988116923190693, 0.9806085916071439, -1.6824429551783415, -3.2088613236414134, -2.4691782318650457, -1.2802714203017858, -1.0507147440114224, -0.49583139166809775, 0.2637875375518507, 1.2475760909599074, -1.040256173734535, -0.5394280105539119, -3.4191666936452507, 1.7924721923263793, 0.5884813107648482, -0.11860641564548884, -0.5530700247133962, 1.2415844616695326, 0.55350293752419, -1.665798153276596, 2.0368850748238456, -1.0505714865203666, -2.128507095851278, -0.3136253791384694, 0.34174705400337135, -2.646455070305013, -1.898350763556149, -0.766089707974816, 0.6949237839636357, -2.391661278466697, -2.5259591834511745},
    {-2.756232093015188, 2.878630728158179, -0.08782658533187301, -1.8819068111117268, 0.2355454418327837, 0.34850681055585064, -0.9864337365316797, -2.763558097861643, 0.6002809487849227, 2.1751783290259774, -1.1365547414122361, 1.3567927351860685, 0.5498542201390249, -3.671422136940289, -0.9323785799201845, 0.6712445683341098, -0.9973794862335584, 1.2496304714535922, -1.3599907386375918, -1.0107502966553796, -3.759750591273632, 2.3814401652612993, 0.7797912477300865, -3.62966782441749, -0.7666479223211518, -1.3688506467363852, -0.31731750921722585, -0.7859877327304655, -0.13007355253235045, -3.4733875957324956, -0.4794859290862054, -2.497847119549127},
    {1.5191380843198772, -1.6081309225366467, 0.37333531705532164, -0.8181363050758425, -0.12165757656270429, -2.950581146701912, -1.6771556863470032, 0.2422547645285196, -1.1325673205180187, -1.2506098858546448, -2.8894119186932, -0.12404778236139803, -2.0021934243942265, -1.7606630425933811, 0.7063186316330833, 1.4943939191376432, 0.8770707052705017, -0.03605541690276837, -1.0665242188068966, 1.4550447056110032, -0.9590003611244909, 1.858228296905497, -0.2345603268738226, -0.6756901026513977, 1.7870383689448446, -2.454666750923563, -1.014486815459532, -0.3358052225130102, -0.6268505109731887, 0.3736885835031877, -0.30270546064782466, -0.39624532276095853},
    {-0.8326848135405327, -0.6615845119387914, 0.24191884105660164, -1.1061171775259508, 0.3759154927986226, 0.2731708794703432, -0.0044180443305433595, 0.6331012382309809, -0.7570211246128605, 0.7771776483608699, -0.20186726082125744, -1.6738628717967994, 0.15537532318345718, -1.368610738646807, 1.2569249624907715, 0.11863467025314764, 0.8467232717488908, 1.5022584410054005, -1.2875375451761024, 1.4557517511088671, -1.2221076139191493, 2.045809443675347, 1.199992338677677, -1.6235976080284682, -1.1996781131111958, -1.2296625138733364, 0.3812214082006865, -0.5485708391332742, -3.407197055927965, -1.3041113899745502, -0.3302924964006661, -0.6769996114711125},
    {-0.43171323535783296, 0.14114273253058254, 1.9531196203236687, -1.0324136971188913, 2.051578830673119, 0.08333280859198419, -1.738950408178958, -2.8022625195593043, -0.5832107795727965, -1.398191876004046, 3.367224992956965, 1.0016107150283227, 1.4713505103634192, -3.398471996921984, 2.9869431019769017, 0.15196146199482985, 0.5244706565896823, -0.38517602385825983, 1.7456395060993286, 2.6944587379447094, -0.04827000271644769, 2.3926324762796716, 1.5622400316861762, -1.427344665083696, -1.8353618847476785, -0.43293515692437934, 2.4459352790883715, -0.6064347870781227, -1.3032591362493033, -1.3472905145122573, 1.1677846165497683, -2.5951542476397575},
    {-2.5392158996402565, -2.5048703523494464, -1.370617519812744, -2.431238303148504, -2.1431138079888035, 1.0601756979893895, -4.928561683818906, -0.970035249310653, -1.645768370310438, -2.1448992015798876, -1.737260915697187, -2.108281310776252, -1.9934849154527678, -3.7007895027849433, -0.2551562981085033, -1.355320846465465, -0.8675799377626618, -1.892899571855598, -5.970876882932241, -2.8127326220908406, -4.167845323424796, 0.6334306211120587, -1.5969434473444923, -2.964564462308479, -2.5467798634286143, 0.6197962480126588, -1.5954983705744339, 0.6400735015094782, -4.04215349925977, -1.745079502443387, -1.929649128880627, -0.8687192468719921},
    {-0.5169855844196252, -1.5725666319646283, -3.439284270719646, -3.667301243268988, -2.0227637339353457, -0.04048031238116057, -4.5415470110321445, -0.4833124684056328, -3.719969782861767, -1.093718336888274, -3.140932736357621, -0.8809538229318888, 1.089743105014204, -4.555668203147059, -0.23084917536522842, -1.4948354556974839, -2.2616136276375616, -0.2657419592425064, -2.5510855014281546, -1.0557145111598263, -4.588267617042872, 1.2956038799592606, -4.054440416671036, -0.5165409835845528, -3.421430398346933, -0.5258989307786196, 0.03775069664738147, -0.030792101463016953, -1.9576691686896488, -2.4948906426065345, -0.9127455168911879, -4.336877585968506},
    {-1.6387196731927138, 1.412669454692782, -2.2566943372639785, -1.3788382347863615, -0.049407142609179035, 0.04409623783933853, -4.733412518812964, 0.9765682457189637, -4.241256906482244, -0.9854203144295729, -3.5407107126434827, 0.5875623811422328, 0.07468175008113175, -1.6766994072458192, 1.6975123995061954, 2.2015569369197365, -0.5758829396100446, -1.951506175777371, 0.7564320169996863, -1.678914849784547, -2.710232813707054, -0.45314139876448173, 0.38077196545745345, -1.346902326578088, -3.7293040794123384, 0.05850798706111007, 1.8669450174550912, -1.2428325142043342, -2.3534108370702516, -1.2593220670033363, -0.42146588262920054, 1.040281287012339},
    {-0.23185861596371618, 0.551077025357279, -1.5567090689479237, -0.4747368458601085, -0.40600946218890416, -0.6223212291298741, -2.110402775581585, 1.348113765365033, -1.4334095602737662, -1.8846180730784812, 4.313581373441554, 0.789936863995247, -0.9938830367013056, -0.7369709012683612, -0.9873016634308666, 0.854403919376771, 0.06117802063762641, 1.076361466972837, 0.05685355601336186, -0.11554850335504427, -0.6046223948532797, -0.3750016865778911, -0.06525058254181756, -0.9357812055034653, 0.23384701346100592, -0.8242843591924875, 0.40592230693072723, 1.0549540447920094, -1.4460861167663968, -1.6480838240524875, -1.7946025615818186, 0.3680736402512575},
    {1.3656087392111906, 3.4946026997972517, -2.4559745819848455, 2.221256949061329, 0.9615996752209407, 0.5576881289539729, 0.7825352975441139, 1.1051256850365199, -1.891713327994053, -1.1664973609258211, -1.405256075989107, -0.2230167164052038, -1.491468838831568, -0.3976657381103374, 0.6247334880681804, -0.5343569203698425, -0.7742250879237738, -0.5667006121194943, -3.0308877567762047, -1.3237423809075897, -2.606484458454338, -0.47818780130261035, -0.6130818187276448, -0.7172038836377475, -1.2827553881958864, -0.1631655384814844, -0.32815226574865863, 1.3717304704019715, -1.3945002035621867, 0.6851808960962694, -1.0898198026764898, 2.678333937468392},
    {-0.3573962195045913, -0.17586248113057618, -1.9381873888285959, 2.351050742607962, 2.114550586771699, -2.9637903829012715, -3.0562391351939198, -0.18761757286033673, 0.36021332921016014, -0.8954762551901514, -0.17803995406429998, -0.7040364943369667, -1.144438934376693, -1.046757382349196, -0.048724061888909966, 0.7745132599232607, -0.08064010785001888, 0.9675508042310572, 1.6173321771594558, 0.9922495721292733, -1.1912208524920709, 0.8760192481917551, -1.1347429304417078, 0.37815476603476245, -2.1944508505720832, -0.6326609530807868, 3.3040426102579077, -0.2308223558721255, -2.276336962747386, 0.22355434787214648, 0.22950495144279068, -2.5010912673254606},
    {0.5557621946347151, 1.6882058226455026, 0.08556038629696285, 0.983251920084206, 1.8499763701340373, -0.5852690831228464, -0.9542014488754801, -0.8304356669509259, -1.7724361993738957, -0.5324185547463159, 0.7177524045201972, 2.6109961782034, -1.2623084706961054, -0.37975067514491034, 1.6973600213318054, -0.41882742290949304, -1.4211562575483292, 0.6081727101306261, 1.650328557823221, -0.48624654568513515, -0.724137589470179, -0.1764921163257136, 1.3814406795004797, 1.514724003125271, -0.07032049179305458, -3.409307360974437, -1.4542623517650448, -1.4154711784358842, -3.000167973967273, -1.2954264419282258, 1.1866445467065634, 1.2731744800476814},
    {-0.5137541588776953, 1.7759402092680703, 2.2557824341416493, 0.31959175030228726, -1.1763932693056172, -0.8098701679029681, -0.17982764419124853, -0.4626399274522347, 1.2117637593423416, 0.500367845256305, 0.5569776210360647, 1.0366517851171118, 2.0520746950050506, -2.705592641292866, 1.6153021774978624, -1.9790804496614485, -1.6184082378588927, -0.887667629141283, -0.6914948212912986, 0.26632175551757475, -1.3972148261194173, 2.4420154166974326, 0.6216313781083208, 0.9316271450145635, 1.2368440379217696, -0.21950992387872637, 1.589367176213344, -0.9312787178028253, -1.0937663591049838, -2.1096798502732033, 1.2785035533206979, -1.4774146503316412},
    {1.726678711314948, -0.25913324704088364, -0.17277743432586332, -0.48986356329265124, -1.8557165151742951, -2.088819848457545, -0.6515685806474699, -0.335769459035391, -2.562147455511278, 0.3440918346153968, 0.9969205236536145, 0.8048906676329449, 0.8851123292248515, 0.6626500897287189, 0.4886077417921089, -0.942771146903957, -0.4590491795196292, -1.2993445734276359, -2.5803281342456157, 1.5669082385827044, -0.1879920395873792, -0.05342132596144413, -0.6876542934786354, 0.17353195867233315, 0.0034964840402139184, -1.1994720584259277, 1.734719000547072, 0.7948238422378049, -1.9552824852382171, 0.6408753834658417, -0.6769344894136383, -0.22921597415932804},
    {0.9476518583927126, 1.1907781191328595, -0.44292492708563314, 2.0011037900124657, 0.0816261677522288, -3.102238781362378, -1.5767662360928423, 0.9954619811470968, -3.1030015186065203, -1.830175915681509, -0.13741377550775183, 0.8557493723512983, -1.082668476558621, -0.5204984189120525, -0.20671630433623406, 0.610265353775499, -1.1209146532815106, 1.3349613985417685, -0.6510941045322245, -0.14780422012534553, -2.2363710056310344, 1.3332233670190836, -0.27313845776719586, 1.468133615454376, -1.9697464217479286, 0.6688173463124819, -0.5369174842432767, -1.1097275309334242, 0.041519552127950304, -0.6909767451376589, -0.7503935951292292, -0.9825834657376442},
    {0.4711214121421547, 2.8753249688017943, -1.6797776737876644, 0.19141887199388372, -0.47517946939501016, -1.3584929885115347, -0.5668887942289137, -0.9310105889909843, 1.9907318688597835, 2.1221841621054547, 0.8268985315390674, -1.1347613811767805, 1.296566046956427, -0.7787187907229806, -1.5384290581511957, -1.97766607550569, -1.8668780207929248, 0.7420713994860845, 0.35125526206031377, 1.0591380062656226, 1.3944839432022427, -0.5332949539471821, 0.1579810230444248, -1.1670765565680952, 1.3685409303278624, 1.5386888206269098, -0.011488440037991663, 2.3862644956033807, 0.7943885398500891, -1.4144855496113364, -0.7206760603059142, -2.0309826596439966},
    {-1.596378641240585, 0.5452217962219839, 0.44968678453740263, 1.363752360810129, 1.6274607446333045, -1.5123254210934356, -0.45332030642179744, 0.8477249640698228, 1.2062799705622345, 2.47003243070234, -0.39739635820973696, -2.4252862864616063, -0.6202533323653087, -0.7636117049616653, 0.3398914768575947, -1.2800308980223891, 0.30377390888509975, -0.10727930588047488, 0.6147494554344034, 0.47302197694052867, -1.3672666197891412, -0.5064445555580264, 1.8499883622462008, -0.8835598095338775, 1.4592322095704564, 0.09922802857520777, 1.8555480980832695, 1.7774869229768469, -0.32367345015798793, -0.1874838519375714, 0.43039071941745194, 1.154568933686302},
    {-2.064035122789781, 1.6073939866089524, 1.1768672941943807, 1.2696565142906449, -1.518644696286257, -1.8134030615962393, -3.075409888006819, 0.43660255193253356, 0.36528512753339204, -0.27394941154779084, 2.802945243429533, 1.78615363670522, 0.49096274483363583, -1.7344216575160438, 1.149928817767825, -1.5964108414064315, 0.5684481258521005, -0.02550823364784709, -2.1934527271273994, 0.09833432747959868, -0.30178989726070754, -2.2186535045971834, -3.9556304182846933, 0.1609268397890521, -0.04494769022321846, -0.9013339887286174, -0.3814510289585329, -0.926902796681458, 1.0665793437236077, -1.0503132788775003, -1.4616793169819844, 0.46789532732387895},
    {-0.1899452665251733, 3.3007068346026225, -0.9907247567802004, -1.3599352011530623, -0.9998812606896856, -1.1564893416780087, -2.799143813234778, -1.0477339934943053, -1.8612180680536379, 2.2076048936086736, 1.517698198088207, 0.4154401058705818, 1.032865028155952, 0.3177002872237326, -1.2901233092036328, 3.1809741542572034, 0.6760577276265672, -0.037163548926160556, -0.35248458553746476, 0.9196491511922651, -0.012320834219981735, 0.6167611339594957, 0.5765455975359697, 0.34749484068599057, -0.5800501014523549, 1.7653803940080306, 1.72876334797553, 0.9230563067391646, -0.5588439829423344, 3.1213656616647842, 0.6361630701728453, -1.1326129023115803},
    {-0.5355455432804725, 2.2028833947962934, -2.437312978980243, 2.5121663088316937, 1.699127755994023, -0.12951127821460387, -1.7368238142674022, 1.1915295665735401, -1.8111545035548284, 0.7764821838125155, 0.35209089833349455, -0.8423845718521226, -2.3507046675941177, 0.31133443057318183, 1.3744539177053163, -0.6636411000475843, -1.4303223421309024, -1.3209844759685532, -0.5243339509533789, 1.7750607306686932, 0.45860948581779876, -2.341044179068403, 0.03302331069093469, 0.42594748406195687, -1.3596504134707195, 1.2332369120169082, 0.9900168140009243, -0.29753732578501335, -1.8413072799845178, 1.1267030648783396, -2.721980785105821, 0.6033583790724563},
    {-2.5278664543874947, -0.027043863043558082, -0.6527441431483963, -1.7453934052433906, 0.49799836571282174, 1.2884939127392372, -1.3972281622707083, -1.6708591735589666, -0.8277100552021582, 0.33192129690879973, 0.03875897935754424, -1.418876324512577, -0.9430606875633856, -2.721948273315054, -2.1458226420149513, 0.18108168721525617, -0.5977767018308632, 1.2917668358949417, -0.9395448229625795, -2.303941264545514, 0.0571873785472529, 1.785560941879658, -0.3106997010292975, 2.408731835856404, 0.546186005999757, -1.642669882808009, -1.8313130285962678, -0.277307576507632, -0.23238758066569384, -3.675910997696, -0.7131038070030851, -2.0653415205295587},
    {-1.6340996985508751, -0.7182460690178808, -0.20676035634395945, -1.3118409639074, -0.5432242678945436, 0.4183780504389447, 1.809617314284065, 0.0855406386256461, -0.02135259349714155, -1.4857128940748203, -0.041356650992443476, -0.7178070371316384, 0.9692584843498743, 0.26060552147497024, -1.8242747568567304, -0.23195712920303577, -1.3401668675473903, 1.7465546343058018, -1.0602338684274109, -1.1232911593968904, 0.5201562106302179, -3.802453703265032, 0.22748178657380058, -1.285850922989032, 0.4505044342121161, 1.682666370332918, 3.080172490361921, -2.0080584083807897, 1.7978555967628334, -0.24903036744627177, -0.5732650342798015, 3.6172937346862137},
    {1.2744576482352972, 0.7526721035136544, -0.163186107164841, -0.9270206222684072, -0.06194243297666714, -1.5098881682213088, 0.45527098088758255, -3.2134786232219485, 0.3046909587593427, -0.4784885381912712, 0.27445971962305643, 0.3517049799151899, 0.7851842401534967, 0.5757986110153062, 0.6632995412635767, -2.4087886566665797, -0.2695614144821171, -0.4627123650558724, -1.71240870933513, 1.035312553338503, -0.0525816841435071, -1.7966811848239945, -0.4568586213587185, 1.1071254060481182, -1.7541331040602002, 1.5733047169016725, -2.4913708682659492, 1.1295990418332453, -0.15636944327479557, 0.9524569945808382, -2.0092322086933803, -2.5487305623376098},
    {-2.102672187401608, 0.32740503610956245, -0.7150504557976466, 3.691939318910313, -1.3484254647127705, 0.39855577500944983, 1.6246610807701318, -0.2316770216007134, -3.1400204744831295, -1.8724388024191883, -0.5883271272024362, -3.218732038848476, 3.343222786297034, 1.2818428882559436, 1.113736239089645, 1.0419142895764226, -0.31947547807675303, -0.7436342150788295, -0.07308123311200355, -0.33416559343344676, 0.25964280867281064, -3.166832412795218, 1.1474693933350952, 0.5355649943806005, 0.39308057431028026, 0.816040257006071, 1.6618742826895034, 1.6069442088697545, 0.7301425126465736, 1.4255555972615386, 0.976147658638022, -0.5659536863514756},
    {-0.5781932362030279, 0.8974877021024192, -1.993510040837733, -2.4070325198321276, -0.6407247303743394, -0.7663212571413515, -1.9670031584486165, -1.3959840048622143, -1.7254757164666945, 0.32351714721073255, 0.7236090767687126, -0.6525054324722096, 1.5149838612643156, -1.9612804205770429, 0.9097321559158916, -0.6660645095848018, -0.2777166365961847, -0.6242719490025603, 0.6483577495561138, -0.2443937608831398, -0.8322158283121697, -1.6662111180895676, -1.1358520154147764, -0.8916422305233117, 0.5900781360314094, 0.7727818983714073, 1.1273436663149699, -1.4181858909975285, -0.3194880719717642, 0.2524281333481513, 0.4942399237290881, 1.4722260392174567},
    {1.891652234136805, 1.1976427665434, 1.8525305264061878, 0.7638883759027322, 0.1420761485498014, -1.4045208678151042, 0.7317451296521509, -0.12800092283559542, -1.328122910873365, 1.9144619356447181, -0.34999401912440964, -1.2013297484715306, 1.6663324496601868, 0.2788608364185895, 0.6040017609215891, 1.8820927587439018, 0.4775549067328016, 2.3087615483364803, 2.2025285309205653, 1.3125123397824374, -0.41455527866497366, 0.3798268079111216, 0.7981948454945268, 1.3527936288884461, -0.0643633956315151, 0.39626340160684, -1.4401581490283841, 0.5077235926509648, 0.35674376455242474, 1.4265044155794027, -0.15022725723647332, 2.96927910379852},
    {0.4573880387792577, -0.7498489973176307, 2.4293872823544347, -1.3758245691559743, 0.527184563596267, 1.0600294027647859, 0.30950684631532355, -0.2622515551114522, -0.7392123819014526, -0.31792355340789835, -0.34301664773389384, 0.475617041685986, 1.343214892363442, -1.5269348758893129, -0.060113918674571686, 0.4184073238843082, 0.01736195965597564, 1.5050653879951845, -0.11876163930473332, 3.112835948122956, 1.225411412631673, -1.04456369111029, -2.3365149034047117, 2.460223318269663, -0.46635777695371916, 1.4134694488854818, 0.6013700503475666, 1.4935708536091052, 2.0577726937673377, 0.6357645787110907, 0.6189170725678551, -0.8240047037540434},
    {2.4106979320812654, 0.02879852821189803, 0.6577309784014035, -1.0512384448765968, 1.1228877625025713, -0.901733353249825, -1.1729599540393572, -0.16171886059249402, 3.6101700056401183, -0.2600818491707876, 1.6998310293671255, 1.9475927727135192, 0.05856513601439565, 0.5277617884798904, 1.7635114941055596, 1.5782569186838509, 1.0914197674109873, 1.4873812601070433, -0.9444593688970931, -1.163819146368241, -2.541217071642076, -0.7476038495203972, 1.1762250973794235, 1.3206802281617676, 1.092553798043285, 0.19301144775437906, 3.264533385677747, 0.31664097221346754, 0.9790166191207766, -0.047072505587084854, -0.9756971403131977, 3.4428728896516385},
    {1.7720765382973878, -0.45268249410322725, 2.682968952695819, -0.2818258867709214, -0.11469969036309739, 0.038982474029441314, 0.04939784827856776, -0.8574721396718235, 1.1442954096498525, 1.5955871442853737, -0.7260623731855186, 0.5354145038005909, -0.34152539447474634, 1.0235001137130906, -2.1538769442104355, -2.5108117709354145, -2.064491216899634, 0.4774560489786838, -1.164595270422464, 1.4029721428097635, 0.17269268653041825, 0.22627479250766847, 1.648205789063248, 1.8327377909938496, -1.7322579706509547, 0.6270368775834172, -1.8310684609447583, 1.1954561840137445, 2.394781844122944, -2.34232450390193, 1.0933326512960804, 0.0015035022770057691},
    {0.5635716045566789, 2.243942438565931, 1.5881478301853247, 2.9791002447532753, -1.157295048616803, 0.24728795676779278, -0.12113810126655693, -1.1978250710192633, -2.213840734346183, 3.112525315790949, 1.7199034867444583, -2.0831662102018966, 0.16533946853676718, 0.9380300443903803, -4.275612179920668, 0.6623393386165877, 2.1419200358005344, 0.19939519048335155, -2.1341728053819624, 0.7503137647594802, -1.0914171533566666, 1.283302881113085, -1.368206946075071, 0.29213329571511903, -0.6104048916154012, 0.36267029745559853, 1.492125267431132, 1.8382591750375732, -1.52225554853857, 0.9621081780445689, -0.18702081701350268, -0.27307010087000066},
    {-0.4168706326113893, -1.1347367853918788, 0.5451134818090795, -0.806750582897178, 0.11858465999127915, -0.8258192964804308, 1.404848685352433, 0.04891089351300089, 0.537634624459052, 0.3232483893116609, -0.22939593695320046, 0.8772670049866566, -1.52364519267366, 0.3446370351653248, -0.8086690877496102, -0.6159901816105261, -0.5981528151187896, 0.8584610322766406, -1.5959869964618387, 1.325963477357864, -0.35133437741163115, 1.3485643325886807, 0.3632077845842019, 0.033439586045975495, 0.7441458387130974, 0.008915290854173441, 2.2792569649286722, 0.8696453193541185, -0.7688576414659439, -0.07099733342307565, 0.6540938093914607, -0.27176579683648816},
    {1.8073418741291976, 0.5118697074187852, 1.3318620555592444, 1.4620371259584568, -0.8639805843839563, 3.4895014384064362, 1.5592492818336259, -1.2750074499405348, -2.3600646760883626, -2.406868225270378, 0.7126293154402985, 0.5450781904799457, 1.239907897259621, -3.416167846558625, -1.7015138902985336, 0.2198783976985186, 0.4682105173027708, -2.477311480650012, 0.13125976101153464, 0.983563082225302, -2.2246579037521657, -0.11021784538686305, -0.2714143558641895, -1.1966031621874866, -3.89257036108569, -1.5025502245676072, -1.911687862059084, -0.19676396140118815, -1.58040744238056, -1.6460613229934038, -0.9695884438737196, 0.38827021292750663},
    {-2.0481183732003525, 0.4492334624186297, -2.3298342255620708, 2.297266931083807, 1.7698280808227882, 0.1495538345054597, -1.1397105965044387, 0.4841641839079389, 2.778606371796416, -0.491150309965189, 2.3404364611126174, 2.3561623817208592, 0.5947692882113692, -0.11481424860099002, 0.36799008850100307, -0.3692377350219759, -0.501773858856282, 2.7409758555255017, 0.14792713376867145, -2.4438935863926794, -0.002446670094857277, 3.241875275621106, 1.0171026920038466, -1.37913622913763, 1.0675958128032428, -2.465228689111963, 0.6741530758799312, 1.812627705389296, -2.456903259554192, -0.2879025069787786, -1.7468328314778512, 1.2773653995834262},
    {1.3861380400920906, 2.2888645757696073, 1.3979141966059894, 0.35361974038260774, 2.152393848852475, -0.7080179211489588, -1.623697257043796, -0.4238417017450167, -0.9087793414837139, 0.8233038620401242, 0.3725660196954597, -0.20505333835580952, 1.4643485836556336, 0.1132191200893863, -0.36466703362299074, -0.10806431989397043, 0.975186002411306, 1.8819566250912225, 2.646166456054478, 1.6880800846605883, 0.4620362931364744, 0.6535198169935933, -3.10674286488269, 0.016398748342848973, 0.3604733258814304, -1.0071000347540093, 1.8181722221393521, -0.553559101812459, 1.6646210045064165, -0.29884286496853546, -2.9942038050192323, -1.6081509451382208},
    {0.3758871195690085, -1.7078490384075726, 0.17749167950779587, 1.0334504471556891, 1.4273641721932595, -0.11416989207346387, 0.7875131109358657, 0.2417846852728538, 0.32367122785829705, -0.8752481725071674, -3.0308017799904685, -1.6967208293188814, 1.2414550166313454, 0.370877511592794, 2.451028296299768, -2.035064024195056, -1.1509547132603655, 0.7247090009543856, -1.1950924543296295, -2.18849046453529, -0.941327912021807, 1.5544524541925142, 0.6799798963605309, -0.33255556706723277, 0.9562614629753294, 0.8587161387415497, -0.6816305076689021, -2.107239872452872, -2.3807433456953913, 2.0583817151547743, 0.6252976706802863, 0.31481870314759236},
    {0.7982624378500672, -0.22657491766193477, 0.35914160796016675, 1.6807496422995076, 0.25978775840926815, 0.7840275607124922, 1.8238031459365704, 0.5880923615775846, 0.6566214299253623, -0.6407391372788439, 2.6065652553374, 0.8495019395126495, -0.46928056402596485, -1.5508291678717119, -0.8924950557904151, -0.801640195885417, 1.147623170222983, 2.985265690608299, -0.3913969301979455, -0.6514701488175721, 0.5995998768763419, -0.41791394588942515, -0.4689366103627496, 0.4750602091615591, -0.5247336987662296, 0.23680413598346353, 0.1369875007692088, 0.2964198254905522, 5.16154635382557, -0.9731112966022117, 1.1684121689687919, 0.0781726504100732},
    {-0.43792502787612525, 3.0125927383502877, 0.05532983523161837, -0.03799548789016794, -0.9625267653433736, -0.4049479990520979, 0.5357289697909715, -1.2807020594024374, -0.549761629182071, 0.2512093938401221, 1.0737648569808256, -2.25816421923041, -0.7657340561206333, -1.7053856742999414, -0.1833348435961972, -0.8389072607701543, -1.2329331244426935, -1.3383972854802957, 0.8324174876334192, 2.8311133240213446, -0.009664199898439347, 0.5398570551430111, -0.3887163194375118, 0.3420913954917262, -0.002006930990825907, -0.9120628319554561, 1.2719714225345806, -1.4632946720674025, -0.9820934250808165, 0.6392763006056702, -0.839272920407058, -2.632144368357635},
    {-1.0871255835662927, -1.205589114697767, -0.48053725259620805, 0.336535007248998, -0.43392852086681866, -0.026983388990409845, 0.20328818167990592, 0.014212753917051114, 4.080867093053284, -0.47336918685119117, -0.34744421711506146, -2.1537885383532007, 0.23144959447991556, 0.09479729204079561, 2.223354159143166, 0.02297054525658233, 0.14028425229558597, -3.3182682705391833, 0.7622689689936542, -0.44546555544367344, 0.8248759394567603, -0.9305065289640081, 1.1510108348037953, -1.9798478380694855, -3.0868032252148376, 1.6939063515266701, 1.4473403362262738, 0.7650408293147658, 0.5774286022869595, 1.2740629777791934, -1.6853513442819257, 0.6288443433869898},
    {0.5315166918585134, 2.0008268830238, -1.54835296423172, -0.39633229888104476, -1.279175259313895, -0.7189708786128457, -0.6344010592867279, -0.5992704334979772, 1.0268131173667885, -0.35279180132861165, -0.7383475928760447, -2.966278908876503, -0.6383273156320788, 1.815432898908383, -0.7572446342103416, -1.628457683106033, 1.0000739866221995, -2.4670988879007227, 1.3404216088002474, -1.6567473762691576, -0.6845018157535481, 0.3399931666878569, -2.30985900483675, -0.21054493131400517, 0.49608566912176727, 1.1927691171630772, 1.8441247544787662, 0.2813321195023465, -1.277076807360749, -0.7790774622385268, -2.6952397670749684, -0.6341810494381347},
    {2.6101721527490436, 0.9019959448391148, -2.078696136047813, -1.0269207987672722, -0.0579299438862477, 1.9675703567291116, 0.34166690988024123, 0.8041300103251892, -0.7497414115682085, -1.8934536940065698, 1.7606235732183728, 0.06718037524240388, 0.8683712577959117, -2.1338854410173242, -1.4744974676340867, -1.5835077807676448, 0.5748090845498904, -2.393705778114736, -1.7881394006424784, 0.887369053370017, 0.43553523790625126, 0.31885509978580157, -0.8985485607793561, 0.7598477917347622, 1.029281068575237, -1.2894192675456329, -0.893444114323892, 0.4324320040390076, -0.19345567604830655, 0.9474358625591806, -0.5043465940533541, 0.07471144373237724},
    {-0.04955010711702721, 0.004333504898107802, 0.9409975677398511, -3.4576335070543873, 0.05597902682095664, -0.19115526347980996, 0.28638108901707615, -1.979516326036769, -1.7023242971831776, 0.6215344810072968, 0.5141736860576677, 1.0218143986875245, 0.0774630040609673, -0.2033163729029415, -0.004198348057130245, -0.06565497788182086, -2.0482399042341037, -0.37219497233057885, -0.4628774629991469, 0.24630536551628743, 0.9029489798278721, 1.181317043382869, -1.813850459106665, 0.561947828210597, 0.9676026425713845, -1.7220996459258426, 2.916272982760176, 0.32224878860839784, 2.323268406352642, 0.7402907005036085, 3.347566492954471, -2.003708758434008},
    {-1.4851731251245879, 0.6857099061939997, -0.24968077631285784, 0.4166373414336813, 0.05074051801000568, 2.1956926564842414, -1.824641762695471, -3.3625161688922343, 0.24271564033655105, 0.02559553707160574, -1.3008615507216046, -0.375117070860581, -0.6884453113933777, 0.5386935749205528, 0.6839207052098811, -0.27090887818626896, 0.18399246657652524, -2.8021159635064072, -1.7403425885072719, 1.4611262383628276, -0.649251750871715, -2.5105395779248965, -0.9882830247599115, -2.3185106124642716, -1.1742007816369802, -1.248828393566886, 0.4753178878867218, 0.33906016963702695, 0.3234099657166439, 0.19673891814510197, 0.897921033660408, -0.6623379830018794},
    {1.068622857021781, 0.4722776345771003, 0.8553510569739751, 0.8997838201130268, 0.5388071312107545, -1.8955036084589865, 0.1022807292840401, -0.5430740822545282, -1.839623301126184, 2.1754033733168696, -1.5949041595647742, -1.104380428473452, -0.4064836600807662, -1.13522400844294, 2.1040458616634083, -1.1237661131342371, 1.8846305001263932, -0.15167928379600304, -0.27532115465982004, 0.5360901135401033, -0.997490815367236, -0.18069878512343826, -0.26788011834727893, -2.2972900502904845, 0.08639266922832378, 0.9927782859394221, -0.5505600869122742, 0.7481488698216023, -1.1926012122725727, -2.409894586515188, 1.510265594802472, -1.7039546488717396},
    {-1.191840962299027, 0.7862489605336878, -0.8400849638905549, -1.8834050678719165, -1.1865122417364014, -1.4833419257274882, 0.4429828295733818, 1.9967680495098419, 3.1817585897668503, 0.6639953416814327, -1.8305671294880697, 0.05083457747895565, 0.7875661838237799, -1.2480884680985256, 1.7375857117648321, 1.5688929192347583, -0.07179589734603443, -0.8719944696800062, 0.6026385502188619, -0.37997203040576577, 1.9934913747560319, 0.22872578764728466, -1.585201009935292, -2.2392899022499897, -2.1034241469783006, -0.026397958438641178, -0.554129866785663, 1.0485198146680972, -0.9821233417840104, 1.329683163791274, 0.6992633317474576, 0.4989017775917225},
    {1.0684387017850292, 1.0827968941390773, 0.9772201295395792, -0.04874542460225372, -0.9760104853850747, 0.5614606098933793, 0.31370124482230427, -0.6222824853061724, -1.6440147993331742, 0.8877593201678494, 0.11422353841966959, -0.8961640502523255, -2.1451973889765057, 0.9763841695537581, -2.6326186171518757, -1.341506011010273, 1.1732447083228807, 1.1106029460589224, 0.07851695765619437, 0.3529424748060794, -0.31785704690606886, 2.0434160032032413, 0.6360363128556791, -0.7237953033970368, -0.42881350245517175, -1.4314530040616247, -0.12198099370985219, 1.6255574906411296, 0.052484399708092856, -0.6239232694255631, -2.0142068101560433, 0.8037340185962936},
    {-0.1494978106517435, 1.1140503490456413, -1.1169088096703208, -2.3805445193766848, -1.8397160442637936, 2.44579911493197, 1.8972105105112, 0.8850115943013278, -3.089859313612173, -1.8155811470816017, -1.0005383090845557, -0.7607677687506141, 0.44245716833664894, 0.8710330535396694, -4.211013849989519, 1.0265261064594922, -1.4842563694421211, 3.5559665941740706, -0.7951772487478319, 0.6055779390112209, -2.0028342053085733, -0.4040583827196417, 0.2059353810143939, 0.9249118216659767, 0.6080590148583341, -1.830459510112988, -2.5200624553407023, 0.862995779579148, 0.22091922618320206, 0.35376076649935273, -0.17164799820368581, 0.5597506414935463},
    {0.4259538162923967, -0.8892624266127701, -0.9079139292795091, -0.7512259545076757, -0.8412600115109714, -2.6829760568365923, -1.246233497725235, 2.9550979731864038, -0.6239561424237287, -0.48050213924599405, 0.7713863591412028, 0.26737960837588176, 0.40960454957026854, -1.7949968868191646, -0.8062927577972223, 0.4587360663208184, -2.2653501413320463, 1.4550133117299184, -2.0674611167833734, 0.622904911318098, -0.8306517587042463, 1.6627490893365895, 0.31381162735636753, -0.31635831269741826, 0.5305595050805562, -1.2154969988714432, -1.8162382143922473, -0.43082626208425906, -0.16637762770029962, -0.7543414003405702, -2.5190557493060037, -0.36536536766950495},
    {-0.8938422928979783, 0.042490324884806065, -4.756577960162392, -0.8874266115469323, -0.03139237488342216, -0.9052931096713768, -1.006652762256929, 0.6022466224186049, 0.03246762043401949, 0.8234594189335698, -0.9173970496572152, 0.777298633191636, 0.6557926275141333, -1.4579819839937493, 0.9295449476813982, -2.026126818415742, -0.20538606859536665, -1.3884162868901384, 0.2723965430397799, 0.18561248996747468, 2.137006712355466, -0.5520455324954348, -0.4377589632620638, -0.5362297713131613, -1.2955690382370555, -0.04191527885050038, 2.598886322189825, 0.6534842451842434, 1.670373035929939, -1.8541285932174196, -0.48560586083600504, 0.04022529985900703},
    {0.6814083728534304, 3.565371207849335, -2.3848005865649897, 0.6041248128126746, -1.2143268515519645, -2.3387544151881796, -1.5361297524000355, 0.49518301605275034, 0.5916941468436017, 0.09521363133933483, -0.7445917508255664, -0.480651060178282, -0.6490140650985006, -0.7286638637403748, -1.0756126342699563, 0.6492973614648169, 1.7005905633157055, -2.535737612429788, -0.8959555762839881, -2.347028147414198, 1.4424981423388932, -1.928919785383201, -0.613968492907372, 2.550490254675805, -1.921339344499447, 1.9883974246996896, 0.01940067495593196, 0.5137840262307746, 0.649124953397032, 0.655990056985742, 0.3298530474490096, 1.5464354038890153},
    {0.6233817703715158, -0.37708028912006336, -0.24564287546793181, -0.14470806113867699, -1.7128189777714216, 0.03860702885154473, 1.2827040085292931, 1.9741483131423194, 0.817233409655257, 0.6169829033207541, -0.6895130703266726, -3.414871975548751, 0.7591771013400745, 1.2916184582861117, 1.327551562936839, -0.4696288504151225, -0.2611652039659267, 1.5084552137477576, 2.100196283459133, -0.9411636278105832, -0.016025351420076953, -1.2555081890417406, -2.2401092776536617, -1.7886637887080257, 0.05088247942231756, 1.7916178043728892, 1.8717047002320184, 1.4116945025261043, 1.1630687909291497, 1.9745100374305389, 1.3048757055112106, 1.3390689817769306},
    {0.37388956566490866, -0.5130823963503944, 0.4891459908664539, -0.43233905277704987, -0.21633465980789587, -0.9127543000000985, 0.09527331870015497, -0.5970188294462806, 1.165676455651545, -0.3497871425428243, -0.7665318507019347, -0.5457018414655679, -0.6183532075737914, -0.847919164112492, 0.2742356642855895, -3.3469367910066414, 0.8051081766712646, 2.7178615302264637, 1.2309695538250174, -0.823409014314656, -1.1196130375878086, 0.9965561096427437, 1.9531156672189312, 1.2510460248472555, 0.5282679773824691, 0.753205994652948, 2.343004056916218, 1.6945035889879376, -2.8457056766633624, 2.086443820109485, 1.3111287008031332, -0.24584825530839657},
    {2.830926542067121, 0.35317824159841577, 0.289458818509081, 1.6108123806083254, 0.7485574469005072, -1.1747346994896013, -0.6953296797568291, -0.38412698236561044, 1.2735570263231233, -2.4577489812235984, -0.43285657680429185, -0.41045215145941166, 2.136431598008062, 0.10597920714524625, -0.34035784965670346, 4.210613230074817, 1.216423898066431, -0.43317910825265665, -0.36009450473176935, 1.5529665310333785, -2.4314765651529213, -1.1140939297432737, 1.3668621631358986, 1.9015583227705446, 0.6988237092140659, 0.4671643922573765, -0.8829059323488017, -2.757673590361434, -0.42427441476631794, 0.1398197909436568, -0.6868810801365928, 1.5624641033760298},
    {0.8044890229830696, 1.2979884686881933, 3.292106025790211, 1.1939101216056034, 2.413865553341933, 0.2269006061601117, 1.4167198646516888, -1.8572275436461079, -2.0618848287018015, -0.2295537236374725, 0.473191309734611, 0.2009993475577599, 2.410133861195164, -2.1449412575455433, -0.2529972366072491, 0.775826671816375, 0.0361290423059414, -1.0481843045693333, -0.4299230427438271, -0.31181591224270244, -0.35864332167410445, -0.12384233357901794, -2.239433471894036, 1.6320981975728552, -0.45720307805744204, -1.4345982637443315, 0.037771232491418484, -1.3613480312760242, -1.0979767694757339, -2.2785540110207934, 0.7810815741138664, 0.9399413506481278},
    {-0.13170387429241054, 0.9832423222381537, -0.7244752144478698, 2.7605451101471554, -0.011766463775296129, 0.6340101689354243, 1.360314121128044, 3.2901669845633714, -1.3318444604859965, -0.5119506664014157, 0.29380132394094893, -1.0523699643485727, -1.006627817067593, 1.2392394034477114, 0.2216652417704069, 0.6604539053202755, -0.4431055584098591, 1.5669729298088553, 0.3930289353764528, -2.1378067235953426, -0.0028946157461696496, 0.2907742617601513, -0.1608738941778708, -1.7146483396647145, 1.3582559597185502, -0.4058433399523082, 1.572549707333463, -1.4884510023586135, -1.1246766802877328, -0.9962181195839472, -1.8867756692035202, 2.6926298701330604},
    {-0.3721665398805771, -0.33460590858598865, -3.008587377236206, 2.503247957515839, 1.3218310597725675, 0.8248968704082268, -0.7524726222083665, -0.3366697091681015, 0.7326468764414589, 0.015312287719190423, -1.4745402044470144, 0.26472547801970026, 0.8890752085636866, 1.0207808867115293, 1.1708864491163458, 0.8841369557818013, 1.9817389840229458, 1.9411612005374939, 1.5739777456543262, -0.8210871474467134, -0.685508295742475, 1.0798957491281362, -0.5111694432614815, -0.4757851081757552, 0.3949771817196683, 1.392604295665057, 1.7857371360702803, 0.6956789731548544, 0.12684625923360607, 0.6286420203790631, 0.5516589965121487, 1.558702145046665},
    {-1.0269818328061469, -0.7829566388693664, -0.6170928148201882, 0.4294839485288199, -0.6639483884319851, -0.29280871199496794, -0.9577490359048688, -2.2998379125033064, -0.011383403385287235, 3.298785148428774, 0.10027286372815249, 0.1594801412128292, 0.15692883896884113, -0.2417529334927157, -0.6940714753188252, -0.1264908820515283, 0.15978832594118092, 0.13097981927505112, 1.163902856206301, 0.4736221165080299, 0.15736160886165154, 2.068512915974762, 0.24853894819924727, 1.2098006941360344, 1.4236485554597067, -1.7547094186636396, -0.009538029765697611, 0.7446589189242877, -1.092504219931257, -0.6242625613535677, 1.1643749739326628, 1.3646911989113408},
    {-0.006156212522332038, -1.9984584676218946, 1.3276836644899914, 0.45526153037245354, 0.3206200715904888, 0.9102881875411453, -0.10132903450190056, 1.3658033439013841, 2.7967631030983666, -1.2482787271013036, 0.05087701109567564, 1.320423854575308, -1.7465915819466309, 0.6281718453687474, -0.9525198625579308, -0.9258136931743972, 0.1628256625434161, -0.09721646672944295, -1.3282424337600303, -1.9492483043130602, -0.2200324405515282, -3.560039521345957, 0.3054604539585459, 0.4543009066755166, -0.2072472291041545, 1.0027279652981558, -0.7751224697425247, -0.24709303438591004, 3.097402664470674, 1.426343598661712, 0.807858395521599, 0.6076586439890408},
    {-1.6530049350197211, -0.21024922731543083, -1.471858276235821, 0.4814013011495754, -0.8711959306005563, 1.8070133656666838, -1.102926390618126, -2.2637945681503555, -0.9626496388000059, 0.24591518382563807, -0.4125932555225687, -0.6900420296298773, -1.5817328616897972, 1.0778095970072343, 0.767294866201389, 0.27252578297331964, -2.399641513123192, -0.044643231554701214, -0.4487580756272897, 0.9028971740509217, -0.4970688722215248, 1.7175872535970012, -0.20352438969332415, -0.30210672101816083, 0.5991396691734447, -0.853170157838691, -0.7518994641712993, -2.775527475630997, -0.6291168590384062, -2.6303257074861515, -1.1579474022649459, -0.7762257169831837},
    {0.8768934138684423, -1.2802206253536101, -0.10723740287793515, 1.2464410552511798, -4.528177257592145, -0.747626758307494, -0.5095087235862319, -1.146993449403968, 0.7378143035970727, 1.1403680859828291, -1.0016868752775265, -0.5542620287011776, 2.2232171566363883, 0.7692855580157842, 0.9204976418520854, -0.30318261601533997, 0.7272775560062835, -0.9992413882941399, -0.3142890794074351, -0.3042302667524354, -5.013493911109806, 0.948668149401515, -0.7952616486132419, 0.7188461695464224, 0.6798769488200119, 0.739472520806989, -1.9974354880878822, 0.5482445949189793, -1.1325955669297254, 0.22638541865346803, 2.1513781832435157, 0.4026211314022939},
    {-1.3632670259874604, -2.1305267277847313, 1.7159374151331355, 0.3028737583125385, -0.5637015496972017, -2.472823174406549, 0.25280928042074324, -1.5209237740202524, -0.43694778397031403, -1.2919843391283257, -0.5580774894591958, -0.31908713017857887, -0.18289348389595442, 1.1237279985076203, -0.17053579988902062, -0.10137634226071283, -1.6112109837584045, -1.2976013111644666, 3.365041848030268, 0.6255427669103253, -1.2822120291791845, -1.4317069757212086, -1.0524812602912463, 1.2790507121323267, 0.39586307621724853, 1.4387814734749913, -0.06071537559418554, 1.4241416450574058, -2.292663234915345, 1.6257347330933933, 1.3619413575455805, 0.15147002606154117},
    {1.0523174776673934, 1.208867077836372, 0.8477759847680372, 1.192422323398897, -1.416376699854365, -0.9421956433510101, -0.664243976951478, 0.4464985141979133, -2.74348723993209, 2.3636452976941067, -1.3707665290039002, 0.36462982893815055, -0.918671320863777, 0.9995389997047643, 0.4097796513717165, -0.7818203356644472, -1.6223436235734716, -1.2549393796791848, 1.4902344900832396, -0.1401058701598021, -1.2520942870654572, -1.5647565944421973, -1.023574536880789, -0.2076053969661975, 0.026829333419894727, 0.01646303210447273, -0.6736464208139484, -0.9869948948750539, -0.7622958643457527, 1.2738400901906823, 1.280928775164407, 1.2386881793689613},
    {-1.4759299877131091, -0.023393763800661216, -2.550782779941582, 3.8695030882009784, -0.06656567725115729, -1.0451322961786587, -1.380920540461184, 0.026143206737391636, 0.8450406238139023, 2.2209894334189366, -1.4409624316046699, -1.5816781873228538, -0.8628341481086197, 1.0091160583484444, 0.40457657691256715, -1.65349350939329, 0.288106757262454, 3.2420461511741343, -1.0366468776367126, -3.293192430368619, 0.9466997750897054, 2.620900636272989, -0.8139432530724556, 1.2112583058707547, -0.2598930167008294, -0.8034708720693012, 1.8391250779838522, -0.41073513071356205, -0.7583074575289248, -1.7017994291792988, -0.29655738606481896, -1.1756280247011779},
    {-1.9173475895619259, -1.206938699287579, 0.4307260960045779, 0.462854244108423, -2.6038292497167346, -1.3171734209598054, 0.28524773737706055, 2.0321134400589522, 2.723388495199091, 0.3927599931341821, 2.818416883021369, 0.43931739352384597, -0.9916191072061493, -1.1979064869259952, 0.8263182024395828, 1.4345189882833322, -1.7360039372857108, 0.6185239155535868, -1.4584183822450603, 0.11739372992924844, 0.09336704704923665, -0.760001867405738, -0.23422299014134718, -1.5594598323904068, -1.8363437876914224, -1.4205942297896585, 0.7759814957506427, 4.162278003490539, -0.20930157112496672, 0.47470340962167645, -1.1307654730129466, -0.006784129072123114},
    {1.9550318085098477, 1.4373781023520364, -0.6814536932327586, 0.12310435400289532, 0.018122334588320518, 1.7279784849677935, -0.5602653675830033, 1.373574345985657, -2.654382924013877, -1.4508067359437542, -2.1964666289919634, -0.670225315459403, 2.856238821460497, 1.0611455381647876, 1.0227510904103356, 0.14154529716685854, 1.4272287250430797, 0.5233152332154943, 1.8346114667183209, 1.0997006854904823, -1.1240035771060748, 2.0228050269012905, -1.4978590837959531, 2.349598889152883, 0.34544206280402057, 0.8621590751526076, -1.1448944320211458, -2.7597342160166796, 0.6259597983586833, -0.4681975031249155, -0.2080952431100797, -1.3587838481387824},
    {2.9917416566991184, -0.3591715981288517, -2.2410509377984558, 0.08246792218658429, 1.0627886284109764, -2.1780668541188164, 1.0159082840423264, 1.1076641094377557, -2.4835828396245203, -1.1243679313780723, 0.0632114166704522, -0.3569786939776546, -0.9815421406575648, -0.9980347041689192, -2.668530959359903, 1.3271525777529738, 1.1696007227903265, 0.25923698646806626, 0.8459614195943013, 1.3255143328469632, 1.563222654010439, -0.6558540487677399, 1.1572095403145746, -1.206160480890994, -1.8730090832897308, -1.3104017411610704, -1.4541281275657594, -3.6329999761266416, -0.6356579027238818, -1.7479285789832257, 0.2824185099365116, -2.205597971141463},
    {-1.427523407428185, -2.87648596911796, 0.2742708172043627, -3.1138833898800033, -2.1055815481026814, 0.6828435045535731, -5.319521029618105, -1.122455502005182, -1.153543214146525, 0.7994731168675395, -3.1375351446155877, 0.2915957292805813, -1.3453087241258663, -4.266796840967586, 1.263237019496701, -0.6704528554494943, -1.035452698169802, 0.6313258428901708, -1.5504816767913367, -1.3011107276869638, -5.4636552625466495, -0.8330634615549855, -3.925069297754088, -0.8450260358271379, -3.174780692791563, -0.30113829863628705, 0.49026814148344694, -0.20042832582364803, -2.882668020336285, -2.2035323444987407, -4.0418940242271, -1.4773861674970954},
    {-0.7048422575698746, -2.3670166144153773, 0.20214656168879996, -2.2353089529920394, -1.2864654844256158, -0.9127509849143847, -4.698267858665332, -1.45428546689671, -4.069660890888341, 0.7140926131105205, -5.791522119985824, -3.1044704790163986, -1.7636983670491253, -3.3694765409917133, 0.13383095256936936, -0.147957536414561, -1.9241747916915781, 1.0522977488555514, -2.4660082698371264, -2.427521633477403, -2.5875984087240287, -0.6484930095925865, -1.2287359049595874, -2.509547962106386, -4.325304609053535, -1.9055111538855047, 0.6962348543566671, -0.2571223017700833, -2.915983941300182, -1.4543867968149062, -1.1486108935224852, -4.306002655838017},
    {-1.4803817630119358, 0.9002619829045356, -0.6739192923025744, -0.006632726144711332, -1.9201541127381776, -0.2323016237591701, -1.608477635395267, -0.44259140660399704, -2.4981969615851707, -0.6090583306939101, -1.0861816576841596, -1.1043656771565908, -0.6756660550015215, -0.6994685726814983, 0.5418152345454487, 1.0275521725214258, -0.043918119381178754, -0.5136793038338596, -1.3444988658937604, -1.299419326908468, -0.9680461701248978, -0.9016716071468083, -0.4643019484881503, 0.22499957032477888, -3.0566808848150617, -0.060985596106261974, -1.8435385939455784, -3.4985542526546465, -3.4921457514498884, -2.6659348631672937, -1.273183377212639, -1.3679568256771821},
    {0.7754092039399966, -1.856500334500408, -1.2163845289025035, -0.19258920153447, -1.2861619237714235, 0.5978768562603365, -2.671597529215244, 2.3377439312460546, -0.26965473986322447, -1.475729970516692, 1.5221991112371385, -0.4725674692301213, -0.48487245357171255, 0.6954527372262806, -0.4772980066057784, -0.6347582662486709, 0.5125461230465742, -1.418897762915877, -3.5346162244518062, -0.2959573995568629, -3.1293904050487176, -0.007079058486440249, 2.587616721805234, -0.29741525989255924, -2.5878888242349642, 1.7238728852828917, -0.15310773166154582, -0.7035548958715143, -2.1884817510436085, -0.9600341988724781, -2.021843508763916, 0.8175476383478417},
    {1.3356136370209075, 1.1426537613183434, -0.3092482933326056, -2.1010363523271103, 1.1742830817554284, -0.4299925350828891, 0.21504985927269515, -1.0900543926448396, -1.247177818119283, -0.11063424017140679, -2.178212093449804, 2.4866951696265645, -0.9040139358393344, 1.0660472063448603, 0.33628997189215243, -1.362979445531495, -1.8034314507898275, 0.6686111096860662, -0.19547700213156616, -1.538815955253497, -0.9191926628583876, 1.497839900218605, 1.7895664589917288, -0.7936882224871921, -1.5773174150852702, 1.3939957082891632, 1.2207476251687785, -1.5932968176408544, -2.7624399961493995, -0.7610621394758604, -2.604038328256659, 1.4765962278832043},
    {-1.7579695983918278, -1.2705490733609797, -2.0056986332244575, 1.4143681981231822, -0.27000617452628534, -1.2814238536845644, -1.9801254743077876, -1.3610896899327727, -2.468294380509333, 1.6954817330519563, -0.24166072264953894, -0.12541161211554303, -0.8100405784694712, -2.2387375218198695, -1.8276386739650583, 0.5571331407504677, -0.8462318899107695, -1.2150349574093677, -0.714814713732171, 0.24698652089199596, -0.7132183508582729, -0.6186277095552594, -1.4380986551196773, -3.136790965022413, -1.9855925520429911, -2.0023168893136516, 0.0649641237201953, -0.168203524809719, -1.7183571396187896, 1.627859755075767, -1.4145136885309688, -0.7914370821057625},
    {2.9226386053226614, 0.12894609419936573, -1.089291231578994, 0.04800921040970709, 0.026993659775333915, 0.12520352613807512, -1.4892797482839508, -0.8496641707138987, 1.010503607255881, -0.33823472970828233, 1.3955320655657297, -0.31224436015310664, -0.6485913526717814, -0.411536239757011, 0.4965918355516109, 0.6137931439649835, 0.10027594663138245, 0.10378835892423491, -1.4681520184971777, -0.6830516828647832, -1.465892753986863, 1.360786936788721, 1.2328163846239335, -0.44075629758057416, -1.6418677517285725, -1.008774685606326, -0.9324008157347087, -0.654257903719256, -0.658296292909222, -0.6100636035234155, -1.0233339655704878, -0.3812407377513666},
    {1.01431158604237, 0.7924795337812516, 1.4622365636946768, 1.4465152125799101, -1.8048693411725516, -0.08121269740592303, 0.6566300439395396, -0.1744942261978732, -0.8302420115397281, 0.588866380261843, -0.0007659453884358812, 0.9075724492830151, 0.6670097093515711, 0.23558451613831166, -0.6237779325472737, 0.11847860903076779, -1.23652184322086, -0.6590900241317198, -0.7518404639744057, 1.7785408811290888, -0.1238159262308732, 2.1507192011739553, 0.6121367856190327, 2.487802548653843, 2.3576367467919996, -0.6080581179339374, 0.35437281867115683, -1.6587142081470347, -1.622065278027356, -2.2078727128475557, -0.13811357788804954, -0.06993556854958925},
    {1.3199844755728576, -0.19805238976678458, -1.0798786420771769, 0.29771393356945064, -2.4840911597408892, -2.589187858334207, -0.7886998274925449, -1.7414651153120857, -2.5007196916342758, -0.3574090748473096, -0.9266435777711947, -0.501656019886586, -0.3544427290215171, -0.37759112139051293, -0.1797224878044923, -1.2085488022463315, -2.688891956478359, -2.3357625639436446, -1.5488083677341107, 1.4818316258992787, -0.1469753613485215, 3.483322129793325, -0.5712675160664019, -0.4273889595036958, -2.1495546370752323, 1.6486083381532266, -0.7977555944037212, 0.1633517737178876, 0.6799197779841907, 0.13612899062736156, -0.1949686477175729, -1.9069561893473548},
    {1.785244352830891, 0.7859463564799244, 0.4161454918416126, 1.4822991901821199, -0.3394913592757704, 1.314128881520074, -1.318829231884974, -2.1772965406488285, -2.242427633816573, 2.2618460572909167, -0.27334731122118, -0.2646561272911341, 2.258393576316654, -1.1254164416151862, -0.3691071226961749, -0.7903039391839288, 0.7520692722722941, 2.2453781522429836, 1.6205208733409733, 0.1896844322327915, 0.1516150651216771, -1.3203735207694038, 1.8794299449427365, 0.5513559229663122, -0.05364273332455412, -0.9189941799615073, -1.0330065300893956, -1.3396556121695544, 0.6278709060396008, -1.4897498194922267, -0.511308173289737, 0.7190123931367299},
    {0.8411299151001536, 2.598516419451004, -1.2009767975758385, 0.08767737786171359, 0.02729496386325841, 0.992267945638511, -1.7236127912775372, 0.9982697430805695, 0.5291209191812561, 0.4395916358237192, 1.4725831010578132, -0.914753039086724, 1.2995686888457925, -1.5770001310384225, -1.8485002769401722, -2.018081646357771, -3.0458723060503194, -0.6955245764867763, -0.520341570006986, 0.6193418581328421, -0.19282533482439604, -0.919992201729732, 0.7713438021294722, 0.34403332637203504, 1.4709823121461536, 1.5140592725803852, 0.22632445354942232, -0.2509006910911809, -0.3533929534841159, -0.11322227698796042, 0.9434074922061468, -3.0530030702933786},
    {-0.24535518733850153, 0.45247831257851095, -1.6049172458060057, 0.629176425498683, -0.62202649462951, 0.36228530118622176, -0.8271764670444552, 1.2586651937729945, 0.6471817956598942, 1.4989076147612916, 0.585069952772379, -4.173645654273217, -0.05823692589927168, -2.3341900401156477, -0.28175939401350986, -3.7389539634532065, 2.0715225100999812, -1.3289233566439673, 0.46710276908199116, 0.3357390972928941, -1.879446061921756, 1.882469318313431, 0.7961055188955902, -0.26295943312457387, 2.326465533558388, 0.6257486426033568, 0.3466086476860495, -0.8001234488502567, -0.7817284139525257, -0.8723280418840734, 1.2017671993930155, 1.8459181683387706},
    {-2.6070037475936885, 2.184842222786603, 1.0857876542646703, -1.3685012801298109, -0.45490488556824754, -0.40241543478686487, -1.474959614804294, -1.119154894448804, -3.3842986743021406, -0.909224512775702, 1.1527748026974811, -3.3824553334845553, 1.7808253495482116, 0.20861106341688868, 1.950893412128432, -0.7226038280722727, -1.242416215331952, -0.4236776970884486, 0.48226947329674613, 0.027904730260587752, -0.3046227796358939, 2.8146403138075966, -1.310864148235903, -0.2192610170930479, 0.6131915015494134, 1.2768113426516055, 1.1856354130579716, 0.09498332299667747, 2.4199799730215523, -0.16490281584920505, 0.8463079105750551, -0.7199669200629016},
    {0.5435163504984968, 2.2105621167924725, -0.5775477276531125, 1.4876366924921476, -1.2540042532453795, -1.566811280841308, -3.517174050849677, -1.3129704212363864, 1.0457476030716422, 0.9655534464628581, 1.4067685294834777, 1.1606584035891858, 0.07136891556817099, -0.8002642764090044, -0.40416775422438483, 2.808117573185741, 1.7156776397932643, 3.0282127068858213, -0.8238266831293298, -0.23503930557215225, -1.0218994101621903, 0.9487858429110497, 0.2696227466365829, 0.06824711979744447, -3.714908850190953, 1.0759525137257302, 1.4211012797997022, 1.8230606357639072, -0.36671906282920663, 1.0705788107862932, 0.48198072548586274, -0.7398953232224582},
    {0.215082819736862, 0.791742138250627, -0.035856526763731286, -0.05369980858653915, 1.6434982731886227, -0.6786368506487592, -0.4685743040364341, 0.613099872881702, -0.893752292805963, 1.5485681104535363, -0.22279076928599875, -3.1344764066396418, -0.17849498467248853, -0.7569777734333357, 1.3965616988610656, 1.7239804436094088, -2.581686367245338, 0.5361446635626254, 1.0492124418386588, 1.6741504679783117, -1.32774021778541, -0.07899637889094796, -0.30604877548682274, 0.6389418994677897, -2.459455632255525, -0.634814131797574, -1.4574540851858648, -0.8708914340140596, -1.0013139294105082, 0.8929640794323336, -2.06672088360416, -2.1185644341237864},
    {1.117515348431091, 0.9188428553717598, -2.171803941335416, 0.4802038442325724, -0.2644164541485265, -1.247207009282359, -0.636077945106962, -2.3873599683894056, 0.3139346222800722, 1.097350532434819, 1.9921520049342414, -1.551929953888531, 2.733763957563534, -1.0881760467037798, 0.003938473755398952, 0.9529140960857678, -0.49780639199106175, 2.510659764388854, -2.2082168226356558, -1.367877598228013, 1.640714892480803, 2.2399402449586705, 0.6066982545685443, 0.9789529344852836, -1.8408621246121504, -0.13184459590290912, -0.15049343009763153, -0.052762059326008526, -0.7362573090734736, -1.2530448393523514, 1.285423254387596, -1.935747210318594},
    {-1.7003237762772667, -0.6774904598995589, -0.5932764787895216, -1.7734260406184446, -3.239268218488317, -0.047977883749784615, -0.5362151167451176, 0.3125697170924259, -0.38931432829611073, 1.8217295055969818, -2.9190763169708687, 0.8841407324578946, 1.666757487359313, -0.6985743375412123, -2.3417036395555515, -0.25667741114717313, -1.3419801273093734, 0.895878769777008, 0.7859171563597677, -0.6579648988183417, -0.696804094683013, -0.5026675096126249, 1.0864095964030425, 0.9609150199625207, -1.0621198810536785, 0.2655030364116174, 0.8163234867856518, 1.6621869342548392, -0.06069180332610636, -0.1570902442338843, -1.1547658030310148, -1.5133772504300025},
    {3.603275272642125, -0.19025137998341965, 0.009613849945247176, 2.16251803018344, -3.043574723807635, -0.5179598823698703, -0.20018132588544185, -2.830623965885385, -1.2960873172561744, 0.8684468793134966, 2.048243443766237, -1.997629317052219, -2.6717607655689197, -2.132838432793979, -1.4983215955558646, -1.3436917214476505, 0.11890174712982662, 0.34719302595002105, 1.3319541372473644, -0.20600781554904898, -1.4624975046308715, -0.21962697523452437, 0.5108557848836675, 1.6013284513763528, 0.3331481247595221, -0.7339547471980271, -1.2737878183176232, 2.135188116135866, -1.059504652723528, 1.1284934051964306, -0.8806563310749482, 0.0919308726951631},
    {0.23133182207030656, 1.3773323612819877, 0.25759168665403587, 2.348579295721486, -0.849934748657067, -0.32235260154060497, -1.7912670985906525, -1.3842657699214913, -0.9866866149982139, -0.48684544830103854, 1.1053005806565435, 0.927968022002123, 0.6781770450688507, -0.019721398899199757, -2.552844625600985, -3.4991579962836497, 1.5376128789547043, -0.20692848287746174, -3.138121085099456, 0.3657684076792238, -0.6237596174755919, -1.4316537100121067, 2.335880012474346, -1.3514784921715364, 0.08150353259181028, 1.3899137458550677, -0.2963103648730168, -0.8847136250585075, 0.896468684910167, -1.2217705828228063, 1.997558366367236, -1.2457510389071524},
    {-0.36707402972366693, -2.1515971844830997, -0.589026821696843, 0.2720806640807563, -2.963343356347113, -1.7127692647642707, -0.021050988696664292, 1.6981146765809527, -1.7230764452800704, -0.8053238880556015, -1.8283189483510376, -2.765684082684003, 0.7941414174345439, 0.6429456173604949, 0.24148245080782485, 0.08286230951579186, 0.577043016663124, -0.10529191238303308, 1.2340565287601122, -2.2903247795908284, -3.5678446163161257, 1.5136567761110837, -1.1049524546445513, -0.5259752208128099, 1.5086501933824936, -2.2979455615354953, 1.128817107083373, 1.5971805607489855, 0.28411861625664664, -2.1516327266986064, -1.1282195807983404, -1.150202592583577},
    {-0.6578263930606635, 1.7824660290016452, 0.32464972416161897, 0.8275144550732455, -1.7205605372412964, -0.6277432916997242, 0.9474728506447176, -1.2388882638397258, -0.19927481774028874, 1.2827640080859732, -0.8844446804068912, -0.3837142344188722, 1.3495126681671958, -1.0240824671761641, 0.501337760386326, -0.2544705005095966, 0.8966594241108984, -0.7174528919117755, 1.3790323129011164, 0.008908845249142863, 0.16771665214096163, 0.8399633349923842, 2.408770563926558, -0.42082971602801283, -1.6311823126420413, -2.777810294047225, -1.6077102774333225, 0.5761387822481338, 0.5253183848537697, 0.07256107263539467, -0.6671883577146519, 2.2702654582178705},
    {1.25662052630441, -0.5168620364628743, -0.029398199136758455, -0.7893232923745137, 1.8685661645240241, -0.9807412260930811, -0.23204715072332158, 0.36419054765363773, 0.7777245738542078, 0.17380431337599128, 0.4413418796708505, 0.04578134389886785, 1.0805196932817567, -1.0616936822434784, 1.3218923321840528, -0.9072606706663426, 0.2694914399600117, 1.601811329453971, 0.2892977102166477, 1.0674430234005763, -2.661666433278845, -0.9309765614389011, -1.3251479190059454, 0.08072536634703112, -1.1331402220460347, -2.440975773397859, -1.8912166830716677, -0.9239887825550676, 3.674750132746049, 2.7315280259719343, 0.8987521894786065, -0.1250399540708498},
    {0.7134692678207064, 1.047388605931894, -1.3686701146002231, -2.467652649930566, 1.7499088839047072, -0.21372475278020045, 0.09392168309865982, -1.07873392128072, 1.0434794054382606, 1.2221828882581038, -0.850786485335269, 0.15757331387701046, 0.5216908569598016, 0.09799383146295629, 3.3710524163725335, 1.6580244855696393, -1.0958908015024311, 1.465386894374754, -0.22730133560178856, 1.1323101639729836, -1.104027896073908, 0.9265733680967689, -1.077803674276633, 0.032126273131557644, 0.049437468513143394, 2.4669602158580743, -0.5833352695990817, 0.980974395962788, -0.6113316703306079, -0.5379113962145741, -2.111306354410989, 0.31044523730335305},
    {2.4527033339008266, 1.493666342467797, -1.771219311527215, -0.3535876144863591, -1.4523063231088367, 0.11766404912070397, 1.1946934566457745, -4.15770473842077, 0.4493122554372745, 1.486210476120855, 1.076034107709872, 2.129647689583472, -1.2320025374022925, -1.8397076584724794, -2.9017853056825245, 0.33375839452698214, 0.48535436803906673, 2.1168416456297345, -1.6241538868865804, -1.5126414555430743, -0.003759887184474168, 1.4926870798984972, -0.33109439815038555, 2.1759668158542214, 0.2874161903322784, 0.6552764801488768, -2.634113885815365, 0.5887244849964254, -1.5465547781023077, -1.7654442560733095, 2.0632547993092296, -2.4275023340487354},
    {-1.52765330738759, 2.479171428527856, 2.9576823437112836, 2.1054540426079367, 0.9030118506349247, -0.42296523320970664, 1.0471901271926847, -1.5288842382440424, -0.8288560924971339, 1.8833318017562448, 0.031017801867109916, -1.8917025848082347, -0.18684894056141424, 0.6971281321280037, -2.2615828088131718, 0.9253386426094018, 0.4809833712727946, 2.695864506116426, 0.24618100606797497, -1.7421912257228047, -1.7641452935520694, -1.2134205922009298, 0.13346608227840168, 1.3306171784972856, -4.13345460077998, 0.8079648922266861, 2.3066993256019814, 3.2124649804464083, -2.9748899882489868, 1.451462070145679, -0.28909172165265734, 0.47461886201772263},
    {0.5927035003329281, -0.07741018982085257, 0.7057820969359585, -0.513253149878534, 0.29327235786397277, -1.1242493907511788, 0.32986284974579844, -0.3328746908775649, -0.8203904612353038, 1.2862513190636384, 1.4039946087630435, 0.22073024168993555, -0.5935636796188458, 1.3312235262017629, -0.42839684873408335, -0.6306888354728722, 0.24798336430926096, 1.1983050123586207, -0.8098726299415357, 0.7479729470214442, -1.3666035196601423, 0.5449611492749925, 0.7405144227683952, -1.7452326323596767, -3.0212505923906, 2.0147225276559206, -2.1164615802726896, 1.0660463356136107, -0.8704073808176295, -0.7869924721888651, -0.5345769901927666, 0.12536698912700778},
    {-2.0604712823729643, -3.0210485419897197, 0.3320952680353367, -1.2831062854588244, 1.4360442969448786, 0.7842862806837702, -1.7346879881668282, -0.52169242888982, 0.1062430743434273, 0.7710357336100264, -0.3725763402203896, -1.1779752873861353, 0.7399741684708646, -1.4353292082241145, 1.5702550961352724, -1.7496151089175795, -0.5140191027568476, 0.726724682603148, 1.822965648314235, 1.9471811588356602, -1.0737710335805533, 0.38254412517683595, -0.254154732716062, -0.9276248109134542, -0.32478827298359286, -0.35353733374889806, -0.7875832532346879, -1.1677568947994694, 0.26899030003084573, -0.9047534824899642, -0.42067201955776723, -1.4391575401117735},
    {-0.15430765301170712, 3.0826893895329297, -0.870064640542178, -1.678622839217451, 0.9753014350898624, -0.6663246286766583, 1.906573652226979, -2.0801058294922665, 1.3395577746827965, 1.1110971570188912, 0.24000371708857082, -0.7754939487240076, -1.9484218245813913, 0.6021305049931679, -0.7753302095166532, 0.38891763876086133, -2.122247236657648, 3.313268615094831, -1.144934432562344, -3.918857210882901, -1.2918568528508603, 0.3328616180106351, 2.4410428761214344, -0.345539410375426, 0.04095255501356455, -0.6198798917352156, 1.7861734772166653, 0.7575039876565837, -0.29585568425632314, -0.9839943274805029, -2.744455199359288, 1.774327031776486},
    {0.03429734182678449, 0.2508396509633056, -0.48127495911919543, -0.6523050030025526, 1.585476881129957, 1.3644129790862196, -1.679153264521088, -0.4476706062553642, -2.630420749336522, 0.07113419837868523, -0.5360781340217766, -1.3682070053349467, -0.007352898767737868, -0.38913156486897815, -3.488992792077625, -1.9549154800531077, 2.3287649285302896, 2.043944815977393, 2.53747630455707, 1.0499911543512943, 0.9428379818793511, 1.0435366481051171, -3.714566318981761, -1.0707672045258803, -1.1088679888053157, 0.5615898402349718, 0.7869792920697601, 0.03633723676652164, 0.8509492406235533, -2.159331807947207, 0.5075132956656968, -0.97812388176164},
    {-0.8937148136928136, 0.05038708613090148, 2.522448642013187, 0.761980154381992, 0.24023336612595467, 3.06876089282189, 0.2414802797993462, -1.128937375268494, -0.5641653629069511, -0.661168146644953, -1.8379240635369851, -0.18073078624431893, 2.8247288958548538, -1.400912398341097, 2.5028929438603815, -1.2638060351008011, -2.350107451467282, 0.11238002158062388, -2.0570350293010162, -2.3699586291078876, 0.2841033601162493, 1.118498356444596, 0.28233008800323584, 0.44102695940447983, -2.651191862183018, 1.2312254742488076, -0.5947558924369899, 0.7653177123000041, -0.37018940427766056, 1.2480468309599162, 0.6285806832678135, -0.30217483039817483}
};

static const float b1[32] = {6.497852465560992, 6.093173063468665, 5.750098162179552, 6.031800957684445, 5.710546402234656, 5.611826164411495, 6.432295555297248, 6.001099431429019, 6.862198470469443, 3.610978551384617, 6.048299953884045, 5.562769175945971, 5.230315884195896, 6.436004891080491, 5.948839353355068, 6.03338841027782, 5.831677174394144, 6.018399390965317, 5.7426007777993435, 6.675148198377942, 5.994260865201422, 5.603853961603492, 5.744868973783636, 4.3862177908160405, 6.1779805465570306, 4.341485444856261, 5.574857770248792, 5.614782488173877, 6.17529300748454, 4.304705328423482, 4.819129463516326, 6.693255362463944};

static const float w2[32][16] = {
    {3.7133064170024013, 3.754636206409599, 5.2028556606298935, 3.95104564105418, -1.5757983391463584, 3.7837688092215265, 0.8610784637113352, 5.491304314815092, 3.1619784134668465, -0.03134369261113399, 2.9897886775131677, 4.687127689996374, -0.7566007705433025, 1.323474091860832, 4.042813651714281, 4.436483872466074},
    {5.099068054150318, 3.9377066777353975, 6.409401286937356, 5.50687850719018, 0.19772383194181756, 3.5725979023913967, 1.5172135802374669, 3.9218856445365518, 3.571785521947351, 0.1928722765278309, 3.602554769651329, 5.0369201093878795, -1.0284748969431616, 0.32892431391382904, 3.807833774770679, 5.516855426904699},
    {4.220112158310407, 4.448576598630498, 6.042760294031979, 4.377295660876001, 0.34537790034043203, 3.0931915506612886, 1.4774782581081582, 4.9315631312325685, 3.0262854008451336, -0.6356328701240229, 3.6414876384422485, 5.100271018952358, 0.34415204134434274, 0.6016628764261137, 2.9952622789841588, 2.56550009681847},
    {4.567680857102643, 3.3078768466536244, 4.5627502851287804, 3.745276837805076, -0.42561911293125093, 3.7869195345029434, 2.510641744187137, 3.1838775473526235, 2.782053374345775, -0.12041841253843841, 2.8669242519472453, 5.925110082333107, -1.243390691831543, 1.120453598773771, 2.941971123560426, 4.290896398401789},
    {2.996723496368057, 2.9740175192317673, 3.7436185722238617, 2.52332386718401, -2.3089688941046997, 4.94343345968025, 3.0779798700081704, 6.648680787825734, 3.4166507846238923, 0.08756733739409822, 4.75822538384745, 5.74457046926217, -0.7596748434105607, 0.2737756464967895, 4.394998298079065, 4.71905204055731},
    {3.172162454387176, 3.7112303276123444, 5.275580284049253, 5.471678054761714, -1.0372124528375148, 3.5575252990698933, 2.6765824501241493, 4.4339525832214886, 4.1814940961256415, 1.6491785639915293, 3.477375339556591, 5.554246274802948, 1.9823931521721125, 0.9639230715917101, 4.695189183255875, 5.871317163544952},
    {6.8368291998297765, 2.8620645040826598, 4.255593392681293, 4.628743672192564, -1.9699873969592674, 3.953251292217987, 0.8095754190741946, 4.127543917638797, 1.7757932190806598, -0.09875099737534518, 4.574764144479514, 7.12502045347814, -0.6249225972820283, 1.10619816949116, 3.9613546704898894, 6.367487778831388},
    {4.447053051781663, 3.190659754074074, 5.542138504173748, 3.1732278295071943, 1.2753453594375006, 2.5705423276715837, 2.7655992913180896, 4.249343957548649, 3.670238032750698, -0.27857797843001614, 2.485151700777531, 5.05226926020643, 1.6837270338266743, 0.15126344746294146, 3.0095731370255248, 5.268933158316479},
    {4.6876166672689665, 2.676433097183053, 5.4361314516063555, 5.461306134231017, -0.8254412099705977, 4.358308522664144, 2.7252420358569007, 4.188470710882329, 3.032531104638533, -0.3708921179940635, 3.7530159925868394, 5.230063326571147, 0.1964723625973436, 0.39777487849988674, 4.697818243281166, 5.483797128282386},
    {1.526508054858281, 2.0716153983124443, 2.7821988264943607, 4.623873050983593, 1.7405681472367696, 3.170196677767145, 1.2358669462270195, 6.664087464991489, 3.153095405427638, 0.06630299954599479, 2.5171347299149023, 2.1328389141478246, 1.7158471771149535, 0.781547768971032, 4.282289256029003, 3.8071118865318225},
    {5.691202933914229, 4.8534006231871665, 5.517035881666599, 4.953589030194534, -1.1441085873981367, 2.0484331739450115, 1.6824030361430584, 5.048220244277142, 3.3217445983353513, -0.8771493785771838, 1.205601889589441, 5.392936350567449, 0.23527890585639422, 2.0855711762711673, 5.465524559066698, 3.9986179713299213},
    {5.2684816931888525, 3.7197377981161592, 4.599510982067472, 4.273162261248694, -0.7207731172425439, 3.044658183921708, 1.7624360059084356, 5.136818810599475, 4.436177120433405, -0.4908173154599405, 2.1516231366203153, 3.457431392962721, -0.6122763876106336, 1.6507601463356922, 3.9453691096419354, 5.027808806465904},
    {2.547079621374037, 1.424111522836892, 3.9889439496327337, 2.794235479974844, -1.7361133821929369, 3.4936634086589367, 0.9896560810692738, 5.740246096740346, 2.7446237123986634, -1.9791413397030961, 4.009425124288825, 3.200392706336029, 2.583078806917301, 1.3717990918782872, 4.72322300906351, 4.774379286357945},
    {5.320304966600451, 1.9218333780467438, 5.581948372133109, 3.656060745650593, -1.9042792800478585, 3.4421590739849477, 2.1211929888514285, 5.565217901353473, 3.8954512729829593, 0.3868791370133302, 4.432545346766111, 4.808264596603502, 0.9365491093146706, -0.2771246247728972, 4.018007779043644, 4.377204188835543},
    {4.112292959664111, 4.887468261231476, 5.720637744323782, 4.469071511329422, -0.9296482274616028, 3.5826299917540174, 1.3043307126015153, 4.406132333076865, 1.6053536654019105, 0.2921771720905908, 2.10379654890654, 3.6483712398342174, -0.20410457102928206, 1.4494204227037029, 3.392796737511385, 5.65502933935253},
    {4.143463554666779, 4.331254526941915, 5.185487731268102, 2.173014542094118, -0.11202320272943699, 4.541047962539135, 2.347826649084937, 4.980071677477656, 3.2985092817133785, -1.400561746777009, 2.529001029036207, 6.034870500865829, -0.3335096841933889, 0.13076289779372902, 4.754579896519477, 3.6863205634728606},
    {6.137196175935689, 3.650269433255638, 5.446470809916033, 2.345111673870101, -0.798060521430244, 3.105849588760255, 2.3941776300052746, 3.5456119543814815, 3.881915381466072, 0.6514440582839977, 2.505242877676685, 4.227616509904171, 1.6453266079360462, 0.835086151646086, 5.088165085520693, 4.982314748383157},
    {6.613793160452398, 2.5596862307601396, 6.312571156815648, 3.4181324210811983, 0.8122126380494951, 5.16162346476944, 1.8600259072157743, 3.386870855882786, 2.1525941107607376, -1.2076010027102502, 2.9978055095914535, 3.9983148433322158, 0.06413620607374206, 0.16279597250636427, 3.4119078229087303, 4.664532168504362},
    {3.737642910483269, 5.117193525391449, 5.36448019996278, 4.083181289959668, -0.5328406588234779, 3.2759157953810627, 3.2715922168754936, 3.5816153194169456, 3.2118677881214794, -0.13748330897689212, 3.9908575073537067, 5.5405914999061885, 0.652137749676442, 0.15775396267996364, 4.222452497212255, 4.551839341271985},
    {4.1243121461387116, 2.3930280818109133, 4.610901477537995, 5.3523563909298, -0.91051020385147, 4.255659781880109, 1.7284050205720576, 4.320676574322221, 2.402624641734986, -0.8700484658673641, 3.7388470281035597, 4.132631910451285, -0.3275041066987662, 0.6190927684748643, 1.8064112791655238, 5.6123072256615165},
    {5.162495131176049, 4.098082554054542, 4.103069055443248, 4.865304574041039, -0.34661689479438623, 1.532172536215879, 1.0360019412173997, 5.272552522399775, 2.9272508021953167, -0.3564868619125988, 2.6337448850507776, 4.86059027512223, 2.115246048802247, 1.725184690292301, 4.47245458725403, 3.788139024373533},
    {4.583749553887441, 3.6321666261541967, 4.343424799542659, 3.2286185377724212, 0.762642374886511, 4.274788421091812, 1.5428447843048285, 3.772765861662562, 2.851785127290613, 0.6343868716407477, 4.825869921144487, 5.605229570004447, 0.3182228478120725, -0.5389270909996742, 2.6099974209665513, 3.7757672112410816},
    {6.1579524885079175, 3.942810360310157, 4.751389911571802, 3.394589636202006, 0.8142051118282156, 3.8522161814226923, 4.180571067117151, 5.61258280167779, 3.818527305631111, 0.33758387075094576, 2.784996572811166, 3.724497974233851, 0.24923017207299453, -0.15179534525396055, 3.574386429459646, 3.94868366134629},
    {3.8448493112948277, 2.375285988885346, 2.947811440178064, 3.3126691716979275, -1.3432966904279033, 3.457343281725308, 1.6777104638491136, 4.053688464990931, 3.518773412743899, 1.6243637782355855, 4.877989170692406, 4.299366758204329, 0.266655135106286, 1.4123073147032117, 3.3478786585652442, 4.556849494670574},
    {4.8126801644603265, 4.449458114727653, 4.536404255868781, 3.698600333604484, -0.661634257077829, 4.280040877214103, 3.308884155153634, 5.663606573646379, 2.991873929409139, -1.2241061228062133, 2.653257054190941, 5.981760491773617, -0.3865515256958832, 0.6800015027378618, 2.8868842023698713, 5.465617437678177},
    {2.2972289785100037, 4.809149139326815, 3.126040666386631, 4.468719127128779, 1.0296876107911404, 4.907661261791556, 1.2384489215081331, 5.8526816853640335, 3.3132852791188037, -1.7891264125137378, 2.3810958285423665, 4.363936805703941, 0.5226744478846552, -0.35894448822835606, 2.0139400142273853, 3.136553458952564},
    {5.694773742303775, 4.089158371696103, 5.437435050295115, 1.3067196105359662, 0.8000616487931563, 3.6061330881873093, 2.7800396562360703, 4.636147886188489, 3.811713385828695, 0.8013437175492124, 4.543598413199092, 3.799221909129451, 0.41055358657026786, 1.3885716857076071, 4.605223950266528, 4.558386490372716},
    {2.537254220993464, 3.6483029108143965, 4.313428602272574, 4.284456547433842, -0.7922700459650397, 3.204020442495292, 2.2991738831438018, 5.173422915535874, 3.147469919182695, 0.23597485457083497, 2.7065956621535263, 4.265117253157243, 0.12291466764184981, 0.7967176879247999, 1.5809395918816376, 4.996824365190026},
    {5.622066297460106, 4.790919166256257, 5.783698475479994, 4.3469116667166965, 0.4260435678173235, 3.357566467489643, 2.5509841904524335, 4.290964654203662, 2.759568923494054, 1.7269924872344877, 1.8045789575506037, 5.690048817404489, -0.9839040292273715, -0.24428971968222404, 4.278968749890453, 4.732256573226831},
    {4.369145605762776, 2.847900122997106, 2.608492227307931, 3.7423148212000723, 0.9694163713760271, 3.761228545103256, 1.6468822245939494, 4.1700802410816635, 3.1550750482349676, -1.1325743404200834, 2.799167243303152, 3.5181930924635854, -0.5960901527762472, 1.7691627940545445, 3.189976091970365, 4.539524329653372},
    {3.8462908636046933, 3.0357556947698914, 3.5109578714670824, 4.001651637552101, 1.249016686098093, 3.9915082843088716, 0.4767994454865954, 5.680082952075678, 4.573084428963359, 0.542840851271266, 2.9641955813234886, 3.938335419438697, -0.12270718652145725, 0.5757287479401408, 4.001316131420283, 3.9491342377407697},
    {5.1152924424205475, 2.9326049217245163, 5.739460365536653, 4.0889526888522045, -1.6260121585664578, 3.804653024500646, 3.0954445855854815, 5.589861226622269, 2.3807335781970442, -1.1279281897313542, 2.81754788528151, 5.881596907341365, -0.04556527056162001, 1.425415950185129, 3.5534956298058358, 3.8488335366150666}
};

static const float b2[16] = {5.579316276839581, 3.997433953070138, 6.070676342932647, 5.253444946855971, -0.31183509042875235, 4.3779551296944055, 2.7927964267782914, 5.880223762113384, 3.4884275002140086, -0.5064144978738991, 4.191373339487441, 5.697865517200902, 0.6061484193106333, 0.660064116524, 4.546458602744557, 5.539204073548882};

static const float w3[16][12] = {
    {-3.637610447642616, -2.9219488178672677, -3.712978164804396, -2.4928084855696477, -2.440758682129438, -4.808585955986542, -5.191111381266763, -3.7502527152612206, -3.480618880952337, -2.623829224742848, -2.213079224796604, -3.07937355498708},
    {-2.933456644857966, -1.268705818132359, -1.8747192438885925, -3.9310487677599113, -3.670253545490407, -3.759988592061023, -2.186802126159328, -3.9565113445586597, -2.8560444317790226, -2.352591705036161, -2.952228023385133, -2.9338938214581147},
    {-4.019728151625912, -4.976810798231966, -2.6448228954271578, -3.707540388215064, -4.734202691803474, -3.261975297112758, -4.558593431794234, -4.3559874129595615, -2.201641017004304, -3.9620202304084784, -3.40964207553531, -2.5977244406487485},
    {-3.5082622945918094, -5.05384311460634, -3.048610422732029, -3.3462495609083174, -4.451348722098517, -3.8271954717503527, -2.6086606344053664, -2.6587380362005426, -3.322963760015748, -2.60600153149755, -2.196669161007229, -2.6508583551387934},
    {0.6474897062242123, -1.0662337444833552, 0.40355514674179477, -1.3927719169028117, 1.07152429453304, -0.8427933140354813, 2.015210227392268, -0.16068560473249302, 0.8779553984549184, -1.6378510626100269, -0.7322987713308688, -1.1970062252173486},
    {-4.663149836727024, -2.386245323172165, -3.9775198913225895, -2.270975521252678, -2.640961507690805, -3.0756999349005483, -2.760645524222884, -2.475993242931571, -2.0815266647076602, -1.665999618419967, -3.175785659413425, -3.341056071132447},
    {-1.648269792894957, -2.6034208504486, -2.956094680536824, -2.521636723884745, -1.7120411340914141, -1.6607213018512619, -0.8364158196127487, -1.7721476347944143, -2.705375509543514, -1.274380517699485, -1.100571561491865, -2.944315097062784},
    {-2.7919766353963875, -3.6398826616254882, -3.8887374934192307, -3.3482120772273385, -2.389785039718617, -3.454852520972953, -3.776383333765722, -2.770184739314888, -2.530362667385752, -4.117579440574164, -5.6211149445181015, -3.6081215368598882},
    {-3.4358822750561813, -1.4942156626435976, -3.270278995270673, -3.6377906147927734, -3.9931697982615173, -0.5027554512697909, -2.5632173810966554, -2.838805073118851, -3.4247351979384533, -3.3536940694940998, -1.8270690830886158, -2.7943853243385863},
    {-0.29330301129829783, 0.4013511663032474, -1.6300733337577764, 0.6510156085138589, 0.0864786456791964, 0.4424850385518031, 0.30442206020768364, -0.8876678648222803, 0.1825456690577474, -0.22922304004672966, -1.0256934886107256, -1.3910225875557882},
    {-2.140907843999896, -1.7931417793836926, -1.1339603962009948, -2.4904847059975666, -3.969254663341839, -2.849203555700302, -4.080397067585086, -2.607837093989396, -3.8655257044454503, -3.26139035549416, -2.9238823244221908, -2.6390442559441047},
    {-3.9201021785188486, -3.682616329385581, -3.0796126059636437, -4.273767825869437, -3.27558157974834, -2.443092479952414, -2.303385105108825, -2.445813538535026, -4.924744275004703, -3.778450643571126, -4.8683377860005885, -3.7546057036032208},
    {-1.7617113354835277, -0.12141194518995287, -1.2449243495967677, -0.29152739507944836, -0.6385200953801408, -1.6852607285994647, -0.8141857739385318, -0.20803292300958245, 1.18784675779057, 0.7754779369651412, -0.8387985358682123, -2.4753197934423605},
    {-2.5337585193906964, -2.5355676652037418, -1.8426411728775358, 0.06881994017925647, -2.1423469685092087, -0.5576191486301261, -0.09277564475117524, -0.43303698402291135, -1.7076588437887865, 0.5255751113372665, -1.136272766190134, -1.6388585230813835},
    {-1.6538911370684966, -3.862475229355541, -3.4279806206849823, -2.555238082494995, -1.9175349028071142, -4.008412681890595, -2.3278202805221477, -2.4261564803931908, -2.65253268283512, -3.1356505743843344, -3.3499083954419575, -1.975543839788811},
    {-2.569859759866046, -2.929541756964164, -4.4624642397606635, -3.3218211987334425, -2.52028091031007, -3.3649200454625694, -3.6136596941218446, -5.193308376006525, -4.010422969119987, -4.827224389254418, -2.683202267227141, -5.202390082652045}
};

static const float b3[12] = {-2.6007389820680054, -2.914230912459535, -2.6908898747770715, -2.6374526989044758, -2.781653960336052, -2.812658212701073, -2.8509841421913427, -2.916625185138298, -2.4381685231662904, -2.678431125704465, -2.707404568820668, -2.7522627006797618};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
