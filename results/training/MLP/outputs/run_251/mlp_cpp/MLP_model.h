#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {5.730923010959439, 1.1541046896120173, 0.40641381721265274, 1.1293962437782845, -0.302149604251123, -0.1266606538571199, 0.9667179135354016, -0.6952693131510419, -0.2987917847412614, -0.9766845092738309, 0.8438911077138962, 1.1774567640381726, -2.9049512872196317, 3.0443730995616165, 1.258051451841278, 2.025280826031506},
    {4.2771292341910465, -4.253566739675957, -2.7171618390964274, 0.4793316803307879, -3.3329003978125975, -1.8034792707062397, -2.839238319810861, -4.828250372201594, -3.2607583556660784, -3.3234465658856913, -2.6324654726181556, -1.757820295258523, -5.371742014626974, 0.06585980546498223, -3.50172487316416, -2.340533425270619},
    {5.409758853810512, -5.624331578352978, -6.348726850144029, -2.634647631689474, -5.479573603146688, -5.277569345391919, -5.116432454129433, -6.902497481382948, -5.370013630898624, -6.3084345081431765, -4.232334657858095, -4.3356877368671425, -7.0219533108475405, -5.273130952941079, -4.808447726618899, -5.519705795163111},
    {6.665992629675567, -5.302111183180539, -6.493324033944223, -2.072959639811571, -5.249548599956313, -5.593464319105493, -4.037118457274676, -7.023460243842634, -5.432541685367612, -6.6082788616727175, -4.069988053372033, -4.366106922263055, -7.075376315396996, -4.950827353717401, -4.042755777107542, -5.4717078099642364},
    {5.570850885006591, -6.037544803779937, -6.89299289891149, -2.0896174544180406, -6.058269627248181, -6.509333974687063, -5.41289392917166, -7.152520027682759, -6.109171011755501, -7.279610251425375, -5.42165580421532, -5.7223906259442545, -7.090045881984431, -7.181596995454973, -5.322523581173221, -6.290503237381175},
    {5.021649774736004, -5.939559250451331, -6.46040031484448, -2.0823856003433967, -6.402860171929146, -6.263807489068331, -5.438335442353881, -7.255328514150011, -5.913891749107678, -6.693543182881224, -5.662808945898731, -5.692422953906115, -6.673748678755633, -7.404273242345428, -5.478257055866843, -6.588402927259206},
    {4.5264825571199, -6.014111391200224, -5.928580744812718, -1.2372328803082935, -6.211949569501923, -6.210775460040505, -5.267837973523548, -6.798361727285539, -5.92963066389844, -6.598273867941183, -5.5489164370835695, -5.434740220644186, -6.298303100206634, -6.81661706755997, -5.490387067594573, -6.257712076290315},
    {5.32028311333102, -5.776593545475643, -6.145212979448926, -0.6556125140272221, -5.711835581485793, -6.014777559037161, -4.843599129515332, -6.78038549065027, -5.702408780846294, -6.201313188285488, -5.0720535452890525, -5.339797200977536, -6.395472003779609, -6.424572845028416, -5.17917559962188, -6.157999535556621},
    {5.953229591593601, -5.465404691317631, -6.07562286959118, -0.6500370965891612, -5.7127920877340905, -5.262328983998735, -4.107015304547388, -6.630830070641247, -5.686438537774258, -6.244939071662217, -4.5933391535011845, -4.977417714611347, -6.709309214472202, -5.465180925505685, -4.80694397321962, -6.029821668491525},
    {5.9504786299687416, -6.243157361771118, -6.207088547368902, -0.7907873442564435, -5.684857613275588, -5.483981364615994, -4.265113926051082, -6.730514609991003, -5.6936668710518035, -6.061404453642123, -4.800101694989208, -4.604138210659329, -6.656103134359229, -5.050433026646835, -4.8006261720629775, -6.044129122379588},
    {5.243371550999391, -5.549341511366433, -5.157247724140909, -0.316039271056232, -4.227701786133856, -5.023852309471597, -3.7253437386547135, -5.695982276837783, -4.808103980430038, -5.045038117476196, -4.1858721563993, -3.308216170745637, -5.858137579664887, -4.037076398326072, -4.112520829555788, -5.047146637446816},
    {5.234683239158146, -5.452561471690823, -5.720611853896037, -0.9039357018846746, -4.378275890250165, -5.499834089237796, -3.3532570909529964, -5.76296322616613, -5.284158267980215, -5.5015793956911, -4.308161860764462, -3.366582063027084, -5.9338131050169745, -3.975258378545244, -4.26622521208466, -5.6620510970292655},
    {4.913846854723127, -6.442977060782152, -6.731912440247833, -1.922169387624739, -5.621036014658549, -6.121080346291052, -4.276758936345848, -6.597078781861763, -6.099185312666863, -6.2682303040974885, -4.8060779074966264, -4.601327516464255, -6.746607317149093, -5.108991945925972, -4.934313797779296, -6.547840375351203},
    {4.59186184729723, -6.385834570310066, -6.67633307867812, -2.000113042032405, -6.09918715396152, -6.382661760010732, -4.977507971922419, -6.715516048492196, -6.370363800831742, -6.747192758904121, -4.897168559630138, -5.217914907964939, -7.2755040740393895, -5.847414674470455, -5.421931850520578, -7.050264236115234},
    {5.126564821074715, -6.691797416777298, -6.328501573396455, -0.7574729163032462, -6.3899689208223664, -6.519334563769939, -5.391293807661271, -6.696144515052754, -6.421450499611449, -6.779063631770058, -5.426230782209461, -5.382415971095187, -7.036054371074929, -5.923275385447654, -5.540856549266794, -6.678458953954499},
    {5.053460032512337, -6.780795059977012, -6.677455390969939, -0.8994009994331449, -6.444261456254244, -6.06624258171512, -5.226201576782452, -7.070346596373354, -6.615402145265673, -6.943344951837802, -5.284946788342617, -5.898377926359281, -7.124644652967768, -6.0546893271965185, -6.044451867645426, -6.716345333823271},
    {5.725445178212187, -6.462933750924855, -6.859893069655241, -1.0252780087742421, -6.168277255947489, -5.613950168427669, -5.436974581172854, -6.928421088383561, -6.4098951554389405, -6.737357067646347, -5.2119459942686515, -5.97121772267301, -7.332164885316706, -6.133381011377087, -5.980890753545614, -6.479028571338233},
    {6.586734901015064, -6.289985686913919, -6.419412992854746, -1.307004304636771, -6.1059262678008945, -5.4859156470491195, -4.779562560982214, -6.742470344391414, -6.413723702340721, -6.656574535958373, -4.77404296869639, -5.047155162561348, -7.420248190463652, -5.090372755107895, -5.363436956487093, -6.269849664546028},
    {6.33453357611387, -5.814576031787788, -6.338861665482627, -2.185517791210896, -5.878699705492036, -5.960483002908111, -4.647372256415205, -6.588066103342569, -5.958011320855964, -6.570946274192438, -4.828370985996008, -4.909239555187011, -7.108740341257363, -5.807506106366278, -4.878298386959627, -6.4262486561652326},
    {6.1400628378373, -6.194459523102435, -6.224786682768612, -1.9612631543517798, -5.857173662384094, -6.35723935168163, -4.392786713018243, -6.7844972539851875, -5.590166936664421, -6.7038519211766605, -4.794660292534109, -4.773616841086339, -6.825379890980677, -5.505353730717569, -4.559425434726883, -6.2454215643554045},
    {6.3442451395932, -6.214924008461317, -6.351756906029861, -0.6341350531318583, -5.386099174936159, -5.903626619226507, -3.90264505929796, -6.920290408281955, -5.797646459835407, -6.566982511281244, -4.675956727321133, -4.364405103758906, -7.353371938711025, -4.422783619399405, -4.549558622767619, -6.356378126781683},
    {7.3680804621809255, -5.357574592946395, -6.101118382871946, -0.32269660815719725, -4.822823223116109, -5.134445093566335, -3.7702288894973903, -6.242070462493928, -5.203947404443472, -6.233550431485193, -3.7722198825201954, -3.9491068815706676, -6.932707849826188, -3.4118857539440697, -4.076485054150817, -5.606318154377683},
    {7.776398005526217, -5.0291774564139144, -5.262306082723875, 0.2297235244955629, -4.513227005344035, -4.122120731780119, -3.2912144771401826, -5.368914361166895, -5.049082730141217, -5.308338279758692, -3.3973958479543427, -2.898678787662889, -6.384722046566881, -2.1660292035432067, -3.7390498906130745, -4.514661998673926},
    {6.95045640352994, -5.751053582550734, -5.677222962622483, -0.19574413240713853, -5.295017379489458, -3.955181444993384, -3.9015108383006685, -5.911162698245073, -5.703319504150307, -5.816548495629023, -4.4467346620846815, -4.499019369491118, -6.858833284821194, -3.2170797099015784, -4.6786157413959035, -5.051276280564982},
    {6.047984562238828, -6.134231261930211, -5.869537540289342, -1.2883176658232556, -5.388319450210739, -3.758975809065339, -3.887311014147695, -5.9756700596108345, -5.495879736222171, -5.570312406223895, -4.607706656820704, -4.669656983344606, -6.919605610678331, -3.841766891451568, -4.893499915006425, -5.259102507445514},
    {6.360995176173725, -5.8410264326696035, -5.509801477643178, -1.2077802167120184, -5.288134651774538, -4.438675316615592, -3.4804910966796805, -5.608051248206613, -5.651245065807539, -5.565638540114377, -4.174450866126661, -3.6384388902290747, -6.537411149671039, -3.4858280834361652, -4.512439249285972, -5.258081183591735},
    {6.494154006694205, -6.201688617695851, -6.112650666748484, -1.0835092280945018, -5.710183043887652, -5.086123271323781, -4.451887555689011, -6.389273749227108, -5.737260959290919, -6.148280075028923, -4.326673811450082, -4.485426700084645, -6.93087435988658, -4.117350741929553, -5.010091093947193, -5.540206368035123},
    {6.6675618899340385, -6.613308400125441, -6.596017024842405, -1.1932556124818, -6.275906630239545, -5.893179079426479, -5.164977824419297, -6.983098959027168, -6.273226185953564, -6.563862619751826, -5.01449549860881, -4.680482808005492, -7.37816319935845, -4.871654141736313, -5.509236013657657, -6.261770790427902},
    {6.0276179155900085, -6.275988576701157, -6.1314044102093, -1.1215545478644566, -5.889226160107441, -5.620611351231616, -4.915905952513481, -6.777460475792365, -5.996520261257049, -6.383878804641435, -5.244503117009057, -4.849335048671923, -7.119877714928095, -4.374520893884733, -5.427733959092096, -6.1252240208228015},
    {6.316636527851334, -6.064053435166557, -6.084374628020516, -2.103163849509643, -5.8575609118584895, -4.973871174696698, -4.412159451076774, -6.358831289355247, -6.057945624121354, -6.3066622748548715, -4.7676611504005955, -4.678801108564754, -7.447022662148813, -2.9306915356633136, -5.222858728729547, -5.94004040881632},
    {-1.0118897331554055, -1.8468478444040153, -2.407271854566349, -2.0734454742999118, -2.133126990306278, -1.6757667757394163, -1.2365422770975054, -2.8268824869734352, -0.7948594489865805, -1.9984924439799645, -1.617556294036859, -0.6426988564680564, 0.6926894612819027, -0.8117689951112487, -1.3122156981469988, -1.8407806464071355},
    {3.7820379980849617, -4.249439259965095, -4.322655625332682, -2.809838013333434, -4.769087126423915, -3.940347726134629, -3.522963012766359, -4.860865653412158, -4.088942301721505, -4.317107402127124, -3.5564647463639925, -2.5467330176473775, -5.615652180442152, -3.7174780750830245, -3.781950784242774, -3.0043041388812246},
    {1.0905224872971706, -2.7944791303571366, -3.2024755500283564, -3.3614524726353636, -3.6591698241959967, -2.456577250454953, -3.180337828322003, -2.1809447736439442, -3.49868808071836, -3.268841489462202, -3.1933665644984477, -3.576214382918952, -3.3593577808038613, -4.783543062092161, -2.5516659746970114, -3.451260349230261},
    {2.663818934656366, -2.444895886278481, -0.21005437665391033, -1.8800506484755306, -2.1458168507583966, -0.006843826054879876, -2.4293864084697843, 0.28212687596436375, -2.731297230048166, -0.6878038835516189, -2.437672400953418, -2.425102431099117, -2.090813683738468, -1.439020513063465, -2.6902659796761004, -1.2567431559481301},
    {3.7222771319923607, -4.060274644634296, -3.5979945299430325, -2.92883583752916, -3.687939192701831, -2.551054580948473, -3.718738101173514, -3.8168609382264385, -3.943230381406697, -3.7804924042198524, -3.7854553586209625, -3.069480182765864, -4.115108902058852, -4.607854565619813, -3.7076585083358053, -2.983309338545114},
    {3.8483462824390755, -2.8952521025055424, -2.4786292220036303, -2.405086655833156, -3.200672313185547, -1.9569917801796866, -3.235484422984941, -2.9503344715368645, -3.1047022131610267, -3.066223795359445, -3.095029756950427, -3.167014296589015, -3.640460334683895, -3.7011465621709077, -3.0918174830848644, -2.1601512777805},
    {3.6244431393503964, -3.080776742425122, -3.008874336719482, -2.426310821296582, -3.5191187696656065, -2.5048058747687842, -3.4243994237812347, -3.76795315719586, -2.9142851132679137, -3.159806724491816, -3.2599141223631585, -3.341602537998762, -3.413021900096296, -3.382230506312078, -3.2815612804586283, -2.7253445264282146},
    {2.453117222480595, -3.481404828122618, -3.9060065161449784, -2.6374139701457655, -3.724520301876189, -3.337567827495188, -3.5713523260024695, -3.478371390734384, -3.8870762740918177, -3.6749925119039926, -3.157803550575271, -3.6223038432775305, -4.203385247031182, -3.7564590572894887, -3.145061090577365, -3.64539952428593},
    {3.184082617105339, -3.1525366232372733, -4.011155089674629, -3.1670035363147013, -3.739605245805552, -3.3665040924875647, -3.4513960653486757, -3.8754412557584703, -3.0979469933620534, -4.182093657413334, -2.6857991763799394, -3.2862784032497205, -4.608097698715451, -4.359792426764555, -2.7732233144290053, -3.7095573188989914},
    {2.652732916859434, -3.8647125248590424, -4.7959775001381, -4.377410960791546, -4.627903907129111, -4.221478771679315, -4.336045903511883, -5.078644211133755, -3.3647141427479608, -5.289542361371425, -3.5558766559781603, -4.087794279949136, -5.035580033483013, -4.949381849051911, -3.4038903756197274, -4.877024422383517},
    {1.7440732476500518, -3.8652026258973105, -3.8152754605239525, -4.279749327645711, -3.986883157070115, -3.476280314347377, -4.156577025923967, -3.902938226835457, -3.3961838839609193, -3.8440812882290976, -3.795817093198519, -3.130944707097993, -3.8685526050448815, -3.7471576444938264, -3.58080686585519, -3.763802891993908},
    {2.717356852786692, -3.5451577539744457, -2.8847795944264454, -3.5226472357986447, -3.7016611707856613, -2.970409152875031, -3.506169139132513, -3.204030574563273, -3.166807679742165, -3.7628007936535544, -3.463572699109546, -3.9170975732692384, -3.85240402625918, -3.8912973127010457, -3.3335987086673007, -3.698182776491375},
    {1.996875058087102, -3.7418352394564653, -4.593401302649997, -3.9860005798601135, -4.032749139310474, -3.3999690765075914, -3.3788258362096864, -4.893498590994754, -3.653322750611149, -4.664666540742236, -3.496926927742443, -3.79628009593699, -4.5465589627443, -5.083019679384399, -3.048851604492592, -3.962752525820011},
    {1.7276750137900418, -3.7563159440544287, -3.4717992371783915, -4.452216902327734, -4.343197681048362, -2.9734001060548585, -3.6990581127292415, -4.065435691323058, -3.4661642682051643, -3.6969363519302147, -3.153751848679917, -3.69148463037985, -4.56604466946384, -4.668174861963472, -2.7686573866750135, -3.4931385813333016},
    {1.9588238942514038, -4.362476875988655, -4.703565884312691, -5.0271833549562235, -4.923434108388616, -3.943205721603943, -4.557422566220945, -4.89298728217246, -4.370256778920602, -5.070466901222651, -4.372218601513157, -4.260486398643265, -4.708313415990947, -5.727350809999852, -3.7289283533039104, -4.42339783425499},
    {1.6180628868768565, -4.350363405741992, -3.4949019641403494, -5.06810415925496, -4.906250476959899, -3.4614936114316563, -4.6490706800646855, -4.068498214278804, -4.477699717392863, -4.282624510956019, -4.332054954314707, -4.776030177190241, -4.260013550255123, -5.250656016003184, -4.209583458168831, -3.7641572231353546},
    {1.6538768404090527, -3.012600120083683, -3.00967363365795, -4.595176435763194, -3.047268025301616, -3.044531937451863, -3.7523844683497276, -3.0966024763349083, -3.184677046793204, -3.491222041857403, -3.0513079192540093, -3.992812326940323, -3.423886207699637, -4.031170133743704, -3.14498973946752, -3.6649251049203393},
    {2.064828468839538, -3.850778060136116, -4.013728698993428, -4.709116898661803, -4.360403498298125, -3.727156447071365, -4.556489665290901, -4.13944104361084, -3.8477948676385885, -4.239440476200497, -3.399758660622787, -4.413241867405276, -4.852146887538721, -4.871991764762884, -3.6678730730148925, -4.5194565199424686},
    {1.0460903021919292, -3.7844568737948707, -4.153726491998858, -5.305773938471243, -4.626380331039651, -3.3875671503563387, -5.064735867700626, -4.173686114165537, -4.078113584587557, -4.215849248780017, -4.232026512011498, -4.766329840687373, -4.255642978071794, -5.682127677133062, -4.318702773801422, -4.270285941288767},
    {2.227662118183828, -3.7461599524858915, -3.4794399028514382, -5.025794067899311, -4.404578687772232, -3.168613751331586, -4.3656816724421645, -3.6853075846974797, -3.4296177357912914, -3.7308053570006594, -3.9964608989943624, -4.235799125041711, -3.522141985380699, -5.3290228316203105, -3.719132038254364, -3.6277715648338362},
    {3.2516055947931193, -4.8491871341981065, -4.175277689429607, -4.21478369351594, -4.560618085950646, -3.508800240305044, -4.871804560531452, -4.604512605018683, -4.313633723069471, -4.619060442865192, -4.740828173787723, -4.660008224429106, -3.8106703827329222, -5.642695805425885, -4.430671578695445, -4.601586139131894},
    {4.371535509498808, -4.109476772674498, -4.530363577523272, -5.228269039927351, -5.186176579408349, -3.6347954797914173, -5.198694189781052, -5.4031360258526435, -4.32693533878639, -5.691074089773572, -4.761263579739146, -4.614130045373969, -4.118573046028042, -5.683061951959947, -4.2688043834682965, -4.440260201598908},
    {3.147726171853446, -1.158656410199014, -3.852188986557203, -5.328486145294462, -4.201474156648144, -2.878937603263586, -4.774872153885375, -4.192817996088236, -2.348140499030891, -4.744149853943134, -3.1355456574581044, -4.29727365876086, -1.3648940675196213, -5.913389037491111, -2.76993065656599, -3.2398888753818946},
    {2.211357683631973, -2.9716155559548127, -4.302715800501259, -5.3893874994457835, -4.258554153805474, -3.250152687133255, -4.774233217857912, -4.4705983620185705, -3.3214156946299993, -4.7225594346737685, -3.6065462189594513, -4.766671029618322, -2.2945154991911205, -6.225851528908933, -3.419574984814558, -4.335660502680269},
    {1.859623373545255, -4.4938777444636955, -5.320477029138609, -6.093880572535984, -5.361539658354767, -4.29287473046777, -4.988741766178286, -5.681513606983419, -4.72087157883613, -5.496062588004083, -4.424247317674513, -5.018521357502461, -4.530696972696985, -6.6553304615608395, -4.291552361346605, -5.462221552198532},
    {1.9588336701946254, -1.6621348955938384, -3.506739002767219, -5.591464959077348, -3.6331643279944466, -3.618587518335745, -3.57040367770405, -3.32611975718381, -2.610326633457301, -3.729013387518932, -2.4205314222957988, -3.2140102450464916, -1.1287057018771325, -5.522526602830627, -2.3974361334707424, -4.018510609410129},
    {2.3679017492236443, -3.7878683999871936, -4.011371551971544, -4.8373445092595695, -5.020202112125256, -3.5546870128401173, -4.65326227336477, -4.107204295632747, -3.7039628298725535, -4.37434260496939, -3.8769495407366055, -4.227566169565131, -2.507193759979779, -5.816459529464263, -3.6931157119614206, -3.58176690159316},
    {2.237877081713583, -4.935950076814, -3.942894490430568, -5.730612054738707, -5.626469071481712, -3.617532976981605, -4.907351133205855, -3.9277791075479414, -4.660329515783519, -4.708881007224066, -4.668600510990231, -4.9396457549336885, -3.676651140891275, -6.225998562908795, -4.611559969092447, -3.920207174274778},
    {1.7977692642768157, -3.97742762682579, -3.766538766071011, -5.584123464743937, -5.7513737849434134, -3.4022895185038204, -5.731001375726271, -3.9318431110301706, -4.636888400015037, -4.636229478255605, -5.042754645820972, -5.7828972588343355, -3.1084784110160175, -6.300691471239096, -4.622568795710228, -4.086228762407164},
    {2.3750048518742957, -2.4643601213789483, -2.0476304172236546, -4.78208135386503, -4.576363735471307, -1.6884208216734764, -4.679282327026019, -2.8210723007828777, -2.9649254193605366, -3.810454615240051, -3.820318667001906, -5.42881077463211, -1.5573338197520854, -4.603344994382391, -3.309738074921796, -2.483955417062521},
    {1.7692540435497777, -3.5001544330716565, 2.30851035558115, 3.443830014942972, -2.730139882312524, 3.1064315569699206, -3.7934538169494494, 2.2410091760251327, -3.4486859686819558, 2.2400242522227285, -4.014909967546083, -3.22828131994041, 0.9961400364286785, 0.7645834310586838, -4.114981087786268, 2.9518056502361794},
    {1.3556974883245942, -2.771408756581845, 2.4957798789428227, 3.257952314227734, -2.5886736011668323, 2.481565100699449, -3.2919093596243134, 2.1406866612690316, -2.8705076237221605, 2.2622398853062045, -3.579257911329815, -3.2016170886146993, 0.5359230285595604, 0.1744431699611149, -3.7998894831041983, 2.55860724965801},
    {1.8248948510373042, -3.169996660782185, 3.7083540657866467, 4.216158388313824, -3.0637208974319408, 4.087008330596876, -4.285949012070772, 3.5118688618293867, -3.4493029467066063, 3.5774759396889397, -4.385825599523436, -4.260492823978071, 1.5732349794798828, 0.16550909973254946, -4.289265086419703, 4.2943474869291345},
    {2.668338902236017, -2.2920688533505262, 4.418321311683828, 4.654788613346941, -1.837337981608015, 4.535118711744743, -3.1873579443841473, 4.421768882897471, -2.3050536114551234, 4.321625471168756, -3.5143754953868527, -2.9785547619810506, 2.365939850301203, 2.260519615598102, -3.9260326213615833, 4.867411568217943},
    {2.2278764757048357, -2.4089878156074045, 4.341416855150153, 4.460422627440459, -1.8143526686247613, 4.681578439335419, -3.721014371624997, 4.576344786377988, -2.6581348164639578, 4.128016737156051, -4.194772582953373, -3.449413777344648, 2.387169085999504, 2.9617368954656706, -4.105606352683621, 4.805008146615538},
    {1.497317348068187, -3.421361025475855, 4.096679312722959, 4.5179310153703796, -2.663845775907781, 4.349834389428985, -4.437450843328257, 4.416320677321938, -3.636067418344749, 3.9784867637545402, -4.813497746908866, -4.347140797791365, 2.365630862222883, 1.9264872740773886, -4.933435365469528, 4.717095982868916},
    {1.1385245060196507, -4.355626822442358, 3.752421296905456, 3.9201879580639245, -3.7101815570793852, 4.42665498200577, -4.8149702893401125, 3.5605985736714, -4.525112802773009, 3.4608132526791047, -5.528673084526436, -4.809936826827772, 1.595296732682637, 0.30579368816388275, -5.559872351296816, 4.287763239207443},
    {0.9045745839102858, -4.6969375320617575, 3.761353148162664, 3.808939094445009, -3.6019906403707918, 4.543711051077625, -4.8562956500068415, 3.4727158705398344, -4.814246572478866, 3.505626709827134, -5.572838429139375, -4.661833729837437, 1.2266272565293013, 0.5733415653562972, -5.241843207013928, 4.5076546982352665},
    {2.2039594627450447, -4.024167650197388, 4.705509977716926, 4.66806429817391, -3.3047362162031884, 5.027529021482319, -4.497370715933585, 4.677718903303807, -4.273961304866422, 4.595347089091, -5.140052318576771, -4.480133210786606, 2.7672411203689204, 1.5539085518643654, -5.053287029943333, 5.224608520517765},
    {3.2387121388227578, -4.14224967952915, 4.085117450902107, 4.32423762694816, -3.6176632188378806, 5.031609379982172, -5.165421186389651, 3.9779349680482317, -4.499439769887003, 3.9830015819752083, -5.469479730548058, -4.662328017879301, 1.5012610259699897, 1.1082242295454285, -5.131850666050815, 4.657179562799295},
    {2.8056230292411217, -3.7963527176419083, 3.517133980431075, 3.4877744364636927, -3.3128444704840945, 4.220674642221062, -4.704870985303191, 3.606110799252242, -4.211605851967675, 3.3688593040712385, -4.614906543547588, -4.05978459444745, 1.7353057291438931, 1.126474607739083, -4.708173247743002, 4.27964303528088},
    {2.6126014331778817, -3.8401746760021185, 4.427160290637091, 4.525030876637063, -3.037945675170212, 4.9940886433765455, -4.484605710088161, 3.989212089702971, -4.0276150681756615, 4.164885112075337, -4.656045805545596, -4.237868473261075, 2.4950891052141952, 1.5637598213120938, -5.07624577589386, 4.70118730683403},
    {2.8045581927873555, -4.269170849031764, 4.318119633543221, 4.925500306306572, -3.5575513694163607, 4.86162845150328, -4.858614960612642, 4.506387249074047, -4.295685087230291, 4.045634697078059, -5.168514481248084, -4.517714679161678, 2.0460392956711435, 1.256563439179224, -5.42502216829736, 4.834945692136418},
    {2.194880996230219, -3.961888609800557, 3.710989845190758, 3.7665721870211564, -3.642965434120511, 4.630987713218611, -4.869608530822772, 3.545814739392076, -4.137140000535598, 3.461369153511165, -5.137644491082679, -4.859281684173305, 1.1941564255414676, 0.7930118666568541, -5.334292371170567, 4.635764214049793},
    {1.4126269991472753, -4.225664985083125, 4.180601977554041, 3.958551281278958, -3.9051504298759157, 4.776826257693843, -5.189528912663341, 3.880164616404758, -4.782033621268487, 3.6874735875345763, -4.9170424726160595, -4.81957589780781, 1.4611627579850517, 0.6102880035439944, -5.187279788823669, 4.957333874673682},
    {2.005344519546367, -4.5742707235421705, 4.030449824994193, 4.565575526316294, -4.391716006967933, 4.9402281105881105, -4.9668464087449955, 3.82044746895229, -4.887302937230346, 3.8675424982568507, -5.108306944363932, -4.7028541300968065, 1.5361344985925514, 0.9419573882080879, -5.505643508049174, 4.8370021608214735},
    {3.505423340775266, -4.283218675755933, 4.491152572341879, 4.906761700143322, -4.453206777417972, 5.306754239343658, -5.309055809674039, 4.1147853890401445, -5.135124463245148, 4.243595200187967, -5.5067958087745925, -4.761636492607892, 1.6004242789248986, 1.4697945036107005, -5.647461476557673, 4.9017815942655085},
    {1.9410164933252627, -4.178069939184605, 4.79788663325526, 5.112878154970412, -4.272888065193249, 5.425460081481912, -5.350211101536725, 4.411350438624029, -4.927805694917681, 4.633680262503905, -5.381995443818991, -4.897994884703059, 2.091493628516796, 1.171031497585681, -5.6655853005989565, 5.27298847017865},
    {2.1406389015751004, -4.646871892953452, 4.161365908304676, 4.3930113328212395, -4.5361095568171095, 4.964188191059436, -5.121264486167908, 4.0905084431568515, -5.112965130729743, 3.959552086900583, -5.578770931899327, -4.761574670616015, 1.454404235695103, 0.26764846211192816, -5.854349648431098, 4.688947596349495},
    {3.295429935607332, -4.441902369134197, 4.525362619091639, 4.914871537361387, -4.10142380905008, 5.378050125733241, -4.95174480340766, 4.120388674363378, -5.040895461426119, 4.032161555766561, -5.489019728221204, -4.57951738978759, 1.6132109175214826, 0.9752203960120664, -5.577711337523599, 5.228787083982887},
    {3.198625220518828, -4.277524383303191, 4.2431049672698045, 5.053435242741542, -4.378445116281455, 5.3190901243654825, -5.116009247262192, 3.8306286313382745, -4.860059320573978, 3.7290517019957363, -5.331677483484861, -4.62433207516468, 1.837434855296683, 1.0455754349677175, -5.344501323123396, 4.959531455703026},
    {3.5052538719506066, -4.172780793115816, 4.134335895308169, 5.236415764711866, -4.278164734869987, 5.133792758914021, -5.148788030209753, 3.790537202975404, -4.919024541198489, 3.9787057312177656, -5.371251760514612, -4.649580404593148, 1.529422344225361, 1.331667282996382, -5.166961050204719, 5.111382804213045},
    {2.962865004708855, -4.105926685631802, 4.371243589058509, 5.392403733717692, -4.32742376646912, 5.417330895122381, -5.549952976463878, 4.142697594829993, -4.700964117073944, 4.154350754299501, -5.522768509776353, -5.0610460130768145, 1.4535054133750573, 0.8844594805856003, -5.633528222138004, 5.386388162927897},
    {2.9725104829650677, -4.902965413436682, 4.576143640894404, 5.794484012033254, -4.70475352160813, 5.946220527474543, -5.880032171213508, 4.153791958485817, -5.3520465372945125, 4.644758974489292, -5.866751845175629, -5.376823492571479, 1.8563820963505, 1.0803477518198927, -5.6458620984678465, 5.4651741805430785},
    {3.1292292098614194, -5.000905241278814, 4.75663584139884, 5.776990273229277, -4.631780928773937, 5.482158870058664, -5.509820450445371, 4.2246366271255855, -5.225511935039595, 4.361350369644135, -5.775201754212101, -5.087641409280558, 1.3295683705315458, 1.3134271865316816, -5.851228508034041, 5.505108817569875},
    {2.424087097075736, -5.097516380828957, 4.482253016122271, 5.40704059657759, -5.1440495574918055, 5.59878970857052, -5.841289411573123, 3.8255649783380066, -5.710271819888314, 4.452886849994804, -5.953101396410921, -5.759170536221911, 0.6033819415823463, 0.2482721609911022, -6.009488535155785, 5.1925054392298975},
    {2.1941827369198403, -4.877081402074515, 4.73950601817441, 5.431597533537549, -4.8025940562860026, 5.456842719961018, -5.791981422544341, 4.290890607864496, -5.397554318687076, 4.1456370754996295, -5.909866144223624, -5.567429885953143, 1.0885928539953433, 0.8883171583312536, -6.148020969244881, 5.516908772355566},
    {2.8473787174528713, -5.186431835964418, 4.728557123782094, 4.986452948563618, -5.197397180007064, 5.759781358305392, -5.759143463932004, 4.044883897329473, -5.5722479921969, 4.062872766070132, -5.842351214921548, -5.365677532696905, 1.4733770505961874, 0.22970783121231925, -5.9907212511240315, 5.470638411482512},
    {3.144653488294496, -5.095954567847872, 4.079098916434976, 5.266200073538615, -5.455121925487415, 5.193103934154764, -5.894011883790788, 3.74584728804525, -5.505751045719706, 3.651823775250334, -6.04606542282037, -5.569496514081105, 1.3970686016117972, -0.1518014309422188, -6.139437245712117, 5.284520433563838},
    {3.2819853197278017, -4.443588208801138, 4.399514031365273, 5.497149116083053, -4.730619793610253, 5.523187824634582, -5.57057860948174, 3.976600917832642, -5.313557001719561, 4.078944755387247, -5.662392313276896, -5.27239762356257, 1.7068705172239051, 1.1236660092955977, -5.904591328277908, 5.446043421458882},
    {-0.21776629747090487, 0.7563206236470257, 0.31409989862711346, -0.0436899485452387, 0.6185404653493324, 0.7599958714667933, 0.5018479510286159, 1.193533443320287, 1.5459127705520075, 0.8346979776028371, 1.035747183665252, -0.040434123697291144, 3.2597118783695755, 0.6780775977243692, 1.848646065673529, 1.2357510219394496},
    {2.5950005358693886, -1.7577940740001123, -1.623254090185435, -1.4258248519035936, -2.0995629145561354, -1.6649854729629143, -3.000733298606211, -1.2235913580433144, -2.772266457465219, -2.1380278187191766, -2.053065219589713, -1.4651125728003915, -2.3032494681451934, -4.613513594559884, -2.332230651377439, -2.5495173040397012},
    {1.6524330498453568, -0.3228625719940385, -0.7096919698684052, -2.35624621790863, -1.5310855468711224, -1.0482450335481708, -0.04826525797356512, -1.1302933730664204, -0.8023224223753892, -1.6804307883659444, -0.21892823496179004, -1.1735706805844062, -1.0813796086564575, -1.3083606267378545, -0.32867063672376134, -1.5017434508865073},
    {3.523152456596358, -1.291464140492377, 0.46064517952712, -0.5397037471060679, -1.6103384386544777, 0.08877273303943818, -0.8961555071299137, 0.8444446286626076, -1.7490542574077188, 0.20372363942702326, -1.4413277870839223, -1.9073790744293546, -0.49251884820580194, -0.6215636991012433, -1.1828771999753371, -0.08517719818916221},
    {4.208629526023967, -2.3919912855896004, -2.710056735495888, -2.5165995714510774, -3.763133805169971, -1.4314199901326867, -3.480975833558231, -3.040804030616745, -3.146704420728396, -3.0223339532135847, -2.7773535275771764, -3.3736699875179497, -2.923694510459461, -4.178363181565924, -3.4428701710361396, -1.868953077520868},
    {3.6136589681619453, -2.1468971568892483, -1.4884149881912123, -1.6522817879795992, -2.0075881048709863, -0.4712735505923758, -2.4675068094136825, -1.3314326354257682, -2.0567617038306425, -1.3475904448732698, -2.3466092431336905, -2.66005125558905, -2.1255239781166892, -2.8032932090265557, -2.3996990422143947, -1.4276600690716064},
    {3.661018569193449, -1.9412124537444662, -1.50819355601632, -1.7389927570089156, -1.9049780034181685, -0.9779351322190191, -2.5128925504916597, -1.5585496724885064, -1.7212859821502917, -1.519426002341715, -2.6026192769618026, -2.4186553282762557, -1.2930528428358843, -2.0833568482865368, -2.5551739320376736, -1.181663569074632},
    {2.7897543128347304, -1.9068392799455296, -1.3668781734860103, -1.1849832724638434, -2.002300549948291, -1.0512077540304379, -2.240234592908482, -1.3012149633692114, -1.9176802483187734, -1.789665431281001, -1.473346766351439, -1.869172880870725, -1.2048780644676644, -1.7710206900460064, -1.9919754509920773, -1.2131821798029347},
    {3.1800831749094582, -2.413777490547827, -2.377671852791485, -2.3156519011831582, -3.40136977703147, -2.0067615958780434, -2.7170953867097807, -3.001937961414558, -2.835779344461707, -2.83915990196726, -2.2567971988562383, -2.6619220330939637, -3.1221046243612913, -3.324961739714282, -2.1780522054094833, -2.548288881488651},
    {2.9332074046884995, -1.9265809464133206, -3.340561220632761, -2.943274082556625, -3.335581061975596, -2.8665589964811593, -2.9121175006534354, -3.8448287387428053, -1.796547678336259, -3.8230812625358483, -2.3972543107617392, -2.7331554344903024, -3.428571491826966, -3.6651433077979383, -1.7534198142511965, -3.217305281651011},
    {2.2370276317139024, -2.573476914966831, -1.4828154339745572, -2.7094681546586425, -3.28933108726471, -1.5099162515844409, -3.070582030334403, -1.6199929585355581, -2.240230749223287, -1.5008991230053876, -2.629181944539133, -2.382581350687781, -1.540807613827863, -2.7428032389075545, -2.7027682011028302, -1.608280252672599},
    {2.88980915802709, -2.3198658431645205, -1.4642540689509633, -2.882180750141431, -3.0939551866043877, -1.4827987612053113, -3.0345953593556145, -1.7965588350298953, -2.52568429147994, -2.0524850961251793, -2.6209343163910104, -3.179172455357953, -2.0736017978230077, -2.9540185766797102, -2.1659831319066036, -1.988260945212612},
    {2.270818032327601, -2.08663422815909, -2.254649137132626, -2.9773693840569853, -2.07790204686957, -1.9231132256964978, -2.3371372607896492, -2.9356519238606715, -1.663257146387451, -2.839450007721039, -1.8420668042901351, -2.1128883276936636, -2.4256442283033737, -3.1213478994355963, -1.4960234861591446, -2.259361436953518},
    {2.2440862483553086, -0.9946685577720895, -1.8064868183753355, -3.067850453923342, -1.7625588283044784, -1.5982758773326347, -1.3563691180309776, -1.993363844430508, -0.5220154771857268, -2.1711538272269055, -0.9817599847458814, -1.7261405875499958, -1.7505090433965862, -3.00524690602233, -0.6645590620714382, -2.1616180290972107},
    {2.038958520770158, -1.2613138169121545, -3.18004273620269, -3.7301053802453445, -2.638916977618876, -2.513801986610525, -2.260194941514147, -3.7030692472458537, -1.7412898774831669, -3.9818925626963475, -2.080075857187608, -2.5647142738034767, -2.3612448299378985, -4.5209358971514195, -1.1877775046035817, -2.903240368892889},
    {2.272663523702036, -2.010114903789185, -1.1901920669504276, -2.9173183499458966, -2.7747394699690107, -1.0551278118937908, -3.040807449693693, -1.8418081177001226, -2.3077267190625816, -2.2972347174820937, -2.232707632599081, -3.367942995670599, -1.4391663354329511, -3.418107877282855, -2.041637810442258, -1.5240986619634582},
    {2.2973824308293405, -0.28457848027177, -0.5893975879055346, -3.0589804364120963, -0.8322333772568645, -0.238837255096701, -1.6252812937048096, -0.862522867710589, -0.4118282688805782, -1.3410107171613665, -0.750591999185869, -2.196201105209856, -0.17108013860823315, -2.486699051603073, -0.8858767988063937, -0.6688471497557127},
    {2.7298626626391473, -1.0644229916062047, -2.395989809672268, -4.147724808683831, -2.461036766171861, -1.9598596664765535, -2.6115875649646174, -2.578428383957653, -1.692629670470243, -3.7371240526661347, -1.2726213598041571, -2.9720157325109184, -1.4474604414093197, -4.656183311123423, -1.8579732714747053, -2.8787473014189104},
    {2.099953296018422, -1.455413103730134, -1.6197347730860137, -3.215757274453732, -2.8954981486684983, -0.9129447919574941, -3.5434632633865966, -1.615887365313851, -2.059793166786229, -2.385508131085745, -2.4180356902855222, -3.68862627071845, -0.9284976814630379, -4.070476367261556, -2.628558625519072, -1.8802497532096938},
    {2.369942494592688, -1.8328233145652781, -1.174397878632434, -3.7109611781009226, -3.1937610570990715, -1.180201986472888, -3.4184354027593993, -1.6157444847511335, -2.029698495025808, -1.4670103771361174, -2.832877675582829, -3.68463877545497, -0.382996261400625, -3.3879697505270983, -2.373558769736113, -1.5758847934458295},
    {3.179313133758293, -1.1999574080056037, -0.6584916757517079, -3.455570421610411, -3.020200829092193, -0.08438815017233674, -3.71044366325912, -1.3336278187103945, -1.3056284936104752, -1.9451661341528204, -2.4329189033734333, -4.159645991880483, 0.6113617026657414, -4.764513630385772, -2.0412748785327794, -0.9846164500010255},
    {3.634430412888089, 1.0092822294989625, -0.14122650913794324, -4.5055795195194275, -1.6350802850020716, 0.14465128782350303, -2.5266893950456626, -1.0555642404312469, -0.08961162407331486, -2.43771080436944, -0.9439586615508119, -3.4617642547825063, 1.5735178731613277, -4.755836540887163, -0.7029636643184743, -0.44349553187703644},
    {3.1547516494457937, 3.0793440457499903, 1.3211625123717092, -3.7279121496395016, 0.11683001701761303, 1.014463874135295, -0.6597491329897531, 0.9816252011650073, 1.8145779278795726, -0.4062666422158148, 0.9331475933573281, -1.660743655606344, 3.407000264717973, -3.497702715008701, 1.2523193316373955, 0.9897050297815727},
    {2.416884728760469, 0.9820020312082887, -0.7135416688969167, -4.38983755478803, -1.3602242332727346, -0.39240068801093014, -2.133958997033048, -0.8706296182126074, 0.0122630293901463, -2.109299234520378, -0.6509514122448588, -2.783544990238383, 2.1958788867419674, -4.689469729740771, -0.6279804971155547, -1.0104186275320823},
    {2.2507101798550884, -1.7769535028606347, -3.1804446465797236, -4.8696776171403755, -3.7766501361207565, -2.3341099723553405, -4.104350794406513, -3.0644182376776423, -2.5584224116043033, -3.5713831274445793, -2.9303427396130415, -4.405167783423493, -1.315563915747023, -5.8092171290231835, -3.1218486129185155, -3.6413862766840497},
    {2.5063966046644444, 1.4501299207663971, -0.41207225155721183, -3.8353956459040894, -1.3494593889155615, -0.7208011915272883, -1.596400182070611, -0.20856380410380543, -0.16050782318648496, -1.39851815038458, -0.6146488875060002, -2.1751622244269715, 2.350478704908898, -3.9817928301973344, -0.33843097620504714, -0.7015707210295922},
    {1.6821655318723423, 0.6938670140112043, -1.4009359567701787, -4.281704428889158, -2.127783361115404, -1.2041095657380188, -2.427539091449532, -1.7919567427294707, -0.2219910821456026, -2.777730529878994, -1.2286589982624265, -2.6822147363521434, 2.119511542600116, -5.16602156865287, -0.5279705576351129, -1.7050049662489792},
    {2.0970360025330974, -0.19069535038419685, -1.5672334026866686, -5.230070829964806, -3.094909897907528, -1.328618815552154, -2.9728546593891454, -1.8562832665955413, -1.0207635085840767, -2.9500705739154394, -2.0667464354683687, -3.708579222672875, 1.1555138965872038, -5.6685975002579125, -1.5800572060440645, -2.063845496555426},
    {1.8000941516263018, 0.3047628393876117, -0.9067977643432739, -4.618846070531315, -2.3617769224251846, -1.138928386752427, -3.5142021276868376, -1.2561500881610475, -0.6471636206679343, -2.7487369487607416, -1.968084773190695, -3.8436003960500176, 2.003630109902483, -5.416533020816685, -1.5683269241427473, -1.4989288121190454},
    {2.12023899671636, 2.366576373903941, 1.7184484917688767, -3.4496166569870566, -0.0609759383027082, 1.4578904790931184, -1.1101363878013784, 0.9283967301033573, 1.8413457050040414, -0.22248760624066727, 0.4392359157469397, -2.6383055949345615, 3.9857701736634925, -3.1953436832532414, 0.9195429488018663, 1.0301937714887486}
};

static const float b1[16] = {9.338666475300482, 7.936893572678238, 7.90365271954686, 8.398248101095668, 7.874714433462221, 8.034166528978973, 8.002560519726686, 7.926871431580722, 7.93193624785044, 7.82752390757211, 7.84381916335741, 8.059970200032197, 7.940226176046878, 8.227507203367573, 8.002461800022834, 7.99917834927619};

static const float w2[16][12] = {
    {-6.408652852003955, -6.371925562377219, -6.410509892580705, -6.426387103054046, -6.410004898550832, -6.39063543508865, -6.3910135288871315, -6.396095235548996, -6.387790234269653, -6.407131716942726, -6.406848086513639, -6.379932837935338},
    {-4.43558115280698, -3.6429832805143563, -4.260275856433578, -4.409874679492438, -4.37203544051996, -4.463065517539689, -4.172048338357802, -4.313764743981506, -3.7008677972902375, -4.034018269110707, -4.769281357337244, -4.305477082859824},
    {-4.094940772698544, -3.5440743511453636, -4.145450542343751, -3.6794978838830676, -4.658599983440669, -3.4969492552682766, -3.8267564955132567, -4.258255461148931, -3.7452724181657793, -3.950052413490989, -3.9340653294778978, -3.4904946606793823},
    {-4.134267126733364, -4.077800001478989, -4.0632763977994175, -4.028764997826334, -4.330268100762491, -4.1636401618919034, -4.092125506232417, -3.9434154492988562, -4.170774615766402, -4.2054823787707765, -4.057976122207473, -4.05009456675404},
    {-4.1162879283966145, -4.121298146519106, -3.6044474597259937, -3.8877570133471786, -4.174311857288543, -3.5673066941492166, -4.491717129126144, -3.6899402582369714, -4.163441991734999, -4.140830135844836, -4.158451670827093, -4.094663530916653},
    {-4.250655044009705, -4.301859848936898, -3.602144329726688, -3.785812929115148, -3.6754051381580366, -3.882338682058641, -3.7512458576390992, -3.813805309452569, -4.145880709082365, -3.7011501744745425, -4.068514282286536, -4.685649850335125},
    {-4.162398243449, -4.2750243136000785, -4.715714206250792, -4.379042642803899, -4.124414316977251, -4.3636040048234905, -3.8459468298608495, -3.4266493100522832, -3.757557067770657, -4.091248918165877, -4.148320853726515, -4.826736099049878},
    {-3.243858553589732, -3.520470876966797, -3.4401459754685755, -3.8939044614886953, -3.9987615703104282, -4.178809918121333, -4.080026202843215, -3.5041757561974554, -4.019284981960819, -3.869791662454844, -3.905926427673717, -4.11948928672341},
    {-3.839091883535277, -4.500485019994511, -4.496991426830556, -3.7932441268810484, -3.939486494573191, -4.114220321683878, -4.088741177221254, -4.407163284043194, -4.631678158057588, -4.3398031281974285, -3.6115488686931068, -4.0508032986826485},
    {-3.744669930317451, -3.780300604969719, -3.8353417174574758, -3.654874182641179, -3.4584348816315, -3.9768291335837183, -3.970191674668631, -3.3888035792389712, -4.326946084512165, -4.074625624868571, -4.004983672703842, -3.8573172954727193},
    {-4.382872841251078, -3.91043981250255, -3.93218959339677, -4.007374341922857, -3.7804884111035877, -3.6587485877074992, -4.034388623899627, -4.359899846120684, -4.133282479894373, -4.423812803742658, -4.33772891166423, -4.402386707429894},
    {-4.16478855716506, -3.9836500032323343, -3.9222918313007433, -3.8406070788164586, -4.215523008680501, -4.712320378487896, -4.212962413500676, -4.550683045712348, -4.717592334791688, -4.026038263444303, -4.330975008227349, -3.3675694087463635},
    {-4.08663251203287, -4.080703539117675, -4.273708761274109, -3.9740218125866784, -3.9790733064402883, -4.0076972656795204, -4.447700224231361, -3.9118517669350457, -3.9942578241510773, -4.249289287675061, -3.6266906128500396, -4.150258744345513},
    {-4.036305724221461, -4.253690690643837, -3.926026733350605, -4.133555843467325, -3.765295499866165, -3.9161259322481676, -3.6841791946517612, -4.198455425476829, -4.105470082682921, -3.6245909772661182, -4.015256261717336, -4.036901395852623},
    {-3.976895794363388, -4.517646953196993, -4.046889719084563, -4.6568008091258175, -4.531167885052121, -4.157780782484763, -4.3008276889087025, -4.398692092652588, -4.037200441012963, -4.033365184306355, -3.8243637156654873, -3.984783029942855},
    {-3.924598061492657, -4.088694808312987, -4.28795565021244, -4.385647712922848, -3.589496183990536, -3.8853628139283582, -3.8783939320397494, -4.588728203121807, -3.270037222032204, -3.7867877329285777, -3.790571915345877, -3.227683616195869}
};

static const float b2[12] = {-4.970929310927355, -6.247361128642419, -4.320941248061592, -4.096237009105777, -4.792347842406607, -5.265924502193682, -4.572518879339075, -4.7306414493631035, -4.517735794166266, -4.5480820476323265, -4.5455515144734475, -4.620429898573826};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
