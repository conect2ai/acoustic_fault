#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-4.470811824106558, -3.9863732140248693, -0.42748606262429456, -0.2644868303214276, -3.3354583913239066, -2.7046024959042345, -2.062914572010115, -3.3532017107203353, -1.708930264466634, -2.4326868997970723, -1.737297159690871, 0.7807085049169982, -1.7213610549180038, -1.4694114165699728, -2.454565470575206, 0.9782526605026496},
    {3.1353830583134212, 2.2154461076888263, -0.793899116775809, -1.840716512930287, 0.7478750442947978, -1.346788316194017, 0.2717122899291317, -2.3480272868568908, -1.3134584130242726, -1.6613222551770817, -0.6148735113829782, 2.911637442865015, 3.374170760484901, -2.924623533032071, 3.4485087808374844, 0.5283839766452567},
    {0.5988480616963769, 1.9990416696705744, 1.9132628408189951, -2.572686649040281, 0.7705494119660542, 1.7977348432018672, 1.2175696831453446, 3.9284594495639, 1.6339534945977976, 2.54800921681998, -0.3598668266706901, 0.5033071277489825, -0.9220338098595715, 1.5815839071108597, -1.0292128903464146, -0.528934445901728},
    {0.031628391705953704, -1.4573759295238702, 3.7015500365724385, -0.20527964925690878, -1.2334634075681639, 1.8841147310524882, 0.5539461170221394, 2.789013127519469, 2.307980238422671, 2.3011941880194815, -1.9799036099779037, 0.039082359487749525, 0.34067027171341063, 2.8082315904609763, -1.3222529203059883, 0.7404103701567492},
    {4.544983194574, 3.925936703299913, -0.11736640647547582, -2.6626600018851936, 3.850048989473222, 3.299949052759105, 0.15417044490875573, 1.470046055474077, 4.658602182642963, -1.8817552868405096, 0.2768428228463591, 1.331603011788597, -2.2513896837273255, 2.06191061465144, 1.7398928926419472, 0.8530447453938386},
    {3.4252520134550233, 4.726521215265084, 0.7091925529856885, 0.44992745683687374, 4.043685329677321, 4.248953360749254, 2.590733444592619, 4.300743012335404, 2.47957809015256, 1.4229391057885872, -0.19915184589668666, 0.4050801061045622, 3.4748954216130663, 1.75463138111114, -0.17274111994808194, 1.0925290563689858},
    {2.046573017840663, 3.773218425670917, 0.6438799317384464, -0.3242334773821838, 4.162946676688527, 3.008994888297291, 3.092612529710187, 1.5104396326781078, 2.151861146868016, 1.2861339948818327, 0.4311185185502731, -1.639892521993279, 3.465836354711184, 0.033665637527918575, -1.805061406629016, -1.5265620387407237},
    {1.9221514142422456, 1.0620882023706466, -0.722440487851264, -0.8027375738046256, 1.9675732962499966, -0.7161121452499881, 1.0556214950945488, 1.2331926149416752, 1.2779226343209211, -2.1139418328239703, -1.597344930109758, -2.5173386226581123, 1.8102513786226573, 0.8027386902641727, 1.5970349356570246, 0.017065325533585186},
    {-0.48539018467785994, 2.7992730318758734, 0.4154606088199819, -0.7306717984753928, -1.3547148545263321, -0.7223929984988243, 0.20644431444252842, -3.660934132685378, -0.06046032486877072, -1.9831658390853268, 2.2799054507354275, -1.7712955451768764, -0.9418636974746751, -0.13822573018372686, -1.1417786031096395, -2.2846118090666416},
    {2.6090442630733066, 0.8679656657517366, -0.6150079576143725, -2.5927635446693755, 2.3639769188504838, 0.17914327950086734, 2.0973267287272637, -0.6103943939521297, -0.6577152789501676, -1.118588035442514, 1.9110268701288977, 0.5175608921627222, 4.43671612807803, -2.3326046310974724, 1.3264194498692155, 1.6055957183573324},
    {1.6471617680730013, -0.4750821443494859, -0.40171719319110627, 1.0381088728477397, -1.343831359197186, 1.14676927497986, -0.6424584464108832, 0.0637928456627158, 0.20399929791818153, -1.769768347033915, 1.9208282414369415, -0.13130463800916886, 1.516211214385829, -1.7368949301654588, -2.072653361615547, -0.038953666648485895},
    {-0.9659096279311556, 0.3553490870568458, 1.5695105362011426, -0.7656815367895471, 1.6598166128889194, 2.142421585051968, 2.1499792480837434, 0.23248171812785798, 0.45992027287675324, 1.847626386407632, 0.17960775976110555, -1.8455599732119243, 0.7296768560732801, -0.47842872314195123, 2.58330373374074, -2.8122520281305494},
    {1.9070054788891622, 1.112365230769296, -2.564591986173902, -2.5167834885735467, 1.48681225157691, 0.5237095081087508, 1.1093046768759756, -1.696095172068221, -4.023441361539898, -1.5533404894947196, 4.2192991411642184, -1.998261496657462, 1.4604029095994748, -2.335548270241072, 0.791350742403695, -0.06741195870406269},
    {-1.5227807171098442, 0.9261591405034695, 0.36951337223026615, 0.6276817381058808, -0.33676445627629453, 3.201847772965626, 0.48250867545383863, 3.8185200916540984, -1.359952499050026, 3.9406445013005635, -0.24513971181173036, -2.514271415273097, 2.6173016269518348, 1.9933057985737497, -4.068065621514162, -4.746617441127659},
    {-4.757532944552325, 1.6592289102519262, 0.41127127835819977, 4.617387016687022, -0.5801772922721136, 2.630440364861749, 1.4373806167855654, 3.1137931745236145, -1.5709166941701547, 5.3524099090060435, -0.38175695048216945, -1.8228000746903175, 0.46801363033012994, 1.4016198355597655, -5.404434857093889, -4.471925184249608},
    {-2.8297658920962365, -0.6489880371515777, 0.8140561121978117, 2.403484647364397, -1.8390829439891854, 2.268095419290108, -0.9727980668765848, 2.1054651017603243, -2.181071799317015, -2.941596491384637, -0.9739792294339437, -4.371511535719822, 1.4214009290050658, -0.48748450014608985, -3.135899634716316, -1.7721776805961282},
    {0.82307746077537, -0.2781793021708732, 2.1166730960857993, 1.7763756467810912, 1.1198730376223776, 2.9599709828929486, 1.7913979926627899, 3.385979850575656, -1.3533739855450795, 2.3227953835204485, 1.1726302964671507, -2.652884034497178, 3.6889018187340525, 2.691602114968359, -3.6105466301111755, -4.156102446134541},
    {0.017343719634618417, -2.8036292069152435, 3.2156605730830554, 1.2772107677624862, 1.8090389048688675, 1.364090501427303, 1.373623874133075, 1.834816826528169, -1.706950332925349, 4.47939860456748, 1.4356076964330413, -4.76616595591319, 1.7420422849070922, 0.16279913196447007, -5.089325371968575, -1.7536325518374276},
    {-1.2783127659534426, -2.8456905595009254, 0.27852278741893494, -0.09359155492265697, -2.271844023307362, 1.207578170862892, 1.4451973774915763, -0.7164111434323328, -1.4130655707560604, 0.5291463621328384, -2.2797592300611886, -2.0107034598000486, -0.5667317722834166, 0.2833535904189572, -1.426480811431468, -4.087478401940001},
    {-1.3907666326880257, -0.20950173958926618, 0.7273119082458948, 0.18500834210785136, 0.3720577166026167, -1.032009560409928, 1.7358521622339163, 2.032240468749969, 1.0802548391788893, 2.854666960737019, -2.0184525915083706, -0.47662203818015764, 3.0398281151172903, -1.5237539594787437, -1.4113683320104324, -2.410975988907219},
    {-2.184311913520794, 1.2839592812980485, 2.6761695299392487, -1.889897029665163, -0.14542050019764388, 0.3751845435790496, -1.3103784821555462, 1.3470624609097595, -0.8682185914109372, 3.3968928927671147, -3.58464172397514, -1.4262200892753427, 0.45745663107441087, 2.054059147070177, -0.05680789773458125, -2.5803549694734227},
    {-2.992637748089652, -0.6549951126186789, 0.813702332881152, -2.0993961924846065, -2.2439805589970976, 1.3731918658086522, -2.450184327381662, 1.052961279973701, -0.48264751559655167, 3.6855456373846085, -2.0351467782974098, -3.063562417716386, -1.846910443135411, -0.04227575606532161, -0.6523486074585386, -3.928449912064401},
    {-2.8659399762390425, -0.5813555612648281, -0.3757051827825151, 2.8538323882624277, -2.6949160274844064, -2.723021999469652, 1.0778432363596866, 3.944566445818964, 0.11029933188356449, 2.9025113758312004, -1.0003251373270607, 0.6812798369428383, -2.74377129234715, -0.33064022476183, 0.6493595981391689, -0.8264157601669818},
    {-0.6622733025442957, -1.2265461457447218, -1.217616020336623, -2.6876869145312967, -2.3197361362332805, -3.2624434021910385, -0.5208590977410282, 1.975996427217913, 0.9135493903282245, 1.0035943013822453, -2.649324870251629, 1.4313579349332082, -2.3142326775167246, 2.1840179142579363, 4.669423991777141, 0.17792156463367784},
    {-3.696452783996681, -1.6520964240234584, 2.8358180953153114, -1.9856222258623515, -0.16927377091424056, -2.458876246285266, -0.33483873466921166, 1.874532161693855, 2.733058648736312, 3.187723712757526, -3.857775686353803, 1.46373300674176, -0.4156580597221147, 3.1484221416661864, -1.6584977739041311, -0.8005176862976039},
    {-0.5485673293197889, -5.160922137762585, 0.8601174540779886, -1.3213417912549275, -2.6851860670590963, -2.7014703239582545, 1.8184253807457404, 1.1197329613021056, 2.2062755298001124, 2.0098835408046347, -1.395321585299234, 3.7880106342251585, -3.3962623308998214, 1.8049345852068608, 0.6473481300577789, 1.6306025833045394},
    {1.661519691355247, -4.484112795848981, 0.9390621736711467, 2.924155116584537, -3.0400230417298695, -3.2804433827025994, -0.9007176161973233, 0.48569996254329123, -0.21269926566224825, 2.419981768350894, -1.3111179877813373, -0.7244375310708714, -2.3525917451688216, 3.0800235204970074, 0.3289034522462692, 1.5450970667779544},
    {0.6656554300091646, -2.013145168018339, -1.4672290842459408, -1.1892016321133223, -0.7074426588725566, 0.4237977985866416, 0.006228242724629416, -1.320387736169605, 0.18710611093259327, 1.0327985991565896, 0.4185225386547707, 1.956258594897112, -1.7182440511677324, 2.7743992347579756, 4.467828629146626, 1.7290458265152155},
    {-0.890644830516537, -2.9154979338029463, 0.5020545084835767, 0.3218515554072849, -1.9065923414588928, -1.7264205427032457, 0.8528304205667153, 2.5965723972758434, 2.2766346051577027, 4.429987544825757, -2.6560750521890855, 1.9688280314653983, -2.6242891758925047, 0.3758422434875661, -3.7754675553703643, 1.306116540372826},
    {-0.46215539454546056, -2.2338088578011703, 2.3564840712975483, 0.07538032344935722, 0.8645492762158923, -1.069737030844635, -0.2711615305229693, 0.04592323998488705, 2.8543832193031666, 2.90551767818654, -1.5475250568384789, 2.581252651767749, -1.6967696300902566, 3.2617574031727794, -1.453506710761517, -2.0471674038672623},
    {-1.0328876982762754, -3.8182967351766184, 1.1368978923379423, 0.6545469291986521, -3.3750597122991053, -1.3888001613684502, -2.942288986360812, 0.7471802224226215, 0.30624907291175835, -4.6219029860147325, -3.4966081077015447, -0.13659784612310139, 0.7273655507783944, -1.1961385985738267, 0.6027181474857574, 1.41843229090067},
    {-1.3839078503635527, -5.78368481571438, 2.329980834220417, 3.9886266075088583, -2.3107255041941914, -1.736638749625897, 1.131975653507481, 1.933700011680364, 2.027360288670481, 1.9531522514786706, -1.414148364174112, 2.251170086628879, -0.40655378062326186, 2.4711938444107338, 0.4406252438760531, 0.7856872726373861},
    {-3.788830656978357, -3.589081172566199, 0.2541424267168596, 2.4867593726011115, -1.008116802120877, -2.097898311080546, -1.5193066708270018, 1.2026673675513764, 1.59488447472482, -0.46887377031538063, 0.1742167528909204, 2.2935248569216586, -1.5210679069427369, -0.390202646406157, -3.0221043731397073, 0.03934181755044945},
    {-0.3830431292653323, -2.827152586405025, -1.991555494267484, 2.060099131415724, -0.6890092408132654, 1.0864016325391646, 0.06333010016273961, 0.9866235848235074, -0.4781915346911379, 0.5888070041439037, 1.3118949053328366, 0.052457729592274904, -3.3637047383658643, 0.787268992938707, -1.009056409018256, 1.7135151547988425},
    {-0.3834118502729971, -1.2439321137679749, 1.5308824481911383, 2.0866169946186495, 1.1016506939070196, -2.3124967079463867, 0.4699999585495176, 2.5871820401216468, 0.3273092046705724, -1.3869304235012414, 1.4814777328385789, -0.05439068210683626, -1.1765594872247418, 0.08974427591035743, 0.6423766093689064, 3.098158465754271},
    {-3.0374381678906706, -0.688455673469388, -0.7388573374217835, 0.9842078460276455, -0.9736192517971434, -0.7498149977234823, 0.132848705608059, 0.001234152204723785, 0.4450594872791054, 3.240879206353897, -2.0034748457756733, 2.423532535665656, 1.3336864653450504, -0.43457186669894987, 0.1676636703281539, -0.7540526232329684},
    {1.2158577416442389, -1.7596030958421425, -3.224231300616394, 2.2001143100252607, -0.30166396709901816, -0.7274115552861796, 2.2267266993914627, 4.424104133193679, 1.3320158084351872, -0.10186562554631243, -1.31206311226688, 3.9558941667234095, 0.5162005819435189, -1.3669977261085893, -0.9189377493491047, 0.48273590071910294},
    {-0.997136259337216, -2.8095609632586727, 1.5321566124232515, 0.6697327103490481, -0.3018262300873228, -1.081096393140097, 1.3451429158019437, 1.9707276390433528, 3.497663208115204, 1.5533869222103602, -2.4187334685557897, 2.7503570465057434, -0.6154511265716881, 0.3792611400823487, 0.037269855561516324, 1.789067332762718},
    {-1.0482994042590945, -3.011338047892583, 0.7970433813271052, 1.519973123709013, -3.212513271382587, 0.8716828609741181, 2.1004546115493192, 1.4794291250952183, -0.35311539040052353, -1.236318083427409, -2.104717701278145, 0.5361342720646053, -0.5150142487917153, -0.39824904872319467, 2.0540995676033673, -0.01650233945024019},
    {0.5435901475294144, -0.6008535931130511, -0.2926204937081413, -0.7605568110701222, 0.1673004875661132, 0.2166987413811773, -1.2970595240989313, -0.17228352426481083, 1.8350424576258968, -0.5006290882078623, -0.7244248950592647, 1.070137360062291, 0.23308663055129053, -2.3169631901615397, -0.16940808576456515, 0.37306619532698615},
    {-1.5034647131221772, -1.5773301875003563, 2.455407466886696, -1.742414814088138, -1.8788344625028186, -0.30644858168541195, -2.416532354632209, -1.575052045971107, 3.8787280852433077, -0.3604069979224312, -1.4561910825055902, 0.3062764336972222, -1.879185516015616, -2.380704508059156, 1.3030827500110285, 1.5694664937328093},
    {-0.6723422086084537, -0.6052730116404144, 1.0111253611121196, -1.1549249943151134, -0.4883308551185612, -0.0849604874431253, 1.792765055840969, 0.6314339273637259, 1.0506322462144901, 2.2465221262831485, -1.3229958110491762, 0.6766513257997206, 0.16151626711863734, 0.27526061314935624, 2.3603394492163323, -2.6065672398785398},
    {-0.866512569285448, -0.09571669354834834, -0.5268564686632026, -0.31097810252510755, 0.09804950353610378, -0.9312854354594216, -2.844771902450433, -0.8112918236698222, -1.567851512442138, 1.3260933781649653, -0.30876335192878057, -0.0903422048438968, 0.24515110483525157, -1.2607924174172478, -1.6312605927336092, 0.7653030692661231},
    {-1.7630974426472417, -2.843962796157915, 0.6872560882685455, -0.30527918589226444, -3.191100978475769, 0.4193432455398151, 1.496968719392605, -1.1432317053010776, -2.3736467051838406, -2.291458949254997, -3.1784824572413237, 0.5869767846782366, 0.7929043747532591, 2.7414159476870585, -0.2277333642369461, 0.4518173429785275},
    {1.9011255586255955, -0.514409941234993, -0.6601436861227146, -0.46651160298708716, 1.4835750432171932, -0.7034174396374273, -1.1210256002731263, 0.48162141356555555, 1.8629992205595687, 0.7823017738514662, 1.2349000103351813, 1.0734723488541786, 1.1754564520274013, -3.8726523252285796, 2.1757615317513284, 1.7569672593007586},
    {-0.8809989920188082, 0.6758617620396238, 1.8146229826299878, -0.4443930403117399, 2.259949089390428, -2.004325350334127, 1.737902952079735, 1.9967117312613574, 1.7587943930324546, 2.882583924986191, 0.07446934663661202, -1.257807481061655, 0.02840829173125961, 0.35559416010176226, 0.5208997030503331, 2.6643990429286326},
    {2.2268331126280274, -2.524688110441534, 3.2948059049390315, 2.2854875317846868, 1.720772770728008, 1.2849803524673313, 0.8091144862963514, -0.37969220491523814, 3.232874652678381, 2.0602522716871654, -0.09458422526513655, 2.590823297056085, -0.8695726068186878, 3.6653782512700177, 1.229170869419055, 1.889173469654183},
    {-0.038112576152765004, -2.508678544692183, 2.524801444917983, 0.07004312048272303, -1.631774621485578, 0.07000420371763232, -1.1821829184550308, -2.9969008788186264, -1.969408715497516, -2.162368951997558, 1.7226806722592805, 0.22236655865314742, 0.08849928041716414, -1.2494250539611775, -0.265106829128103, -1.4667060358628168},
    {1.4921858651034037, -0.15099609658503885, -0.8135200290430237, 1.8306577736503524, 0.3035589011186837, 1.6603530187536846, 1.5260766072362026, -0.4619612220499205, 0.9131778839918551, 0.906035902057987, 1.0515697570009654, 2.189722608142897, -1.4242600864038053, 1.2748657595592214, 0.14158459019709366, 0.2728203129737615},
    {3.5468731035633163, 2.1413594167454226, 2.6901111873600447, -2.247574397915458, -0.4836936447047507, -0.5885511067024999, 0.37500385160974276, -1.1890619696236886, 0.6737378049960416, 0.4207740416801174, -1.3562967522907547, -1.1591646859848481, -1.6803653265778584, -2.2288188135865337, 2.3141407582235973, -2.2355454978209774},
    {-2.9723055211886615, 0.43674646109393755, 1.2226033645476737, -1.038721205489951, 1.00542952122306, 1.0645098330573468, -3.539555770771443, -0.7792762559286929, 2.2745217223007463, 1.3436443671754172, 2.4837977489652006, -0.3689697694189624, -0.14690876148898918, 0.8711984444609917, -1.1412811593723897, -2.24625343710799},
    {1.9071382006389597, -0.7640395503843599, -0.7073835271794032, 2.563105978377112, -0.7751929678947961, -0.7615630203460834, 4.883047496222695, 1.97790157289755, -0.3168847185250751, 1.4670977966682828, 1.0878067809615084, 0.15547266802081303, 2.239420786895062, 0.8644303180455102, -0.7099969945786212, -3.0993301323812474},
    {-0.4189063046045101, 2.0411310859691145, 0.02691100596866921, 3.156216704965044, 2.981554763349744, 0.7720665187783716, -0.19703138806556356, 1.2038569048445, 1.3782323916128592, 0.7766257876180174, 0.866914513214892, 0.9526507513204372, 1.5290923085864585, -0.8283713056362569, -1.6675640413085702, -0.6019505884161367},
    {0.511423338680804, 0.049285956454445744, 3.216224899808625, -0.04958443750018251, 0.009637302214624312, 0.9764612641692313, 1.4805129721335752, 0.5546328711607641, -1.2504664319560532, 0.7907555411346747, -0.10360965994237213, 1.7006590462921118, 0.9088595644402344, 1.628606856383533, -0.7855441693713815, -1.3519731705174678},
    {-0.6837368335209159, -3.0345946171225946, 0.42880192993904853, 1.8914951884196038, 0.18456519083774445, 0.5740706959006086, 1.7113499233156337, -0.11957940027104963, -0.1675638555576013, 2.028095143979988, 0.579973696934135, -1.6707109324928675, -0.7459623616528143, 2.2404301135031095, -2.0178499923416613, -0.49933352279412047},
    {3.65597985045107, 1.6828057141699595, -2.8399365574684916, 1.3570172054406542, 1.2007077920040823, 0.4321747947149886, -1.4558391129029065, 1.5164267111476666, 1.224719367156755, -0.4465538695724487, 1.1538399959217582, 1.014531238528455, -1.0250964728808012, -1.772330671895447, -0.5563420331031278, -0.28267261671473626},
    {-2.995401440120118, 1.5920283151973216, 0.8705180314484993, 2.4601303805908823, -0.7496502235913265, -0.9403430425830456, 0.3473337135339425, 0.2238695298761496, -0.8577716903480582, 1.5237959880823082, 0.979165366514323, -3.5676246604256994, -0.2875370800519233, -0.4408853806877442, -0.9452023508710528, 0.23856686604172922},
    {-1.5645152578761816, 0.10107735907084006, 2.334057826889397, 2.9564586914142774, -1.7567002608948241, -0.5600587500207573, 1.626741972340883, 0.4221263645395352, 0.3930221469542549, 1.5422958455498474, 1.4542233523943897, -2.0440237992753674, -0.416690237509726, -2.1465038888167562, 0.9942958825855688, 0.9042450940487401},
    {-1.7643979924014612, -1.2933606509415454, 0.48801334620827136, 6.520406368707399, 0.23678650309290822, -0.15019612934025933, 1.9214315943105693, 0.37094742305145406, 0.2541567215617549, 0.04240284387811399, 1.8434229672892053, -1.3304097024036607, -0.28418769130834015, 1.4843947999566285, -0.28708509142648836, 0.27899733088935347},
    {0.7096758086261717, 2.2681123837703625, 2.008175954867223, 0.25347436334628715, 1.202282246711514, -1.0448075978820472, 4.558213231576193, 1.0875171443780318, 0.9881809984932997, 1.6665211812103937, 1.7103316730649536, 0.05587570858792324, 2.4499297732687952, 2.050251393359784, 1.6610509080179858, 1.296390535986608},
    {1.1662926723568483, 0.8299443379863727, -2.1719125680059563, -1.1215995964728516, 1.2335897247159702, 0.1371544089195857, 1.1887970117577054, -0.6805132555231035, -2.527562286456093, -0.630415920722219, -0.39858843903931424, -1.6836475548142813, -0.806409034097849, 1.7428778114415588, -0.7503041393701774, -0.726395956106074},
    {-2.2367001910580573, 1.6409728110731547, 1.154439340625768, 3.8113112352407894, 1.219940716851325, -0.9073507515563879, 0.03443486685912536, 1.0056197651600252, -0.19462667644015516, 1.949366613839812, 2.4700582081411135, 1.0565782704509512, 0.8231269690878287, -0.3798148793474162, 1.3870143350703803, 0.6541646568086116},
    {-3.5928084232289534, 2.0974426159014894, -2.122058498059504, 0.17342222400216345, -0.49080220875391334, -0.11375598853040285, -1.610797142843935, 2.0237564406834245, 2.1521378316525874, 0.006866376319640175, -1.1787740291866813, -0.12950817387489225, 1.0585495621130545, 0.11455420595334485, -2.3739963642944377, -2.4907811101995674},
    {-0.8129001791505163, 0.1845136129703804, -0.9187317830283878, -2.5725230051907992, -0.963090222937392, -0.4189808445508455, -2.106444082855229, 0.3605926213680103, 0.7219561097672845, -4.574969872240189, -0.5445591963540088, -2.2558627708380676, 0.42733062873456235, -2.6120401069804036, -0.8552450123152827, -0.3486263659187218},
    {-1.8596498736705713, -1.0214019789777846, 1.379664741536377, -0.9752474179282052, 1.2911603424375115, -0.777822661528481, -0.8952595276033449, 1.3970718298003157, -0.3630773891816457, -0.5734740009726222, 1.1922101617068679, 0.6903756774382692, 0.2136724921990416, -1.3801486807916077, -0.970304463237002, 0.5957978315046527},
    {2.369069620533894, -1.4726583648496627, 0.6143469669633023, -1.3691044132932797, 2.3914541914131284, -1.6785587813646032, 1.166584028881354, 0.7961207784195916, -2.532526104046585, -1.0800122078142653, -1.4031443504119727, 0.006629055021263687, -0.11470064163426819, 1.0429232395520838, 2.4583975631183494, 2.4097662583340047},
    {4.357929859656302, 1.2019372328975026, 0.022144265698697093, 2.6498513395092607, 2.6042028952959146, -0.3514753519286937, 0.8617628342470596, 1.9079376365965381, 0.5172511968704857, -0.39891727783120917, -0.705917381148146, 0.4660099324890563, 0.6244765983448358, 1.2751964048408277, 0.8875406364354257, 1.8099711893565915},
    {0.4321858350424688, 0.6587371758523662, -0.2907241481689172, -0.4787571450617029, -1.2603404919348489, 1.8344208383332352, 1.89434869397627, 1.2656136604905839, -1.2607165351506513, 0.4066465199750949, -1.1731777707573474, 0.5990830986675927, -2.2003670874459704, 0.6002024443580156, 1.0863437700464869, -1.8008489265554537},
    {1.383165281347664, 0.17865837485600392, -0.9330866824685519, -3.772196513922244, -0.8988176261758064, -0.13650119030764757, -1.3498799087058966, -0.6711742907925198, -1.334697651348189, -1.8662565483196734, -2.5726475168810063, -1.2789979956797353, -1.3675597758705045, 0.41534345781867643, 1.3482934999388985, -4.152789447716252},
    {0.5977419704506174, -1.738094596822625, -2.1544781737206113, -0.9509445754017932, 2.5659430987402154, -0.5724706437843112, -2.849613676462573, -4.20712713684261, -0.8103860314001139, -1.661028349044207, -2.2765427520760575, -2.382088925491357, -1.7666843787393949, -0.21984709523473353, -1.9557067290638817, 0.2153358890079547},
    {-1.9739384552716641, 0.05245107973362446, 2.9689641155262514, -1.621073961815318, -1.6000981605073623, -1.3450427401842722, -1.217977862378089, -0.09021767114824904, 2.570695847082458, 0.22722659653182772, -0.9603640132964377, 1.2458550807002693, 0.409604067400725, 0.9276074071803364, -0.18504423092901526, 1.752572085451373},
    {1.0367962242824103, -1.8328588203785607, 1.6756883221979393, -0.34986029044644273, 0.7035041918516842, 0.12446721611534486, -2.975792352623166, 0.09707819611207585, 1.2950073693751514, 0.5713895740548497, 0.2781740084131905, -1.240597819899833, 0.20860818766796688, -0.4094021020905654, 0.7696151567280333, 2.3959077287980777},
    {2.0264952382916195, -0.7225843820321458, -0.2578764133772455, 1.0518924493213297, -1.398445521475104, 1.1863947498149072, 0.7597596727409827, 0.9194066794368628, 2.384654511529644, 1.336348825330247, -0.4836212570821061, 0.22524531442434362, -0.9456181768194054, -2.095994151369714, 1.0405639778079525, -0.7836085068691682},
    {2.2878528794966217, 0.6313247981880028, -2.0537795464997304, -0.112557409801505, 1.6565344585201651, -0.03448689734140791, 1.0861304809930874, 2.078813534361576, -0.10505606995126354, 3.5152606036823575, 1.1410924179986792, 2.6510002911871537, 0.2930546323198448, 0.6300018704311424, 0.8531066141677062, 1.428906873262756},
    {2.578495627367392, -1.557369665947253, 1.5037320750381455, 0.6521097288356319, -0.6829385730813778, 1.5480041781266858, -1.0343784628322779, 3.422648034993163, -1.8408448811705178, 1.9555137735646146, 0.37882285905773644, 1.372236488016116, -3.5518200200206103, 0.4400026942913881, 1.8530053000780102, 0.9537260136254897},
    {-1.004339592298871, -1.7003665516179536, -0.09553438800714584, 0.36048450843317603, 1.465567674506111, -0.014810147707647695, -0.6870996690292211, -1.6622282455539716, -1.2749710593795172, 1.4663434992338642, 0.23782665427795124, -0.1755565499379874, 0.03367673069660593, 2.6838858978034863, -0.3331470890729164, -2.6588160362641604},
    {0.14455093476074476, 1.9376310802993075, -0.4786515384292546, -0.4460901680974404, 1.6388902394581712, -1.0559722915793046, -0.22189956323991303, 0.9340488048216272, 1.3833300120870706, 0.8178086531124732, 2.273042100700087, 0.04174646853892355, 0.6668537755601933, 2.524708473604488, -1.407464881701546, -0.0949262859151011},
    {-1.4169053361443769, -0.14581841339642035, 0.445732576340854, 0.39109394404197584, 1.9868763419977515, 0.5748472933713513, 0.37650969588504624, 0.140444331670631, -1.600801475756732, 1.4856174734451975, 0.15173048202059194, 2.2526992501149903, -0.9847112694284466, 2.658783608963963, -1.501346433105182, 1.4660901664037453},
    {-0.9463046240101624, -2.1033140020311323, 1.1958140004994942, 1.8157868423179628, 0.29751265914957636, 1.1342520507290477, -0.8393795734441437, -1.34037789123944, 0.548964531717181, 1.1472826082575185, -0.02621805950440324, 2.246040403482224, 1.434232903343617, 0.9302652118241751, 2.2270387919535377, -0.11829932473069044},
    {0.9316713555748883, -0.5644830364005963, -0.5446958026133643, 1.581344640048777, 0.6855324797490838, 0.9792207890572028, 1.4431531912053661, 1.6582379198876462, 1.6284324359209181, -0.9652049170201548, -0.140161566462963, -1.1041500164940874, 1.152553362403363, 0.3151110897136932, 1.8591430553490629, -0.07737853739506502},
    {1.0292481742799888, -2.275260217579831, 0.5089304706967364, 1.7384747590555338, 0.0451573505790008, 0.3258083481230764, -1.551590402689753, 1.4451025994830928, 1.858470828906414, -0.5845947220339672, -0.16285330716927598, 0.8622623420235876, 1.8193988540576174, -1.2337388502164925, 1.2861071447763406, -0.3538526151165732},
    {-3.213452531364799, -1.515543113134451, -0.30802633930361306, 0.025604561156354632, -0.8737882140101081, -1.2519103050466833, -1.6323855314212194, 0.4771318381158821, 0.6041165384914768, -1.0605078500094625, -2.484614093962545, -0.8729459738673397, 2.7285894105308715, -1.1892830377731725, -1.1838622947732045, -2.8984595167875082},
    {-0.5760832260019575, 1.9032648668030454, -0.6267256972428837, -0.5147531430580775, -0.07538111949651229, 0.8836344217394229, 0.2875646076010209, 1.2192785750999842, -0.9372454605144327, 0.502727604374876, -1.5346973258928678, 1.1697387048986623, -0.9622246391260311, -1.400198702206973, -1.5321240914672136, -1.8356609279292722},
    {1.0076103932518672, -1.8829921864213852, -0.3920302048176094, -1.6465800931173749, -0.2727809557957537, 0.542509818383024, -0.4821486182833523, -2.3675628657739543, 2.035918857305873, -0.6737441729361608, -1.382350914955013, -0.5105602159662999, -0.785761301823021, -0.7121884915524902, -0.36959055931526746, 2.270601808057715},
    {-0.4940108107158933, -1.6104401170036016, -2.148969335651023, -1.621554640428293, -1.3050391916689452, -0.42547038707317847, -2.5015957675345635, -1.4367920813747437, -0.0588479642722058, -4.166433123228801, -1.3807930318416133, -1.1406130385924782, 1.2165049274950166, -0.856698835779122, 0.09616480686034473, -0.15323888514811732},
    {-0.944409143998992, 1.2550886200094875, -0.6262885837991118, 1.2055514448633673, 1.0119189434942137, 1.5717209879478677, 2.1902135799906683, -0.31210019626823937, -0.43329994765276764, 1.2146890660206786, 2.18822733618261, 2.2533801448569784, 1.6994219621854159, 1.7818235523332784, -2.407441402089502, 2.8376121687460567},
    {-0.42313624862024635, -0.23011905654750595, -2.222937358184235, 0.09260062749348187, 3.743580519803219, -2.5412716965217004, 0.8905888965329531, 0.27086650244766214, 0.7700525972461497, -1.0538140730105325, -0.31397591136968206, -1.8642621298869615, 0.6303026029435977, 2.713145310436995, 2.32224556780564, 1.9800217204186201},
    {-2.0681407031346954, -3.2980422383745363, 1.4518059965657044, 0.11665932669570808, 0.2529186790939063, 2.75362655985251, -0.8884735335446308, -3.370536839512132, 2.4025892583718464, 0.9831562372176909, -0.5317608410832263, 1.6012295636069704, 1.4396748043316407, 0.45451886580473494, -1.3410374025044889, 1.4436774289475123},
    {0.3669652926593671, -3.1082027186986694, -0.19496202522769784, -3.483806110844223, -0.9809274518625066, -2.403806947591614, -2.629088272464163, -2.328532133568465, -0.36164273623494236, 0.5533261882925267, -2.307636405293562, -1.0411759592547647, -1.2681015777516158, -0.9225752150135882, -1.1657836807397668, -2.0144751165703862},
    {-0.2322386206406067, -1.2030713614193176, 3.1418985510552933, -2.6198730465678257, -0.32616164798111996, 2.720816682986787, 2.8256555043856637, -0.25381377269991684, -0.519311997650952, 2.3128411258547734, 0.912920915825679, -0.1598969391370249, 1.5823322178278416, 2.50974755483401, 1.9294390398345418, -1.1722881945935404},
    {0.8673161366162625, -3.222060840185318, 1.3442101417186547, -0.7264467742642109, -2.2136585501075947, -0.9434102761481716, 2.1939434551197188, 2.2273775325999092, 1.3519319319500103, -2.145693906421136, -1.0454141986261436, 2.5082007195633023, 2.1821618467775408, 0.7520619393583875, -0.14752511122187761, 1.152665676410413},
    {-2.3133645974824613, -3.2302879289109665, 1.6892415424722298, 2.48204962339238, -1.111397366420579, -1.8301932831427608, 1.757631065126601, 5.3733439509716, 1.5357392574116644, 1.788170291752864, -2.479575830300825, 3.5072596210964435, 2.629438495137804, 1.663453052465889, 2.930220117365058, 0.04176804357627867},
    {-2.1338442025656232, -0.820126763479583, 1.9437566500019292, -1.1274112948947757, -2.0465247471442227, -0.6759181230862801, -1.04458555759596, 0.40818853544521205, 1.7972047349031468, 0.9410065705383207, 0.7738465979864896, 3.792275985704585, -0.9022284644042685, 3.2582098288399908, 0.31972885932457384, 2.2558948136538635},
    {-0.43441235730642724, 0.43829677470078093, -0.6766748215202708, 1.2317504292880204, 1.6589708311263343, -0.1756115507046037, -2.2383952794886937, 0.9038836373597948, 1.5947987844812497, -1.076028308998967, 1.2046703657755524, 1.1349136848375398, 1.3532148477979122, -0.4111003179415656, -1.0229132069571067, 1.638096036421076},
    {-1.2143297340141745, 0.5269054737542154, 0.4250747065195957, -0.024426607407707485, 0.9516435109913877, -0.7622576918451436, -0.38238429300112897, 2.0586368132136874, 0.9120250873353152, -0.33670568605175516, 0.850144860658389, -2.992659510770572, 1.7032334306940806, 0.29397509085387263, 1.4847098939127275, 0.5440491276998715},
    {-2.5245489936949603, 0.21689499693765116, -1.0685133334042358, 0.41294674340982745, -3.541658778095179, -1.0043933443477762, -1.9414203481023045, 2.322124760573719, 2.99985054957485, 2.2227199859917106, -2.4974050199778244, 0.24151182039158955, 1.4076543414670215, -0.29733351683085624, -2.0374894487704323, -2.0615196625283554},
    {-0.7528704088513035, 1.1464650322554863, 1.2156491761373815, 0.25075441385819386, -0.11455084868961803, 1.4967789934197513, -1.6579817106831425, 1.1838921294358395, 2.332660486488384, 1.107943160625031, 1.5608492876167779, -0.34357473674353184, -0.43120063146167414, -0.8685694408264147, 1.1854751851230576, 0.615258681615103},
    {-2.637578331886574, -1.038114851846891, -0.6661639691973088, 0.242517055834529, -1.6958914881818183, -0.5830688994104267, 0.869884119065153, -0.17262705226398428, 1.0191338270450723, -0.29180123186247037, -0.8392298552361482, -2.4927907639664775, 0.010928728883912586, -0.2457378687390233, 0.518775932344059, 1.3783291711360848},
    {-1.3351849670727207, -4.918992099179781, 1.3138065977268216, -1.0652860354680653, -5.750228971497942, 0.0979682214305997, 0.25192425662384943, 1.0845743393523977, -3.1392256544349437, -2.1037298435764313, -2.0667513816312493, -0.14480345863116145, 2.3564493829077815, -1.2005667335532624, -0.9329819736271717, -0.7187265192979022},
    {2.178002631493359, 1.2998369302079313, -0.7898345461530002, -1.541342953241593, -0.12790530818222906, -0.7932124055053144, -0.7942373162707611, 1.025108064778649, 1.2495334098941244, -2.477576803526218, -3.019945352988025, -4.217043346014315, 1.4774170701113194, -1.2696745475914213, -1.3816885947244908, -4.860178922966},
    {2.993795971399329, -1.3090137468233716, 0.7273972002969632, -1.0101978579425837, 0.5167759377301719, -0.2403941741373198, -4.419217206139255, -1.217068570130715, 2.0599422312108144, -0.19876268592291926, 1.558807076799969, 0.08480718930150508, -0.6349986502786699, -0.7467291907219837, 1.150908135116859, 2.167072497566604},
    {-0.6334420525654249, 1.614311434537658, -1.5440345217252294, -0.5244430769729426, 2.635117118953305, 0.02351923492477077, 0.42630133653947483, 2.783719568540551, -0.21253825449764902, 2.019169229314181, -2.4570262940651264, 3.820202635169417, 1.6011542362509554, 1.5188416344240188, 1.0828797889666149, -1.0201000923407983},
    {1.1467304068939208, 1.470882776580511, 0.3125819098467206, 1.1184561314715888, -1.4806534949391834, -0.34198144073647435, 0.8673006305303763, 2.9852053064794264, 3.77784566187427, 1.1158754320839845, -0.6427758134723809, 1.4172112425961767, 1.6002624953401816, -1.5171218289789377, -0.5806285634039832, 1.780412079995466},
    {-0.5034231546195518, -0.655202754371858, 1.4022515974832808, -0.2997222352569525, -2.7881215013729346, -4.533807997368743, 0.7514017407471116, 2.0635082587524955, -1.5849061110905789, -3.6660220647119113, -0.7104886242963807, 0.6380960677421197, 1.9237729032505573, 0.5135279169869188, 3.3780812874372996, -0.657937068503651},
    {0.9091907297654136, -0.5811935593678438, 0.8204066268595984, 1.376701268035022, -0.44911315999118956, -0.6577221050061356, 0.5109858274123052, 1.3463868225007767, -0.7817876588971959, 1.1578716820560817, -1.602065564928548, -0.6963724399784615, -1.5463484375147087, 0.0672271566977816, 1.940528598369144, 1.3412790596027548},
    {2.2703738144601213, 3.491647635116111, 0.5483999576108466, 0.036262676505943794, 1.7621582826998325, -0.5330643438181156, -0.4346529256435375, -0.5161246868412299, 1.6110048905429797, 0.6442287833078446, 0.6032337724047849, -0.5089892766312136, 2.9446772407999644, 0.059801157664095855, 2.9785500162583234, 0.7729388136328967},
    {-1.4611532734235602, -0.809710977888512, -0.6400272606488322, 1.8226033501402437, -0.6162600193907442, -1.730034496345324, -1.5931991681917195, 1.3693305315672655, 3.0624681528271256, 0.43166803938942294, -0.27211614524198896, 1.3810304114426823, 0.9523986870540312, 1.5976604331880695, 1.8411251588423572, 1.6730429442901842},
    {-0.09186114669696153, -2.988104852631272, 3.216359536343944, -0.4000508761151256, -2.6653994765715874, -0.011986273102580585, 0.53681034216846, -0.9429596333005017, -2.524165717633503, -0.4173981785198768, 1.3890679165766193, -0.30632271181782, 2.0001494731239693, 1.7344116070352087, -0.4359635395564, -0.761103199116458},
    {2.0994979022411915, -1.895355018639135, -1.1361870820115794, 2.3771202579131447, 1.9052076169031986, 1.0261792924521378, 1.5606160097720598, 1.0337055734600333, 0.2574980741145886, 0.5610954060810501, 1.015243820419739, 1.4825986589649909, 1.779276654621334, -1.3776789900916302, -1.6327642795682813, 1.6719952061252072},
    {-0.8223668688233134, -0.8241954143199239, 1.6552961659087615, -2.8704126785830213, 0.6479151531515778, -3.2739287354066735, -0.8486796032024386, 0.6136742291514046, 0.8478099118746426, 0.07376360789134107, -1.105620484846729, -2.6934453490075065, 0.07254626784858505, -1.564277706152082, 2.010531645608878, -0.9776383917025079},
    {0.34415454983952093, 0.13009531200594676, -0.12181037463407257, -0.05967925178302766, 1.0193854994867901, -0.13335565103751315, -0.28992336829659454, -2.9213066358165993, 2.103142276003725, -3.23787743723655, 2.218133174203477, -0.060827391503501305, 0.4004479380452549, 0.07957657217628558, 0.6056638820494996, 0.32637529928946396},
    {2.7869091202962712, 0.323607649079079, -0.44480982292497695, 1.3692318497648104, -0.7317442515788222, 0.6502238401548304, 4.944574508639935, 1.662873213258925, -1.7173349394936004, 0.3426254640715236, -1.5856417731736228, -0.2353578028038188, -1.3039955098569023, 1.5387434196605239, 2.148962672583899, -0.4044004076317617},
    {-0.24313792402335926, 0.16316639049523388, 1.7917176164108974, 1.5298835756089981, 1.044166568989408, 1.4487195629910252, 0.8762639462362642, 0.152269198953055, 2.244622909217145, 2.812763036883052, 1.1557054164128087, 0.6201792688435165, 0.9178878057902824, 1.4193282173433777, 2.478316807402597, -1.5228045723176467},
    {-1.504589791579706, 2.3203810484036356, 0.6992450770161707, -0.7077117538761517, 1.9333227853402049, 2.0512885076915897, -0.3394798046793225, 1.9838824141366915, -1.83493303479759, 3.212983995262404, 1.1650625406946897, -0.42804325851411046, 0.21635885750766448, 1.2415895933045553, -0.3488799807603551, 2.5883920023073093},
    {-4.092080290713633, 0.23813011185906116, 0.29938646105362937, 1.8816832129871268, -1.940698806883111, 0.28200141424463926, 2.6871191310077527, -1.273525238777292, -2.2083208032238066, 2.9093712870558672, 0.9380478594809137, 0.5716905783918033, -1.2846287469252973, 0.88921879460131, -2.029304481719597, -3.520278878887879},
    {1.8847427460497637, 1.6985034146887994, -0.4219879895487065, -2.1426736911522157, 2.6817690183907277, 0.2992381843687713, -1.9417084361782302, -0.016711662188154675, -1.874427711701735, -0.2667314672444837, 1.3862040933461013, 0.2744190426901396, 0.09417531218773183, 2.4055522718242464, -0.0810428626757829, 1.0930643202471138},
    {-1.9727865162311333, 0.633883503874485, -0.20428622555092016, 4.306266771491075, -2.442627845127561, 0.5533667720857692, -1.605827481989894, -0.7750111640994635, -2.2068563615670858, 0.11276997197642688, 3.1785965459969026, -2.5294162005706426, -0.41352656574541247, -0.5122068472807398, -0.5328244202451444, -1.1613262811142333},
    {-1.2152806412710135, 0.419768894573943, -0.16341533534776112, -0.1290940517949876, -0.42721426017184105, -1.4023603532078843, 3.319078551296228, -0.1448692978663076, 0.2634046830863316, 3.732591899509155, 1.1575982520156938, -0.12956750604148268, 0.1398390580404506, 0.9254443233176763, 1.558890842682682, 0.7471429552907698},
    {-0.9317401835280491, -0.6212127563943733, 0.7179886422430475, 1.795222952515976, 0.30252642754476794, 0.24013534896615013, 1.9765488087372756, 1.775750239525784, 0.3143763659417336, 0.4814658144556548, 0.6991859540212275, -0.36443307440604655, 2.2606217736076313, 1.155932858497225, 0.27145547731674285, 2.1379213111571707},
    {0.030682072338490306, 1.942182166357923, 2.539619526826525, -1.943966760502905, 0.5338107286271022, 1.2555438891632469, 0.3402996969210284, 0.6701508383107854, 0.4701929747720569, -0.0638847317660668, 0.8766442401327968, -0.5666605167455665, 4.539741174882805, 0.04187397177228221, 1.6653361851954829, -0.2156060731989383}
};

static const float b1[16] = {6.393597263294812, 7.543068010939352, 6.930399183844108, 6.824628379460916, 6.828593193829942, 5.0782370974916216, 6.810110032859911, 7.577563461277921, 6.793492760179839, 7.49374221289336, 6.238476225409541, 7.665097479358367, 6.463474061516547, 5.880398629623356, 7.60071204444022, 7.404160164855832};

static const float w2[16][12] = {
    {-3.3345329451005408, -4.89195826859993, -2.902645896544987, -4.175751536774704, -4.680341078838749, -3.6601066496193164, -4.345764667094043, -3.52786622601461, -2.880789469728619, -4.685218735948284, -3.5946627412723995, -3.7854356759032393},
    {-4.5138655564267784, -4.098003484960716, -3.0993747929725495, -3.9024853465432923, -3.446941494659556, -3.531484297511542, -3.5653317620230474, -2.841154296616477, -4.518131945069633, -3.964731113795226, -4.086298731776443, -3.9145874750064182},
    {-5.099596989027366, -4.738228514962075, -3.4561077075819715, -5.626247804005612, -3.5091548012042075, -2.2062542568554306, -4.00910510773786, -4.490470501344901, -4.231819901714524, -3.2499568363949787, -4.64261066114119, -3.125382110878426},
    {-3.550919407192092, -2.914602661171455, -2.9524893050389993, -4.491676585955314, -3.584804217193053, -2.991271186444081, -3.1905917451255, -2.737493689815694, -3.6490065173241213, -3.69042786360284, -3.363403995514366, -3.4465940236618833},
    {-3.8465164694773435, -4.06197463516764, -4.519366310886283, -3.8088611642037105, -2.4734880030277853, -3.009082423183204, -3.3365942844131187, -5.201521620447289, -5.0232699224814406, -2.7177654465377317, -3.6726761419273015, -3.410566699155093},
    {-2.9056216620651547, -1.3187486208984998, -4.223859521291153, -3.363587276153449, -2.8781530200489778, -4.279931689449222, -2.516727632564937, -3.7740625485378394, -3.6792826473042584, -2.6515210152016393, -4.128200058566917, -4.010130859794038},
    {-4.043081402330573, -4.383742960931062, -3.8753771476375505, -3.2098049136599345, -2.794815638768514, -3.4244401354783087, -3.055604588515508, -3.900908307208791, -4.271520819420901, -2.889181226772949, -3.786970392295218, -2.912209182854757},
    {-4.103982860858756, -4.188702531920384, -4.4014075266862065, -4.752917194143848, -4.3705730267679535, -3.698993264052832, -4.564289754776636, -4.283381117995258, -2.811757835933989, -3.2180440219783013, -3.3876447352306664, -4.464119426722797},
    {-3.5269464449026278, -4.219814483393501, -3.4825320116021095, -3.104662672394961, -4.034054328283756, -3.88959978902454, -2.666654436540705, -4.041639572897761, -3.880476220623453, -3.6530749953796438, -4.341816575112221, -2.8812179545188696},
    {-3.078386721262073, -3.4783196962863197, -3.0592067309764728, -3.483691786946009, -3.609404361809239, -4.5747840156543464, -4.751785640381715, -3.2599139828353723, -3.4663907756520986, -4.322271705883196, -3.8563433104251863, -3.8903024407195996},
    {-2.701219765700072, -4.950196279264771, -4.769104172644811, -2.05660287876157, -3.9620122475071944, -3.2288539534143093, -3.999609983383252, -2.70160466064096, -2.5018347662960196, -2.8654587991964293, -2.433302340752662, -2.2331647419263088},
    {-4.293439214559864, -2.918371450184136, -4.030145711734701, -3.4799007744228234, -4.239018210727236, -3.5446205430370594, -4.256001429541443, -4.055541524760758, -4.357899271802135, -3.9287992909827603, -3.491355251622001, -2.9924017731661046},
    {-2.7664247351959808, -2.8740600890618704, -3.985460960948164, -4.12754926691556, -5.056387963117992, -3.9636644312382114, -4.314539829428527, -4.262681580517398, -3.508451715005086, -5.353938964254315, -3.8138241642932442, -4.302370120174537},
    {-3.338197125521802, -3.825062105090363, -2.582600043789923, -3.4164737044098126, -4.501640611345531, -4.262176699336295, -2.2275369332329715, -3.056236984914504, -2.6248821442761923, -3.9911260667256667, -2.760535341109124, -4.239815002828244},
    {-4.037733870872698, -3.475176458643203, -5.24618283455339, -2.3808046982023248, -3.1070176345312284, -4.376093861463858, -4.090918809156197, -4.363632222116462, -3.957422785137556, -4.315630610764386, -3.409173231455522, -4.129265267939113},
    {-3.9355338016711032, -3.4544052634826707, -3.2270347353883486, -4.69566567368256, -3.5781886687249513, -4.555680272846163, -3.5883122397281864, -2.848260411082553, -3.8206372813368965, -3.3494767268897654, -3.851373671828988, -4.676948577725615}
};

static const float b2[12] = {-4.602906381679585, -4.879586148400297, -4.941394967922545, -4.466425756109637, -4.445103711288505, -5.000151434084313, -4.555217983734249, -4.356798181045536, -4.84394492960142, -4.013328600984834, -4.540635413326815, -4.652858499220371};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
