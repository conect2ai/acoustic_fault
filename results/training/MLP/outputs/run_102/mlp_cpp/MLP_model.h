#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.45403494548628415, -0.7914863742500049, 0.4272046413151573, 0.20436071704461978, 0.11326787888221442, 0.18693031708877172, -0.5511566324029089, -0.4645235327398886, -0.3756275255472665, -0.493065240044832, -0.8129794644274988, 0.36858660809155624, -0.8173917388843704, -0.9658973141414133, 0.012915849236519252, -0.4365769614088118, 0.5726231328227172, -0.37956644433374886, -0.04430516804132702, -0.9255377062933654, 0.22526521779024372, -0.9791962025558064, -0.453316405581254, -0.6822474430497668, -0.2669824864591545, 0.10953188035724044, -0.7638933721468611, -0.8224445407173234, -0.7077562751486525, -0.47488785687985186, 0.25568624986722555, -0.3442250257820236, 0.48419951061342525, -0.6598551662793495, 0.5568939588335441, -0.8370881765689416, -0.46826072115310824, -0.008161494324232953, -0.28238145081917476, -0.6914382057982212, 0.03776596455017928, -0.9559686701296304, -0.42851478326431314, -0.4501046423566713, -0.8298500397777974, -0.7282233332242736, -0.2786513699361917, -0.031229746365101823, -0.5683997003786849, 0.3681373137974527, -0.5873808067884171, 0.265226350330505, 0.0375284402239779, 0.6252362586120922, -0.17252889227514548, -0.8852717215254255, -1.1699418954324836, -0.5959626085275335, 0.01621319237121719, 0.5916069301546082, 0.6181869516434999, 0.5234644252576298, -0.2658833414581056, -0.6978767349946656},
    {-0.6219584682023147, 0.39418007912548764, -0.8245224997193952, -0.8615358365498761, -0.5633036583582364, -0.687629811192938, 0.5196256595528508, 0.5817275171431504, 0.5876019392522279, 0.514892803244873, 0.4491520506465321, 0.6679172896818776, 0.7227581769244884, -0.10612651570720227, -0.38611569733351714, -0.39620686872285316, -0.6284579731004594, 0.23377216173368598, -0.026740029114483994, -0.29303399392240187, -0.006484730692520449, 0.22290252066166022, 0.1953660413961531, 0.7495176707086311, -0.9099886634893992, -0.6087098027733082, 0.0017404065440132005, 0.09330736031602954, -0.5683377182023817, 0.6994409805526114, -0.08381929782594937, -0.2377508977576302, -0.010382835312280016, -0.2506042039137219, -0.19392165339042797, 0.3887057195013945, -0.15798540893090093, -0.08556350161657013, -0.24446888755177887, 0.46433660707102775, -0.34390031714605024, 0.2618609879964865, -0.861352425908994, 0.07361407220419537, 0.4955862874458779, 0.5884089772252602, -0.07292160274576454, 0.14923853952200683, -0.4093906730768533, 0.118309533463102, -0.08891885166413413, 0.43633028307311555, -0.663069131322337, -0.6503666900250108, -0.47194782032959015, 0.8031481428806255, 0.49911001995791465, -0.642919405242009, -0.9310679258656872, -0.5181472280180849, -0.9411984390802596, -0.3818462777671018, -0.28516328648862804, -0.3820269549204671},
    {0.17964756759016418, 0.21842324101582028, 0.4122403827603151, -0.40198967430278487, 0.008337641442911057, -0.04907591081211841, 0.5406371594298935, 0.6003167066909183, 0.20125509937042035, 0.40753347203476675, 0.4296142003292431, -0.16416231529897754, 0.4817325381728199, 0.6009446095589748, 0.031122417741453277, 0.22482175121602332, 0.10679687100372681, 0.6829797518617478, 0.24468579565610613, 0.306734289446732, -0.7172461207944484, 0.8374733162916722, 0.42975127719525996, 0.3479653245169545, 0.43154475704461126, 0.7672977114496445, -0.16305041403016163, 0.4200222365705452, 0.6392430060151897, 0.3475301679042685, -0.24863033692963085, -0.4930647512511274, 0.05007043434617349, 0.7374003208818813, -0.40816576165118135, 0.8976684116713236, -0.9185916913170689, 0.7683661599056352, 0.47558424590127396, 0.5084265490802401, 0.2880887933810578, 0.43450733449768236, -0.3525683919859642, 0.6326187043659787, 0.7542244812310949, 0.7015219500400969, 0.9046987194383346, -0.3404864759930458, 0.05416222945162869, 0.16662322321662337, 0.6508501676647063, -0.023609800268202395, -0.258406530628177, -0.40472497144131253, -0.06567648895373518, 0.533205078984777, 0.6644157122629786, 0.4913669185100899, -0.03950544028550553, -0.43013918085232833, -0.24918500660785736, -0.454968272226418, 0.14037476313217415, -0.22969849399586692},
    {0.36758689611095546, 0.1068596615994566, 0.6623939308562743, 0.5410739314557549, 0.38250422933426903, 0.45046423178307593, -0.6012192126521703, 0.23082687999301166, -0.3980857514763085, 0.03255715644268569, -0.07657347628582319, -0.4513954834799826, -0.5068044961118077, 0.27683909225669995, 0.4498500410361967, 0.46896158911883773, 0.39229570560685034, 0.17116670532048223, 0.12241646885165756, 0.8681092103897187, -0.04889278254999384, 0.5764574207761637, -0.5502265050535299, -0.595201544384988, 0.7143013068748694, 0.692466059479903, 0.09760093440075696, 0.5973222675545312, 0.6824396392763892, -0.5631887986470865, -0.5555848917990043, 0.16826259874381402, -0.8207922300865841, 0.35755746544018363, -0.4792105642399784, 0.6394043829825777, -0.2618944545473445, 0.32586811872677096, 0.9415824778995701, -0.03707909152789298, 0.7180390509145426, 0.1512819469874778, 0.5594250119775585, 0.9943419395486264, 0.09676702611100042, 0.33471500453488806, 0.6557612522317433, -0.8520250596575417, 0.5847895428775945, -0.5814951574859367, 0.39106283101715617, -0.17293427827837507, 0.16453206743246235, 0.39586000086079104, 0.3897198134420934, -0.23175114523851653, 0.18323735667392413, 0.8427084503643507, 0.04508140890128916, 0.5548967205164873, 0.8538438750720498, 0.22291610943841833, 0.012174732986825289, 0.5024148257525488},
    {0.5648993838296448, 0.4483977735152316, 0.5695889106716018, 0.4347208573999296, 0.1797545509534163, -0.09393808940040409, 0.1220114249872205, 0.596170513295588, 0.3596876637920539, 0.5839302910357727, 0.042892534951172144, 0.008297961819533782, -0.11006728768113797, 0.9055196331273502, 0.33584901952623497, 0.9273650235801432, 0.181275472669587, 0.7289020949573928, 0.33199939793916605, 0.9609993989737441, -0.0973160851956335, 1.037722677630717, 0.2776115569589651, 0.4598068173158009, 0.6288756754396186, 0.4181214169720558, 0.5964856085491976, 0.523587611019996, 1.1065381925421198, 0.42607098759615464, -0.14174916943995572, 0.3117869215229949, -0.024987011415548155, 0.6899795462289315, 0.04115128390744096, 0.9558505753357716, 0.3749493510295097, 0.654514853591147, 0.8927840205702197, 0.7795545985431687, 0.6148043921585158, 0.5999555107891297, 0.5128532178852729, 0.5957273840238441, 0.7492469889541777, 0.6368341995365125, 0.76385038712568, 0.05642684737964371, 0.719873911728971, -0.04698422822829515, 0.6043867406049923, -0.1320556937308343, 0.036123315378846596, 0.26737517127509075, 0.11708573559746809, 0.6844999580942933, 0.7616874571553288, 0.77063122385481, 0.09823489850515099, -0.027024791580119282, 0.2382480916366462, 0.34381094274574886, 0.49405645041275936, 0.5986438953998069},
    {0.7072997684529533, 0.8521638327415563, 0.4878850735466702, 0.6388981802175199, 0.7606659057967061, 0.5476279345972238, -0.01473997290458976, 0.5898759913147391, 0.7538870704988896, 0.8373701670207311, 0.21009635057143955, 0.3516275863380088, 0.03151390357082548, 1.0425375490801811, 0.28854759947367636, 0.7424782683475426, 0.10159481753753836, 0.44895427500540713, 0.3200801404363353, 1.0801550911455602, -0.23731073220423018, 0.9421662213744931, -0.01731573557151899, 0.6327677533624285, 0.694758624650792, 0.76632488550846, 0.7567424606874606, 0.49650177709698373, 0.7074784727100563, 0.29203946291394867, -0.043068244147196344, 0.5449663988828224, 0.22892428328698963, 0.5261523219231863, 0.0027156720638898293, 0.542379235611521, 0.2917558225820371, 0.3021450917076321, 0.8364150695729781, 0.6640473228194056, 0.4998035790759493, 0.4677968308598372, 0.4596138767013347, 0.5338026993973212, 0.49746707385785255, 0.3401907988879432, 0.8441968634435798, -0.23791408138758752, 0.8852231273684208, 0.39077380154477703, 0.9074782057961934, -0.7204596877659147, 0.6398512048243294, -0.1389209716238884, 0.3836217511230724, 0.49508372819962343, 0.9213504532494221, 0.7146087978325322, 0.8034468106931343, 0.08371027703397116, 0.6977875627925316, 0.14322477443518664, 0.4034125442833761, 0.7538813605564224},
    {0.788547232339713, 0.7133534741312874, 0.4183611079647587, 0.6487494862031066, 0.6490099945377317, 0.032521422413393015, 0.2992523367546785, 0.7137301584910852, 0.6005505123461428, 0.9592632247337656, 0.24189310066151284, -0.022571165697670276, 0.0038237319493766644, 0.7498342836269472, 0.3328356780219246, 0.8028998658075274, 0.4561160459422085, 0.1641369204846631, 0.12311618659732546, 0.8846248704040345, -0.34971873336536297, 0.9900987685709709, 0.22338591178739362, 0.7860358248216697, 0.4794729616726564, 0.7408988050269915, 0.27487762293299617, 0.33932007535467895, 0.7002703944290193, 0.2404155617750443, -0.33753418089884807, 0.3061282169120987, -0.036557527532610094, 0.6523123850070486, 0.09824058913665819, 0.3105355025948516, 0.12477512982924187, 0.2305429509175206, 0.7576456459755573, 0.6992146067150199, 0.625210030499137, 0.43549750535915266, 0.8389623555148226, 0.28009463540422175, 0.48545247920240525, -0.04398516552576476, 0.4301257735973905, -0.10092719517017969, 1.1347697502686083, 0.19070494402831206, 0.893716953189121, -0.6398768131074533, 0.2927028469252954, -0.18378947148091263, 0.18468253064663834, 0.5312760515401597, 0.45433283445839157, 0.7480246763740219, 0.790787864138841, 0.028563392184353397, 0.5303078843137412, -0.05006780962418393, -0.21502195300146046, 0.5022522905526935},
    {-0.13498198798622033, 0.3160155018276715, -0.5427775855800788, -0.38658244971088707, -0.14565913354234802, -0.7256905982819545, -0.056738132567097574, -0.321585092234849, 0.6056013151772233, 0.370512667564633, 0.49519963237235526, -0.15086973812862625, 0.10043857771416602, -0.031960259427283845, -0.25978180398413714, 0.0791358577483383, -0.4936948827189134, 0.08326029296081365, -0.23826106311804154, 0.019687471272540568, -0.1955202609400836, 0.5059861685376071, -0.1357509171647959, 0.7382895433296492, -0.23643114782354638, 0.14901532950044655, 0.08383882057686576, 0.6132472486288021, -0.14982788853583504, -0.011276251006122001, 0.019522781304764803, -0.5599212340320541, -0.37283102874594126, 0.09692499464675376, -0.27221401097050796, -0.09760660569035531, -0.45036774256934764, -0.24968948884779105, 0.03640643855172295, 0.1499271013494424, -0.15960173623033197, -0.42903304326797354, -0.020912940649645675, 0.04328781248753793, 0.26045053857029493, 0.389280473454875, 0.11459884134395344, -0.3727638568664354, -0.46925367141283725, 0.035225945392527894, 0.3203222926119202, -0.2022664068998606, -0.5282795564101721, -0.3232772129221749, -0.024260911090706355, 0.5027167418295253, 0.2298387630180414, -0.6504371490487662, -0.31395124090956655, -0.10411220505620783, -0.9010390609716139, -0.4507490097468726, -0.2557910610962721, 0.13061253064894326},
    {-0.5633187039707594, 0.2064675022719481, -0.6331369549041628, -0.4389224594549837, -0.5092556337870534, -0.49857189570906907, -0.06248465609270972, -0.3152756033854302, 0.51944655124844, 0.29454064643354616, 0.4325976949824434, -0.06502592965509126, -0.019012279525244258, -0.3651131750383348, -0.03792901716285791, -0.20467421237479724, -0.3487582714240261, -0.055156957130105724, -0.6314946358128934, -0.11302202593233858, -0.4772747506032771, 0.36538900581534745, -0.0012088562978467647, -0.05775550507684472, -0.04437318646876294, -0.2645337408851488, -0.11718582213148965, -0.040959371038290504, -0.07919774087664319, 0.31793749090981993, -0.11548654444841386, -0.2805070430311194, -0.17476601839876713, -0.0432462341475696, -0.5284811735903502, -0.5528301754231603, -0.42098803185351585, -0.7433202652229556, -0.39971288887470013, -0.23120955974385712, -0.22021737695863694, -0.513877785885524, -0.06460164745629612, -0.39135695868480797, -0.0002698162707357991, -0.13228580748475796, 0.0491149114129187, -0.5516274351867737, -0.6612303941100953, -0.050091332826868964, -0.2784600240141482, -0.30738466190247904, -0.5179605001300037, -0.5292077276251561, 0.38115807337249524, 0.5645874165358364, -0.15044904668634418, -0.6875408060661834, -0.5531853552566129, -0.028422065919531884, -0.6190832970988065, -0.540375492998707, -0.14130193245566697, -0.3758065882627605},
    {-0.944112562580032, 0.887495136565364, -0.8010236152156589, -0.6603435389404031, -0.5790920542197225, -0.5815464186973005, -0.13505322867298156, -0.15903131832440606, 0.8131304791925773, -0.21892876497539832, 0.45684851023790923, 0.6042016567197924, 0.11510236143880778, -0.034010576752165546, -0.4225379783420401, -0.28485142765798366, -0.10874003320896843, -0.013011173060591009, 0.4419520982832653, -0.8346915367844603, 0.5040732448992877, -0.29466877372330774, 0.38905394620655626, 0.3864275723725649, -0.7044408554958088, -0.7367276840113398, 0.37219916295527805, 0.16760654940336048, -0.08411318504040631, 0.6267314036329396, -0.016970866142636733, -0.11734168740394377, -0.1280326873646937, -0.3324762289513484, 0.3930889243165542, -0.0364031178350969, 0.23690596452829935, -0.3384757786573275, -0.680308597531193, -0.18733462430794096, 0.028647706603460887, -0.3114564826718928, -0.3211972501593615, -0.006209415830189799, -0.08484580186464206, 0.12154316547017102, -0.4458565208977998, -0.16471585096479072, -0.5653949659110157, 0.4214039006392989, -0.3551825796143931, 0.38992913682582236, -0.6045172400061163, -0.15748108717378662, 0.45486394453737666, 0.8074780189516022, 0.5639401525597219, -0.3444157953919675, -0.06464437606034087, 0.16386326382568303, -0.2147071126406433, -0.25054896656056724, -0.39113647509710986, 0.08995119725465102},
    {-0.19898515870182248, 0.49887674382585745, -0.061147688559715495, 0.6642445405812164, 0.03518128419566266, 0.07768489658059066, -0.2838188232837656, 0.1452257033581167, 0.7089770078776113, -0.2745986655736905, 0.0012204957475597889, -0.01846526752016484, -0.29509364285858375, 0.632926886255141, -0.10133850783663054, -0.07558243604367919, 0.26925203162447814, -0.10003595720299822, -0.07185308646111113, -0.1049425354275525, 0.06716712051262262, 0.45284256350290425, 0.024563125970932603, 0.37091202523524947, 0.2586278504220449, -0.3670981094035359, 0.6241726680944655, 0.14707964456512637, -0.026706507404730497, 0.3915023735480896, -0.3746530705983792, 0.3783046490909424, -0.30583445370882745, -0.5018598421212913, -0.03486149214017183, 0.39245895785140483, 0.05693254004172582, -0.22861411040093751, 0.11422333293718262, 0.09242549018693196, 0.2836946647645099, 0.13862736210427296, -0.01524978209544672, -0.14350283099743477, 0.15673590488211803, -0.12306177811424776, -0.030249488398007562, -0.31860441827049407, 0.44226044506072576, -0.3464010630627295, -0.10496278197231901, -0.2978685205638074, 0.07855705970645029, -0.06798031138126633, 0.756178198249539, 0.5450448061563318, 1.0156855600498225, -0.12540192529465224, 0.21995047431761178, 0.49531857853461736, 0.5771476548182847, 0.025568205521971275, -0.27461831685853105, 0.5915623563495129},
    {-0.2608099264598983, 0.026112804953513626, 0.3243899189688247, -0.25670576451107585, 0.05296246386300132, 0.14284572852486832, 0.6748985998599313, -0.23485566097415259, 0.8230303632670772, 0.5207970177981412, 0.6826876263300267, 0.08203386558539531, 0.2645815358355868, -0.0016900817285076689, 0.5375858104964295, -0.299992658228667, 0.6510853534931393, 0.4066520116525766, 0.27971649219547384, 0.07144284710002621, 0.6209085496207237, 0.395250525185901, 0.17678296951181027, -0.13728221297323823, 0.22276215826714285, -0.07433734076005984, 0.019630212146151977, 0.572981346701965, 0.10419524216396966, 0.20736873707061404, 0.6259695084492692, -0.15163897073916757, -0.023983543150945176, 0.07778889111379449, -0.00442694557036018, 0.7146215666784695, 0.013920128612117078, 0.34885315859095095, 0.6636735747200501, 0.10102781954837134, 0.48614775908858704, -0.3158088814443271, -0.26699912834964384, -0.06386589137771737, 0.0612915570169333, 0.5128420093501281, 0.154413078756015, -0.2831169343172492, 0.08282370742599819, -0.08089133974785892, 0.04732510123935705, 0.3527872483806419, 0.006253386135883362, 0.4442490257582889, 0.2959448958626915, 0.6873107178537877, 0.016930142988405686, 0.3225130585575375, 0.17889294461671082, 0.2554225552209312, 0.16473900782885162, -0.020445823723988333, -0.04492936561342857, 0.13611840171650802},
    {-0.38722014455556036, 0.39600599344005827, -0.4180165346791845, -0.3632731295663224, -0.4539347721934534, -0.39499916759529335, 0.3874063020053283, 0.371152217720317, 0.5566955568516975, 0.4522164736888134, 0.39718092455813647, -0.21866906830596283, 0.7084577501818337, -0.18664586450257772, -0.6773204884944788, -0.31339119001025345, -0.3625335228791838, 0.10033735564965454, 0.03708948335103245, -0.3119501264028983, -0.48013383914284946, 0.02366364846476344, 0.32356784480044065, 0.5677339120151118, -0.8410790777442425, -0.47505699085746683, 0.1243085106972782, -0.601679065020852, -0.3013697963810193, 0.41663608029047033, 0.0088182325622494, -0.4360307506575483, 0.5939858939698964, 0.2727694207894572, 0.4515572871795256, -0.25236070414992817, -0.6610604882495593, -0.26848842056046307, -0.345848618416417, 0.756062570684837, -0.5162323273169065, 0.7234778623322257, -0.3328535137696018, -0.4137013138151922, 0.8345413577902168, -0.24284928334315423, 0.2116058213146688, 0.5317710939234186, -0.08728432711478055, -0.18106325369343562, -0.12324632301209883, -0.33224045721655937, -0.48448154959503076, -0.8191154107301578, -0.766646838169326, 0.10876890260156684, -0.011773532588045218, -0.20060157749668517, -0.5996409054021908, -0.4718240035651161, -0.6808532302270442, -0.4882485529935074, -0.5380165903538873, -0.11076406119400033},
    {0.4320945912635857, 0.14294913850003058, 0.34921124787074864, 0.7031138307053086, 0.612702382065978, 0.6859793270193065, -0.3632323044884553, -0.16240523261589201, 0.38354265504144053, 0.14872569004449812, -0.6602504937795586, -0.4692933720803027, -0.7300815059962522, 0.17400777358741734, 0.4763890920526986, 0.4654672572733793, 0.3043490132856989, -0.39008791239080176, -0.52080857779668, 0.7243792744792575, -0.032262226858773335, -0.0016076479720029335, -0.8202416834420665, -0.14665208130243712, 0.4309268326008703, 0.1619867609360847, 0.07664269456762905, -0.18624949567578483, 0.5456314000224028, -0.5489634262235137, -0.3319721647591048, 0.5904341876336797, -0.8405834134823283, -0.24513701084918454, -0.6299100166811442, 0.2977093257357339, 0.46716126106488176, -0.47760971585638173, 0.7524144985411083, -0.1979866520791283, 0.27713905336397615, -0.04130978987349234, 0.5434103458732653, -0.4996524336554336, -0.4914187226063966, -0.29483971480612403, -0.4401742676075431, -0.12041894318368232, 0.6628764122387535, -0.7429660539434391, -0.47662348877504135, -0.7482288549664595, 0.4980732936688424, 0.771683439607008, 0.6848205973274709, -0.21274234464384204, 0.26133330913172736, 0.5692811858693071, 0.3028250228591883, 0.42687120542833734, 0.9440595094283942, 0.32767576510021995, -0.5214491285629043, 0.6828714137764762},
    {0.44005541307475887, -0.3172129656249715, 0.5894692489182969, 0.6862529593441133, 0.28255523216744843, 0.4476091251695234, -0.6801064834144271, -0.5196057676279828, -0.5006858844239704, 0.37998677375716994, -0.5432455670142015, -0.6639425147333284, -0.517297600864912, -0.29390766449939226, -0.29503230137209935, 0.11134615016662308, 0.31328356252030554, -0.8914067933657772, -0.44843844716072523, 0.6543511133824489, -0.45028699164580116, 0.1121567032080684, -0.8470850274878354, -0.4814685030121918, 0.32154723803607815, 0.3380213440118448, -0.3268599863187323, -0.5764834487430828, 0.5681872447472666, -0.684421975711419, -0.1763531856651627, 0.4419295655784897, -0.4731662120576638, -0.26767644016062786, -0.641990273357395, -0.48135018620306586, 0.09582680992388969, -0.3710542244495581, 0.19258792549022588, -0.3501400731811653, -0.5213913675829672, -0.2954304548251057, 0.3311124811073624, -0.7958286013348947, -0.7922180672273044, -0.8996586320497916, -0.4703735953653153, -0.24183958200747763, 0.8154818061140382, -0.7941800024051147, -0.8184970003250469, -0.7041011760076366, 0.000912101422452886, 0.16631544014322536, 0.04117575699348431, -0.8116726319565098, -0.3359819337583386, 0.8456894909662904, 0.10414982627097366, -0.13857537079836066, 0.6641948486580642, 0.4855162154103569, -0.44683307883449086, 0.6054647260176661},
    {-0.22091562174071055, -0.6730708200437552, -0.357176167016442, -0.06436178831636546, -0.41320541385499265, -0.5741667062018951, 0.07463221087074426, -0.5080109450360433, -0.13314455617130236, -0.06803168393313933, -0.34699761818318064, -0.31823828475858185, 0.5266529784616523, -0.28197044435198254, -0.5826255385972898, -0.28735292281162944, -0.5632841202111485, -0.7465039094305749, -0.6351477676682867, 0.26707621490162387, -0.5892388573250081, -0.03753775597565654, -0.41209778158551336, -0.2372192622009688, -0.45779859657426014, -0.4149147606596846, -0.3665358400988026, -0.6121050835934625, -0.14461216602314775, -0.7890824506143694, -0.2902690721990523, -0.5408446762810032, -0.1767922602347719, -0.6535708066908077, -0.4920339522188545, -0.6475085345679266, -0.12946894399266975, -0.7692802184485305, -0.46061607456858816, -0.532403324443808, -0.7847500320833017, -0.09840559408921466, -0.2601667697380359, -0.7533640776324352, -0.46779481396372835, -0.8501794598403284, -0.7759019980983195, 0.38521617547081916, 0.129829539423453, -0.7020564838129598, -0.682340321240185, -0.6859479016972014, -0.44401808380306157, -0.4109209908227872, -0.1577583829249874, -0.4282838435732914, -0.3944694954494023, -0.025317072560336638, -0.43807087776679965, -0.7355628429560399, -0.5354131463558925, 0.006063269874497559, -0.4419945986297055, 0.06597652647388476},
    {0.3192383353385229, 0.05349577328330573, 0.5283251586167645, 0.9098519437704851, 0.7119517895401247, 0.4265501798955241, -0.44425526173772995, -0.2591095503288472, 0.196659588495873, 0.4000060177596644, -0.3645993601491191, -0.7735323609730745, -0.44488975821492943, 0.3448050274800085, 0.08309959021033092, 0.053919100172513605, 0.15939411834036463, -0.8019028466452379, -0.4184941570409609, 1.0869234039001243, 0.14310552376227284, 0.32958947927974946, -0.6728954832603736, -0.32477591976766373, 0.44573727135303576, 0.1072180674347068, -0.10715981410576723, -0.062422165613817956, 0.6002093497230392, -0.8065092231181729, -0.05063371139060672, 0.773765226095851, -0.5564292758141746, -0.5833966018417016, -0.5974009181677346, -0.4363411572743506, 0.22113914011459543, -0.3329816020560016, 0.5666162776412705, -0.5761741221528148, 0.2102166768355297, -0.13148156199371214, 0.4249731376695177, -0.48887319214728453, -0.3383652922891413, -0.5836974902570701, -0.5419449297857241, -0.3639399859522454, 0.6470509289773175, -0.5190962618839953, -0.7551011186386467, -1.0601176866005892, 0.23260879449243213, 0.38543910338981724, 0.8840296513168828, -0.19369115082680136, 0.27802138871254434, 1.0491747757073957, 0.6718412174816962, -0.015056429195148482, 0.9492400766424065, 0.6832149532091771, -0.4648985369579157, 0.7855835633518258},
    {0.13710476506569302, 0.19407288923395566, 0.4086098093541255, 0.5941478508452324, 0.4525626728667723, 0.3930646563280943, -0.06835720454362289, -0.41499914609421384, 0.09462508485007087, 0.3100779411675487, -0.20550537535338295, -0.31379326396263435, -0.26950616571472386, 0.37673740671210215, 0.28694075483755127, 0.25739449585247703, 0.34780694808760276, -0.40186966273439617, 0.10834741828466593, 0.6163252454984175, -0.23741922826050788, 0.7152068918169638, -0.5684908143584861, 0.06096678062933093, 0.7971923221854789, 0.3244894157110283, 0.1336641827466665, -0.5813599747889029, 0.750197215369218, -0.062341847017036406, 0.433398536373159, 0.7278938164942381, -0.7564680373529015, -0.19408351860290443, -0.223560578689614, -0.2234420014821179, 0.6453821997748134, -0.1919167733102355, 0.44451334300677636, 0.13375092784970233, 0.020747802493150752, 0.06961271648737226, 0.4972852288529111, -0.23794048238920476, -0.5112341164269737, -0.8398329375163216, -0.48484423774127466, -0.495472490582117, 0.7668265313553324, -0.5962487536500918, -0.6630089197337055, -0.9680914956937835, 0.6985007987280079, 0.01456785149986226, 0.43902278082569796, -0.2814221771694713, 0.2893594274350586, 1.0833463978016178, 0.8599302769987491, 0.11324930252652124, 0.5913152396701334, 0.6746636177147047, -0.08931905617895075, 0.7349796448254032},
    {0.228936408180109, -0.34014145121709266, 0.18364914237277646, -0.19812559210742514, 0.32018038560015144, 0.20426749051484977, -0.5534030121977829, -0.0571038198725705, -0.5115807825747938, 0.42007824770462754, -0.10264522171287482, -0.7732087119965817, -0.39773109851278404, 0.06417378207422601, 0.16983455262237213, -0.3764032834944348, 0.3396134968332584, -0.20828417369697072, -0.37432378334373945, 0.5508893274714306, -0.031487073843071325, 0.5758128814703886, -0.5222480874650474, 0.04885814411444847, -0.07696354761995927, 0.7215144974462758, -0.16728648984914168, -0.21101307742723088, 0.09449444806692613, -0.34613860515778966, 0.08232929837469148, -0.28654966034633716, -0.3518757977347444, 0.12828733324276168, 0.07405392892008868, -0.011264763643261316, 0.10480745538920988, -0.3009621104615927, 0.08826209889647547, -0.29815612805727293, -0.6371924475411228, 0.02676487351036381, 0.013165514117149668, 0.10899420747014009, 0.32969333248661414, -0.000923781552129526, -0.07184840604995164, -0.5214000017194511, -0.12116518633502232, -0.33215600349511337, -0.08789439228445552, -0.4350096536151458, 0.08984657391781979, -0.1264764681656836, 0.042339249668971644, -0.20128566341461016, -0.08338047693452444, 0.7627343537869619, 0.17081518231596296, -0.03443652318296863, 0.37166915407859297, 0.21334660222299437, -0.3123467828099911, -0.2978822720897343},
    {0.3360698068047208, 0.2256295966663247, 0.585646224241131, 0.4083058516291267, 0.6273012394716168, 0.6739968161050339, -0.18106785556969066, -0.12700534823882142, 0.2503530274053827, -0.07160404249736735, -0.27587573420704625, -0.586627115479551, -0.375681617462789, -0.13873300483869566, 0.08012877948587249, -0.4019172332541227, 0.17737785124032973, -0.32366176701511945, -0.389407161485072, -0.1146668662291469, 0.4173089039524236, -0.1902046212275576, -0.48667278792391166, -0.2635961691025892, -0.18156050371537313, 0.017510751631059484, -0.02725975554362642, -0.25106515230533644, -0.2816324657808006, -0.3417199434200239, -0.5216570164288387, 0.5053204333460211, -0.5620873387957304, -0.4585020906624255, -0.2735916476198793, -0.4668257749592346, 0.21503319994263717, -0.10452704403385957, 0.08846220059001905, -0.132051323747684, 0.23535046516363373, -0.15410872755135238, 0.36690098552750133, -0.12671025619022888, -0.5803317900829019, -0.19366182832252804, -0.05097797064492679, -0.2161955797108675, 0.13096171325412587, -0.125514772996469, -0.3595187585506113, -0.3624705450948164, 0.7112187981940123, 0.04361053939360377, -0.1706488481505806, -0.12217616788208302, -0.30907572981221754, 0.40258618311386907, 0.17549931394165794, 0.1720264003904271, 0.5797296894092774, -0.16260923632131954, -0.14752992252764996, 0.0017951678824360536},
    {0.2694273292415384, -0.6994975199900847, 0.2563781081086567, 0.5466444392098072, 0.9240481341581754, 0.7934859076292679, -0.5025554843655258, -0.33977110311232445, -0.7355995159515579, -0.6533871999139902, -0.27740002513175005, -0.7841150807383018, -0.5275717783274295, -0.6075829792564575, 0.2322491233161758, -0.21721802782887017, 0.4224615469301264, -0.3271206085381774, -0.5217758621410502, 0.19466153594797966, 0.15676829885663127, -0.3836869433789203, -0.6172404044779339, -0.5653965398551715, 0.6462947699143934, 0.04401975209726427, -0.24269438096108908, -0.3783521299133485, -0.04638356005062261, -0.6431120692974585, -0.5663761529088287, 0.3875593120479915, -0.6850234269215609, -0.21116095764776857, -0.23161369925946626, -0.23165731765920514, -0.19395400733782814, -0.3441585220215376, 0.36764407741928345, -0.4181833658048496, 0.11569310616022527, 0.2977643906601364, 0.7661734894711731, -0.4508251628729514, -0.6414285816267423, -0.3571363436279029, -0.21414759981329068, -0.5118607602857472, -0.016807800758136444, -0.5086258855473667, -0.16851851021573808, -0.3385226687535174, 0.5623576897067738, 0.3932653032433287, 0.3950004230198004, -0.5672273299420619, -0.5666562314853589, 0.8416073753472556, 0.46597562019745215, -0.13521003112350705, 0.7690737499974776, 0.14471764785221747, 0.022479713693866307, 0.8864664392155219},
    {-0.09540708865029017, -0.22286306141916795, 0.6884600354098243, 0.7991805401675561, 0.6200145357116245, 0.6867966297136647, -0.6311218569720626, -0.6288020446270395, -0.09384967538282676, -0.4277391623111255, -0.609146296215389, -0.396501420514752, -0.5453563187119512, -0.10497799626487579, 0.3333095349866398, 0.3333904845008264, -0.09478232743404716, -0.47925108704094443, -0.38141411648806195, 0.6038414799542678, 0.7589519330143506, -0.6550794844296921, -0.7232407587882307, -0.37967130202154775, 0.4003376227910332, -0.3475697812347336, 0.5349408425207244, -0.14153055508109338, 0.2966946403623801, -0.8201633184683529, -0.6067794069465702, 0.8243048749421504, -0.8905367385027928, -0.5373807463467793, -0.4810313889202358, -0.3046233467530342, 1.0393414602722748, -0.3797855158868272, 0.23206851012830992, -0.46596653597886484, 0.015224140260701697, -0.16700445248002901, 0.47475659654084945, -0.6293428115610346, -0.998996814880434, -0.27736331653412943, -0.6019153392324071, -0.5551385203576408, 0.5219587042997049, -1.0067130757640896, -0.3153147674780549, -0.30182143283499585, 0.8257922593192518, 0.49058041203789915, 0.5537653524395603, -0.38803579024758905, 0.27308151270193776, 0.6276520488076173, 0.43779376321530067, 0.31991494910937657, 0.7643500937503492, 0.7948635482691428, -0.26435327766402145, 0.7563267255705881},
    {0.5961601195258475, -0.6009745083548904, 0.5112113528786156, 0.30055884633445046, 0.7869543156454648, 0.6302079657169457, -0.2928638167428685, -0.023530892056327513, -0.548137005335734, -0.5256196635943658, -0.5408501951452497, -0.6810638890492362, -0.16964236523386717, -0.29395368235746305, 0.3170865540765206, -0.021649194097489756, 0.07104306725995851, -0.3325023316514532, -0.2505915501608887, 0.3392669196639113, 0.18114549485419465, -0.3783487271714692, -0.6055459609752428, -0.5798832073871031, 0.00763446346873912, 0.38689223769362074, -0.016472553441148043, -0.22384072375095945, 0.013173222846780198, -0.5631507511490844, -0.7363008491703681, 0.37632289467558794, -0.5966297728970775, -0.2086765977879261, -0.3767669067688179, 0.12384031200811352, 0.43877008730645156, -0.14700144331969267, 0.28185382690039074, -0.195537904161852, -0.4989764205894813, -0.24197766387474956, 0.31849849254445567, -0.29745247410918974, -0.35140681689875397, -0.28508121162465117, -0.41970641360982025, -0.1318452622454775, 0.23299343845152962, -0.3732674282277703, -0.005924452000502959, -0.26738880988238384, 0.4322158464598463, -0.21411236110269227, 0.07466700371688047, -0.740086379737328, -0.21247600231338795, 0.5911173675435035, 0.34389945378087616, -0.4896900386352063, 0.5655871172737086, 0.046906412445171096, 0.15911874369985576, 0.7239447312466314},
    {-0.1700659361638845, 0.06096312652817015, 0.42827453503376545, 0.24246747218831943, 0.5545132251758113, 0.5012593432869722, -0.6722731605434321, 0.17022230766114232, -0.1570704466489141, -0.7360272726390561, 0.04242919736389296, 0.1982090133638246, -0.21008809554783553, -0.054174055355588516, 0.17125932805232083, 0.17843804638082694, -0.4919528351292915, 0.1354066788974555, 0.3502590617396328, 0.044181518700166886, 0.8529985156975592, -0.8231314132101046, -0.5331926279921736, -0.21661069686874346, -0.295640812958309, -0.2698958173180543, 0.6297752616765665, 0.01843375823154135, -0.18272600154589322, -0.2383139726392976, -0.4292159549984198, 0.6506960583820415, -0.31942784556776327, -0.48302755409901715, 0.04850668500192795, 0.4080675958801093, 0.8760322963420156, 0.019871488349412863, 0.2847217006591822, 0.009616021400503048, 0.11379473568229065, -0.25313634219049486, 0.36806572767975254, 0.1992885476932365, -0.4472018564296457, 0.7817713335014134, -0.4326832694392654, -0.33113559065996945, -0.1758227626714809, -0.6008053084494093, 0.4408330310628977, 0.4206286473024169, 0.45030790867742326, 0.7480620767719017, 0.4066964968909482, -0.24812333589455227, 0.19531627759205333, 0.2659150825389021, 0.5182775489437702, 0.237728552632049, 0.294341237487383, 0.7157923567688993, 0.24758280491667278, 0.5241060047563105},
    {0.07100438871260481, 0.3173982391070809, 0.5662502426820708, 0.8178951411084533, 0.8086057883587547, 1.08794360107411, -0.3197300551729494, -0.12051912484197778, 0.33924892530097406, -0.5064579285208081, -0.3849115411599909, -0.2791825781671069, -0.4593571358162608, 0.15314740785486025, 0.6543538900081547, 0.015718867031607228, 0.6275992279806379, 0.4722630666409202, 0.4636479474433667, 0.295217984366262, 0.6469511532813254, -0.4040106198448696, -0.607947763813121, -0.3075249336964023, 0.5900446898245936, 0.09152658886032329, 0.6177059133983577, 0.5018235171819997, 0.46736320425873673, -0.2788090810705297, -0.5124994581088699, 0.5386314646883317, -0.36899432916814057, -0.18468644054611896, -0.4070773571650291, 0.7701135601662779, 0.4446847486914648, 0.19302739446045564, 0.6463235848173027, -0.16921401476041126, 0.8056326065027866, -0.4483733689330191, 0.7631715799758, 0.3333684124298718, -0.6391787475547686, 0.8331133388733244, 0.13042178487866074, -0.4190674078524049, 0.36036030894546583, 0.2115884607982862, 0.5060386353256657, 0.2706514713471642, 0.819616852940467, 0.8407336791892314, 0.6659613953890272, 0.36885388028047594, 0.3593837865463188, 0.852272912078928, 0.3326500020633418, 0.7172841854466578, 0.6743355971573026, 0.44657781725801693, 0.0844629069960438, 1.2243314016432478},
    {0.13487217676259136, 0.2530261352518699, 0.4882152580414642, 0.3465979832488138, 0.8929524169664468, 0.7502941428007237, -0.18168191546568993, -0.36902522348757066, -0.2719817868847786, -0.6915349073399194, -0.05055869477925163, 0.2726730393216866, -0.800178316271681, -0.6445144845966759, 0.4249248360594587, -0.43282557699689794, 0.66901349789934, 0.17384080143540026, 0.30010883604832894, -0.6278593339019622, 0.8254542255132921, -0.6691371844894072, -0.17117940263216472, -0.6818420198977834, 0.1020756144604615, 0.11103733312181349, 0.28027717140373604, 0.38714358010631494, -0.5175757192539268, -0.26721321721558383, -0.3507909950878985, -0.10211904964226787, -0.6463179352831262, -0.6029643439124746, 0.4521206669825998, 0.462113881211541, 0.25265589669472704, 0.20772485363682625, 0.5606257227185409, -0.2502071695309705, 0.4762140199704429, -0.39735217041254767, 0.3890474277154222, 0.33755893912271334, -0.46492405802101344, 0.9038531795102731, 0.15597357342299611, -0.32085724518487857, -0.536135636530599, 0.32612273558309096, 0.5273605126182407, 0.9719929089888324, 0.7205409607460861, 0.4968132264631652, 0.7123515928653641, -0.08648001059290135, -0.4644340796489708, 0.025854242870564523, 0.5778811293690647, 0.7189273187123032, 0.7276614512339464, 0.5756034404612914, -0.5826705282950566, 0.6142653676326424},
    {-0.5174005936879785, -0.1491796322733331, -0.16395784917575512, 0.3420186428377131, 0.6765518225228413, 0.6807198425812051, -0.627104467587851, -0.40104411492171205, -0.6770924183180533, -0.9915252991168295, -0.7265425958474413, -0.3614994805387592, -0.7812063067033957, -0.507116693357577, -0.16867378812968226, -0.21282662345885744, 0.6133282783113704, -0.8380307373621622, -0.16719002839191338, -0.3280863601602849, 0.7009407421751251, -0.6147753689253299, -0.3364028145950084, -0.8869727564109092, -0.25727617892528276, -0.6021660336040051, 0.12022378240461301, -0.006657129821717602, -0.3676257503636275, -0.4954270105564424, -0.21472528051016743, 0.3428799374403772, -0.6629336934088398, -0.7926271402021554, 0.046356780256805584, -0.510655196203878, 0.6804148386314735, -0.08502963653550617, -0.014034052367687825, -0.8538950206984788, 0.13286737928651496, -0.558408413525468, 0.4494317097417936, -0.5267212334291164, -0.9460242235540857, 0.32393715447224514, -0.8092837757049436, -0.14000048740780413, 0.07027833819446865, -0.5445564400510854, 0.12457221924059804, -0.01459749596041339, 0.3515071460880266, 0.8034193148513761, 0.5068737610623625, -0.906231879196537, -0.43761517854094945, 0.22156668335771304, 0.5502527810139632, 0.33503722540248465, 0.4795956774486001, 0.4366861822270407, 0.21068196522707588, 0.42199079076009605},
    {-0.2123165896558152, 0.20523459830796287, 0.14773971095881497, 0.25366411323209875, 0.5423854162748091, 0.4367193693391148, 0.129615692934123, 0.25076746027924796, -0.04264758914506514, -0.3220800714215781, -0.13660655624122822, 0.05906543605531277, 0.09026634443511425, -0.0037863097986999337, 0.35895619956291197, 0.11146375634090447, 0.3909884029737982, 0.5029037660591495, 0.5883868769998589, -0.03438686241850429, 0.16055937778480944, 0.09519152928190606, -0.14047936414670298, -0.05327491457701099, 0.21161456660090214, 0.4756635114507633, 0.9357482183732704, 0.1886452827646485, -0.18765607458605232, 0.05799915635219099, -0.4726850193594096, 0.1500329366652081, 0.35717039179913734, 0.28887520837022607, -0.12654297982944993, 0.8317647437407212, 0.44178487574494013, 0.24487125340180016, 0.2289324134345055, 0.09718280858678884, 0.5850360927003957, 0.310374183829082, 0.7297231294101598, 0.362958616878936, 0.22960281027305204, 0.9500465724166527, 0.7199054993050122, 0.1290493227751801, 0.27240169268217446, 0.46375363575746836, 0.426049181858688, 0.43129933785957014, 0.356008360948405, -0.14359640028247458, -0.0678642175099976, 0.21584562134885224, 0.0010430493729310505, -0.05298367092033311, 0.3216486992036261, 0.4776521390468332, 0.5676056260861733, 0.16083048580892478, 0.03267920232183047, 0.33902218163850767},
    {0.35458925503720445, 0.09030634597668374, 0.6307403322235616, 0.7223279082091583, 0.76182798799776, 1.0384615082985529, -0.7417213381110008, 0.21505678793383814, 0.012413430001879132, -0.33653981760814344, -0.3200898866116634, -0.2500779570691183, -0.7276930616893124, 0.12153996174499944, 0.649522588688309, 0.28139808198843286, 0.7824750508735145, -0.0897216759735036, 0.12201071041441323, 0.24271627016398223, 0.49579207377156226, -0.09204750034845054, -0.6363871881220347, -0.7309647433732933, 0.5639573895971612, 0.516507924694307, 0.9225918768260146, 0.503829607120699, 0.2680527262440184, -0.015709907350730114, -0.25898064998641557, 0.5740664429074657, -0.8257181855780318, -0.07990115818958322, -0.12451250145491273, 0.7718252618865978, 0.6201951690216035, 0.442415808210507, 0.8724773255156121, -0.2917983185310516, 0.9352144796005486, -0.3779567627120997, 0.7231934859561733, 0.17638663969314025, -0.7694452116968823, 0.47694104693279704, 0.08969030358829012, -0.5715527849283591, 0.5230738777284141, -0.22583654843482567, 0.12223442470716185, 0.02396029532114787, 0.7182289682891475, 0.7188651212842787, 0.61309669434581, 0.004759376331139271, 0.5376491183769233, 0.7503491082728868, 0.806499885906855, 0.8127501348621475, 0.5958276605353346, 0.6667262446178001, -0.3574273555979737, 0.7209947213560552},
    {0.33480130127021673, 0.3409625385941553, 0.18164932693727476, 0.7876527450646926, 0.7671605747398773, 0.7016564882135049, -0.32317085930114386, 0.3499873209417659, 0.06625946986332706, -0.029125134446033273, -0.2572203422372441, -0.12739679401300585, -0.5686050706297894, 0.3084148837508695, 0.31846717669223906, 0.07477481687667929, 0.43101642218827774, 0.25733009397297485, -0.5158085300612923, 0.6935524797267496, 0.4293510887116943, 0.1137198646851974, -0.13541273582094587, -0.18629733383967997, 0.8381092185539767, 0.5631038482762117, 0.4635860976776945, 0.3200304980682326, 0.7734011178387684, -0.4180807599718585, -0.22989126015365152, 0.4157953055076101, -0.24452367848169113, 0.002277279961832849, -0.35556350528784014, 0.44443686680197586, 0.5822516554449699, 0.05004256588708477, 0.6596325323864288, -0.24710425032532501, 0.4286502492015095, 0.13132100733025326, 0.5333196268704721, -0.29861307035976736, 0.095447968464341, 0.5315816704944143, 0.00942329801529898, 0.06820278065866253, 0.6420131969371039, -0.4953371407764524, 0.3836772533123874, -0.08319933078895214, 0.5103902366054753, 0.5810000527778594, 0.5620388742180957, 0.057748352377803, 0.3889452955024793, 0.5687823289485431, 0.7905867539871616, 0.5938956140630649, 0.6194420303390828, 0.8318731099412724, -0.07803129127604827, 0.7181663101316246},
    {0.32568695150101484, -0.3800612618801747, 0.41704344075803385, 0.6842102023191518, 0.5422679838408473, 0.3050061365405356, -0.9963949975770321, -0.8740813672903892, 0.22156315321121617, -1.1774703734758931, -0.7954122264370103, 0.422193419433634, -1.051129787804235, -0.8563968486045979, -0.25179688974205683, -0.8753906824659712, 0.1849679306761557, -0.26170859031427735, 0.06639479169452808, -0.6373741682911301, 0.07497414419507886, -1.0213294159731332, -0.6576058069751258, -0.7512922620377095, -0.28795129552555276, -0.05696117942296191, -0.10419294940145783, -0.40490838767847154, -0.8661516686955864, -0.09280049005726959, 0.44306079054277797, -0.738436416734871, -0.1916915885666884, -0.7744304757182187, 0.2956234883156207, -0.9620996656575445, -0.6181754947024239, 0.26311583763376833, 0.13033136285575317, -1.1833539941566829, 0.4869210464795302, -1.0682575111545474, -0.8963215291704048, -0.6971772554630701, -0.8585544924297172, -0.7331730186603441, -0.5443194367413973, -0.7476453840714521, -0.8096090682400852, 0.4257583744161592, -0.5249699603060282, -0.375096336075291, 0.3502205907692159, 0.589102237807615, 0.0661527437297395, -0.5303689124123963, -0.9350529445133601, -0.6713916909526931, 0.7026711564938842, 0.39602644138090104, 0.38128115467831986, 0.4057623786853808, -1.1151888455038181, 0.0361372870334592},
    {0.2309622297959449, -0.262473868003035, 0.7703962790721095, 0.12591849615255463, 0.18354044797441454, 0.3472097273835873, -0.6290302421434084, -0.6851425287670586, 0.2071036606941295, -1.0081118207027127, -0.3552845763926761, -0.22329677881793142, -0.9871039127532866, -0.9083016546449623, -0.41242080499306066, -0.8321706821668656, 0.5155405204150746, -0.15160049793423577, -0.18273536037200247, -0.820450089186227, -0.5661744203497922, -0.5533558488382423, -0.44638241341613727, -0.5926436318754343, -0.10136299798164111, 0.043263648146879254, -0.0949350509531847, -0.17557887047658777, -0.22774159325185003, -0.2979698539377997, -0.13569080658375846, -0.8007879636401048, -0.21602653767225766, -0.776277329174115, -0.06735757757982024, -0.8643699915124802, -0.876701834886531, -0.15967081596270882, -0.1703353991305022, -0.6764920601411368, 0.4606469596527939, -0.5386101805851474, -0.3939701524419561, -0.5799217119102588, -0.841282319484092, 0.07596989319425887, -0.5165447334745821, -0.8083187502074775, -0.709133478845422, 0.15154761054718943, -0.4167834063793642, -0.17597602968568907, 0.5725347303802908, 0.5985693704959044, 0.7383670428904447, -0.36933863551218055, -1.0228457603410521, -0.6056066001294366, 0.32765576412640707, 0.7001333811389979, 0.1611073107417974, 0.5551087182362268, -0.962442718668411, 0.04942950033700117},
    {0.5831118117295944, -0.6957358482333713, 0.6229428314479136, 0.3272098803123883, 0.09133497372230524, -0.001742933525950349, -0.0746356781688816, -0.40664881941373715, 0.06320595198213012, -0.38445855606248597, -0.2285058342358882, 0.1680910126349437, -0.2704111969116304, -0.551285231063847, 0.20749964291095602, -0.7114836993395939, 0.4045429659844629, -0.23537068156557628, 0.4234483922336812, -0.48346093433246184, 0.19921882640700456, -0.02940224642685606, 0.05369100314400827, -0.2631037914283429, 0.3438570300397712, 0.049582437633214016, -0.08308648690863907, -0.02817704240160046, -0.6325652321803663, 0.2745224308061444, 0.40486319189446873, -0.6221348709787285, 0.5821301170395055, -0.45832441838326676, 0.4409972838247482, -0.6358464461409358, -0.6510953349888724, 0.18455332153305282, 0.04756239191394129, -0.31024225500604313, 0.2749878403361918, -0.2708515508658183, -0.6111351932169896, 0.10959213179480996, -0.6416935955384561, 0.17341635858009305, -0.28634666564431327, -0.6631572668694631, -0.6771300916906574, 0.5566054068559998, -0.5169938307995973, 0.10465920115834279, 0.19573749339816823, 0.553239953747935, 0.305951475716782, -0.403910390330484, -0.35819674525477524, -0.27653103980769395, 0.4660389065944966, 0.5898142017488983, 0.6035582494871019, 0.5092522700155883, -0.45328646534932704, -0.297989042399758},
    {0.48899599030239055, -0.170213579885014, 0.5098437683162402, -0.2710151214074159, 0.22234665330351164, 0.054274664627898254, 0.3172080075997233, -0.3200522368297488, 0.3210880557476078, -0.38743150914097885, -0.3422926033802628, -0.01587252032480372, -0.21084843498296235, -0.6052503719567008, 0.651935567451232, -0.6553710274056287, 0.5430045973937433, 0.1746707221875214, 0.3047433177527588, -0.4898104596375504, 0.21987253201512383, -0.32630286751247306, 0.22576227086956846, -0.18707909410765808, 0.0018344279685025902, -0.039746186530523184, -0.16048499100440328, 0.2082007415935368, -0.3932867209268148, 0.16129541102298636, 0.3404972899890267, -0.7051611314258046, 0.7867801884961134, -0.2246428880553652, 0.6107277285867093, -0.22928723377690635, -0.9946891175204992, 0.3096270769305156, 0.23777873276541683, -0.533825542923595, 0.2815828301368944, -0.06731511600291326, -0.6082438485472499, -0.339084495341407, -0.1790571666884947, -0.3593171492703434, -0.21197562947966953, -0.5050448884407679, -0.9250576898462165, 0.6999266262211842, -0.07381940151837793, 0.2919421289801124, 0.2868324206403411, 0.561466963766552, 0.6130105135724372, -0.39880522973529575, -0.7257159370248621, -0.10331814764620063, 0.20181429501513004, 0.5252878815195187, 0.30499683970268965, 0.2028505435581421, -0.10968420359139144, -0.2326384694936209},
    {-0.035352939800625614, -0.3878432882084909, 0.4167993719144348, 0.4699614302727755, 0.6010936005619674, -0.03217921234798153, -0.553614163216434, -0.2992624212238408, 0.10108256195531352, -0.574071002609484, -0.08381611384920773, 0.29529664545862594, -0.7889331145449131, -0.3072338789116261, -0.23912490967535777, -0.05583994240864111, 0.6630644680631724, 0.26241972220219095, 0.6215155725713846, -0.3749397317708538, 0.13300543812590288, 0.15646860018750894, -0.23787837262122102, -0.3901120113496134, -0.046783102336286145, -0.18720283784194441, 0.038685281364348074, -0.16696381367706298, -0.20828829422164735, 0.2640354970507377, -0.05066883818163889, -0.2835577410237809, 0.16226389408660327, -0.6590924110794919, 0.724098984123314, -0.013982457264359798, -0.31802215376475595, 0.25799373796521663, -0.4898867703763487, 0.25178374469223397, 0.6028788452157416, 0.11118377690731195, -0.11840792293348736, -0.09570436876084003, -0.17521013105854932, 0.3425429057170185, -0.28712000459051196, 0.039933689262548276, -0.3126164057319212, 0.18603873101025098, 0.3078727008583684, 0.3239031080301766, 0.4557801964071136, 0.546487586755749, 0.019607087320248132, 0.036161121202132676, -0.4559843653569695, -0.47808003824094814, 0.11039790105405943, 0.44273874742899993, 0.3065045027619996, 0.25565766995919315, -0.15404452595111084, -0.6645278120274812},
    {0.22666968822288966, 0.1363661365354693, 0.3056689099267018, 0.7147782489783231, -0.16121491826673887, 0.1738057177778817, -0.1905633536973141, -0.5160647190080544, 0.06289249767510012, -0.577905289622177, 0.46420261426163084, 0.5905793697929632, -0.7738097393581288, -0.29566205310274146, 0.29526510352914104, -0.5955687562112141, 0.31944599395607975, 0.707980478875302, 0.43859861181066195, -0.3601816052962219, 0.3004715875791786, -0.8299593837442119, 0.32857028743353067, -0.5833887514815854, 0.13387697832100784, -0.022361718242147662, -0.13628671186139268, 0.40260463500098176, -0.42024594698324896, 0.6123967941452152, 0.011090462320589783, -0.04504763878872707, -0.19392835566115635, -0.7338419615677518, 0.5217104762886574, -0.010654868875621549, -0.18936369704167066, -0.3796317081092829, 0.10076047277394216, 0.47271529015518765, 0.14892349297169216, -0.2391293155706972, -0.4388971270871259, -0.048999692424877464, -0.32584909371252646, 0.21092180901336702, -0.45693625166835594, -0.4082609459003712, -0.5458791808314818, 0.5752312326528635, 0.02614904866353237, 0.22442324140001063, 0.7016090983583071, 0.6992571959281896, 0.5524136336237806, 0.08809833591734356, -0.10307148759033248, 0.24060701233489248, 0.5921200292138729, 0.5989522800709755, 0.1769261790399067, 0.5199062402642262, -0.09274234946181677, -0.13184760383795832},
    {0.24004384382555038, -0.3327387248885159, 0.711953820563885, 0.6041095484195317, -0.12386053806480693, 0.10577479703024015, -0.08060077965076395, -0.24310642067502963, -0.5247068816388447, -0.045745703366922325, 0.17797072379801063, -0.04889213007025756, -0.5472945328249161, 0.0203185118080632, 0.4901986909404201, -0.2530352398573361, 0.6525520686764316, 0.1511153081462806, 0.7199812899486652, -0.4102763927862559, 0.009773412773297319, 0.058252567472339443, 0.36345587283760933, -0.2277943976647304, 0.13251140826882377, 0.4460058503308452, 0.10586158500993735, 0.2977884993902835, -0.2455108460165119, 0.2330579368044125, 0.20229876578556388, -0.07716522024867452, 0.5385845883648382, -0.22119044080127537, 0.4716756700921336, 0.027567718214657835, -0.2729191743246174, -0.12445551032539183, 0.19739086104929568, -0.022429379571166363, 0.5112902389671129, 0.06504009959443113, 0.4442962522382394, -0.13288130354104594, -0.22802686638582734, -0.08779368448702057, -0.5200513363075485, -0.6260969533599143, -0.1072918253415767, 0.6543414992664617, -0.318430504969237, 0.2545732279238541, 0.49398243279875, 0.8710297625323428, -0.16687098868717193, 0.2623681956963749, 0.3503620270076292, -0.07040229110185908, -0.01674216440779293, 0.2994103468527804, 0.3687541532454892, -0.2500876551335146, 0.2296551342513905, -0.25795607120257513},
    {0.4235000969928342, -0.24148294502916606, -0.06950772840265207, 0.8445218748296799, 0.3955007189545395, 0.3254001120405155, -0.209063834934169, 0.30435695807494034, -0.2769482478482512, -0.4953657557609102, 0.3115387484010545, 0.25484630174482, -0.12089786695024958, -0.16513820597031384, 0.28769260585818146, -0.20333002096151906, 0.8406694554617657, 0.14665687132310834, -0.03873720216093671, -0.25489050946585207, 0.2876866604983999, -0.015262464403040663, -0.44933450953858406, 0.019047790629346435, 0.7951205852664243, 0.21784997390242217, -0.24264202723779965, 0.4122509356384087, 0.42404860450888454, -0.09449265920676, 0.41355448524620336, 0.09769693798558923, 0.11213758465988552, -0.0073656897754291765, -0.3935961758654202, 0.06710225796760756, 0.3383751019250768, 0.12800517311927562, -0.07047397463653482, -0.5087396156102683, -0.05243879812838307, 0.0390978611710439, -0.01084767640800892, 0.008818272738145207, -0.47276607356146744, -0.11553670888185529, -0.010452007290924787, -0.2443039489277121, 0.15990727657070286, 0.09570610298101162, 0.1342510148305832, -0.018024599065306405, 0.5333563247336423, 0.7571674457410643, 0.5239441058386957, -0.679204714382016, -0.333833474077529, -0.1327301978658919, 0.7774966295876566, 0.5704247435261063, 0.11059180637008796, 0.5331960271418347, 0.38563795302812176, 0.18153833716050546},
    {0.4277482654609445, -0.6860444731241381, 0.6561634220138051, 0.6181433026476506, 0.27745187490114254, 0.15494542191222457, -0.21906285273512072, 0.013696086096915198, -0.5683229720473026, -0.9709971441180473, -0.19948762065058187, 0.5187834300541436, -0.3197215291996031, -0.37735943759305735, 0.13115908654433311, -0.5868928811345194, 0.6274548862302737, -0.2658290757354425, -0.1638086286842147, 0.26133583905941377, 0.5009638220889441, -0.15111709930824754, -0.7257809858634928, -0.04722041500050819, -0.0022123523882644444, 0.31183994276715726, -0.449969689953394, -0.31218241193362567, -0.43131718785469164, -0.39886869907273204, 0.003782214331720946, -0.3227495161929795, 0.022652613824840805, -0.3418365910673204, -0.5800537120780831, -0.24397103194723083, -0.5681052891246551, 0.25427711882310056, 0.465249356394529, -0.8003599949302737, -0.23461565165180243, -0.38237295654862924, 0.10716182752837235, -0.41008729352707535, -0.7651441026299431, 0.07034932081321917, -0.14260684729144946, -0.42370545890644357, -0.09505742859886629, 0.1266735828920997, 0.2468762510114754, 0.14611272988709964, 0.33034579903200256, 0.42473507300364616, 0.3369374863278216, -0.47838972948037284, -0.2404451054510253, -0.1495802773421827, 0.14123823284372802, 0.4724134346009286, 0.433216775437199, 0.8482433738292144, -0.478580263852632, 0.2571331599698182},
    {0.38838971005101114, -0.25515258853467154, -0.31350033625488316, 0.291877070790072, 0.2951483836420228, -0.12962011162942685, -0.17876015806020473, -0.7891757894439647, 0.14675370105155794, -0.1037247604269682, -0.29127948311036406, 0.3816865751954183, -0.10600379239801036, -0.6921334157558319, 0.4066719161589909, -0.5223165007700504, 0.06886462351207077, -0.2346593290770942, 0.14098047790378268, -0.17105764533018758, -0.6912468645042789, -0.09113950139014362, -0.20229761051901646, -0.27298656856237025, 0.18773844479974477, -0.14938770835825926, -0.3022346556245271, 0.24812495525204997, -0.3363332533634961, 0.32741490539104057, 0.37984289589533377, -0.18382294650266454, -0.7981485777807957, -0.6685946766744508, -0.31472481099376776, -0.4604907077599095, -0.4589240849529555, 0.3102370260395277, 0.019630370950340918, 0.1005128008176947, 0.44158779643505897, -0.44749275838954505, 0.060907211434063885, -0.1418426072322128, -0.17150701002869184, -0.08134757888424159, -0.5726289904185683, -0.705476518032812, -0.13376492541732543, -0.1274130310190632, -0.05734260795800207, 0.34276085946260904, 0.04038329062419751, 0.39208527378830166, -0.3274318514402264, -0.037530173669458204, -0.003420200486783479, -0.2018056005952583, -0.0994915460403762, 0.011731679749688365, -0.17060259462960997, -0.005557755995463471, 0.28279706154615813, 0.09696874945934507},
    {0.17149181871708588, -0.47122105813687853, 0.6479338830857132, 0.08960361234054884, -0.35676800850827967, -0.18545204064370985, -0.1734975182946038, -0.33789718574405214, -0.02702832995814996, -0.3623105937922341, 0.15934950025165898, 0.15921727078242182, 0.4276925778695351, -0.2598887616192925, 0.5232743692963127, -0.25386336753543176, 0.5551577670294255, 0.18812721971620985, 0.5417926028495632, 0.08015130354118095, 0.48413816305819746, 0.11268236551655188, 0.40960575751986056, -0.06849300893817717, 0.5831069454204992, -0.13022339541785408, -0.5032381264269947, -0.1278602686053135, -0.07386358414602982, 0.35647781828711844, -0.05714989321902029, -0.28983055223830556, 0.3707242396906103, 0.07304956463195324, 0.5222210063397703, -0.11668930340228557, 0.07342450447715392, 0.5805505568486975, -0.04442861231143281, 0.4042783371639699, 0.31464918324833335, 0.35969399025015497, 0.13156827506356258, -0.10507199095527103, 0.12937219924682072, 0.0003683689235860809, 0.11045687821623028, 0.32737565754889564, 0.3548980983257259, -0.35925888562467956, 0.038388574028906754, -0.04524358527504973, 0.14615573795300127, 0.2386610567313018, 0.1637041725599009, -0.3311400012108359, -0.8998814335883989, -0.35385444121254206, -0.1606694766163738, -0.010834918499340656, -0.49536630332299236, -0.006844072114193602, 0.33608045982542256, 0.4746885489845329},
    {0.24776581621766477, 0.24494544486722972, -0.3953288598288995, 0.07079722521263702, 0.1442127572860831, 0.4189579398526673, -0.4649904786195704, 0.03278559427096908, 0.10519042597734955, 0.19944195318344418, 0.23668794070485927, 0.5564301019593662, 0.2371177606231728, -0.14924693792984753, 0.31807645295036435, -0.6760189375547818, 0.3620510868371714, 0.3906918404227825, 0.18764491617254697, 0.12920972874162942, 0.257441279908973, -0.06516755441654336, 0.46666427925887766, 0.16936889756688897, -0.16357122571860505, -0.29052083135542744, 0.18922794261246415, -0.04635448209251631, -0.16645972615747248, 0.6033529493263283, -0.359252083310623, -0.20975273094453695, -0.3216175080413114, 0.3142049904094218, 0.39521896497830356, -0.20884919297318277, -0.025595783913150795, -0.10541319151403052, 0.1479147732364656, 0.02365995275251882, -0.11441001569273504, 0.2594050331471523, -0.5325274128795976, -0.2341773315122095, -0.27424640381382154, 0.3555551163519449, 0.4058776672331693, 0.029341744170703257, -0.37724186811329824, 0.4340255510732577, 0.3540178447135753, -0.034952804229781684, -0.6068904725168366, 0.2879816668549023, 0.35105450035149227, -0.11518115761718932, -0.253320511057993, 0.3026150189202979, -0.5427463048009731, 0.30710326270660065, 0.009770591005317233, -0.3568934779758988, 0.0429855489375484, 0.4943650011209949},
    {0.015607434421410667, -0.29448990356792476, 0.2872789120456006, 0.4946993533816572, 0.04983873410848728, 0.27392606284886395, -0.5388872684764752, 0.07681151841295433, 0.3820366824497891, -0.24478361324332643, 0.5798435051300407, 0.4570613831187572, -0.3134594510675262, 0.05717498688662536, 0.5816265001814396, 0.43736192108709937, 0.5799036163760338, 0.3693799780649346, 0.5039161982249215, 0.23841861344603985, 0.08703665196634171, -0.05266432555001096, -0.5595709838108119, -0.03680221152747299, 0.2965290166184138, -0.2523217093374369, -0.3886904951223404, 0.5180101166728631, 0.3400530561466489, -0.048806622362257926, -0.19430950499241148, 0.2307238736279598, -0.24791753261676244, -0.12353696694209515, -0.6149071132507125, -0.014935926083236935, 0.14678860566462879, -0.013603547953608726, 0.7795477350296591, -0.6178570103137028, -0.059066982553615636, -0.016508708459773445, -0.06024203498648443, -0.19507203777624257, -0.3523373794322713, 0.4578422541923687, -0.24297980905320057, -0.27758750446852787, 0.17182615271038806, -0.3862831382312809, -0.34107427804025814, 0.43314255802345003, 0.23897740557833966, 0.7238344412170247, -0.005501913905608504, 0.048864697665997395, 0.38110205713744016, 0.07569163680708332, 0.4753785521280821, 0.23329875437332864, 0.13130953692314076, -0.060188645488164876, -0.46567203613886, 0.06331040153032995},
    {-0.46663336769511876, -0.15977062676006495, 0.4456084753752936, 0.28753737400826834, -0.3397235057561769, 0.28927619137769184, 0.1468315851446639, -0.45018011217687093, -0.4910836377043664, -0.17110333057538887, -0.02376082848882472, -0.07683520020335635, -0.00015221418351278785, -0.579745339114066, 0.01798095030607295, 0.038990475415225746, -0.18229301475832235, -0.40422875912035894, 0.12097449905651543, -0.33405732434123886, -0.21975373361653108, -0.20287279195869215, -0.05371960800121483, 0.4178744011645573, 0.013255686329075174, -0.5773998207755616, -0.5985857173155164, -0.06406859716563378, 0.614775424708677, 0.11236458414459151, -0.02841466269182229, -0.04155037182936945, 0.43583141338574455, -0.39131580348965467, -0.2995181716575939, -0.42735171626602736, 0.013964561620951754, 0.37098991389564345, 0.12546914497828898, -0.12283812346880388, 0.23402697560655294, -0.5539758955801563, 0.013097679540564733, 0.20104394428752762, 0.3122289798437258, 0.04443701908556536, -0.29544976975148934, -0.16488473565969342, 0.028650762276590275, 0.1805499365255991, -0.388023200187, 0.09074074603411496, 0.024301527912864416, 0.11511217867113388, 0.033660653523076234, -0.45808585332826646, 0.28150342045555915, -0.43916744656653967, -0.3481762097276392, 0.13445728161145082, -0.22218655443866778, -0.2127356560426165, -0.17100171539548878, 0.07645701881717532},
    {-0.0930836359605289, -0.16812068556397328, -0.051180715174594674, -0.29550556921827964, -0.331402513388317, -0.005834828279350502, -0.17431828176131603, 0.3652861854900763, -0.1480157829221728, 0.08982345367357382, 0.17036153876367832, -0.04920902804860803, -0.25902679073043194, 0.19702745554909934, 0.1238390309045486, -0.06423044719702652, -0.13984573751798496, 0.6857353158908014, 0.24885166529993627, 0.20646267496864143, -0.1049034764895345, -0.09767556526151447, -0.3922718748440244, 0.14519231316257064, 0.125878991269735, 0.2321312378414032, 0.1937720585706167, 0.39398225386497376, -0.28023132448115223, 0.006219800004387092, -0.2428798875825672, -0.16789073278677757, -0.34136758478908147, -0.0830712434806048, -0.5258501708188194, -0.3063550229185263, 0.16034023618077367, 0.1299390531294585, 0.6787049834204457, 0.30675240105469787, -0.1492091161971503, -0.1772224020416079, 0.03421676386935784, 0.41854212189613554, 0.22883917810452828, 0.1689089437244196, 0.006116058390289672, -0.49143561631663774, -0.11103502055932812, -0.033734636200737286, -0.6443588409015538, 0.5494108425984697, -0.04173731108289319, -0.20942470473757152, -0.11395722505447199, 0.1411530721478064, -0.1787976212530708, 0.08835237975602268, 0.2760841181312095, -0.21937133693126679, 0.08888056655524765, 0.5188990936223988, -0.1488719232849511, 0.03009726634529973},
    {-0.36103264186956835, -0.013615342455019061, 0.4662253194271651, 0.392759906009892, 0.1585533026089406, 0.33535569459028436, -0.004854437521973198, -0.43827090924195233, 0.006948462450908429, -0.5190811045113133, 0.014061140986223986, -0.42540764969012446, -0.037005240091630004, -0.11547766941742413, 0.2787295400377039, -0.16155695893939853, -0.45892893963522063, 0.1371386590619546, 0.5903963118235197, 0.11713302664119951, -0.05454543950041864, 0.09470890082608366, -0.18037154880944262, -0.640087334764421, 0.2948752051499321, 0.48039730838649414, 0.050069736216758656, 0.3023064866422565, 0.26197531467101953, 0.3415586550803031, -0.008932683735298298, 0.30508337749672987, 0.0352866312834989, -0.10958500477677303, 0.10827461946830995, 0.3080377152376316, -0.2956340361511525, 0.3433577921368532, 0.22168891669540197, 0.2271840972994351, 0.5456623306301238, -0.7635980760063771, -0.22133518294328128, 0.030915857399776186, -0.5316073096595403, 0.4265461871817501, -0.021619966774938968, -0.1472783069144309, 0.067935114756927, 0.4212073286784797, -0.380359579958023, -0.08291068300091112, 0.231729822901655, 0.3953668616472307, 0.37830207429481805, 0.3603011701399486, -0.2633434316639288, -0.1956748920488264, 0.012843183933729945, 0.6217488726873296, -0.19962314697848293, 0.2641882777854637, -0.44720851556288105, 0.2287939627789667},
    {0.07319809718137936, 0.18690528542955814, 0.5911943844188462, -0.2973837684233501, -0.41069850368799804, -0.4810584966912492, 0.2164435968261529, 0.20645453036204486, -0.06969776280211235, -0.21959677519357737, 0.03765000530815979, -0.7832373744005913, 0.4149401396374918, -0.006436485214525207, 0.5081656510951523, 0.34631057355707523, -0.1493624255999379, 0.40191553720660694, 0.1095944121558747, 0.12359534300201619, 0.03151070843208053, 0.14928280815907125, 0.20124192109946806, 0.156371973229626, 0.6323500035347545, -0.008646593311647126, 0.08411327197381309, -0.4979598877001069, 0.13951901393421118, 0.19845068097768553, 0.39274759975311474, 0.536206740795556, 0.275825693257549, -0.37879445108601717, 0.3145445076005497, 0.33867821116396346, 0.2194939687014588, -0.4490096263733738, 0.34594880781072324, -0.023261009833126685, -0.022252624684343535, -0.29937851852045605, 0.3925695337890743, 0.1576631429723962, -0.09059645921731221, 0.2415229202030619, 0.26132827314768275, -0.07821527002972381, -0.1714864000116372, 0.38139219140967484, -0.15250920796460118, 0.5642505141609014, -0.28860829424137935, 0.03273461677003977, 0.25685743239769154, 0.2887908812258082, -0.023997792370453342, -0.035005082538755, -0.8809851358354543, 0.44995102603304754, 0.15016447482749468, 0.2709218011264867, 0.3926214632773838, -0.20655111463053705},
    {-0.01777428600271049, -0.5812987873020724, -0.5832097813921059, -0.25669183112478666, 0.00409152358613665, 0.1901131944894312, 0.618572580421596, -0.027249598067080143, -0.9179947366549341, 0.05602789723517598, 0.4382023349257245, -0.6840896711389546, 0.08642240219926718, -0.23063255784090908, 0.9509859178967067, -0.6840346227739319, -0.17516368700568033, 0.08553607670472539, 0.20913889324061194, 0.06763748051280219, -0.6877023289767771, 0.45136345197477407, 0.2642524252860665, -0.0016228661042472375, 0.28575430631561594, 0.15032874514331582, -0.39227928401651235, 0.2415157503406873, 0.488257955451594, -0.05523698793158001, 0.23148927364002467, -0.16772916035695598, -0.15046085844225063, 0.36809141994362826, 0.22217873871927307, 0.2931291363884175, -0.38324359478671854, 0.5251708056034469, 0.38875355525312066, 0.454160321539765, -0.19796458169133252, -0.54317490754229, 0.039991588431847434, -0.19457632648519194, 0.2957998803174855, 0.37374699722109866, 0.3184982706430505, -0.34988440021629186, -0.02560720545617628, -0.027590075637804717, -0.3809032446405206, 0.3719033197981796, -0.15281994640328853, 0.07015196050772908, 0.01497832257357418, 0.05723311557401884, -0.16358139532553181, -0.10666776824091893, -0.032730209332038705, 0.08121388167062561, -0.23535717359334338, 0.5556430303652945, 0.37830788290221967, -0.05749851164080977},
    {0.03863356181459794, -0.5317025389520658, -0.13830212262950742, -0.41231642573950494, -0.34732632660805757, 0.024190361213849914, 0.570655730135833, 0.5104107104573367, 0.11901387789097832, -0.03445007721826735, 0.0673118315963399, 0.5127323672479013, 0.33933084248704304, 0.19688154986434872, 0.18590543458882297, -0.45484303966979367, -0.06184008412178052, 0.3934083124511894, -0.11508424622180835, 0.020559077027106444, -0.5717501962380019, 0.22963856987532827, 0.2825632407897269, 0.1788202778539075, -0.1808474200774046, 0.06813459554369672, 0.06185891218179813, 0.48077797871964845, 0.050968194740012886, 0.34012445439527106, -0.2421478769711177, 0.04231525305866422, 0.43415573366880605, 0.1513548257955125, -0.5404339412009397, -0.222937219345387, 0.132072512514451, 0.44826316945629185, 0.24184490652090432, 0.49746838165185353, -0.30746615119434145, 0.06590913740106007, -0.675990367803293, 0.390161770606701, 0.11837004095905368, 0.19976618383499312, 0.44612170434246473, 0.37028576551229886, -0.34841019685621183, 0.3831346178991478, -0.6673653412449947, 0.34858763300757806, 0.035597214690256396, -0.2644223812165716, -0.22231966619096563, 0.6088096418847249, 0.24826706245423077, -0.4535551932880749, 0.02433460378207216, -0.022727325748746464, 0.04849908267799302, -0.3263095560078581, 0.2090787616098161, 0.5160714403724201},
    {-0.29005168209394017, -0.42300882032130166, 0.32297695361943235, -0.4979608404100082, -0.46278004749957796, 0.12377663558081746, 0.24397464136672645, -0.011870066215158253, -0.5121814260626072, 0.08714381853078737, 0.5588709390318152, -0.04980938935721783, 0.12924310909367992, -0.30179645918674164, 0.22349757853929392, -0.1373003094520983, 0.14119406392491474, 0.09210311424911476, 0.25398572209578346, 0.30015826086991015, -0.6925258977295111, -0.3086021797272094, 0.4055785459156768, 0.24742653384298272, 0.183700220244204, 0.3684771586788765, -0.10297738062369509, -0.05532121926752602, 0.5755794440916253, 0.5310883073003456, 0.17692183197782743, -0.13478415911702182, -0.4177870433327304, 0.49447062544497916, -0.28015600140939245, 0.6990782493764516, 0.009181500305727983, 0.5650607956550278, 0.036771295879222426, 0.5588065651163218, -0.39489208116275576, 0.7988888979778346, -0.12835606978687417, 0.6392969662826875, -0.0028357165179401776, 0.6272325931533751, 0.45746461314188824, 0.44122127224092883, -0.7494591070920259, 0.33840338269256665, 0.0941105300982612, 0.4042127116668191, 0.21369191798763937, -0.4364223814662047, -0.37602024572897336, 0.018699096541844675, 0.06386703733346161, 0.1323358066685675, -0.061741933676657375, -0.3749386901958622, -0.44872803359002333, -0.11099969741731183, 0.37839811625486935, 0.09131759269015398},
    {0.12893643475766775, -0.3452515315162526, 0.5903900880035005, -0.40639564978602954, 0.19521755933877658, -0.10266268010726298, 0.5349154537090646, 0.22413688692815997, 0.15695948413756186, 0.4239651444037615, -0.1813041834017855, 0.006252742612878934, 0.24358252319890378, -0.12905737439517093, 0.7535886330316145, 0.03910889035164183, 0.2524674332230561, 0.24191065324977984, 0.055067499800075755, -0.15155236219628251, -0.6816148371396425, 0.6430812171615193, 0.02616050404249245, -0.6022322232554472, 0.08259650802748321, 0.20220120020460883, 0.1136543949683357, 0.16204403629510006, 0.06840783890575416, 0.4267666319098638, -0.4059222363572863, -0.003508730957530413, 0.4426521110480957, 0.36413531582850106, -0.37062608899376437, 0.2388826918667555, -0.568463513033918, -0.23078272601790026, 0.2732344012040335, 0.4625348601413603, 0.18632808531166267, -0.1872709964442249, -0.1572913885847134, 0.43235345557363464, -0.18362637978364402, 0.2995177984704845, 0.5169402328126584, 0.2144049531850185, -0.3626530415895762, 0.37312859697125156, 0.1366811053213404, 0.16382601224736404, 0.2964847721180071, -0.3614290023169207, -0.6504600575700582, 0.09113626502764179, -0.4984483063805812, -0.09728231392224033, -0.06274277263122151, -0.46848079790363706, -0.1405924992968438, 0.022098980471674513, 0.3371861350376249, 0.030866951614819546},
    {0.19199012172575528, 0.4942591697792659, 0.4474240771228181, 0.29396758644559645, -0.41838939274902404, -0.055252836719456064, 0.19127260894630635, 0.182099051468936, 0.6375836745762281, 0.3832965200914321, 0.45026390591893173, 0.712558752503347, 0.2615657391599633, -0.08877134603779797, 0.445953062103082, -0.2167546704366815, 0.4323520960723316, 0.5741270771960202, 0.19679481269420346, -0.16069190973561034, -0.4843666999535874, 0.42018565333729063, 0.5040725966126498, -0.20790695204519366, 0.32780594147725545, -0.08709624783910336, -0.03607226118212464, 0.3488450048728735, 0.04704808301168059, 0.20245275307236477, -0.036739750115063516, 0.04898405020724748, 0.3081583162395431, 0.3606849923427893, -0.20792770577243666, 0.627064233053531, 0.12192574987901134, 0.0007755066502643851, 0.2054418155346102, 0.49503763321374167, 0.5363369085257677, 0.2554757224306135, -0.38327216400393443, 0.4961286713829872, 0.5327686346244089, 0.6697055882052316, -0.033095678429347096, -0.3839985037906569, -0.05187497036755673, 0.4870620257999692, -0.016106299371587397, 0.20745028531243484, 0.04632656807866965, 0.2321504083662319, 0.19011229183102674, 0.7463492629143343, 0.4702634965437543, 0.024516374953263427, 0.12249706272510247, -0.4405406097236244, -0.3700372331707553, -0.014734843100864937, -0.193775814122686, 0.2055213122693108},
    {0.09812033801111153, 0.13158430173975133, 0.19742644593394584, -0.2681133998522764, 0.19662341321654048, -0.5318517181853917, 0.570893530103636, 0.17029493780459073, 0.027259681460836547, 0.24442423064976637, 0.8154883936119766, 0.06011709193213104, -0.08908740131900635, 0.34703415900179535, 0.28236444521340287, -0.3546523419568233, -0.2179499162634328, -0.6205985611465096, -0.08448444377312228, 0.0290000209976135, -0.5195317875038794, 0.324549606269292, 0.7093849597574017, -0.10119315061921376, -0.060076081028210424, -0.21185969492271817, 0.12860179498854277, 0.3404960089414949, -0.6210469015344503, 0.6755577761981817, -0.15879916463148888, -0.07505257681293562, -0.1314432421450735, 0.004099060179536908, -0.42008507119589517, 0.3064287721731024, -0.04712080862667084, 0.8771825786113737, 0.17180000504559867, 0.5507020224881138, 0.049240995335801716, -0.35936952830358426, -0.4036022590037773, -0.15239218054202971, 0.059215455930914235, 0.2985058302979751, -0.018698033028027933, -0.3366083546293913, -0.6204699794028846, -0.008116437602791732, -0.1425469661050989, 0.28505387716064, -0.2907657517745844, 0.5414748413060773, -0.19329710281115936, 0.058063316997517524, 0.37029783036658875, -0.1443450544126175, 0.5142957167264912, -0.25113618530797566, 0.00745960911609105, -0.5377267435518185, 0.32934087466909023, 0.07604270623084984},
    {-0.5334592055360331, -0.0872372934678001, 0.25869860039922427, -0.0726928489535785, -0.11779711094802651, -0.012852160618880747, 0.16760677983675443, 0.1615673136837288, 0.3279587412109312, 0.4457170981142855, 0.40529132092911563, -0.46534515390651526, -0.23387218664798742, -0.025578563923705472, 0.05086357471468538, -0.271511621837165, 0.28146469605942953, -0.22620266540334996, -0.2371199726950826, -0.49970489557665826, 0.3442737783952004, 0.11553966911428802, 0.045832261049764914, 0.07091972213029013, 0.1799314974502083, -0.7280223361653415, 0.15218242926716175, 0.5017400981823437, 0.06697356152262335, -0.2539264152907273, -0.08284434633577399, 0.007136356502385888, -0.8450513968845723, -0.26138442226082753, 0.162056403670681, 0.16070584803443416, -0.1635964581438127, 0.02407869500018535, 0.2587289246092702, -0.14315832817113947, -0.11972846645880023, 0.2978972401637545, 0.1787962277062718, -0.40856106873804304, -0.6145403975134306, 0.002536135855692814, -0.3096790813428964, -0.3815649711969949, 0.11559279542585607, -0.0483286225155592, 0.5104582366390576, -0.2616671149198271, 0.2132790958821191, 0.17817019188079058, 0.20125339840954592, -0.0911309546987563, -0.14248910621039593, 0.22500363905096663, -0.4010033845785737, -0.6057738907129192, -0.5748889159074002, 0.20825032914894848, -0.23386372235234207, 0.04162285880496773},
    {0.009328054464993902, -0.18468115647234742, 0.24847963889153146, -0.06727221623402933, -0.0827402114816051, 0.427730496263365, -0.1895752875321418, -0.22922069720492505, -0.3756559357510986, -0.30209553661515887, -0.6256852970380734, -0.013436373094114312, -0.07183485279891315, -0.3689147747307669, 0.017699476291548943, 0.4306516056846818, -0.06129287597866241, -0.1991525799869672, 0.09030184085773245, -0.36691307825108305, -0.8154201617787225, 0.49091505747242853, -0.05620402832901526, -0.24526505808040758, 0.6432739088028374, -0.19753528705579548, -0.043212199818902126, -0.31712613426342934, 0.5852231942157013, -0.7424393132303494, -0.3604386608682011, 0.4068482547976185, -0.35875469354572526, -0.2889442180661298, -0.3839373990395547, -0.10905429066376005, -0.15430151201031714, -0.47604272866525893, -0.05831128505443793, 0.05187061203848519, 0.2932150766042589, 0.0938473082120796, 0.025081010224979727, -0.02680364020313914, -0.1997497384070191, 0.1166940402557714, 0.10297255604703279, -0.28431659327396647, -0.08815103691184627, -0.4764578160200357, -0.8521466762640089, -0.4974060405394055, 0.3489959288756814, 0.0864165346099033, 0.6676964235617096, 0.3188811146311271, -0.23959871925219017, 0.34243737505272176, -0.1751313092318088, 0.07045473128582432, 0.12315819982241542, -0.6974921249670507, -0.0892697686382691, -0.040033149271858824},
    {0.35111632275937577, 0.11607835178106708, -0.592769060226131, 0.20394628833606218, 0.17498252046038565, 0.2530658286559245, -0.14090889038172386, 0.3166058161299703, -0.17740182284725434, 0.2573842526602225, 0.43991955995459486, 0.13060944941885705, -0.12565398627561317, 0.5967463337924165, 0.3401874589234826, -0.010356181945159318, -0.5105875282274926, -0.39952014697544963, 0.09153293543749624, -0.20099136717231403, -0.1339195800903839, -0.38336163844025173, 0.318555446048252, -0.16058647596316927, 0.5671625532446759, -0.11402283862123112, 0.2976961854871961, 0.49578679207349885, 0.356700426574237, 0.3175032252794401, -0.05340996931904175, 0.40743729411389373, -0.46949852502514566, -0.1224430931825342, -0.35801168758153024, -0.0982484347402522, 0.15364428561254362, -0.06344841061786743, 0.39268637076221063, -0.23656130348988577, 0.24190319952813752, -0.16354838887458012, 0.4813381993894581, 0.2223305691785386, -0.09775763952752775, 0.607527721580618, -0.42721115981607016, -0.46526620217607834, 0.15265436705370142, -0.6751398463938706, 0.5345950019188549, -0.012491408897620482, -0.2809143672725645, -0.10042640864869476, 0.231688823167979, 0.2823120404417779, 0.317153617868555, -0.07367239172009225, 0.14136782481431306, 0.34670271095129196, -0.24362531701255874, -0.34994522728359406, 0.5458297435291614, 0.2710808538507965},
    {-0.02593563517630669, 0.23875004400660993, -0.30904033771647066, 0.058260105884842504, 0.057333037574147726, 0.46151052550340416, -0.567065046053463, -0.16050507726947594, 0.1178670412531402, 0.20438246256981601, -0.0689870855292952, -0.3644345190927961, -0.03134486484168447, -0.13658178667950877, -0.41326509932547384, -0.6734538463814319, 0.23752225318660605, -0.27902286877157306, 0.11166076870210905, 0.12124995279213932, 0.3064945043142807, -0.14336594131530384, -0.7526668058412307, -0.16634311274708505, 0.49910311221533415, -0.45598213399415644, -0.595802416269338, 0.22685683202958384, 0.328455192838609, -0.6477068117991358, 0.3471430387237135, -0.09593874812023827, -0.4478178972503566, -0.45602566851499643, -0.3284896236077301, -0.5928189482073221, 0.38485903552659495, 0.5865998972172514, -0.12291770645321644, 0.30875425504125364, -0.24225810127526443, -0.11482122279319021, 0.16263246226584663, -0.45818531731527645, -0.11458783838845478, -0.0877170456269356, -0.008920140815278184, -0.41216699060803463, 0.07096732387770684, 0.011638326681246824, -0.6192258313162772, -0.03574069660352557, 0.34077088368014835, 0.10214339452337448, 0.20652482951543313, -0.22298270832390438, 0.017754964411153085, 0.12514679584019672, -0.39176326565160874, 0.3015549582206747, -0.015318656264127409, 0.7067852344961132, 0.06162245056562528, 0.13086312112790102},
    {0.027894515268344307, 0.06895887829854813, -0.26396238515352827, 0.21089813862669432, 0.503288734550357, 0.08253787185535826, 0.03161845100871126, 0.26954085970774544, -0.27490640450399817, 0.19197512188637125, 0.038630128842696065, -0.0776041790754894, -0.3846796784712305, 0.10288359023578744, -0.172631947455491, -0.12427120254036031, 0.3702909934934771, -0.6854869200874931, 0.4778026960316554, 0.21816901875095523, -0.060408759663686126, 0.22240908504940388, 0.46954246223889035, -0.5662332475936378, -0.4344230599197197, -0.6696534675357246, -0.12446752266486907, 0.1516459189649751, 0.2874570222063166, -0.5136208356067842, -0.5269345989803996, 0.540695952928688, -0.15350669838866796, 0.2327883989169882, 0.12021527592336573, 0.4923334821302252, -0.21508850817135414, 0.48201996852626, 0.09597210001048347, -0.29524490736988646, 0.574770660490021, 0.4529735213126851, -0.09505757933543889, 0.04774848369015357, 0.11888328861230911, 0.014460537096763985, -0.3340824358682143, 0.21150103900476785, -0.03478110599422274, 0.1543756568932742, 0.05448958096273298, -0.04119869640100677, 0.13993356511841282, 0.055987694434265954, -0.07260665815221198, -0.10440755435167805, -0.6303931930565156, 0.07567053998249837, -0.548631376881863, 0.18486447852126642, 0.49050096834710843, -0.13225157076348745, 0.49225958377911366, 0.05939484381233417},
    {0.7716479557908925, 0.2169820923391067, 0.16838358673303105, 0.14828184888732954, 0.5640155659013775, 0.5858595297433342, -0.31703782908381556, -0.7154009649119006, 0.08250023760747303, -0.30190782050945353, 0.2622552874842558, 0.10713383966091851, -0.45631037733977636, -0.16113193935946976, 0.7012250103048817, -0.2436041861041876, 0.5292458894856131, -0.18907388955744547, 0.3944045314576385, -0.11659577867268485, 0.2475997123647065, 0.5739847897881418, -0.27305391763663794, 0.24227912470831003, 0.31092854090722416, 0.08255484338770754, 0.11054537220698446, 0.7436101791747951, 0.2957627071182995, 0.15707695034760225, 0.30175349519891925, -0.16150226851553445, -0.5923181500751122, -0.28746660088749637, -0.7370925497915117, 0.35110078548084084, 0.75610948502341, 0.17373426095963085, 0.36769312177433894, -0.11869942550242198, 0.4511233826337306, -0.5035621168874421, 0.36001592078372646, 0.2186540081270343, 0.07733487274508521, 0.521756066560138, -0.3233921620847552, -0.5445844768120015, -0.06170347405885988, -0.08110724236633453, 0.13103263192917894, 0.22385443675817396, 0.06687137198500245, 0.07704369734017909, 0.23563881310613122, -0.34017133598476906, -0.05003861111975703, -0.044910533445346686, 0.5177387060545647, 0.18310007910101855, 0.07866777194547263, -0.00023781020408219472, 0.5237134983510655, -0.08273401441316479},
    {0.5382990706803074, -0.019988624325883376, -0.07315510470687797, 0.11437188589402364, 0.009995728867150529, -0.02760408427811387, 0.015570671243490678, 0.17590668583231478, 0.28337433583585253, -0.04154261851982025, 0.01641911762438276, 0.22966901249264368, -0.43142104433291684, 0.01325016121225605, 0.40002717517634034, -0.06837303517491018, 0.3413037884038168, 0.37189361711382185, -0.4928644601729224, 0.2147154082717265, -0.008692255543677365, 0.0975648203169384, -0.5946112849220455, -0.5820004590305412, 0.047773342228127784, -0.1690841394254789, 0.42082371975361044, 0.31220661299873675, -0.24720005224124153, -0.48502044718629195, -0.007928277536617834, 0.4037420751799479, -0.3619379397174146, -0.5795468602402931, -0.3508066604802315, 0.19405392859074808, -0.5303946916698925, -0.3987786825268456, 0.6505075003651333, -0.2149742049742337, 0.3451043961002714, -0.08236858350432426, 0.13287686827478987, -0.12446578225268486, -0.15451896268934676, -0.09274931767092484, -0.16607772409599053, -0.25734082469166014, 0.06190845576697662, 0.19664217480227578, -0.4551134566632707, 0.3139889177605069, 0.21641109509311796, 0.03392184719003432, 0.05099786253706399, 0.3690108096732536, 0.5632310203211446, 0.33515091174870737, 0.3318433298204312, 0.29771416361502095, 0.45282193859706726, 0.11530290136279922, -0.08430263373784933, 0.2878256220281238},
    {0.23153442051262166, 0.6374572644573313, -0.03482536296296362, 0.09096471932061147, 0.2069769984764458, -0.018070333716955746, 0.07375310587346344, 0.007558667902566981, -0.2163524320421446, 0.13248701226445023, 0.003965548994662538, -0.11920613721220806, -0.2167186075254247, -0.2402233578581793, 0.7304655103401455, 0.13112230920210272, -0.06316107688335237, 0.4972604307691029, 0.048695812315888064, -0.1114813053871125, -0.25756546575326794, 0.3181444500248601, 0.12251983161823353, -0.28564512892820754, 0.6286413492416909, 0.16530413569299734, 0.518614488752229, 0.019725584670510915, -0.02316288065816196, -0.2096289170975467, 0.01967634880673941, 0.10677837072533994, 0.1351846860232358, -0.06444781406019097, -0.05764542435478568, 0.2516283794985909, 0.1037895000356784, -0.25425307111224466, 0.22485571772651872, 0.06022981009810526, -0.06308825026375896, 0.2444597733700911, -0.019931723008309588, 0.019582951676467883, 0.5692185111103245, 0.19721586478157171, 0.27068186194261024, 0.20224537385058233, 0.7382430604431027, -0.1710470913563353, -0.19802916464343936, 0.41583794844313027, 0.09395501774676429, -0.342197976818605, -0.13055804325396958, 0.6408069327299221, 0.7270209947614746, 0.5042877027234243, 0.08994321382156618, -0.08497862810201551, -0.12413535863462193, 0.0809384229263179, -0.4533790804359552, 0.2130588911480737},
    {-0.3080306338583785, 0.10822353875652498, -0.2425255394027895, -0.0059404964745425354, -0.18696741657654622, -0.07744489463854459, -0.11804185792086584, 0.3703306473806726, 0.08142064204948395, -0.10851484827468845, 0.05888084235338788, 0.27346742988900424, 0.3118131388220452, 0.2871333995322196, -0.1882352515383546, 0.09504196336969324, -0.20735783113568798, 0.42487572078630814, -0.16768909667140616, 0.10058629903120724, 0.093563727343338, -0.1314540237560333, 0.2769293142586887, 0.15287590828299868, 0.0036283387362223106, -0.05169778858193797, -0.11193694423467446, 0.08375459097045582, 0.5361343277093918, 0.19933456187877224, 0.39553553120144674, -0.29180481978056105, 0.1435373705331005, 0.5117315507218262, -0.019136310982989607, 0.36218025318415437, -0.4463000583179848, 0.09293828840709553, 0.12625641161520487, -0.024704832520331677, 0.379051646646502, -0.08823053385444649, -0.10039956555674985, 0.06831561057672776, 0.24467437444145748, -0.10528061197984712, 0.29526459134406774, 0.27304018385011225, -0.0035081754443642955, -0.24152816648141961, 0.1545602190645762, -0.3051917329234034, 0.24145872985688852, 0.26270179073877864, -0.24564008026660955, -0.3919201240833008, -0.1511609106316902, 0.2092859129415895, 0.024744901987286433, -0.11464265779861627, 0.16936847615158526, 0.35893398155995715, 0.05435928162320322, -0.0044836316104662766},
    {0.03128538076890939, -0.4646326112612756, -0.31256162379806673, -0.3214811630299069, -0.07572712788028192, -0.001702504792702094, 0.19964359099103968, -0.14206623515768124, 0.3625006860852973, -0.10169859720728741, 0.07593725159315, 0.44263999455723474, 0.5021350204572415, 0.01713792349202932, -0.025253117428661306, 0.01870726301275644, -0.08285493964224439, 0.19635566754373016, -0.5655898093323519, -0.06581886446793536, -0.07734895742444015, -0.40226477506319236, -0.06992273850129213, 0.5275091937366777, -0.4125200318574447, -0.5247485955720984, 0.10846713704406603, -0.4161882674225317, 0.2773474261603455, 0.3970142017232059, -0.0827247236817127, -0.20406733016560735, 0.03849080981352635, 0.2039390134596702, 0.03529511152936795, -0.2331405113932768, 0.36525233045633404, 0.37756971571107156, -0.24568065584733947, 0.36651682538212305, -0.0659265718604845, 0.19049398195173828, 0.1143563253669895, -0.056827513901390056, -0.1664972548292629, 0.19921447129902664, -0.38589691349848604, 0.02791200863746119, 0.047942961170051805, -0.0687739279504038, 0.28072356064329546, 0.3681268444407273, -0.4704248644120648, -0.2867865211254067, 0.09447984166428958, -0.4195564815515667, -0.5003335626926474, 0.10817471333714242, 0.047329984944545954, 0.46138921559874635, -0.05875336163159247, 0.08254836863202374, 0.20317923216479375, -0.2240764349437105},
    {0.41486039754439796, -0.0859545304363838, -0.22546773282956048, -0.07365144494939395, 0.42703813183783895, 0.1876206678821002, -0.009564946790762214, 0.04055133589290084, 0.13266615272447962, 0.20971960824803382, -0.19697553963976142, 0.008892322872296299, -0.1818356351665666, -0.07396876746027876, -0.008286062817440243, 0.08078456658002026, 0.3420742404608167, -0.3592663280041705, 0.21701775799292528, -0.04795987696089908, -0.12168291366959702, 0.21625286252234402, 0.16674737508376852, 0.4043864369416085, -0.3734680230216623, 0.3128829271013906, -0.07143314255748237, -0.37211418632575394, -0.15979158308594169, -0.5860733510798669, -0.3679696906388005, -0.009066569842147838, 0.030837255879725342, 0.012889806510148694, -0.31034874560038705, -0.11088146008653196, 0.5276799777174247, 0.35026161480452667, 0.10111911129747617, -0.11224110019456889, -0.21566489692397703, 0.061065233140423725, 0.32534815861849353, -0.13298357523523574, 0.014932934985176607, -0.04971203516002669, -0.2553276689042282, 0.13202144278615915, -0.12734340400092733, 0.25995493209922865, 0.2188363211347401, 0.4532536356142225, -0.23249477628001175, 0.08550671884191027, -0.12983811918850963, 0.12890759122264578, -0.16379491324872367, 0.22948188763006303, 0.44561753008453076, 0.15945333795273867, 0.3689662743366966, -0.16159746093878272, -0.3974322469848484, -0.30592303967263873},
    {-0.2760369391785568, 0.21687002881342524, -0.45681480302363514, 0.4598305434718824, 0.12490075713571307, 0.1959739559210267, 0.1235418757667501, 0.025687152736803904, -0.47263997063550595, 0.2521437221479057, 0.12474409963695002, -0.2734274107630707, -0.6568504104460346, -0.0013648621499886264, -0.1700075155071787, 0.11612739649934091, -0.18695295292679415, -0.6146701931845187, 0.19349502431291654, 0.01060152877544092, 0.16918995375774545, 0.32811826213561385, -0.09722630233805955, 0.18857305021498308, 0.1723803870056239, 0.33477218684440124, -0.8279277380404219, -0.15207789279130252, 0.18129095434612846, -0.2482103142282488, -0.20977139052488206, 0.22207464686557, 0.038206201390748616, 0.013440948783718959, -0.14344294983487813, -0.4141141540241855, 0.13233679037703494, -0.04250690856541118, 0.12661809604974272, -0.44961606544161403, 0.31223767371409783, 0.18687169957637614, -0.02977217660089294, 0.04377932887090801, -0.16924535786368086, -0.06387441900150814, -0.11330862534531698, -0.15036913278807784, -0.08376417830423134, 0.10561693797061443, -0.20831554864882595, -0.528120438346731, -0.5402764938000455, 0.18494681386909595, 0.04858130709153678, -0.12296979241196251, 0.020728911404891904, -0.36864848310067505, -0.04470732736053953, -0.1714291776722415, 0.08878141946742539, -0.15148648637322437, 0.005099834281088212, -0.17422483525445903},
    {-0.076873948515342, 0.21948299177849545, 0.282082548783099, 0.07952497020308986, -0.18342040581113442, 0.5181517409989183, 0.03983144627129623, -0.11204569251233229, -0.1006745414372026, -0.028096973576893478, 0.42497556614805376, -0.0927791765971441, 0.057320937731248675, 0.27293221738249157, -0.2325447135905713, 0.5313326678946724, 0.28769051689932823, 0.4004089658157235, 0.009241574649943808, -0.1511458507634691, 0.08185909241213661, -0.31956067197783944, -0.5460944289542407, 0.148274540797538, 0.41818506341757, -0.0729202418404953, 0.5398298083244268, 0.2182861355462445, 0.15710304836507893, -0.06743874165706339, -0.6957692020203368, 0.4403193618579044, 0.11013654903511651, -0.30351262498267473, 0.21144585340388844, 0.24407448100173387, 0.10057523948842874, 0.18914001417960716, 0.5480348511159283, -0.12670964975748597, 0.12598373825400624, 0.012119966978917457, 0.11741411585560413, 0.2859911066634859, -0.2942536292619716, -0.24067754413241124, 0.18305242895483753, -0.33120623110831804, -0.06120089597186561, 0.07555830809855138, -0.038202065171113825, -0.29115303836607226, -0.03506971562692217, 0.1670146801161015, 0.5135096847927786, 0.21159606283244045, 0.08948564282638889, -0.16125501754625063, 0.04314394707390393, -0.7369298360238336, -0.22549246688322325, 0.17569375586505878, 0.2858137093554838, 0.24563152253523582},
    {-0.1614653666272105, -0.19153396820269156, 0.39742854717865095, -0.07204475038812462, -0.37359970919753327, 0.476679321339832, -0.2280326163139294, -0.5922404776870278, 0.03477834009985505, 0.14604058723413516, -0.024636880643535034, -0.5223000016392569, 0.006279998043056353, 0.5423806304453898, 0.011736921705172074, 0.17446870833422487, 0.6540456049747658, -0.3323697875692679, -0.18383455426282372, -0.16483585431587844, -0.005077647208553561, -0.11266444145746204, -0.29038382252182204, 0.1872136660294482, -0.2087357151576702, 0.11487833656509228, 0.6547347736693272, 0.20606090556875103, 0.11444701470618936, 0.5509581301675586, 0.21339192565308368, 0.035472680762423305, 0.012216359418220708, -0.5282329555285931, -0.06683470099172358, -0.05131715839949957, 0.14640350950683567, 0.052814032373433614, 0.31496618780879854, 0.21105711108910036, -0.3550971993960862, -0.46749350771313614, -0.14783426140150732, 0.2321363841761613, 0.31314558764453654, 0.05994632715282037, -0.30102988794456353, 0.39479294705584705, -0.005593100652872636, -0.007972476158777102, 0.07217282293056848, -0.31743062951127465, 0.2856521215875325, -0.08866902503457086, 0.2802416404197072, 0.16813955004039552, 0.034475345306940165, 0.025156385486317195, 0.24439541278076676, 0.13460834768599397, -0.02031617151731546, 0.0031911175714456896, 0.15291682528049355, 0.3350076621526875},
    {-0.18428504953749245, -0.004499129426700819, -0.11186299299642784, -0.15359672713923475, 0.08758233421445016, 0.18460034441686882, 0.1924702383408917, -0.6682079109733156, 0.006234211681438148, -0.36256623496547347, -0.28895740649838647, -0.5998997341943908, -0.28431145189277734, -0.32445330658604066, -0.4224342646881502, -0.2785278277834934, -0.3759409847872954, -0.3678010666975016, -0.06784604952849005, -0.3062260415853833, 0.27233565946861454, -0.12535414990355426, -0.01890207507618649, -0.03397626115666366, -0.358728792932654, 0.0429577487060126, -0.029881519041566523, 0.041452922966357296, -0.45011542795096593, 0.06159437230099317, 0.5230343674111164, -0.4755083090742815, 0.025482319662645376, -0.4841757851176753, 0.004275261898436516, -0.40985301045520317, -0.07886411638443465, -0.4680809234942626, -0.09864802825396685, -0.2524062568365607, -0.38992063521875964, -0.3883002243615323, -0.09000485875245705, -0.21600861021369144, 0.006773083871281243, -0.31043058432005083, -0.08738512319582467, -0.10503694309588688, -0.30688022120778424, 0.48281620325197566, -0.04886484121475767, -0.3336888180394919, 0.08920620961405767, -0.10082640254885382, 0.12999356918771376, 0.3755041255748704, 0.08604177025811698, -0.6237241567296261, 0.03223093482249761, 0.20519167497023427, -0.46389564989744714, 0.36265992107164097, -0.11469261137204163, -0.06562854550808842},
    {0.16728659679836952, -0.19117124355063364, -0.1209657430867744, 0.2469808530163974, 0.3573699583788677, -0.1954822884759595, 0.24225830572536897, -0.10292114649903632, -0.35259545343796067, 0.1460280399333182, -0.3905246944315948, 0.4860776133052783, 0.2899273675865153, -0.24411380954277317, 0.10092370085613075, -0.2145488899519404, -0.33236224864915354, -0.34675545972524363, -0.09806383191070438, -0.2484340830313246, 0.17531515406015757, 0.20732620465880927, -0.27616451400670483, 0.05724535537830039, -0.6576755388638327, 0.04998892390505831, -0.23731853754943957, 0.30668280648583257, -0.15186694019248348, -0.05166739121464591, -0.17905492576267476, 0.34122076934788365, -0.18559568741320548, -0.33700049171706475, 0.12252165526106776, -0.273334315997477, 0.20058048900226025, -0.05338285802714216, 0.08137690430414499, -0.3907583227961871, -0.33128596716681175, -0.2504551461370426, -0.4363362575856587, 0.3918827287919173, -0.4026773777992476, 0.39609722164659994, -0.01937730323039767, 0.055354951398450175, 0.20273852968948175, 0.2767310802233403, -0.12880247288714497, 0.08246373412394838, 0.2228795731616252, -0.24460315965810725, 0.037675182169461516, -0.035488420860708234, 0.29849196230231334, -0.03440344071514096, -0.22378974680789027, -0.09881804849969003, -0.3843069651201098, -0.07677937371232185, -0.2783182911487717, 0.08903166210090202},
    {0.08822909620082071, 0.04429697727865198, -0.3507308180517197, 0.20687325494068062, 0.006537040616105325, -0.4415722234153409, 0.07355605608529923, 0.25059607173497456, 0.3341478183779157, -0.32016276629077856, 0.15087929008468398, 0.40175431329082467, 0.20221238199178407, -0.14822203727962738, -0.18984781540970905, -0.22802884071751195, -0.3781424708228442, -0.07647115112710104, -0.11626368651851277, -0.3173104551912961, 0.0939701980036149, -0.16408669679038956, -0.2691567084937138, -0.05293371297772503, -0.010662002025737886, -0.1664528831726148, 0.6411340544795149, 0.32851774883408724, -0.049337037776659085, -0.5129889803653469, -0.08143426075238602, -0.15926474394633125, -0.15163141570596672, 0.09157709846635616, -0.09887781587983285, -0.1637037967175612, 0.0727091124671047, -0.33266906150826314, 0.05371245489851637, -0.0428763379670462, 0.038810257773219003, 0.046991853737897105, 0.033435987941116956, 0.12945938953586725, -0.05103651127068867, -0.14036320751474388, -0.4225294827794174, 0.23419058684652747, -0.10541526873924646, -0.104070346110818, 0.04137218642785033, 0.2535287987893257, 0.13158659060563316, -0.12707954743977237, -0.02218070438544547, -0.5331260737486074, -0.2092303972480003, 0.10272775568990404, -0.24049868725074136, -0.5453396449596263, -0.4052147490589358, -0.09395181741306674, -0.052213136929732666, 0.008491080603757674},
    {0.029034022220387437, 0.15086990018205038, 0.07417312851151153, -0.1785042764951262, -0.43452684540851594, -0.2968021505064966, -0.04989569006255037, 0.37844708562414386, 0.5133008283972814, -0.3760823265436314, -0.11561492793102966, -0.31164211783946694, 0.24392642633606887, -0.28726281254236774, 0.2897040283959135, -0.03238110179639797, -0.6163894969110852, 0.18277806260906437, 0.022111040542946332, 0.32599454118215915, -0.019548772615496795, 0.015086310101717067, 0.05633503719168286, -0.13631106954457783, 0.41908096659298755, -0.3718476040066134, 0.5720670072940133, 0.6084406454737527, -0.09903238249070123, -0.038979459180119365, 0.35612568896918584, -0.16231202600874894, -0.0957838991871131, 0.4094324977097068, 0.13036923995681193, 0.14918890872229593, -0.1973500766730536, -0.3308659808287268, -0.4176107295823903, 0.048662719066411765, 0.32022873835599336, 0.1785019763067265, 0.3797024256034539, 0.3781223744975616, 0.07018431619550813, -0.32708640897417574, -0.1183162752650363, 0.12694091103749325, -0.6277736101426945, 0.36094401350764294, 0.13118442679820158, 0.0067835037468174, -0.2567091990405179, -0.3246642459486298, -0.20983523850940344, -0.07108023008237566, -0.1561153696691691, 0.30414208370628915, -0.16432045613458293, -0.4066723397762753, 0.0010233521717283587, -0.22443561656813862, 0.11090210472822633, -0.21383687286725847},
    {-0.5055863886205628, -0.11080607405628284, 0.11565587721761723, 0.3503728537503347, -0.2956879599042534, -0.2246280659672956, 0.024413802540061518, -0.20404212678451905, 0.14741236138448705, 0.12553164387156024, -0.23076283832863112, -0.2844431918347771, 0.34965459851452246, 0.2640407592374731, 0.2527753801694174, -0.03145882976605915, 0.1006600983096199, -0.03252155449008593, 0.30953344895810875, 0.11464025630191592, 0.5154972270967121, 0.5837917506591769, 0.010378196194949915, -0.21405281093196982, -0.3932859406461745, 0.3351622862132831, 0.07798693414503866, 0.33545930887666625, -0.41794859838171605, 0.207279814051068, 0.015048313867934622, 0.17400637604582755, 0.44811835361678365, 0.20204531226012623, 0.19345815319520582, 0.6868885283399363, 0.24430709146013788, -0.088119728273718, 0.20034904633895015, -0.211214984590426, 0.34878564480407687, 0.1344710702843036, -0.2104536460054875, -0.07896841547546463, 0.0629251558069447, 0.010984985423526264, -0.22021635273703882, -0.35186039425637494, 0.10307997688841718, 0.37268397916544205, 0.29844842445682557, -0.24541638942607671, 0.08737788160819115, -0.16535307577328637, -0.28552751480585736, 0.47598314195612995, -0.24729110549516342, -0.45754913792552704, -0.09001291987286354, 0.11032916890446955, 0.1415805963418188, 0.06648004554996813, 0.03166465472395728, 0.02763360240974384},
    {0.025323233458098334, -0.39531012378272895, -0.2547604092591334, 0.019574536173734794, -0.021346305033032233, -0.41726198932001896, 0.06712480974794467, -0.09354856321216462, -0.3291066042562087, 0.37030712944791977, -0.35391111943976333, 0.16968957873119814, 0.19010348028904456, 0.24201039172785024, -0.012550826787451425, -0.04566429377963656, 0.10857575440382224, -0.3608086106478339, -0.1386019730469532, 0.13091969857577923, -0.041478215446711174, 0.4128988066858125, 0.17889415039691756, -0.0468201077415789, -0.3771215193201063, 0.3415477396041096, -0.32478971195727274, -0.22341038713174644, -0.23051639709610255, 0.31628710635307694, 0.49428133643433847, -0.507776240197917, 0.09333056805198023, -0.009491713434919852, -0.3466161271082681, 0.4122299082539094, -0.12923419387127963, -0.15071649953529653, -0.14181376087744857, 0.5630244193035905, 0.09403244296457644, -0.17605031014392583, -0.305335411306337, -0.13543900965117778, 0.12836386641050213, -0.0034504518840348447, 0.18890928571271046, -0.2428218098532491, 0.12551996565552334, 0.029576327266597896, 0.35757336470123735, -0.2879458597116877, 0.20579167027748985, 0.2495340199230348, -0.05322922537544395, -0.14217601972327765, -0.040222551341417945, -0.06119011523619643, 0.3498258262540904, -0.07357775079002704, 0.2290232942091797, 0.3564473582865205, 0.4727793015887775, 0.01119184760284361},
    {0.36927932861747, -0.15524991071049163, -0.5831964045556468, 0.1450831403002547, -0.2699674909898395, 0.37898870130128914, -0.01837326221622969, -0.07276728212804078, -0.4283945647382819, -0.09530883342058356, 0.039028927269482386, 0.17065682663620663, -0.22428106662965155, 0.11725353608223398, -0.16080727434274988, -0.08357277891347, 0.07726515812061059, 0.054296791074251546, -0.07518493532345029, -0.37259520604177776, -0.19619933029635386, 0.16948909213774294, -0.20539961740597162, 0.18989501852800028, 0.09501730016122087, -0.5100317853370199, -0.025536184799300535, -0.7245769599538642, 0.32439270071710646, -0.4083786569124283, -0.11764563440362757, 0.24476659361215888, -0.02752516559459869, 0.20561955475204338, 0.23814965380667338, -0.9485529692557154, -0.09072435207785168, 0.412550653414815, -0.45585681066549794, 0.38240490304249, 0.12812414461354388, -0.004442677894650065, 0.13576574497579866, 0.18212915536606944, -0.15877122702863844, -0.10491840439297179, -0.0746381003218761, -0.022102369419782643, -0.06000166650080755, -0.33190450564056884, -0.3203615895882666, 0.2975290822538724, -0.09379095715249111, 0.11364799060791464, 0.2940970682910961, -0.15749294347846765, 0.21547270682535152, -0.027792796763273432, 0.03814640463995273, 0.27823042820497346, -0.12092907437642933, 0.26772082691400506, 0.045068607357422706, 0.21468190826657124},
    {-0.10059302737989874, -0.28877364861679156, -0.2918566415016508, -0.11980798756174978, -0.3167144043121331, 0.10540007656813383, -0.2254538547600857, 0.46575184347527104, 0.11680967433502851, -0.2672531605904672, -0.4830817480119036, 0.3339483409194959, 0.0414366157424959, 0.22687268412298103, -0.24462385386457008, -0.11062851053002402, 0.2384423609762946, -0.19705958219060848, -0.3953138727627814, 0.10848962743356567, -0.1150483562876375, -0.1474884909018114, 0.548597392180764, 0.17984538384460333, 0.31455721630037314, -0.0321527473923803, -0.3670219138895575, -0.3283633428349821, 0.3237456282232266, 0.563902790537247, -0.30420026555746715, -0.3466054193507342, -0.17549328484410526, 0.22859150049442092, -0.06750429675441971, -0.38850920508810877, 0.014946277573124167, 0.6171515317888382, -0.22759693341879966, 0.05319602198939965, 0.1601105074256353, 0.2616737790084097, -0.12209009541115803, -0.05148164409743399, 0.045676698909467905, 0.28724785723125285, 0.004355274017352709, 0.08030774860354765, -0.0012974258788530178, -0.22108753476761328, 0.07695045739374473, 0.14859982319443843, -0.15644831631884415, -0.07492016625956086, 0.5836387406992781, -0.3111545405042644, -0.16208774239413612, 0.42314523009294547, -0.06287717202688069, 0.1402987535506216, 0.19813612030191208, 0.03634174894486449, -0.11285912831457066, -0.30870761198564617},
    {0.15651858180543674, 0.5094698194259774, -0.040804422212045006, -0.5478736924225056, -0.2944408555602142, -0.16174613001034172, 0.006446514312296485, 0.3652462901648311, -0.038522242712184775, 0.2969581759804216, -0.1410303412834553, 0.2181226544697229, -0.004643493415223025, -0.09981013851722088, -0.04357204449562455, 0.23962702361496924, 0.22001221878818034, 0.4820440608568906, -0.688523251637981, -0.00818601309882921, 0.10550220523123069, -0.3007015943371067, 0.2833049604376898, 0.31248410831200407, 0.17245863923051705, 0.48475440184939045, -0.2179058361070137, -0.13287806836279076, 0.07015729535449233, 0.5663747696035205, -0.21224726551353898, 0.13402740268081326, 0.33514073807323297, 0.09434718174490546, -0.1821161223071789, 0.25754117852998865, -0.1098794403882588, 0.09230367533294624, -0.30426008745286853, -0.05865365302513267, 0.19487492367585618, 0.2884354360298469, -0.08140302625081323, -0.05380690355158179, -0.14362790952262183, 0.33825065312878394, 0.2962412114649823, 0.10228274773940467, -0.034725316827398024, 0.2172009560912357, -0.05483810231754802, 0.21523667324542367, -0.13296112015643047, 0.31651841008241316, 0.15913629214772718, 0.18469464218999823, -0.08309356850068966, 0.08601090577371694, -0.2874771579773826, 0.06842127978660231, 0.2402952277572962, -0.3978772864928001, 0.4961877554002565, -0.41767198556882074},
    {0.5445104636067812, 0.3692826511999884, 0.05893190209857946, -0.5600369484601669, -0.13649335544958555, -0.06043675352167158, 0.03172849952386477, -0.4781920177480204, 0.09538763056528143, 0.7175957399602425, -0.2638929102890716, 0.28450130699553094, 0.01101265287565869, 0.27895486630437555, 0.12682074861259335, 0.25562421129371415, 0.007973481623150175, -0.07962188503841433, 0.45479719548730335, -0.0348986769956349, 0.20271929217091988, -0.21205932690432244, -0.09109601426096349, 0.2753555671104708, -0.27428737662101155, -0.6742695741664927, -0.42654154605191896, 0.14649178102240423, 0.16832595396828132, -0.011884520249969971, -0.20699846164248545, 0.20268306309227546, 0.040250371909709065, -0.023446853635035105, 0.33455526741996505, -0.1396629630368547, 0.24609077963520362, 0.4216587172381305, -0.013830686663405591, 0.04038581340906961, -0.2288227096875587, 0.24915296260626188, -0.02356374893470347, 0.18952330064361098, -0.1121525871885809, 0.21827161636743767, 0.28515099672829886, -0.20793018385340364, 0.47433352827878267, 0.5020697745524069, -0.04765322118340386, -0.4140716370484869, -0.2856055761965271, 0.05699457220667596, -0.09459497767311423, 0.31384228445722523, 0.3591242702613291, 0.08500075368692056, -0.2483542481634962, 0.2315781743030006, 0.040434870317843936, -0.1484733931767939, 0.04064798794510534, -0.05650837823874293},
    {0.20323640052514663, -0.1580974228420188, 0.04932095401060146, -0.06864806244129397, -0.1629327466418336, 0.5103780611913418, 0.27269404474445175, 0.07387117316566831, -0.16491978853387662, 0.06978172742581261, -0.06723545789783456, 0.2768291856566724, 0.12589262161050488, 0.05375928166366807, -0.06044677907560793, 0.03534849979075513, 0.4227508344967093, -0.5478183498496658, 0.7743601387780025, 0.021871427502668954, -0.09699064613168504, -0.2332350008316235, -0.5984034344772229, 0.19498889825025884, -0.36711961724819153, -0.11088206482002197, -0.46085201429439365, -0.044514785665703334, 0.1152031195749185, 0.009388778619696248, -0.05455004229171971, -0.15329168039177984, -0.45737684343349855, -0.0199747232116834, -0.4222675272628136, -0.31298577088855306, -0.1389218048476492, 0.0970948916465684, 0.767036062441902, 0.11641259619021552, 0.14491240565621702, -0.08083022760168534, -0.19395780194148468, -0.4472684431290052, -0.06422790478433871, 0.13451857904459272, -0.04408418329823204, -0.3890233162589688, 0.1263347930885331, -0.11675516372698229, -0.02110904715197235, -0.2400668588796066, -0.09772186196960408, 0.16790106042308217, 0.4859505987803943, -0.10731781996488, -0.40128789816832244, 0.14430505653790152, -0.14242985071265193, -0.0864323705961513, -0.03425329604485375, -0.06319033030642707, -0.1778472332758319, 0.37188807679606867},
    {-0.04118059491723533, 0.03994331033681313, -0.5961928451784769, -0.14693401061559447, 0.03682227949330597, 0.4603941065847788, -0.2800070463711625, -0.15423457092851006, 0.31743875022655293, 0.11982127499937088, 0.3833218401902767, 0.08648280301759922, -0.28896342546830356, -0.16466310709525106, -0.5228361647317147, 0.010471674131320536, 0.19858871325738334, 0.5045017487723972, 0.2200010699962956, 0.18593372986861761, -0.18822163986029858, 0.13195223176635762, 0.2798948833516326, -0.0011297946415778526, 0.47170444784166016, 0.04563603846400022, -0.10094986485942795, 0.3275066694396091, -0.13121074889346931, 0.6506177903685821, 0.39579569169074713, 0.11988302665421226, 0.19644748432144174, -0.050393156610589046, -0.49050758984094683, 0.27772969016669846, -0.6008653332623317, 0.4802372927095567, -0.031293948455562874, -0.045081027331525095, 0.47038816358702185, 0.016998528161969142, 0.42554655862072704, 0.07868034204551547, 0.016407751156387155, -0.11832310608324553, -0.16378340762807475, 0.11223995681356315, -0.4274754118283609, -0.33352053519999353, -0.03878266770858882, -0.5908583670377344, 0.3438667432338485, 0.22717196606196305, -0.0195306367022581, 0.056038061285720114, -0.36851823443850146, -0.4158651020158501, 0.096763500592843, -0.25181642185524206, -0.09596301149723482, -0.8705962475073558, 0.3935721208898836, 0.3270131051555833},
    {-0.1986099613293734, -0.25165725896446967, -0.580470012201427, 0.3328779036314311, 0.14673779033956139, 0.3606236871114906, -0.24915996718194275, -0.3093593044668592, -0.19460326070159623, -0.18703142410079127, -0.08045393641216521, 0.3400526899438418, -0.17814204483167412, -0.062252027246257, 0.007719346737347829, -0.2713356460106689, 0.3705700346021757, 0.03168691295373, 0.048461803025476737, -0.008697538150394432, -0.36533423079691646, 0.5495906821301068, 0.1589580308172693, -0.2719368197526629, -0.0447984310855801, 0.06716995283529913, -0.08817392514216894, -0.043522268760834176, 0.030454199161260107, 0.34098097948289807, 0.024850772434182815, -0.028535323683619225, -0.2143140426997698, -0.1948910129202777, 0.14002974549484265, 0.2655001355345655, -0.15855869838075684, 0.21369875439697547, 0.037437380578061924, -0.017403719516737807, -0.34969777537255187, 0.13536572589197898, 0.324473678162528, 0.1892730140430452, -0.2736370131857148, -0.11626362153404778, -0.09112441343994492, -0.001782448710414618, -0.052169646113001025, -0.3398938380128404, -0.2993016949714692, -0.0787089081201084, -0.12484618729224832, -0.2230377770344358, -0.08347926083200241, 0.19376628462549347, 0.1387229933599617, -0.16298081128058592, -0.18421212479815893, 0.35191341782581653, -0.7544451460850431, -0.041954297480676674, -0.08237340901019854, 0.158061879257845},
    {-0.0483975031805881, 0.404287783714024, 0.15097531192572677, 0.17172823390003852, -0.2775864061772724, -0.19812767263975928, 0.17524554125879901, -0.11114026848142605, -0.6224480526819632, -0.39849804542699835, 0.09069082059069866, 0.13074147742049266, 0.3800457772209895, 0.08080075738243508, 0.21715150443972833, -0.3053318227006355, -0.1621648726019645, -0.10327962613939552, -0.3095640506762414, -0.13469766947901715, 0.09579588034895661, -0.011514544619024306, -0.29346433776677044, -0.23002395310774973, -0.40336249635928795, -0.13584348301029042, -0.4628270064204473, 0.033443297127786514, -0.043012860351457544, -0.04170154594818306, 0.25811573862373577, -0.03866183728112155, 0.06338342992162302, -0.21971304369377262, -0.3194594504262605, -0.14538263264435622, -0.16846027597134794, -0.4087933472941401, -0.28664304885811975, -0.36178454155376627, -0.22876105285894194, 0.17811650671079032, 0.03743700858232738, 0.19629567212053411, 0.1435953354584169, -0.17226415541347442, -0.6289584271537028, 0.04589216804505249, -0.31569532844376946, -0.26697987270769635, 0.17054859734782404, 0.43552788720688573, 0.17554719925767806, -0.5942156555520041, -0.5041585898912839, -0.3221417074957405, -0.23523843774094538, -0.1456844649393816, -0.1334020005464331, 0.08370390480713098, -0.22130979074851595, 0.009283167651364353, 0.002162461744290966, -0.525274778685363},
    {-0.4049331110659561, 0.3959879061424286, 0.4285752987700508, -0.19742152171526398, -0.010637922502843494, -0.1857572555809969, 0.29349290964892855, 0.4726459229480723, -0.3256233065061251, 0.37145566188941903, -0.16979537248510546, 0.02310492486046556, 0.11892824396403716, -0.667082450408522, -0.10300805383638666, -0.2105427682132688, 0.12767629731340807, -0.11174130779120443, -0.2200621803773581, -0.2340139136066456, -0.4677916693537315, -0.19851284163082764, 0.1872915213451052, -0.49048972324336193, 0.11775306282063153, -0.30150557730268085, 0.25992424971060846, -0.36842754742411987, 0.05584609565450771, -0.07658935933794167, -0.10909768121374024, -0.12945838781120173, -0.08770797441860279, -0.2625935160252376, -0.1603852573116368, -0.3331030973727015, 0.20625571274127194, 0.29204236571132547, -0.2930110977017272, 0.0440773378622104, 0.1391361923224139, -0.3848922974448492, 0.11109629354385618, -0.12549777155355007, 0.018249192252201524, -0.3621571297003373, -0.21209330811347632, 0.002224780103283751, -0.0429258134024239, -0.32166298651202524, -0.4661288349705488, 0.2703103150836282, 0.006263784194728999, -0.29753434830435666, -0.008776721011429246, -0.3402766908164251, 0.16750747338564775, -0.37647046852465943, -0.07326465174468226, 0.2634258788089974, 0.029527208325117422, -0.011464148427904344, -0.6417214079098547, -0.3663864144698694},
    {-0.34301705260858883, -0.14026887288921225, -0.20796358550287505, 0.1898139315429228, 0.2761500179556666, -0.11390204453862163, -0.17850870826840043, 0.3661376982854467, 0.19360850283234504, -0.08281112228204006, 0.31967806199448073, -0.4923478678958986, -0.16875840823815194, -0.10786520361848541, 0.15467464330898523, 0.26464449333689316, -0.3624823809727535, -0.05140572647838119, 0.211818683838868, 0.018362803352296668, -0.15592006435671527, 0.37556485986077004, -0.00534237492248261, -0.12774628797176993, -0.07445092874340745, -0.2209275249381946, 0.5208451243017864, -0.26502063290323385, -0.03087641778462336, -0.5492835354388556, 0.2790362750498898, -0.05092383560044495, 0.2794580771514886, 0.35978519133076037, 0.343981697446778, 0.01547968330647255, 0.4031079954327595, -0.1189306593763359, 0.298958044448988, -0.3685452960243105, 0.41122877029938304, 0.19696096653553394, -0.4948335200852963, 0.11009852544431079, 0.4093128075463378, 0.23188339122476792, 0.2054298322453254, -0.09214712349223433, 0.12952503755742573, -0.19558044688312973, 0.39782214693096984, 0.15373824930448976, -0.16425007035310804, 0.3319489037239639, -0.27972734698951557, -0.12996195695028664, 0.3222946479397178, 0.15770327000362486, 0.7442418458496235, 0.014073114628305041, 0.575693273116161, 0.05763121526858282, -0.14698197042672712, -0.026533769545225752},
    {-0.024630592001417893, 0.14209216156390375, -0.425349905446922, -0.11226323543719177, 0.16390185919575292, 0.6292331842781669, -0.03284365636984747, -0.3474876590336229, -0.0621847835137131, -0.0814775825247094, 0.7249100803367143, -0.46314950932143933, 0.1075158241783489, 0.2002950674089771, -0.07797015133419778, 0.17462529692385204, -0.1978903484076016, -0.30040710956517314, 0.35407412175518316, 0.21170129756824388, 0.12696383856611576, 0.14233841780260742, -0.3957969099739987, -0.09472504614204741, -0.09277503335092116, -0.05995605039307621, 0.39654653258304856, -0.3396944153778725, -0.166169635633151, 0.17420418663535317, 0.21909401446832932, -0.05779539590188574, -0.011044397429308444, -0.019872635275056304, -0.21869086294328952, -0.06948641566324301, 0.21608790171547623, 0.07215143016208853, 0.22825061004679428, -0.0325389092080346, -0.051408110512775565, -0.4800289068657185, -0.4883510122038302, 0.20649166568094335, -0.082601548602563, -0.29702104548963676, -0.09475439027211317, 0.26006279569023755, -0.005995594446592912, -0.3090333791564871, -0.41435209985203564, -0.7061047887336559, -0.2160759651882359, -0.5466367108913279, -0.3196411804419853, -0.10922428508793176, -0.48531645788878697, -0.2697527783255133, 0.2501346264921461, 0.14811620590386337, -0.13903892740519694, -0.1295205917041864, -0.08069758579728656, 0.04454214842916259},
    {-0.1842034190975236, 0.14504991250706367, -0.09062215608585332, 0.15083454908262967, 0.022139346124951, 0.24719055824331998, -0.24965671028302508, -0.507739486901544, 0.007302469107710599, 0.1790151642456775, -0.022249127771130146, -0.13076908881854224, 0.02457041667141076, 0.0871994790524545, 0.05347742479653872, -0.07178939252033102, 0.014416916108691497, -0.44870020093106094, 0.07004388653769242, -0.49214153711657693, 0.12431784985143628, 0.1803713878908142, -0.15173153565209416, -0.13814523416607286, 0.2687134456704785, -0.20780440246962786, 0.1536734906296884, -0.005638233232936283, -0.3766919939366733, -0.3398482392733689, -0.26255591833125624, -0.0583569868220305, -0.01853549599587677, 0.052128800127777805, 0.21063393241928569, 0.23954666879305783, 0.05047883000396396, 0.13648378472794176, -0.16082346115401672, -0.5709304553192671, -0.15486086972406254, -0.4297044363679851, -0.5683017277023108, 0.4674091867696332, -0.09644197324926128, -0.04572476121839085, -0.14397180905459167, -0.3185483346671745, -0.10643185196128753, -0.31600505531020284, 0.15149684328184634, 0.15303085542078787, 0.21465892714068718, -0.08257565138598481, -0.26683278603799054, 0.21641143252709366, 0.1524296471360275, 0.1515712311798876, -0.03422193992364924, -0.25752134736155563, -0.10453973038072818, -0.15529528453868124, -0.01143691578195734, -0.42141506956305463},
    {0.10357050065835668, 0.25289468012104094, 0.117735138920978, 0.10903961346410354, -0.39802735655328775, 0.1734744305560509, -0.2027707753254414, 0.24480574546847916, 0.07210244167079702, -0.019695655418432663, 0.33373719865086615, 0.28369331316476426, 0.1714923346803712, 0.08487055487412301, 0.3369933101365632, -0.30663480254467224, -0.16854371705752458, -0.3245572564992179, -0.17512894168670165, -0.05803497054040093, 0.04314570200276289, -0.02006428141894395, -0.12829238925624098, 0.2485720826925662, 0.30030527199016044, 0.3255863462269034, -0.01635451635840482, 0.43179809348195247, -0.03707918191593907, -0.1595201589028673, -0.40822088912869625, 0.12589915113741934, 0.40975818348795046, 0.2015044991996529, 0.21289441436776924, -0.13217451987801784, -0.420331803716537, -0.35973931444887486, 0.2192866136747119, 0.6738133574134801, -0.3472926723952816, 0.09401833267437641, -0.28087049887395954, -0.108676809661962, 0.19993575471626007, 0.19249581898141388, -0.09644639958894542, -0.5097431060275, -0.1302144227906384, -0.23357145079563638, 0.4739641507999421, -0.4615659597954488, 0.3193262348006963, 0.14792166975215829, 0.23984776609385208, 0.1327217776879186, -0.17893593236993588, 0.10800331493502262, 0.27544073310277684, 0.22522870400142703, 0.03116809139633198, 0.08777190884464264, 0.21939503499304053, -0.08833237098337376},
    {-0.00546929436993528, -0.2369904594763407, -0.09959301971409072, 0.14780598367055603, -0.20412112172020824, 0.3825582592202896, -0.297436187925382, -0.1422891551514042, -0.35425596838574047, -0.06670150501310851, -0.3978020627324124, 0.2982730062125289, -0.635441493476159, -0.2873187866415595, -0.23192224882716944, -0.34437678593394744, 0.11911612444612808, 0.15706293633234739, 0.5692695955937112, -0.2367835064138594, 0.25023643016247904, 0.05289039777501135, -0.03540991687681637, -0.16040375566294873, -0.6488937591833355, -0.026469672905592847, -0.6536469475973308, 0.09168051455258629, -0.25451919961174935, -0.1997713341160028, -0.13611896634950896, 0.41089847941580154, 0.05301496874590292, 0.03328123532041659, 0.012020293993780988, -0.2016663763082505, -0.5480910191163316, -0.5948738057988179, -0.1845830641522089, 0.0022600599544177332, -0.3586028351923094, -0.01847733803669596, 0.11691606414639068, -0.05791700818800206, -0.20703988899875458, -0.10419890830912876, -0.18775982542785954, 0.00879874155277978, -0.32739270691657213, -0.06237976809398772, -0.0761874332129934, -0.4489299683145771, -0.13928029025192604, 0.19221132028212828, 0.1670406337537125, 0.07113559817919299, 0.09407079282990483, 0.049763057063377705, 0.00015561011246183011, -0.28636201241941134, 0.32941829751431234, -0.10386738002554373, -0.05230723675911183, -0.058776575166352305},
    {-0.4665491560290851, -0.18565908559538363, 0.2142576358858493, -0.21591232715295375, 0.5410332761984793, 0.3028400994329756, 0.586804764532083, 0.384467022088668, 0.3416592713742234, 0.3122583078606184, -0.3204197736452102, 0.1295667952584905, 0.08089439400562118, 0.10392412259642085, -0.22653723508747098, 0.2870287368609904, 0.34230670527963397, -0.15015217623254862, -0.20852959686456685, 0.1961693165715237, 0.1608993162378928, -0.011114442282013061, 0.024820660736540545, 0.11889183516761116, -0.336136369756942, -0.2508425519804263, 0.07329801631114127, -0.08525839823661678, 0.030942487309970644, 0.020017849035724504, -0.3028289519652446, 0.10515741261604747, -0.003629797998254668, -0.14628992787927664, 0.11997734674410221, -0.24677577619724794, 0.07642068994789428, -0.4485450471369749, -0.22042201293679675, -0.21273569023743327, -0.07093234275406227, 0.3361589420982336, 0.1627207546883366, -0.38415674951072964, 0.2526239330247699, 0.22018636161371424, 0.3704986668584756, -0.1922326178693907, -0.12817433548408685, -0.06248334047685714, 0.0633523646947115, -0.25611118427115803, 0.2573057572854325, -0.30255642013476214, -0.13680983551527318, -0.054430779399390394, 0.07334457802506872, 0.4062939303053076, -0.056385767058681806, -0.16809638952267625, 0.3811356551159434, 0.01071775404809974, 0.3583954479003839, -0.3345487553393378},
    {-0.43306638969314637, -0.37488400900296454, -0.1692745885018926, -0.1820465276703348, -0.4040511304195053, 0.08886967235332008, -0.2398164450404622, 0.04557707557943282, 0.0923346697143351, -0.42164411251450595, 0.48991628420623023, -0.39582511262772446, -0.21313007100547066, -0.055988116826896354, 0.11824624610539695, -0.24928954252848115, -0.2669473310694571, 0.02027224734075431, -0.6333871800304739, -0.21385044711774392, 0.16230543845445256, -0.23755241679902805, 0.3797268040004735, 0.01688383597627298, -0.007048499741118642, 0.24464770985238807, 0.23992347933179725, -0.16203160032822345, 0.39986978963349196, -0.19339137959525537, 0.31045635283816253, 0.455933431317814, -0.3127843163748685, -0.0769417221690643, 0.34340999892654817, -0.11837574344693862, -0.04711962808357461, -0.07546833423494059, -0.05104597029141608, 0.37985686504987154, -0.02490230880146581, 0.15616046899230834, -0.45383415198747307, -0.01395240058638349, -0.13205096840184005, 0.14148905099959777, 0.11586210920831204, -0.010805713700090116, -0.14009747776106984, 0.4653146763807737, -0.19035543751532732, 0.28122725060065046, -0.3901944932889343, 0.06933396805393051, -0.42267228423192604, -0.22444118364603627, -0.22943237602658514, -0.05810260495419435, -0.03561001185466694, 0.09428678496670119, 0.29559719689633535, -0.408252528750958, 0.143671243568715, 0.03788650036817322},
    {0.17878254367527674, -0.5709933980722361, 0.48592709390905603, 0.4033578810001373, -0.11572453389675633, -0.0330350163139839, -0.3087476948357424, -0.18950476809560082, 0.0642559167431421, 0.3712872841060237, -0.17233856879836681, 0.03504463915060193, -0.355614124315025, 0.0666943591558356, 0.2826633471363159, -0.2904362636608373, -0.06943894672603522, -0.0030306912235474226, -0.08532760565502562, -0.07622809625631603, -0.5981850707043804, 0.27697143789960604, 0.14285752364196397, -0.28190243280687066, -0.4750170299851113, 0.1156402977029487, -0.04602724130399752, 0.31926699222863913, -0.21367969570247727, 0.4620305990822894, -0.1687042272754423, 0.48595165428355064, -0.07143391863815093, 0.030318344156649364, -0.43374945009510674, 0.05243929939890895, 0.13577061016454198, 0.34360706816343733, 0.3186305868625633, 0.0863415893551388, -0.08854433086135617, -0.21873448094305653, -0.061185091197466526, 0.2622499103026433, -0.23066044433859795, 0.024475200705484316, -0.4334872913081982, -0.432436529180993, 0.3169705478118635, 0.08245046991035669, -0.0918605280551297, 0.07463979170256373, -0.1395674570668115, 0.3928169828799478, -0.2501421732881827, -0.2130212019638287, 0.25815666463028925, -0.007356511439929255, 0.12680092548400626, -0.06823293679862759, -0.34243768033743166, 0.21917626936371754, -0.34716614466505397, -0.1587260092720375},
    {-0.006208212506946889, -0.1793785080697292, 0.3898913276159918, 0.4378297108209269, 0.30898964557767333, 0.6232586907001336, -0.9248611913009823, -0.7902374299172514, 0.12589190810135814, -0.7940690051649084, -0.5960321052680703, 0.30321734607195433, -1.085439085364558, -0.8088236750104455, -0.40371537261452695, -0.7651908941319093, 0.4879170256089144, -0.047576540420902244, -0.11528466308535125, -0.73048678131365, 0.42835040744790825, -0.651062291484597, -0.6742647037789167, -0.6773676631835085, -0.37214228240795816, -0.5597790303578634, -0.04439547026461616, -0.5542741332907465, -0.7649495089375005, -0.37445480171968626, 0.1560449834491975, -0.43540249114821544, -0.2027159755796268, -1.0285125165662161, 0.14017584080582832, -0.8500602877067552, -0.574534556402688, -0.2103565903641432, 0.054900779701918194, -0.9757778331487734, 0.35855713042592857, -0.945999592791792, -0.540825333013951, -0.9079923359723926, -0.8117795652955214, -0.6927755669403368, -0.8173547962114767, -0.9440454724132563, -0.8357259677007819, 0.24555798469476733, -0.42918963511873104, -0.4078159886382625, 0.350601767600013, 0.41393370428917603, 0.3202037287700478, -0.11558089327720256, -0.666429806324643, -0.47165280106056545, 0.37277806101394373, 0.4279001728374129, 0.32082350404894117, 0.7988105769321099, -0.6551445928583477, 0.19943430589512226},
    {0.02010728090575887, -0.3929246342701354, 0.3971805454825485, 0.33244933891075384, -0.0955620608649414, 0.2967412708569435, -0.9412887708921701, -0.629251366581746, 0.12622187770671306, -0.6737606725651554, -0.5960229733936606, -0.20582445847493852, -1.0344507363586835, -0.8044202097932113, -0.8523569541309473, -0.9151487633987786, 0.6385513813722299, -0.16807050542560226, -0.09106100500577095, -0.9506553592760876, -0.30202932846642644, -0.5534865698938127, -0.7439165422284367, -0.8395674843620002, -0.9516958552570994, -0.3810910321832282, 0.12180761711795901, 0.12816055233031473, -0.5789242118859205, -0.5848278218325277, -0.31470844048908525, -0.9229270501701258, -0.4767259494342349, -1.0882441622087577, -0.2995133403317154, -0.7342328377324451, -0.41500664797077136, -0.12995512712507212, -0.3926548301311793, -0.9722171072146075, 0.47706412745347215, -0.7654057652533224, -0.3724054045493244, -0.472093308367759, -1.2160228161221964, -0.22124626367211075, -0.9792150912262878, -0.7175199245752981, -0.8913812740851464, -0.0682486403153059, -0.503397590743423, -0.13583496135065812, 0.7178717322785546, 0.8473337986319195, 0.32434746136103687, -0.35558437113155456, -0.6200634988998498, -0.5342598246590079, 0.22286183010687863, 0.37458334025022166, 0.08307565244558321, 0.6603547766107332, -0.5819231467696704, 0.21474989506792977},
    {0.35909895389323515, -0.3620857364963117, 0.16814402636294712, 0.37009301695086394, 0.11482421195054267, -0.11840339348643718, -0.2241402399659684, -0.7094358347020973, -0.17580356716992274, -0.4091001910042565, -0.19030293862567788, 0.39887403970700946, -0.3960012727753685, -0.7305726511228915, 0.3816147609868998, -0.658311300073524, 0.37088570619600386, -0.04652359028890224, 0.28005731913538734, -0.3089301131394075, 0.295735448175978, 0.1586094242359451, 0.07485795530865749, -0.30121750240051676, 0.041685840936971426, -0.01825340603324956, -0.12831693916927342, 0.2274287355472022, -0.47100992873154995, -0.16754276274037933, 0.39992981059882454, -0.5820380156466984, 0.41341448616999504, -0.46300187490780714, 0.3124933392981946, -0.40792019057064566, -0.55009845099329, -0.3387899764240471, -0.1872152240686027, -0.24245844727438692, 0.4484638498708767, -0.1974271013467664, -0.2746276405671307, -0.2395965625729644, -0.4103850475543854, 0.18751401748195384, -0.4890619305534426, -0.31324846263158634, -0.02497468002276275, 0.46371817227256296, -0.25177794734286696, 0.5143821366977771, 0.5300873073426491, 0.5967452512861215, 0.29449497475245034, 0.29275434457575833, -0.4678708464154271, -0.2442552613681558, 0.1523505013012919, 0.3839945619643091, 0.4562506381566605, 0.4473005549355618, -0.5536889772343084, -0.16341462626012804},
    {0.538656553367119, 0.24566143055813175, 0.5816182408647323, 0.03449166983135676, 0.18833926752138355, 0.1847600435386542, 0.26566045309176683, 0.04225173445048634, 0.3872517325696712, -0.37113420565144145, -0.16760348343971126, 0.47275977898512245, -0.5327478900900607, -0.5690958815707374, 0.6091147735426208, -0.2389895854079169, 0.3880349388835527, 0.5563363528227881, 0.6177562909837372, -0.26710395126695546, 0.10953713178308418, -0.4390690371493684, -0.004168134615036833, -0.060304267499336296, -0.2727841107768505, -0.34596159334852505, 0.17107614579090674, 0.21252790664682572, -0.3296018876371537, 0.43466859044996253, 0.44132976893309633, -0.13961498065992284, 0.5946550692686039, -0.5132733557323697, 0.7540423630273271, -0.2670203040653138, -0.5223025640674721, 0.15180160532661982, 0.05413403098373464, -0.3792333744575803, 0.4392191498280715, -0.16396000887103265, -0.44157874681571807, -0.17570666214016012, -0.12156761180437078, -0.09493244240659827, -0.08017227865821962, -0.306497567294601, -1.0870417253010913, 0.9669633885464765, -0.06484750952009892, 0.4248173353975639, 0.5663771489634747, 0.6125020168603228, 0.3651890612489224, -0.21630467753294821, -0.5508689973608076, -0.38050062747043006, 0.4079336392421014, 0.4979029599474174, 0.12412719537876558, 0.2819103068279671, 0.16559825504789566, -0.07146453578616425},
    {-0.0665596746416703, -0.5626616962778768, 0.5032001638552218, 0.4306072586469614, 0.4490254586939233, -0.18304311716377444, -0.4795916405303369, 0.04208821296921002, 0.06736407225717907, -0.4829010331662149, -0.04754148277794589, 0.24662553793193717, -0.26033669508769103, -0.018383014837687322, -0.12203519889470857, 0.11984024453193727, 0.5759549068623483, 0.34415689950998274, 0.5472193629018004, -0.3055219682345593, 0.5305686128597024, 0.07128410374285929, -0.2714389036660495, -0.34327273306763345, 0.014095727897666251, -0.3692142318662968, 0.33582180970588277, -0.3401795918861613, -0.2854398450994812, 0.3498865170640138, 0.02853954125436251, -0.8388695001895403, 0.05611029979428944, -0.35217910612100384, 0.30815496932238307, -0.18930426519335744, -0.38886766828508007, 0.03797807501203419, -0.21308269262942145, -0.2686426218586315, 0.8660529285661634, 0.14713090647411975, 0.04191208142819861, 0.08337807181950369, -0.18426939651671947, -0.007951911155824078, -0.5065331166384412, 0.22949341963786785, -0.5352537928027629, -0.00747507686800735, 0.37954501180016115, 0.41053796211932453, 0.4413618453872207, 0.5056379764622609, 0.0852768936818356, 0.14986918221034676, -0.2470626982292018, -0.060586186761760696, 0.12314390832094689, 0.26560942802134035, 0.30052826194301946, 0.4331998114290955, -0.1406696049170191, -0.24406570000522915},
    {0.019357562907196438, 0.2947428656189109, 0.23393957491363848, 0.17542050731304934, -0.19174538591793666, 0.09048854185702676, -0.3891167984556434, -0.8033152111194275, 0.4045437476078526, -0.8607902718256958, 0.18965336151673118, 0.24387734534461952, -0.6344002504651542, -0.617539172648374, -0.009087049476383063, -0.22112641401829497, 0.3743420156596989, 0.13638506064838324, 0.24448952288932221, -0.6310463959641709, 0.01302147964174272, -0.7842211861928283, -0.1405736243108104, -0.7198350842122431, 0.019546476880546455, -0.23999195896519301, -0.4737509723034721, 0.2646989433134771, -0.13375820755690043, 0.26190339500265364, 0.29922870318433864, -0.2744073584159497, -0.135293921515873, -0.5523123885525293, 0.42583363123736395, -0.398347990091677, -0.46156639944402966, -0.45238144643059525, -0.0028540025212600816, 0.01260307800012829, 0.3630762021823938, -0.21095396260013782, -0.3690292713077302, -0.4903286863403093, -0.552454595308357, -0.14535128577471584, -0.6710995560610193, -0.66805793947708, -0.3730227758943766, 0.363954143586969, 0.039098990761388286, 0.16474056339509396, 0.6001681833118421, 0.7191733036526586, 0.5099788088419064, -0.15846152681557707, -0.4335476695813925, -0.26562171922943034, 0.4051132599565964, 0.6823495936387685, 0.15784786155933017, -0.13669213668173832, -0.6659006439068996, -0.10478985540566908},
    {0.046941969635400094, 0.23332496693253893, 0.4805561657277965, 0.6185788056019916, 0.02645935805608481, -0.07152720753387973, -0.276815597367359, -0.09634561788263853, -0.5524787321523883, -0.19621776137142105, 0.1713125360041772, 0.35093138654169803, -0.43289051418745417, -0.05549473538536448, 0.6034473072585187, -0.46529310333218793, 0.49477481114625965, -0.17787739118776735, 0.7160536162870665, -0.3929881123971601, 0.17606869437790956, 0.5337217677370222, -0.3800178176581473, -0.2966514377409441, -0.08533439312162042, 0.1914282523084933, -0.09659971880412117, 0.3708839893486482, 0.014841939003038615, -0.018653962308708485, 0.0020838898389850154, 0.27336799904040515, 0.28681966492011113, -0.2827305664838572, 0.3893741192347318, -0.11394489285786294, -0.08590467408706272, -0.32084773348624945, 0.2671675995746134, -0.4270873072356719, 0.4343926780875914, 0.14045034667851442, 0.5913335739845879, -0.41234078588828077, -0.5278094460850528, -0.533788856075683, -0.564871297162782, -0.6204838402990599, 0.3803179817486928, -0.03058147795478747, -0.3338803634996345, 0.08294414443903907, 0.1521509602568638, 0.8880438537054095, 0.007075731558858035, 0.1691468554732531, 0.23476365491186613, -0.015619564119429517, -0.14245819396075077, 0.2607026062574786, 0.20322803808633239, -0.031148283577625207, 0.11411893937079504, -0.5267248091673914},
    {0.05577335166773672, -0.45130945045924464, -0.07767196901890025, 0.27021866412729534, 0.36886643966093097, 0.531811177342587, -0.6540429195094145, -0.07715751309563804, -0.45968510269179824, 0.00849226785236813, -0.11298262510315764, 0.5961301438459473, -0.28273661215294055, -0.3844505090627996, -0.13346509436243303, -0.4388430739912671, 0.47686789659960493, 0.10543642828282723, -0.4439473887379944, -0.40817228350993406, 0.5178216486024539, -0.192052991779433, -0.813203291900432, 0.14128490233072996, 0.4374111501456942, 0.41692648245509684, -0.5465058816560722, 0.14362217132088362, 0.18502012760609307, 0.12799405246650056, 0.5964727930032355, 0.0921116267090965, -0.14785641646313794, -0.5589331532526999, -0.10807825526799557, -0.019409624030173322, 0.022999426000883717, -0.15707128286322136, -0.4728323910634952, -0.4191893878624909, -0.6484941338898398, -0.3274330534456667, 0.2756724141619636, -0.37768368636751776, -0.6950310757271131, 0.046217917376386294, -0.37894060823558634, -0.3798178301129684, -0.11773625745607523, -0.06432491071397659, -0.13712111783888545, -0.2930430117711122, 0.525721370078457, 0.762768562263216, 0.6600372900022601, -0.4216531212261052, 0.1769855282410424, -0.28785953782822665, 0.5671548799485067, 0.3311479026341858, -0.26720560524238607, 0.16546523052290318, 0.2442532065131588, -0.029586229597180862},
    {0.789564790259089, -0.5638281775901043, 0.365854762130656, 0.2778813546092365, 0.20789825001848306, 0.17467590968254385, -0.36909776970643543, -0.2205253942416186, -0.41487310529382604, -0.6103060975833375, -0.13063866522077028, 0.198378958571351, -0.6155591516320068, -0.4978078672320854, -0.10611593775672619, -0.46376465073944684, 0.5253726167229418, -0.38758223761291827, -0.24982483310676795, 0.24459468705992188, 0.19317339477605838, 0.28431843228419157, -0.28787423801273687, -0.15901983451187768, -0.1125249643289377, 0.11705162448453509, -0.5419089812914778, -0.5549750895774922, -0.284299368317381, -0.40733696878982556, 0.054660855967339016, -0.3292083752483997, -0.2825951478197059, -0.7163463919443356, -0.5929537352659794, -0.2439053776931585, -0.5256925693728015, 0.482136856252194, -0.1874925669733048, -0.838399983983337, -0.31232899496878475, -0.4705220073888441, -0.14248573083955898, -0.4537398168936771, -0.8898670464764782, -0.09797693978041025, -0.07468537427485133, -0.7056783138174935, -0.4593509689580047, 0.21235250343326548, -0.04688219614795053, -0.04725925572747332, 0.37477883815986224, 0.6301682446228875, 0.1640239818075879, -0.5425336321422488, -0.41587059331447046, -0.4761164315722947, 0.41499811507503387, 0.6932832694103269, 0.3237110519694879, 1.0250705215379754, -0.6934041572148352, 0.6018899625825522},
    {0.28040066567389227, -0.20585708585037618, -0.12886551884664635, 0.2707558072744562, 0.23023055736320336, 0.15029088784653175, -0.043746648797084314, -0.4813443459368165, 0.32836651065819483, 0.033386212481626154, 0.035618685940190034, 0.5107528181878584, -0.10383207389290593, -0.5343137477757788, 0.428404781953849, -0.8281721262677693, -0.1658091405695211, -0.05053033262249051, 0.10816719714118242, -0.265788938511186, -0.5364758126930246, -0.0011685063194382197, -0.02251595513726876, -0.22796531125311503, 0.15728276791479234, -0.14159846269749146, -0.05141507458214043, 0.28312671574223186, -0.16061331709791335, 0.44035461775482987, 0.5481850530329563, -0.028345819619403988, -0.6880522665657612, -0.4887959451347844, -0.004154048755517521, -0.287427665920971, -0.575219473437593, -0.039753253540630695, -0.37927902554785436, 0.007692377681878703, 0.3422906932199624, -0.5086753929455607, -0.050032536341266975, -0.19382802648644365, -0.1731603541908598, -0.3820359434523077, -0.3716367468786244, -0.3816643462506934, -0.15566028278812308, -0.4357348879285027, -0.22994914130102348, 0.28509417290349504, -0.3018968895930883, 0.06385541645892319, -0.08006263715533324, -0.3722597597186298, -0.20717544472873892, -0.1153434256577289, 0.08157369240051877, 0.05991560096981201, -0.14995400716635923, 0.17119182172235956, -0.009116056585770868, 0.19061288740333793},
    {-0.010033438812798414, -0.7257364378966372, 0.48510733982052845, -0.029413178171216175, -0.1191576135015207, -0.6379162719594237, -0.26138508203602095, -0.36479429899766064, 0.15748429160478927, -0.44496717638381406, 0.20193597279558848, 0.5903197045669007, 0.06502989951250414, -0.17420714142385943, 0.39112770664745966, 0.024506569481839064, 0.5602916827516193, 0.10565558895251201, 0.1897876689618665, 0.13080304073761642, 0.3957088318472957, -0.033519834939493114, -0.10721381347340785, -0.135020838961482, 0.07634415591695919, -0.08029863853732541, -0.16064760528483213, 0.15068595283960817, -0.2105689851633496, 0.0485953181574353, -0.4089837694169373, -0.10067762310012754, 0.09423263523413009, -0.21540061461837137, 0.09947419955848595, -0.18580904156812386, -0.17603976558137296, 0.4230401650601419, -0.03211537277165056, 0.22846998006385474, 0.24981549250967472, 0.2323046475027989, -0.2547387611987547, -0.1651527576053732, -0.2760431130249352, -0.06335325551731602, -0.0837762310033082, 0.01134229333801108, 0.36583726998604504, -0.37071730113995716, -0.1320431068522632, -0.1240940350572509, 0.5513069211746466, 0.24544972877642804, 0.3516178311777817, -0.17081070044421529, -0.6500890404422756, -0.30496153872824344, 0.0910499362713848, 0.06297168040121426, -0.25901855726583745, 0.18134102780286843, 0.3296781941289864, 0.2437115188835787},
    {-0.09721710717415499, 0.6219178516072515, 0.09932860705019685, 0.04244580053635189, 0.1433736473596486, 0.2731225513172826, -0.02328345835951664, -0.02485615715923524, 0.6520743460734, -0.0920728140186918, 0.42118592707660507, 0.471530072338972, 0.007789113973787252, -0.15449872424843125, 0.02469605861503844, -0.4144179302460715, 0.1751229695195712, 0.25370239730536975, 0.45932675602792955, -0.044913399802988516, 0.4264251961611901, -0.2731198172321463, 0.25398834324754355, -0.05108401880403716, 0.025447976344707954, -0.37028069916685813, 0.5576720850241578, -0.2816108058331152, -0.04681636451872679, 0.5498754341498313, -0.4871969844623671, 0.4212450990348973, -0.21789718719797, 0.10750444009533476, 0.1881128044508348, -0.13785603356865972, -0.13797186053985172, 0.1297576491100085, 0.16768993978394658, 0.05905446235408538, 0.2934061388252641, 0.45402630942319383, -0.42090983190425607, -0.3283675634719977, -0.4116713616562784, 0.21700876330108881, -0.019635532792984123, 0.05228140993462736, -0.04007276346761888, 0.30575492772423396, 0.21466114448112408, 0.43087264528061997, -0.3470184400658692, -0.0024043744437101775, 0.36572121029438126, -0.37564544405416694, 0.019841481473791243, 0.4916945344584136, -0.6839315881845017, -0.0589728680162323, -0.0689729389362073, -0.33455225315138254, -0.16196506055749169, -0.0035724014621596996},
    {0.12556720061816945, -0.13577429284143813, 0.35667490306008864, 0.42398278033336745, -0.2306084020312283, 0.27683791319316425, -0.7115814843701281, -0.41194195849999, 0.4915055405007507, -0.0667318515160222, 0.290190804781142, 0.5963929318455795, -0.11538568720039627, 0.253016613509004, 0.6303348958028457, 0.6145882719662571, 0.6700687297541813, 0.3209636761779179, -0.18206312653911924, 0.20122193620500506, 0.34453569446115323, 0.07766735922806915, 0.00703826648944155, -0.14170880804987787, 0.054336272748332866, -0.09251201129191225, -0.30837507523659285, 0.7716657650246457, 0.11583984894406732, 0.48210500174563237, 0.05528465417109823, 0.5159107393109901, -0.5524464083172227, -0.18160916598504934, -0.5958268713998235, 0.0988241208184578, 0.23744062893529452, -0.3712598979563136, 0.5018121841864375, -0.38849152478147303, 0.012233684400111612, -0.21236021564214555, -0.05436421039794007, -0.1423975218510186, -0.348736648511814, 0.268062441606386, -0.2679366700710422, -0.5708974123787283, 0.09277947621240347, -0.6669904346231208, -0.10179325527658221, 0.663735256624447, 0.11240390212704261, 0.9954689576469207, 0.28453009298464393, 0.17914918596938118, 0.1506889180646149, 0.23569889442284622, 0.3732543609083705, 0.33537711842502327, 0.06967876492959213, 0.0954224022796804, -0.24396669067757723, 0.420060176785391},
    {-0.2266394779387487, -0.037144119895468744, 0.2901324416067462, 0.3919576747720248, -0.3449927920868081, 0.340390113196975, 0.4853244722629918, 0.10646077321827455, -0.3853835706698098, -0.10793299373987246, -0.16091515887002736, 0.154217189500945, -0.19793084469151193, -0.2557351693876141, 0.302990233866574, -0.34152392931453357, -0.3814673755134574, 0.09891938854256473, 0.23295834211886612, -0.2158436239537313, -0.09775984355071923, -0.09697868690932909, -0.22712088272183598, 0.17398594552846902, -0.21807058395777806, -0.15180828283385928, -0.5160734405427582, -0.3796141673639125, 0.6881826601076968, -0.36040575394263397, 0.3356264259520414, 0.23104006038408995, -0.13932006940753622, -0.050915198382145845, -0.2609123841494029, 0.19339016678314283, -0.1360140800978085, 0.586317997908513, 0.4115874820881532, -0.1759333402843681, 0.5831128530703535, -0.4646401786396047, -0.17479949856027313, -0.13324234764953122, 0.4850642133603935, 0.17500999987609625, -0.1885079594342166, 0.12153256282566391, -0.16883300625734923, 0.17075947809016034, -0.2619625222752641, -0.16587922087654292, 0.2526078062831889, 0.38961748690745046, -0.19555725102137794, -0.2743761843797468, 0.3649750666539197, -0.43340622267733586, -0.05017578392465769, 0.6174592850796852, -0.16021384057486096, -0.31464767155199497, -0.295202162850913, 0.15917403717676074},
    {-0.3077629744688605, 0.3099775268569305, -0.15016462610294537, 0.27642011431194485, -0.5877100571986877, 0.3088992873653195, -0.19276733997249712, 0.15303842553780206, -0.6168636612002383, -0.2885979011025198, 0.02363741142680367, 0.28554036130472155, 0.17903422501140132, 0.441089725190965, -0.0077580031732103205, -0.15577013278167043, 0.12034501037786802, 0.031180331545122657, 0.22744647849077754, -0.3154673038554895, -0.08407411472669693, -0.1518122258174509, -0.54332580107758, 0.03606462142645551, 0.23088418900877572, 0.07963136838281307, -0.14358839456491126, 0.05047520689893614, -0.1707843495380884, 0.15420202982944223, -0.21373534399708402, -0.26088001959988405, -0.298303070918236, -0.061559943633162174, -0.24401840540731742, -0.4086516562479117, -0.14609370429628485, -0.1466262900255124, 0.5167275708696206, 0.24719013762762237, -0.20651765015894025, -0.49760706107525277, 0.07238569171392761, 0.4289281248393821, -0.1580853526892499, -0.22182504985300244, -0.16132456305304163, -0.4671134365294871, -0.02462154597268855, -0.14587459133485353, -0.8950939306683564, -0.006495427377222587, 0.392941806108786, -0.3649649946962049, 0.21233889789914792, -0.1341575026834254, -0.3744224489939249, -0.44835917850848567, 0.2736142853999772, -0.11987543890971257, 0.1451076143215636, 0.427177258555262, 0.020117897030538644, -0.008425683883190703},
    {-0.026419650579945508, 0.08108450217461909, 0.4203389017557357, 0.36748856223722626, 0.06486688076768485, 0.46548708524529375, -0.6146661078745055, -0.5723129839269119, 0.5628414557297675, -0.05566430269923513, -0.1189419194014967, -0.6389247956066225, -0.2905080187829837, 0.15924255865389017, 0.6183155634089477, -0.06755613903907853, -0.5601716084890526, 0.20867697424287715, -0.12797272362064224, 0.18438361435061382, 3.512930673269441e-05, 0.04606490976905049, -0.4973018556160076, -0.20861619609548554, 0.3511396442665662, 0.5027705262231774, 0.22096411134238686, 0.05696823286885498, 0.3781045381474641, -0.04411610671723823, 0.036528631996789344, 0.8934567367481359, -0.3545856435999235, -0.1779311073669916, 0.13988115219127853, -0.1254174415462634, -0.30411684439919195, 0.3444411711929535, 0.28869282517475314, -0.13879920196919193, -0.03635876065822571, -0.698114721781371, -0.16022020312468846, -0.2875389442515242, -0.7126964316884435, 0.19200336813571534, -0.24132612994633737, -0.4780475990507682, 0.10927710140641338, 0.029807694827891387, -0.630274853362898, -0.5189321661110732, 0.3847461147752481, 0.6356042489794975, 0.7136885355796817, 0.3569687851215126, -0.1717424062661934, -0.251477537322339, 0.46344735358898576, 0.577198286527294, -0.1544794350598251, 0.5536541129391362, 0.05863435566393076, 0.30897438839042435},
    {-0.5449234905381615, 0.04792975549015022, 0.2123916866277273, -0.36750577976562865, -0.1578514404709519, -0.12470554753614715, 0.6152920410155206, -0.05783659554752002, -0.16229849185305234, -0.782364966488488, -0.2075907085134571, -0.3668173282042379, -0.0632009461027807, 0.21022005365708205, 0.09975607028855969, 0.1348747594018902, -0.36557200815707347, 0.4149631403676769, -0.30767602240244446, -0.19288271469817245, 0.4943775280623432, 0.2388526891377134, -0.05659234069818215, 0.09654910113228073, 0.3116177284221387, -0.0912873754966577, 0.41630375243638695, -0.6615351062704483, 0.07256667176150212, 0.15323715747768316, 0.3469495500294349, 0.20462154827082066, 0.2819275472678248, -0.4253602380785824, 0.5475882033114133, -0.018621123026535614, -0.00707368777293839, -0.7230116413817081, -0.03221280196463286, -0.506436545725664, -0.40075761045577213, -0.08798393965867994, -0.25546155647052193, -0.2754795206645515, -0.24561468255335744, 0.19297563820975347, -0.0895954774184517, 0.03220639965992209, -0.2300628529617436, -0.24937531762909332, -0.21594073871681232, 0.5920864048329088, 0.31344784789446084, -0.37743087587338736, 0.45888944608644194, 0.02867617493433192, -0.10539690908445196, -0.2883507982099032, -0.8767130544617716, 0.6681355307429984, 0.6162979974511531, 0.2832228892248433, 0.5466706156275308, -0.1347576075966379},
    {-0.23274334050199774, -0.21164595605041894, 0.028954776350398295, -0.22467799982232384, -0.27769480379746125, -0.3360313767831147, 0.3316003750675092, -0.330502489010197, -0.48174961933862714, -0.1066187834358809, 0.37652910251841326, -0.5436515986968505, 0.09811076643163695, -0.15597800009221716, 0.4269505378899317, -0.4551535653584178, -0.12304039160736391, 0.3797345267735894, -0.36559605751510227, -0.31443343386034345, -0.316905202151557, 0.1775328279302587, 0.07919884465488614, 0.0725378990027331, -0.02827490713038858, -0.017934795370430214, -0.5928180375064895, -0.3473336245378717, -0.02110414358371913, 0.14383473954970283, 0.07734807768324553, -0.5179856671644213, 0.17147978037827216, 0.3667193918179282, 0.20620603085754824, -0.06398842161843166, 0.1145804626527757, 0.3554624946953999, 0.1602627072050043, 0.006614521077926772, 0.2835443050183838, -0.8084354836019766, -0.057247468364008965, -0.3805421934841251, 0.05422476956808439, 0.585338701866098, -0.3427609511489344, -0.5874427036614407, 0.013914231136197362, -0.3384173557331417, -0.2751796419721143, 0.3023540044595517, -0.028293201400896695, 0.25168895125854046, -0.20674710905530222, -0.14017310403006292, -0.7264666327332795, 0.22586755593527655, -0.007093479678472771, 0.46553888851182845, -0.3881761745985738, 0.5926853353417993, 0.23384964859457627, 0.19956445161934225},
    {0.10923589026775916, -0.44040997425284933, -0.40016784116391835, -0.2610663228164787, -0.5175276240298524, 0.046062162802691785, 0.34936673260519097, 0.4725939362038503, -0.03445820806238247, -0.3704739799834897, -0.16690624906608864, 0.10109712330978005, 0.1943117536462705, 0.029802335045359233, -0.030956749208181162, -0.5291452724164033, -0.14779344887831716, 0.5183569813045787, -0.00551668956642233, 0.11946339639592345, -0.11542112998301708, 0.0011152109238537307, 0.32904779634687115, -0.21966742980944232, 0.041931560040539224, 0.02111162893683869, 0.0852625604974262, 0.1771830782143762, 0.23436468194394108, 0.3566777558837521, -0.04960228005501991, -0.20954768027032258, 0.4922563294682859, -0.007378698331363632, 0.041368057237472326, -0.34686377646572847, 0.13769206935846545, 0.050437503124772354, -0.2984616309944113, 0.2213604950318911, 0.23265781061507448, -0.44495483838409633, -0.43672331516646806, 0.15620280304745388, 0.06437293384901492, 0.5518323818309059, -0.08110661126888588, -0.12808740471013264, -0.01888505430886678, 0.8407383774136564, -0.6012723828625177, 0.012124925099623382, -0.03415656557118737, -0.18410004864959617, 0.1971771334487285, 0.192546789823191, -0.0670722180169694, -0.6963003571126916, -0.048440730037483976, 0.3251270799488161, -0.05674934519980108, -0.3438466152864755, 0.13108104612301485, 0.3753600978216882},
    {-0.6747204118681362, -0.555612741362022, 0.046845094723155345, -0.5229161697365963, -0.12280421902269767, 0.6142989493121261, 0.30957196910654156, 0.15295841268591248, -0.4856150933572584, -0.18716045242658, 0.47266476183781314, 0.12498312090253963, 0.1856124324209759, -0.08989325383008442, 0.11154570554308622, -0.7831150913371989, -0.07235547860847519, 0.32761114357871207, 0.4655068428025936, -0.11533785880256532, -0.5266384744677517, -0.2588181495947976, 0.5005127258749491, 0.5709677879895607, -0.2679502556365741, -0.23259094102034164, -0.07849987345667127, -0.02641646972359383, 0.314586005407223, 0.2434595042844884, 0.028872480978635897, -0.2118820841621433, 0.0744965650632004, 0.8329649412983398, -0.5097722485797526, 0.1591965172321808, -0.17786757360377486, 0.9463783959819728, -0.3676278114048432, 0.7071953201767811, -0.021544200566327845, 0.21682321557813547, -0.2096583506787891, 0.467243308708257, -0.3578121815167585, 0.671250650569792, 0.3184805532145796, 0.04164172564286743, -0.5448470453443123, 0.2064233847811256, -0.02446009752669491, 0.6171617554387646, -0.005955784940105315, -0.007340579163041463, -0.13851547067312162, -0.15997754236558975, -0.17464886373484387, -0.07082596131729395, -0.08894978222434392, -0.24915713571226994, -0.1398315452934239, -0.08932122828844083, -0.24472723039065028, -0.013863806656437522},
    {0.04767001722184879, -0.15243939114060512, 0.6754824618631904, -0.23680171432281885, 0.13002140896134684, -0.22508780809864362, 0.6919254858032705, 0.36309064893238446, 0.13522529078929593, 0.40013586612378654, 0.17698490746582013, 0.10186035880768803, -0.1919182434156021, -0.008240388776429658, 0.5823897466487026, 0.04006819615275254, 0.20437610184438412, 0.40321532011383954, -0.0449675507743728, -0.7067024107458264, -0.3459357834551341, 0.6346801302764105, 0.1181021489553018, -0.6330078331380499, -0.32818341166242054, -0.12090003400025508, 0.08064414011662165, 0.337478602063462, 0.0700671542828025, 0.533659129662704, -0.09402494782581035, -0.016450912641615, 0.44847747348503275, -0.33138735926275253, 0.1760925172968371, 0.739298806632196, -0.14074014547644054, 0.24003916966181432, 0.24146544941203124, 0.19271314525840677, 0.34636906545845664, -0.21583368638782618, -0.004465561769118789, 0.5805926890781153, 0.20181115306630504, 0.4238693889448363, 0.34422984604124907, 0.011223053649410897, -0.5547981426785313, 0.29298904024098565, 0.694517724521108, 0.6370278573584017, 0.4634674266611218, 0.45117613440609, -0.5281437986111819, 0.3816375256313787, -0.2225764774974026, -0.2182941023897043, -0.15641438764097662, -0.0035735208503615773, -0.1647861417240663, -0.08382715216336906, 0.415087734760673, 0.028677106249617047},
    {0.1193200452867411, 0.1786137803400193, 0.3627010916141872, 0.6235868144294092, -0.7961927595646279, -0.20911492941318102, 0.0959879176931178, -0.17716026794383002, 0.43995032326924444, 0.30232878902868787, 0.589656969848851, 0.5179111239937443, 0.1100869667307385, -0.31939890808484894, 0.034160673291216484, -0.03783979524321546, -0.00508789135125412, 0.9347069654377554, 0.23704033853320144, -0.4621491093757715, -0.6390940600091857, 0.40362677913083284, 0.4144136431221449, -0.11190367321185501, 0.2979514378036005, -0.06598236282053717, 0.3809107602536916, -0.2171024526026416, -0.579245536193788, -0.1741304190957696, -0.031844331479572316, 0.055660331799027955, -0.05279185297319075, 0.134480897479498, -0.18570311190162836, 0.37482616715718764, -0.38209117266108295, 0.3355901933568794, 0.1687334300922405, -0.16847346753505982, 0.48039346204901223, 0.21066204062829896, -0.6647035546149479, 0.09823886428856593, 0.5641566949356824, 0.28783035456527556, -0.019207708002934337, -0.35757315196097567, -0.3544136007488925, 0.31709756720694804, -0.023645044294503474, 0.5526578220407143, -0.08108205683325331, 0.13865878476042431, 0.06417454300469803, 0.3694660117606292, -0.04890720744432053, -0.04719157005736902, 0.026713186091968835, -0.1371330698937333, -0.16092143813499687, 0.2920896822272806, -0.36201483853332306, 0.415818651839886},
    {-0.6814068838480243, -0.2979176418300244, 0.2824710486903952, -0.37055990664824195, -0.4212454637864619, -0.16094973650060793, 0.44405464110104376, 0.34780061275868374, -0.09047552380315894, 0.46178795810715123, 0.5353863844686351, -0.09453931976015022, -0.23936847990515073, 0.24215233005823739, -0.2524406349920987, -0.517989555837337, -0.12849358730932584, -0.4459602066653608, 0.17324011023762378, -0.24454572139930528, -0.3731220990249452, -0.122637905938811, 0.38994519899311714, -0.3398841044362332, -0.016013093984701125, -0.48501099829993805, 0.4977746490901135, 0.07103088335860361, -0.43384675626671115, 0.4180401838446288, -0.11566336911466674, -0.04357632545942591, -0.3062671263503689, 0.0042156067110967685, -0.24253069797516563, 0.05756830480174157, -0.10272981664484648, 0.509413744739664, 0.11286255768047437, 0.4082660164228565, -0.3844632653146984, -0.314147654782914, -0.6372856063922883, 0.10124327474618944, -0.02686398685344354, -0.09366102376059957, 0.10160340035446175, -0.2930305927429342, -0.3698825403694841, 0.6049548485280819, -0.39207219202145155, 0.33475361737478293, -0.2110627883855953, -0.16684867026697112, -0.35363121342980586, -0.4999005520910207, -0.1454666376333511, -0.4904364492694343, 0.6121952988204831, -0.09345465409782752, 0.23897259267149787, -0.0004591469549695267, -0.02593822189203792, -0.20509950436841048},
    {-0.6553560821980918, -0.00451098989137286, -0.16897466975721, -0.34074784158891336, -0.007421144379402052, 0.03767384164711549, 0.42926963283743513, 0.45630151877564273, 0.20596680570875028, 0.6586158821853545, -0.20867155585526964, -0.5501265787658539, -0.25208453253552215, -0.26141675050390456, 0.038170904303382845, -0.4486493060499134, 0.03325406030142198, -0.7054006391494639, -0.6437308585492426, -0.09640875834702003, 0.09862883587821335, 0.06673717053690471, -0.01620950992576647, 0.1916139890857212, -0.14691757576760037, -0.684357538128053, 0.45392680669678404, 0.13143750950715347, 0.08694156102030984, 0.14493829176553938, -0.2868025296415559, -0.1876426754132153, -0.5228041921989439, 0.16560590347365517, 0.4676130585273727, -0.13271493465343143, -0.5382806272594297, 0.028802657884923276, -0.13526507845782382, -0.3372754007490295, -0.10564839953162825, 0.0647450249034138, -0.07219541233117109, -0.25578982760242847, -0.20190709266862597, -0.2772436085816268, -0.21982528237096077, -0.23615318864724721, -0.12786712170521952, 0.22257682096089487, 0.36154042182037294, -0.3774809315475614, 0.3037195870837923, -0.037015088858302306, 0.04974434149854708, -0.36229986673972475, -0.2559534466247276, -0.24748925666375296, -0.63341177952484, -0.4280043311660521, -0.34144814757884245, -0.12415590629461536, -0.0781988259310808, 0.12185853055665952},
    {-0.41278476775404094, -0.4423920788771596, 0.22608418726620766, 0.11063914019543755, -0.3112954414702919, 0.13020661047656878, 0.051404639662525245, -0.3056177226704851, -0.2398960433614437, -0.45233388108106465, -0.719212068848485, 0.14153546332641692, -0.13111604617666556, -0.5107691689546993, 0.1463347160248091, 0.2705045784319127, 0.009437259410800626, 0.017596447416726696, 0.5264052555435431, -0.5021476067263883, -0.2737004961758294, 0.26126692699208265, -0.10231935381006885, 0.11715445832967143, 0.3841887967544947, -0.4744112776839001, -0.4439387690179888, 0.022135054389183603, -0.0757390853850692, -0.8926282589160991, -0.4696496323330073, -0.2007779800875892, 0.04519720499503706, -0.4425503211191164, 0.07303545613186278, -0.16575330508191982, -0.06624081845831015, -0.4220920656278059, -0.12122983326720355, 0.02027603257897952, 0.1368539869326053, -0.0875264416542719, 0.07097738947462466, -0.23926883226831586, -0.37593387302436443, 0.022436024154323764, 0.1664852597642001, 0.017010089174412265, -0.07757668078923141, -0.6388952130591168, -0.5763812340287177, -0.377955703198263, -0.15288880148390943, 0.14424866944200085, 0.6102117493461935, 0.7210194994372525, -0.6316955703450678, 0.01289450177943109, -0.49858725705097046, 0.21901955967059888, -0.501832322236017, -0.4156129343803907, 0.08076675541421419, 0.1478445711714542},
    {-0.1040088350519491, 0.023735049512840587, -0.5032121016015982, -0.007821339328786831, -0.15316623668101437, 0.07375857797494918, -0.5700206210414432, -0.27389558737911673, -0.21279152760651096, 0.2821843994773808, 0.23593054106333256, -0.007045139363044582, -0.09019070910251666, 0.22888563595106715, 0.053254388861544, -0.08630059599078958, -0.30753933525138355, -0.6425378547114403, -0.11109220603273012, -0.2376040846300408, 0.14943048600620557, -0.395043249595497, 0.1432907953618753, -0.044158083662903136, 0.33399382433538, 0.18279808609771708, 0.009572423646625266, 0.30360804341473846, 0.42494418695552405, 0.2792189335060055, -0.30199476556578997, 0.0943840987010739, -0.2511587358991456, -0.32605372266174165, -0.4167405795708204, -0.30396949206047785, 0.1551877139143219, 0.07513418423358162, 0.060665408338478596, -0.5771359106461345, -0.01473328622554079, -0.4283911792021359, 0.3190224175445898, 0.4227911580078118, -0.2560528451627354, 0.5906706789455958, -0.516912324633655, -0.3219497347039182, -0.1416328744251873, -0.02165802010512785, 0.24790497536017367, -0.0445962228028549, -0.13683665023333497, 0.11915453162180187, 0.14619294165318023, 0.4850458096784885, -0.1858567382659588, -0.05693864665913392, -0.03614914128644369, 0.16834198512612675, -0.4345881949175121, -0.26985620753485473, 0.32032108423046707, 0.1365594479948538},
    {-0.43680699353979835, 0.19422242122350333, -0.1651194162304958, 0.43761426304831424, -0.1301642256170774, 0.0714345988263957, -0.3472800052837881, -0.1387280488907163, 0.018111641851879932, 0.019210315400820997, -0.09380250011330382, 0.19581929928058758, -0.32050857901675583, -0.4327063561582221, -0.2686531237426048, -0.6921638203656338, 0.36066166444450776, -0.23686882655763222, 0.3041776846433994, -0.3379176403606104, 0.2918736044348162, -0.3262937073849892, -0.4999132374602536, -0.1222275043388011, 0.09380438927191453, -0.08202007628865537, -0.3205600660231365, 0.06882311909712115, 0.14008305059880877, -0.6060984541822114, 0.24347553535571567, -0.27827373081012663, -0.2973008004733298, -0.551859153511648, -0.2910369602885866, -0.2989111291532792, 0.20336280747099178, 0.21947999579592475, 0.05613315285583757, -0.12900840831790705, -0.14170475963469437, -0.5552922055113285, 0.3131389319233665, -0.48797622000643187, -0.44684780288576426, -0.3344993740789665, 0.13763728082268586, -0.40903432279399365, -0.22995447114611323, 0.21369088821212742, -0.4981581672091968, 0.1750882017439076, 0.1529261376600788, 0.3524460069513879, 0.2587335846751512, -0.4731503880046741, 0.2078109592482223, 0.2438312212624871, 0.20274059440327044, 0.19809370309778843, 0.16561185951085097, 0.2666052908588247, 0.21715740559517738, -0.1289124587869626},
    {-0.599561741804315, -0.15851429300784206, -0.31482066004982817, -0.05305783879980583, -0.05937995205990909, -0.2064926938308583, 0.11850168920121494, 0.3073032828989384, 0.07045954784158007, 0.23558459290457315, -0.27715932993404907, -0.07753426929586957, -0.2577920624413688, 0.17087643954714582, 0.0016585409694995115, -0.2528251590625184, 0.4799734032777849, -0.4416393826316119, 0.2950387544242403, 0.05427605126378965, 0.3093731624332144, 0.05221044619020841, 0.5052768152648413, -0.5681723114779061, -0.326218807703507, -0.17760975998822676, -0.2904862955373307, 0.2948133810602505, 0.37062164703689227, -0.23260267854691735, -0.010174174415330188, 0.30342904042560187, -0.2940152525241142, -0.08122386682813582, 0.3354440458391061, 0.532428287281897, -0.3959841168935201, 0.4859442265344, 0.040848129366411925, -0.7741220674443291, 0.6481283526416973, 0.47763138364253516, -0.5949232840986332, 0.1085278320250113, 0.2753054073855442, 0.012216067499139529, 0.15615761536522207, -0.007674250172710883, -0.182234657372377, -0.0909393302170502, 0.055980158013401685, 0.07783359786833942, 0.0809846290594539, -0.08322087419569349, -0.16495761104475845, -0.19157351250548466, -0.8289142230712402, -0.08965978421453305, -0.30114137611554886, 0.33978620855215336, 0.5022482121814204, -0.19066007202779456, 0.442642137430352, -0.2901011265974188},
    {0.6153912366672233, 0.2479549312902979, 0.3969607856591215, 0.08711989837944323, 0.36220960520040113, 0.16563812951352186, -0.11890060331964677, -0.08604807045772679, -0.005637193669595341, -0.4412887900548114, 0.09753933683011103, 0.12918945384442834, -0.6593991699895467, -0.155549527963896, 0.6173382051419521, -0.41777933417902635, 0.21075429136872428, -0.09179165707173204, 0.24156471634719787, -0.3853493636031092, -0.0977134099109035, 0.12824321272343417, 0.3491019977333693, 0.5076817946026073, 0.4418886983903081, -0.3165950494952601, -0.3237618875786749, 0.15353617154314803, 0.17237281801129847, 0.02695101441026174, 0.2524660713586236, -0.09693921729718853, -0.29153639563672956, 0.17543329547626632, -0.27592837179981533, 0.30561808851074584, 0.6079342076150823, 0.12040473512127121, 0.177667656472814, -0.38954445134145277, 0.15139142531017058, 0.1754951637547166, 0.22427383056699352, 0.16133784951571992, -0.054628197188441294, -0.0010647397488068582, -0.2475369441379814, -0.2309705148201082, 0.024492986313305636, -0.008144128178777115, -0.46403997288209553, 0.2423378868693411, 0.1642689065724955, 0.2026818608929671, 0.3060253061651694, -0.4933493342323733, -0.04388870186997385, 0.028097722338135435, 0.27707633272068327, 0.2590833236187709, -0.2558525112112155, -0.05603221932905167, 0.16660523166994365, 0.3663408480446501},
    {0.6262928408780858, -0.26238917864719025, -0.18405025009476333, -0.1408117118261975, 0.11938965075884776, 0.4665400513490719, 0.057424764003695714, -0.06881454309305207, -0.5279014109921363, -0.391307390591187, 0.17720442785689405, 0.4068032189989439, -0.2707170782556384, -0.053591221074738266, 0.008672609512624519, -0.08480186402839525, 0.5518659088036914, 0.4586322895827805, -0.43539626132474357, -0.4922561638616402, 0.44710093806840046, 0.015785388528957955, -0.32154294143411505, -0.6496696984008582, -0.0650204197467677, 0.07040937320121238, -0.09839057572558263, 0.027708469038195564, -0.023883516525147537, -0.3831969006613004, 0.2788920063773859, 0.06129900762125886, -0.19025251837964915, -0.6936659736622903, -0.304380575195421, -0.0916265568957259, -0.7836950994944994, -0.49399888136749387, 0.5714457814746235, -0.23413982293886915, 0.15508329461208303, -0.3878155209490726, -0.18920383873574184, -0.1916650072326303, -0.1791566706067616, -0.17045841264755962, -0.652481840262091, -0.37578915807047275, -0.12500660117679158, 0.1866747524382159, -0.28338836114118887, -0.07072645415915663, -0.030174299927030045, 0.2973620065511369, 0.2091038490086284, 0.11389637403693659, 0.17945305822590524, -0.13655569838270556, 0.0029737433121579874, 0.20526196676178787, 0.3304749304357257, 0.17758639041938548, 0.03901768459225276, 0.17819910973446731}
};

static const float b1[64] = {1.0148383520480917, 1.0311399029166475, 1.0047319983738678, 1.054971859157504, 1.0518387648318714, 0.9703977281027457, 0.9166319040618734, 0.9888604400992232, 0.9948607317934347, 1.0713066191387606, 0.935235483220843, 1.0389386114554786, 0.9616645510028988, 1.0423015226372732, 0.9524791313799791, 1.0068239335974842, 0.9966310129550012, 0.9739227688798563, 1.0107177088782682, 1.026732264861311, 0.976758830376453, 1.0400411437568746, 0.8966970807259652, 0.9532274089763009, 0.9328633682692419, 0.8506309238832888, 1.018474199480699, 0.912313107782983, 0.8733248760435145, 1.0686925690126223, 0.7371140565865627, 0.9595973517169759, 0.9263854024115361, 0.9259826017634407, 0.94433519339626, 1.0808179627889725, 0.978319481756676, 1.0356478714922759, 0.9718654016684579, 1.0447838532628806, 0.9417373162129936, 0.9699558980108781, 0.9786447320194174, 0.8641717152260475, 1.0945127809435238, 1.0208127687600455, 0.9468866609230091, 0.9023796663669443, 0.9832312691807199, 1.0579272738157408, 1.0740895824920935, 1.0428544421094774, 0.8657153490660361, 0.9937376965306339, 1.0383982002779597, 0.9477045704235469, 1.0022559282065775, 0.9721517348414431, 0.9780112112445405, 0.9692807895181481, 1.089133368144922, 1.0001484484398908, 0.8648192742503241, 1.0174888571188943};

static const float w2[64][32] = {
    {1.1687223298767748, 0.6736506996551608, 0.561626460288152, -0.03729510400114428, 0.8832999802685466, 0.7323606234722423, 0.7627811588879988, 0.8669496123314822, 0.7107223421290226, 1.0160681727434238, -0.08903647968801161, 0.9621654974144278, 1.0460082881673203, 0.29902711951131605, 0.9637697429792348, 0.8838622034713008, 0.8639444563971058, 0.7838417559429383, 0.8431115236651159, 1.1564494066786644, 0.6917941184501044, 0.7598201416833226, 0.8627976751159606, -0.007333948347495508, 0.6481535833638423, 0.7249219908211494, 0.7951395151981304, 1.0975601370351487, 1.0226657365299887, 0.6214956056709621, 1.215907769982146, 0.6346594466835478},
    {0.842270781015688, 0.7861033324613981, 0.9075114664755356, -0.1922875931161552, 0.7343049453390545, 0.8206976479749116, 0.8479656919466827, 0.8032499956491365, 0.7567526361210019, 0.8442155532053272, -0.15775079951694773, 0.8377520381437469, 0.7559882841045517, 0.42082109456750105, 0.920778251284187, 0.620201524072298, 0.7122268146915386, 0.6613883299311342, 0.8775893050261586, 1.3175501511393943, 0.7660723050557108, 0.7359231534936472, 0.6385465517030158, -0.06090943310370226, 1.0642689868101065, 0.4498916104037199, 0.9442853912082931, 0.8942940331158402, 1.2883868405246075, 0.5503289661733527, 0.7642692102815349, 0.43388625814319154},
    {0.5084503011984788, 0.758865439047262, 1.007518805344312, -0.15334840068027655, 0.8546784845939808, 0.7619536159108887, 0.7135978965049126, 1.063529647730591, 0.8979508404520388, 0.7408843923082837, 0.32630084297140716, 0.8309132298833467, 1.0415867699701316, 0.46468882616937823, 0.4721205191455031, 0.4936053887903245, 0.5114395394254634, 0.8820776254479943, 1.0954646687202743, 0.7563062114156414, 1.0130619866577228, 0.8187753618635814, 0.90201868551422, -0.16957232224079252, 0.8129868887386521, 0.42873634687301065, 0.9871602781260859, 1.1180782431510394, 0.8296367418375077, 0.8987135100770164, 0.9355065087605554, 0.8725812743415833},
    {1.0072322643228333, 0.8269151764548979, 0.5989851366480328, -0.03995261917926596, 0.7070333466811709, 0.8542678400814119, 0.8329823086251514, 0.8500431894840184, 0.9010197662451963, 0.8131327669226183, -0.2683940227811162, 0.8269257728341932, 0.817785302241024, 0.2636221274204306, 1.1091276511185635, 0.9223881091020845, 0.5450703067296652, 0.9028901884920086, 1.2058715678232679, 1.0767477899480073, 0.9633973424549926, 0.9809355090166245, 0.8350940987037773, -0.14414479959057225, 1.0767842174663544, 0.7306978826721369, 0.9336379941618957, 0.9063483032396561, 0.8666369191566103, 0.581060424563465, 1.2556706512562648, 0.9314851574762752},
    {0.9384177108271585, 0.8310476711307597, 1.0388124934999499, -0.12529165834751715, 0.6914271027946591, 1.02046980846425, 0.8524924902301865, 0.7555299644890022, 0.9110650783702227, 0.8443537740800251, 0.14684679819602328, 0.7676970744142338, 1.0138307606810684, 0.5930812107238846, 0.5320738373439893, 0.6269790746091698, 0.5915842855581119, 0.6947418385919831, 1.0422945718714418, 1.2111428052463817, 0.7681807169271956, 0.7557485579348342, 1.1880845516051484, -0.3429708011626473, 0.8483730548247501, 1.023961606308485, 0.8761274902658104, 0.8605424664626887, 0.8849699344740398, 0.8896908466005959, 0.8489615286219038, 0.5551370851604375},
    {0.6313780519678975, 0.8582412985697614, 0.6568455297593842, -0.09176823212329187, 0.6662754153997619, 0.6898057356688615, 0.6280100263712994, 1.2823721960193657, 0.6444734505868649, 0.7911721551303729, -0.25031614434812127, 0.9775231983083992, 1.031988167666847, 0.5742039795321268, 0.5962157667891035, 0.9424135610599648, 0.8206579545834279, 0.7620689023999905, 1.187387914137411, 0.8824643404567912, 0.995003974019374, 0.8733959330921225, 0.8090225052967435, 0.25337689121570783, 1.043052894252961, 0.6537416552485725, 1.1412685133736304, 1.102306952144294, 1.053108074599664, 1.0411098490069028, 0.761016984208356, 0.38319776017623197},
    {0.8712775623657032, 0.7322308118914818, 0.8651755197153732, -0.08501013104355792, 1.0772237904860795, 0.9099778674652014, 0.9235717708300436, 1.081551738140167, 0.8991081517464702, 0.979010192679136, 0.1292624310041874, 0.9989627434493031, 0.5880411275475093, 0.7434547187460163, 0.46134947637603, 0.9461070297082994, 0.6136352070284673, 0.5169956418268039, 0.7613282112495395, 0.9807546840275382, 0.7128326608736294, 0.8060265436700622, 0.8527625718956541, -0.06676458442247502, 0.9482714456690894, 0.7765396135026637, 0.8348556882000573, 1.0991002659314788, 0.9362878936893327, 0.653433193292527, 0.8633346516965548, 0.3263401550687973},
    {0.6291508644664476, 0.9651836416588903, 0.7748987178743, -0.024993066009202956, 0.7790728483550906, 0.8347509400775545, 0.6058916795537105, 0.6572711620315104, 0.8478053208761007, 0.7057812082284701, 0.012670339729556356, 1.0991058163643992, 0.9406618395896732, -0.10785407600563511, 0.6727971633702163, 0.7879900605558616, 0.6857521425472477, 0.9495310493887118, 1.0276686518592253, 0.8516160996964669, 0.923749432709148, 0.7342635493320238, 0.7015998058224917, -0.2701575161414845, 0.6453593218632598, 0.5424112359084724, 0.7574704186299217, 1.118173443934422, 0.7171645550669437, 0.790467377014628, 0.8253439422004665, 0.6690314197990208},
    {0.7960614731386135, 0.7003584349051081, 0.800164124804805, -0.2681115828919522, 0.9188430996661034, 0.7665358742214629, 0.7868653945517475, 1.0254983134868618, 0.9354581724351119, 0.8931122343954766, -0.0843786802526962, 0.5750767218372399, 0.7813733353799452, 0.2639757826487998, 0.8478524612685158, 0.8341784754890083, 0.730517594328601, 0.4476109323506669, 1.0240720077923864, 0.9385659181371834, 0.9681634588411523, 1.014586224533514, 1.130326480441642, -0.19388395124756191, 0.9530863136355798, 0.45363471285470636, 0.8530562663449708, 1.0105017447771003, 1.1095780750067479, 0.897869106358202, 1.0425275099342308, 0.8988872615883076},
    {0.712032673315699, 1.0196381723622459, 0.6111258798130961, 0.0502472013721253, 0.6904609404815558, 0.7086406249542655, 0.7859279318157437, 0.8764805858819763, 0.9862131782103434, 1.0046437342894705, -0.22910581351350756, 1.019706904334535, 1.21996727883072, 0.25457980452664064, 0.8800738447410089, 0.8238222144258429, 0.8450712408755743, 0.5557846292851664, 0.9977552418882052, 1.0837217658365077, 0.8560164677582885, 0.7605641803928479, 0.8669419485886171, -0.11870443642635561, 0.6185048924367859, 0.6343136676922221, 0.8202455903812629, 0.9757974601243268, 0.8429643885022637, 0.5764782926648451, 1.051322384203512, 0.9148717860671388},
    {0.792773024270188, 0.9757212685306524, 0.6958215150563964, -0.023165271791866567, 0.9638997995516695, 0.8568773468733986, 1.026554513775023, 0.7105761404101966, 1.0997736444720525, 0.8761277930230786, 0.04012745747030847, 0.8732743363001421, 0.988499193547454, 0.401550582497948, 0.607299632378747, 0.8794578138624113, 0.8904605872578107, 1.1839842373952938, 0.6927539785766238, 0.8427399604507133, 0.879238145419133, 0.6742885722464664, 0.7691654884318501, -0.02604774835544763, 0.8575028978977159, 0.6924130255108258, 0.990341079610053, 1.3311672537838328, 0.724757611107794, 0.43202953950773365, 1.1161898491111226, 0.8497709813375901},
    {0.815246800896373, 0.7915155373336908, 0.6838933932361355, -0.2633372079558572, 0.7275224607245221, 0.7790847013565934, 0.2947110438489845, 0.7050118287796173, 0.8586037181719368, 0.9488545435320083, -0.039444249902141175, 0.9575396648272544, 0.9552024466188049, 0.5080275301916524, 0.5296970621896967, 0.8081620702281181, 1.0082301595958345, 0.886381870666742, 0.9218057271585925, 0.9022798314950354, 0.6678697358194472, 0.7283361412072443, 0.9188410658881005, 0.2271708186495448, 0.6316772092313251, 0.5223927699216935, 0.7682445666186712, 1.006859925236202, 0.6954609300672057, 0.8171925267192813, 1.2517182940572067, 0.6309684605660063},
    {1.1521595114091725, 0.7583368285262091, 0.2760373184229204, -0.005487954861110027, 0.7819760564726289, 0.7032650495013244, 0.698883079861924, 0.9644255759162419, 1.121386783966055, 0.9303402020326195, -0.18334156000696666, 1.1153126272736311, 0.8197934261786716, 0.5592017657536383, 0.4767343210267464, 0.7365194237445745, 0.925530968578014, 0.5448072430447132, 0.9841673252025093, 1.1904243516451811, 1.1204879158823864, 0.7370882246136214, 0.6642604769907672, -0.3360744428447355, 1.0225029706010489, 0.6382972421437756, 0.815228669257036, 0.8853627905780531, 1.00330804106944, 0.546550810290466, 0.8394898018327662, 0.5396540836940569},
    {0.6292200917294324, 0.5952105367230767, 0.9203246959325678, 0.07049717041473649, 0.6503444456326009, 0.9881977965894911, 0.9549339140447095, 1.041073701167469, 0.75960636853064, 1.1211429875348284, -0.3429515925493084, 0.8679899099537044, 1.0486471172500864, 0.4977328885052497, 0.6844138293912055, 0.899221768846667, 0.5506866121612589, 0.6192500945316427, 1.0319679875778098, 1.0498589482016898, 0.949603282474482, 0.9067499675004285, 0.81131916526876, -0.0625270335181992, 1.0672590572528216, 0.41465689514858317, 1.0563731423728482, 0.9425558501410147, 1.163605204311709, 0.886650313010936, 0.7197961882253288, 0.29227808587517806},
    {0.7712781804947451, 0.42612417187799406, 0.9469366493888252, -0.0762369436244966, 0.5345014258330915, 0.8816716727223018, 0.713897625684695, 1.041631256478499, 1.2141757100551012, 1.1472537287429294, 0.03649627128396482, 1.008337838624071, 0.7096534980406227, 0.7081688620479023, 0.5953141820191168, 0.8959412179241745, 0.8758685923655259, 0.7028034492038144, 1.0984377369612093, 1.0666826343302138, 1.0959089958900594, 0.7584328138953047, 0.9076180508688766, 0.008211460394574804, 0.6947019019643732, 0.5322210119179178, 0.897957569056681, 0.7487275038016219, 0.789590723535448, 0.33529045141283087, 0.8271953588565758, 0.944484189898729},
    {0.8825752978282303, 0.920886177523931, 0.8481656122280516, 0.2446820874032093, 0.8864565314613753, 0.6572650648614747, 0.7884161289800622, 0.7440302072834267, 0.9935256441829202, 0.8193269665077587, 0.18771700001026193, 1.0873181021286338, 1.1003256398916388, 0.07165749970154396, 0.4011004339471089, 0.8205165807137446, 0.8009916365978713, 0.8347607158367587, 0.7654254196733031, 0.9737968548474675, 0.8780081859916283, 1.067892970262477, 0.9316786896918238, 0.1368593177066493, 0.9656599786712406, 0.6941544500851687, 0.6971601347814997, 0.7892285830807927, 0.9636329779228349, 0.7553547915502933, 1.1893102238852422, 0.4492755907487425},
    {1.071428716296268, 0.8267145241454822, 0.874041951591942, 0.14292936535393944, 1.0204553586127825, 1.305788574910385, 0.5991696517586302, 0.896515399666307, 0.9876577018859258, 0.9038455204639041, -0.0706498826308766, 1.2283706078821448, 1.1856980038208533, 0.2707885291062228, 0.6245021143798412, 1.0446759545317712, 0.8939323692663432, 0.5122705773414586, 1.047146548626061, 0.9494490757497771, 0.8186146760127125, 0.6417844345341931, 0.9273316343525878, -0.11698438231086698, 0.8192717226612909, 0.6358533619838347, 0.9374618607552475, 0.8902173423643577, 1.284554450586986, 0.9050094279613748, 1.0799933212657826, 0.6667669477516709},
    {0.9865543713194547, 0.9117485784687195, 0.8407472603965672, 0.18235638478915445, 0.34762611948297995, 0.9769306343449313, 0.606712593704169, 0.576290537283221, 0.9609588177675094, 0.7311249045757093, -0.05117703501857274, 1.0349519938977012, 1.1935665309078511, -0.019901817820985473, 0.6855235336150435, 0.7407272746843446, 0.9264436135093893, 0.8747146420093218, 0.7513679805715341, 0.8263561217802825, 0.9276152503347724, 0.8707171159529313, 0.7718971802585199, -0.42323440540613094, 0.673406596692469, 0.6698952243717116, 1.0016364198608805, 0.8178146541661034, 0.8901668170151726, 0.7273684980623109, 1.0999413311450486, 0.5624555599351823},
    {0.9033907975146075, 0.5682849101810641, 0.667499840511171, -0.3575300875661817, 0.6769396260478773, 1.259621784005475, 0.7263718667555725, 0.9311573197891916, 0.698204251965163, 0.9362940632630622, 0.13597979551936162, 0.8896168026817106, 1.1581199367029795, 0.17494796651251118, 0.4744202515825046, 0.8414219393468394, 0.760534340545031, 0.8158954715203425, 1.0236060930558126, 0.9544663383622358, 0.8173632158123894, 0.9173678080514486, 0.7561664013427677, -0.22999536635146914, 0.8617970747463523, 0.550781333437461, 1.0008588913343186, 1.0579234513675633, 1.0455062857525932, 1.0045657540209625, 0.7933524797397873, 0.46709881560802513},
    {0.7345914368021556, 1.0479403768900104, 0.9308838645710891, -0.17553921303254766, 0.5551698902204134, 1.0072502086162733, 0.4498009873383784, 0.6617452962823744, 0.8676015411478474, 1.0007734220908002, -0.3042226990873174, 1.160414482870544, 0.8196401874420217, 0.17067166218079804, 0.7480719856243953, 0.9212206784818652, 0.5519139155461872, 0.9314012924877282, 1.0335084907339136, 1.0540877812918945, 0.8485394378045872, 0.8666958675114104, 0.7531445478160139, 0.0733252165483516, 0.5838826543276812, 0.4376007345093484, 0.7309262646709538, 0.7326518317487863, 0.9500158229360318, 0.8160795130547145, 1.1774035972606172, 0.5873283310143365},
    {0.9897244392852572, 0.6138988808845534, 0.6862310335662468, 0.13071297636691354, 0.45205896578569627, 0.6637781402414727, 0.5995774029038868, 0.7719631659537746, 0.7548310468869953, 1.0206348397165517, -0.1113882133904229, 1.0577370364698617, 1.0848607424519452, 0.5140178902307123, 0.7465835111135704, 0.915019413485022, 0.8401387520561925, 0.6764802623721421, 0.7760336956170881, 1.018861140798327, 1.287893157289685, 0.5911760546224615, 1.0955427403272209, 0.009921944143872196, 1.0145233019097106, 0.6483606074847906, 0.8740137665063624, 0.859756315453222, 0.7368892613511769, 0.3733294758069821, 0.8561118937317528, 0.8934673663825371},
    {0.8822179692123336, 0.7302262549391039, 0.8340484488246426, 0.05742358135786389, 1.0178203001832233, 0.7555457009832524, 0.6629349346897015, 1.0395976492020669, 0.9206664190123148, 0.8574983103066863, -0.2003599214770179, 0.9398914272789527, 1.2197541371192013, 0.4995384704391308, 0.3191583094683678, 0.6798539216932212, 0.8639931037327149, 0.9380452391154572, 1.018692460635876, 1.1689517195134649, 0.8284706058021415, 0.8998760741266907, 0.9462114676179519, -0.29104438698343676, 0.6256460470299836, 0.5305735923599186, 0.911332238483443, 0.7038377590215472, 1.023487249656659, 0.7404913552872621, 1.282987979692993, 0.5330557245301459},
    {0.6054958799160258, 0.717381983345217, 0.9689068294987242, -0.024133701915807545, 0.8302488215121783, 0.863721002108095, 0.5183903818511377, 0.9522794082848043, 0.6316762017233997, 0.9308491457084571, -0.20721521209630206, 0.9590172157013349, 0.9845823547337471, 0.3671246153476858, 0.5145693709249846, 0.9452964669809075, 1.0701114200636406, 0.7267863146808224, 0.9895749836281756, 1.1018379638761449, 0.8512109386352699, 0.8304965474270524, 0.8936353891731158, -0.09875733744942966, 0.7529466073767547, 0.6223631207629806, 0.9648953252499561, 0.7844829717342587, 0.8344613699867273, 1.1246410856174212, 0.6297127046844309, 0.7336361210939804},
    {0.5227290622196871, 0.7276631191038144, 1.0146999544824373, -0.012901951426127508, 1.0106525822009214, 0.6196735082078408, 0.9383753340220439, 0.9893689819484288, 0.7242657915691415, 0.9735337713467134, 0.06473186076006605, 0.9028721816799593, 0.8736070331818633, 0.3317962381252316, 0.6396199635447085, 0.929839301144239, 0.8005376353025472, 1.0216849180678516, 0.9872231779068019, 0.8570161724020618, 1.0334019380071104, 0.571829644637148, 0.902425014487577, -0.20873960167176334, 0.8705318343882446, 0.6582759225721948, 0.6183511140478878, 0.974920633536336, 0.966966545511778, 0.5795545694991776, 1.0449557727549548, 0.538690236060597},
    {0.7313034115528415, 0.8146952599655499, 0.6909684924071182, -0.33104623043963616, 0.75183815453491, 1.0176328120997635, 0.5474895435093844, 0.8100307958184723, 1.0470064403854495, 0.8370665653302751, -0.16022506923954094, 0.8658030996459838, 0.964718972620894, 0.5001400700642945, 0.8147834938417026, 0.8553408609213905, 0.8649027641583257, 0.8190668495326616, 1.1649537407461608, 0.9331013627414573, 0.8328253873830996, 1.0140599006295719, 0.8900295332792492, 0.1956879962031521, 0.883066731903828, 0.6153108046169475, 0.7934089834539237, 1.06591811627532, 0.6323566360860198, 0.8332346498639267, 0.9940323839337333, 0.5558413366252797},
    {0.8882619907237104, 0.8129027426293505, 0.9101215960826959, -0.07534920540229964, 0.4635203379953374, 0.615822052998423, 0.6946692757131259, 0.9943459651392067, 0.9983411080338596, 0.5718897457210134, 0.22134270271047796, 1.204476300934699, 0.8516322417106623, 0.621704454892195, 0.7090998402324835, 0.7743442486234106, 0.6839998962477067, 0.8366827293651606, 0.6875803021944373, 0.7680356643956038, 0.8244610948611102, 0.6299836231786164, 1.0398686748377879, 0.04060006617008656, 0.8152718156029782, 0.4392604070286425, 0.753040415153543, 0.7055881671204659, 0.8797440851888468, 0.6656386485067987, 0.6419666685582378, 0.46197083519925763},
    {0.9835513080733475, 0.8130416808910655, 0.8828880426568786, -0.3051106197598275, 0.7588140605558858, 0.9359597262099815, 0.5189127442923391, 1.239275187703028, 0.7591339148473286, 0.7359528960159263, -0.1683433274598189, 0.7111943813391388, 1.0667041197129856, 0.45978489111639037, 0.8086501792269798, 0.7685789809298625, 0.8681327951852567, 0.5388436012921776, 1.0724359713593064, 0.7439349974532078, 0.7797957605434988, 0.889026595977118, 0.8361049867101173, 0.12588879537170533, 0.800010496227546, 0.4807357062976722, 0.7542361073000639, 1.078442559653761, 0.8992722085175126, 0.8050008641882068, 1.1930147405989049, 0.32078201849207355},
    {0.5928850152127403, 0.9897580314241604, 0.9188263419205294, -0.18523612220570174, 0.8305973905932361, 0.9702712213616305, 0.7829439107509409, 1.0051426301828286, 1.1244102034699646, 0.7292444062817256, 0.30488172750047515, 0.9011611312138876, 1.0393270711390286, 0.37089760337175554, 0.5621443339141821, 1.137532734510873, 1.085404603421537, 1.0641718658530466, 0.9804690582794836, 0.9682791395586953, 0.7585050835358524, 0.7363875380078383, 1.07917652639938, -0.12097651289239542, 1.0262828083393345, 0.6188514019385615, 0.9589814903834591, 0.9066833872552701, 0.8941150297325693, 0.5326887119287882, 0.6743051127660162, 0.42890154044560747},
    {0.5529226075686419, 0.5702728121051921, 0.9185929370391779, 0.022236583538668683, 0.7565414276125934, 1.0342400594210512, 0.8702861118421559, 0.918632337321132, 0.8586395055901374, 0.8526530222247433, 0.009449793382962665, 0.6806599416556758, 1.214785293314936, 0.40984473150639766, 0.9511867972872282, 0.7923090246584104, 0.9665528797419662, 0.8326403480538577, 0.7647888520478233, 1.0714224732356286, 0.5853221530605034, 0.6435270802979043, 1.0292181696498743, 0.00517620168957584, 1.0683583917977582, 0.4015087657680493, 0.7038418663936418, 0.8439015989775228, 0.8854331405492466, 0.6500770038140619, 0.7739688567214507, 0.6072454862341612},
    {0.632238422168165, 0.9307793916221553, 0.474535722540333, -0.2691037445829997, 0.8554671346603847, 0.9576737199892564, 0.6126127755191421, 0.6315062558659098, 0.8375020471317788, 1.0209366790311072, -0.060838439090757514, 0.9159329845403996, 0.8958602479187229, 0.3726726950561355, 0.6567921513035205, 0.8503303573245045, 0.6377634971804287, 0.803897614302053, 0.9029413048863418, 0.9785687267631404, 0.8891979414263234, 0.7832498885155661, 0.8081192596382758, -0.3377301404269112, 0.9022598505421973, 0.7706292395806617, 0.7541942745591448, 1.0306880038026576, 1.3277705004476652, 1.1512291613287986, 1.0504082964571706, 0.6045677750913145},
    {0.6836110473030637, 0.9292496032756, 0.4174709926343516, -0.20450236663750473, 0.6491074659261128, 0.6255619726074343, 0.7045229533693421, 0.8618184757651427, 1.3020755122481265, 0.9187160109586964, 0.09250465027764229, 0.924804522379488, 0.6680472901961049, 0.2153160841095539, 0.5157912401079908, 1.105718375005224, 0.9849157095407842, 1.0107678536153415, 0.6308595571693338, 0.7801472134878017, 0.544056574125897, 0.7879087932740879, 1.0308437358411093, 0.01464366021047353, 0.9418284501576706, 0.41327291587643233, 1.0644839971708584, 0.8524886715377143, 0.6326871659593865, 1.1032558845628206, 0.9251529568136915, 0.8325505971345559},
    {1.0057885550333239, 0.5242998858718125, 0.5611320680192774, -0.008492229212656055, 0.9468217624330917, 0.701087032411193, 0.7161377817278126, 1.060985306391519, 1.074773663441587, 1.0135703227076835, -0.15819425038724003, 0.9980181154169683, 0.8542153110208035, 0.4188554510624648, 0.6925864196773788, 0.8044863524530529, 0.7569891582954217, 0.9526988265362563, 0.8242554087489404, 0.8496113824590392, 0.76266696829978, 0.9647524967433702, 1.115805635761039, -0.08549430364361436, 0.7597212363919366, 0.5667303285976837, 1.0067985427397168, 1.1687823778812012, 1.0791697449478463, 0.9224243267216786, 0.7313008787349379, 0.7723333683790857},
    {0.8351931783462129, 0.7638193682800108, 0.7482889163549624, -0.05288727360598982, 0.7459735083437735, 0.6737406936454432, 0.7794719676033444, 0.9553039309732464, 0.5928318806579052, 1.235821495731647, 0.04778716943070241, 1.3683868025903596, 0.9307214512984282, 0.3807706043149428, 0.33888191981368576, 0.7232029185090482, 0.7452994471191606, 0.9013858768581305, 0.7055046964631098, 0.8143597334317942, 0.688016310251825, 0.6841664580605433, 0.916497958584283, 0.15982898264896064, 0.839733898674441, 0.8999890573958924, 0.6974685172113871, 0.6331902802625202, 0.8332467286398982, 0.9352503887598738, 0.947828765422995, 0.4906107261211206},
    {0.8636531073586622, 0.6959293210244382, 0.6815013607262537, 0.15745493931038318, 1.17779197281475, 0.7474139827920169, 0.8043409810463793, 0.7175853237796848, 0.8125251803132689, 1.0068528260003882, 0.07707330651262173, 0.8645305377424584, 0.7531361595748943, 0.43619661346878486, 0.3277654911967382, 0.7830719062263121, 0.9981415609982195, 0.5377586157974824, 0.8566521050667595, 0.8094391228265481, 0.9521318820540453, 0.8794212258033117, 1.0965595886309671, 0.03298802778422905, 0.9430394238934591, 0.3704980070619921, 0.9985110187365179, 0.6482248886497315, 1.2144767912947618, 1.0194815958532457, 1.0904290595187216, 0.23868620857332706},
    {0.9708641219463157, 0.6774398862371067, 0.9175071810638873, 0.1834704320236735, 0.8253493139015616, 1.077108221953802, 0.45064165215119967, 1.0225926657396638, 0.9951371756118036, 0.6163142994688351, 0.08775989791437834, 1.034362957687799, 0.9104087086317376, 0.3413954879246961, 0.6837055855469036, 0.8400713047452902, 1.1025141183147906, 1.0315084204574905, 1.0477685652667925, 0.9994564355848502, 0.780731138523795, 0.8039575320727514, 1.000423326383194, 0.2181053880074433, 0.5256186360067224, 0.4680304842982265, 0.9507133148686531, 1.046306866775011, 0.9111366997429168, 0.756795345935344, 0.76331545702858, 0.6377211902301787},
    {0.7814419532029596, 0.9119191023470271, 0.7397495287491151, -0.08215349673669556, 0.9053285978694817, 0.9594440396407412, 0.4668988460051795, 0.8372441681855485, 0.592514100131966, 1.0291076528852208, -0.20381522228584448, 0.7138834930887893, 0.8214611142935727, 0.3442656425270641, 0.7746713195238926, 0.5932118555208747, 0.6965871638302293, 0.6650229971480233, 1.107217624116459, 0.9874243410864156, 0.6826970246691269, 0.7993169101877496, 1.025235350347562, -0.08790889356091067, 0.7717621284720304, 0.46487973873965893, 0.8513630738387984, 1.0967412893644692, 1.0057899598026998, 0.5961203273713541, 1.1978635328866942, 0.7010526559925129},
    {1.0076992521172405, 0.6325590385100329, 0.6689637320652322, -0.3016222404955045, 1.0399895836934767, 1.0533301134867983, 0.7252467235668607, 0.8855881885261379, 1.040093821396018, 0.8182265344627768, -0.001874819197621804, 1.0011213298146167, 0.924802802219876, 0.20520612840579108, 0.6537211277296965, 0.4681334766874895, 0.7316370601567879, 0.7410658987560105, 0.8737532611655401, 1.0457489433125844, 0.981191510790178, 0.7863749227284347, 1.0061531301211541, -0.3204502762082293, 0.5928253246150803, 0.9804782398007997, 0.6280521351685437, 1.1318831282103616, 0.8050618228983353, 0.9457215552193806, 1.0096931513766427, 0.6416254452614956},
    {0.9034136031309246, 0.7063529139488954, 0.6092650856532885, 0.17114927592209425, 0.6621360442713847, 0.8466041984894946, 0.7829804076618883, 0.6831204962031978, 0.9244514204733651, 0.8493423382564868, 0.07393472575494212, 0.9852535688614136, 0.9055063594082975, 0.10854126742912427, 0.4926892427954652, 1.025780110050486, 0.8896222843770534, 0.5404491708274304, 0.7383408061405223, 0.802627957993079, 0.5082281772547805, 0.8781811203229323, 0.891744469830004, -0.023241577208552706, 0.6644205805613249, 0.4547108529592045, 0.6205697036616905, 1.0915992041979445, 0.9857144357490252, 0.6399030256959617, 1.069668401828189, 0.6715686235304996},
    {0.5938290374971573, 1.0845604097478105, 0.8092156144069498, -0.07444428414286201, 0.8241742836235448, 0.8115157757471464, 0.30724037740735655, 0.8272346560902308, 1.1088049165204337, 0.6339234772910958, -0.1855388113948987, 1.1341906033247056, 0.7911044304712833, 0.4166905961878547, 0.8563394236157651, 0.8917002218540097, 0.9607017580081934, 0.6393562209479928, 0.7490570227187902, 0.8189201271714014, 0.6564782491114726, 1.179337580186117, 0.883410486359356, -0.11082109239698472, 0.7553465307966958, 0.5157737392461983, 0.985363404151703, 0.9683205418885225, 1.115990383379509, 0.7115269807737812, 0.9097856661036794, 0.5215735145007989},
    {1.0569592370020584, 0.6596192847092613, 0.8857728628580555, -0.12237427670410392, 0.6159077846998331, 0.7451346876991516, 0.8185245871549279, 0.6530234314373009, 1.0803450676426478, 0.8842839498501485, 0.0905181638365668, 0.7987576272178155, 1.4166987269933338, 0.36902202037367543, 0.7250516991605911, 0.6199158617988015, 0.6087122077766969, 0.41350256838271454, 0.7905182650023183, 1.1242994034129346, 0.633402767447297, 0.7894495305146834, 0.934741217566293, 0.083708912632684, 0.5015681931545655, 0.7874225375585406, 0.7738226730161787, 1.0420487490843406, 1.2139488183137053, 0.6445354953040672, 1.0641453837837427, 0.6553691151556283},
    {1.0492159763836792, 1.1957527676325699, 0.7166163552696563, 0.04602514946142648, 0.7722576952016449, 0.786934187158703, 0.8739760228782536, 0.9507294329436462, 0.8737627088655154, 0.657607475340687, -0.05534204138056157, 0.7895919854782785, 1.0707754226948445, 0.6323582284775038, 0.5694837020388677, 0.7325600413247622, 0.5978072402320374, 0.42409502370012914, 1.0616727289440542, 1.1132993909416646, 0.8558266440299331, 1.0491778462025592, 1.0823689506139251, -0.019104456067949974, 0.846831320198061, 0.4802236478761652, 0.8390789899264529, 0.7275029266647117, 0.6629523379200519, 0.9058926072074741, 0.868295502313005, 0.44929793837010706},
    {1.2260907511621417, 0.8785630371304296, 0.5973088914894298, -0.2062502698993198, 0.9132529776758647, 0.9139747708850318, 0.6575676627411271, 0.9681193202000816, 0.9332699273811615, 0.9041090640274181, 0.29345597585412814, 0.8426452334752327, 0.9019743508865818, 0.41014219339888686, 0.6519078362871666, 0.6750521694090921, 0.9127065927895915, 0.8002589794847002, 0.8454407770924944, 1.113279021193553, 0.8372723191931362, 0.3921768445900205, 0.9495707619180942, 0.11392741238034898, 0.7772826587275544, 0.7243917534942947, 0.6732441443579251, 0.8681763758918535, 1.3223389696859253, 0.578057406614999, 0.9002787991766515, 0.812069632090832},
    {0.6346936696977825, 0.8619709762557192, 0.6589219393106335, 0.30263344353185934, 0.7875585500934069, 1.0628883588317353, 0.8710331549353082, 0.8933874504121811, 1.0268315895396734, 1.116066119024755, -0.006072495072125348, 1.0787319565286346, 0.7430632608315026, 0.4048705457647407, 0.6146394877746824, 0.9312800215420872, 0.9340004201565432, 0.742401426310329, 1.2506950136053048, 1.412932313860704, 0.9568855028722029, 1.1888210555161511, 1.1826684228610587, -0.10743723299644159, 0.919406513525334, 0.46848566446052875, 0.8956934559854622, 0.8438557270308743, 0.7669140467205587, 0.7760544791419457, 0.858531402365565, 0.6767240450008568},
    {0.5150032464371668, 0.8009863238913518, 1.1270497937644006, -0.03404110126037289, 0.8757945262999851, 0.540596012427633, 0.8723032802252557, 0.5928224185571661, 0.9455567124496627, 0.9318625532097818, -0.2525443323991824, 0.6975689640910857, 0.7676488385377781, 0.21995112682979692, 0.6111759160703785, 0.932902515829002, 0.8082532659261711, 0.5964026460236169, 0.8732107169570358, 0.962473724530949, 0.9455236306722634, 1.0161026609041464, 0.8249649647782497, -0.4003198263541166, 0.8413886738538293, 0.8369924411262522, 1.0413506383987512, 0.8593427949669642, 1.087444798110169, 0.12270525239260716, 0.6260515589014014, 0.716333986255324},
    {1.1704865450088666, 0.7503956156630126, 0.782101442688922, -0.02820767902569707, 0.8910169802855217, 0.4628183926533731, 0.7311732041572089, 0.5907893836718331, 0.7932614602966596, 0.9363260712199728, -0.28147830716478506, 1.1616700468264003, 1.1328428660535759, 0.27105464907192867, 0.6083740764191324, 0.7410965575629757, 0.7567727132056157, 0.5562733923744089, 0.9901217849508146, 0.7604075237601482, 1.041520529607842, 0.6630834943763139, 0.829785749171482, -0.09795150750741033, 0.6743809686623632, 0.46851463307743385, 0.8916537547357422, 0.9125792719262047, 1.1099890414495812, 0.5984541385454365, 0.916610117268547, 0.47246370154900974},
    {0.7204866998740501, 0.6760928020253651, 0.5518708343546114, 0.12022029908192143, 0.6138509569358777, 0.9649727294010196, 0.6455022371364262, 1.1546460230307887, 0.8520399907032153, 0.9654251117206345, -0.33587840472324737, 0.9592004026264019, 0.733449052421034, 0.2134141237081953, 0.7240925003527755, 0.8831111704297058, 0.7118668047729251, 0.6319730200524777, 0.8770498543915074, 1.0030038935487557, 1.002804656091157, 0.944198424327474, 0.9074017289875692, 0.01734183260889594, 0.7173681259798185, 0.45689169824212256, 1.0132914067820176, 0.7521886902550516, 1.1123366987732421, 0.8070276192947862, 0.8218454348913102, 0.38345154172528095},
    {0.69459718555645, 0.8339377784273667, 0.9146460627407713, -0.16640853377053264, 1.0215269362410544, 0.8259575207858055, 0.585370468219045, 0.6266276944855508, 0.9342680251552147, 0.9428743031136188, -0.03070982185253567, 0.7743704079556386, 0.9790326813144911, 0.3467475265490595, 0.8273882429004306, 0.6362374797800683, 0.9995959587211186, 0.6979037495007429, 0.8384457656573747, 1.0517320678963469, 0.8496812445869002, 0.9672538577853098, 1.189026492060155, 0.11157312051725683, 0.8922518503608478, 0.7044423294536233, 0.9989701256852684, 0.7601940692610007, 0.9763594616537237, 0.9906336088385341, 1.0596629829378241, 0.7401549243447908},
    {0.9314469965750265, 1.097751576927872, 0.9160931981147188, -0.11052577263562502, 0.9701506942911563, 0.823654659910766, 0.731310202173818, 0.9314179355611747, 0.8402905876744524, 1.1719169391375805, -0.13068364550829084, 1.2172970847586118, 1.2033207641668549, -0.08797968168623967, 0.6624896308261865, 0.8198915595647728, 1.5073121511363352, 0.6169440324303538, 0.7635643150473214, 0.8805266309613387, 0.9293587681989706, 0.8574994873036696, 0.6512052555172558, -0.25454912972180743, 0.7556066008115042, 0.5357825650277933, 0.8650182233781657, 0.6155464330431181, 1.0100713750318353, 0.7034212630332712, 0.8316836729761365, 0.8058245524983982},
    {0.8936724339640163, 0.7538655259562161, 0.6823855747167902, 0.005237277937956065, 0.8974809417260583, 0.8354736943602957, 0.571220449913106, 0.9169274804098484, 0.7480511432005634, 1.009423605817252, -0.05683643158872377, 0.7630084321109109, 1.0545330934117132, 0.32477843724414895, 0.7686802624642209, 0.729159268147498, 0.5551313548261585, 0.7159274601987944, 0.9684124035348508, 0.8740008931365381, 0.8464786628758482, 0.8008502055565481, 0.7750081833486836, -0.08392297636118903, 0.6547849026518598, 0.5948122331966124, 0.972640470239473, 0.8264448024291638, 1.0543468796569144, 0.7625021746675668, 0.7316605123924564, 0.7007292849930157},
    {0.8890145693530198, 0.878969032765419, 0.5480372677146621, 0.00018092185760888336, 0.7878030061875578, 0.679436610315419, 0.6345822653778916, 1.0320166169156935, 0.8947918400235308, 0.7286950356546793, -0.04448367440350462, 1.1000199507154504, 0.9770501696913915, 0.3868052383337798, 0.7479420782502118, 0.9838864229259461, 0.7295498710692131, 0.7282420539730423, 0.6375841923406642, 1.1343677747114072, 0.8493804279101531, 0.9175606825766307, 0.7908614761912808, 0.02560411374472877, 0.5849139188088848, 0.6817485572380021, 1.0016039197251032, 0.9141719541280527, 0.9845087310494142, 0.8194161297874861, 1.4097253272555237, 0.7114553366051409},
    {0.5858364908472936, 0.6723375666611242, 0.6975109452333818, -0.03980818357149188, 0.8228614451878242, 0.953103745911694, 0.7209975118825609, 0.829941052446813, 0.9925538520549918, 0.8391902762771244, -0.054172679555360086, 1.0873202698722082, 1.1741398629818727, 0.3543657598582989, 0.47247134177146366, 0.8651142539691338, 0.6388966539483638, 0.7643765757844988, 0.8984662155593218, 0.8811308285536563, 0.7365166816413288, 0.967282922184524, 1.013644856862869, -0.13188037816705261, 0.6662525229042783, 0.6574563936648642, 0.8448299497213946, 1.060514802098859, 1.3402020160078858, 0.9265040190500379, 1.089759460088585, 0.6660342792641972},
    {0.7578787877852682, 0.5112297970046977, 0.31440468266887056, -0.2291357510863032, 1.086471011911688, 0.7117321402161786, 0.6075602867266753, 0.623086492652925, 0.9146180025435074, 0.9806202381590121, -0.11896059660968757, 1.2019214139052896, 0.9379854314598498, 0.31990665566936743, 0.5487157796932974, 0.9595902183631577, 0.8178764899112255, 0.7942731156947902, 1.1625042760978732, 1.0314500156999347, 0.6688243345189574, 0.7751997384620821, 1.2260548489512444, -0.1206930974013256, 0.8695490432010669, 0.5714497407377027, 1.231341163247639, 1.0458689671448833, 0.590602986690761, 0.6275948380421089, 1.0373905063016609, 0.7911398838369478},
    {0.9121289431308729, 0.954456920697202, 0.7196264593167182, 0.03337768709515307, 0.7070854535746458, 0.6789875130947907, 0.6421303011618819, 0.7284060270778495, 1.206064097218282, 0.8885435799447589, -0.11727008820819507, 0.6297708373769291, 1.1406270522924975, 0.42649233165712225, 0.8109827946216572, 0.7264821301628531, 0.9550630356453151, 0.892091453392317, 0.8361701246193959, 0.6979758082065273, 0.9204544394941097, 0.8911052235969913, 1.2262165170299464, -0.03234466864974222, 1.1639872931694297, 0.36501541366509493, 1.0309238350618646, 1.1029006745799965, 0.7408303455154832, 0.580343389552748, 0.7919058924328678, 0.2847842531357793},
    {1.1393760215371371, 0.7375587725454005, 0.8001795337649529, -0.08007005419053911, 0.9164993512190652, 0.7245647867968422, 0.5893402592768692, 1.0022940148041546, 0.8918922126116143, 1.276148952501535, -0.2677061580598461, 0.8474707061302472, 0.6391859347872795, 0.32618470031704533, 0.5136763052360074, 0.7061681711764931, 0.7487525305606026, 1.0342063506551629, 1.2094834395146332, 1.0248321363020536, 0.8378883551954027, 0.7272543100884532, 0.7760911143257362, 0.02744920573478922, 0.9782591389694772, 0.38413744947644973, 0.928921131496535, 0.8054027821178928, 1.0686175761366694, 0.756529706026855, 0.8865883947552488, 0.7156896166122418},
    {0.9256041674044402, 0.8811980725017077, 0.9343311744027468, 0.19689895638784122, 1.02481488187916, 0.8706928608112549, 0.6876539514421126, 1.1924857043555062, 1.1047084358945838, 0.8724817609303667, -0.13911827951058114, 1.0160542495765665, 1.2628266775075245, 0.5195465760199887, 0.43020167426046313, 0.7856661298226763, 0.8204377006264323, 0.6299795717514448, 0.8118409440462009, 0.9996720405759342, 0.6929338327515563, 1.1200381894706626, 1.1430792670117762, -0.05103068081726377, 0.6282463297205149, 0.26310834704574126, 0.8094335755922273, 1.0087660977595436, 1.3069665371434966, 0.8442369010258609, 0.9231023578837667, 0.5140857199540045},
    {0.6666962946395049, 0.4360194420336366, 0.6396580870798868, -0.2257298250343269, 0.5442627360367193, 0.4712340790200046, 0.7031335745819371, 0.5253111932059027, 0.9144894062207702, 0.865770328296644, -0.1705980731780969, 0.8697342242450625, 1.2585179842146297, 0.16075175106708242, 0.845141275746301, 0.7669436417124066, 0.8651452622551339, 0.5909044143864246, 0.8933545744295133, 0.7672597993450573, 0.873659852834422, 0.38106696234606685, 0.8132654631823552, -0.15789062880927654, 0.7207124320045494, 0.40667705068188414, 0.7325791434949357, 0.679193630339994, 0.8432479095591568, 0.8670132793687441, 0.8574233800808305, 0.6049431399796256},
    {0.8554879452514214, 0.8655423272265396, 0.6782313500692196, -0.22602633748779047, 0.8924386625351212, 1.0555631638114114, 0.34279355122600236, 0.8135296186932921, 0.7697849772539461, 0.8935166986849783, -0.0663406235409595, 0.7937981125811232, 1.1150175889785088, 0.12689445582133693, 0.7155008698183677, 0.8565857254746113, 0.7548905172243254, 0.6164679289272322, 1.3418478183615963, 1.0658497107741662, 1.1777286374733607, 0.7201622585713647, 0.9077118126379706, 0.14309620186404856, 0.4914227592558844, 0.5550298474093797, 0.8849505458691566, 0.8823801939841621, 1.079924828923586, 0.64837418500429, 0.8569177632916422, 0.6688838220105157},
    {0.6992260406942582, 1.0273608487293389, 0.37609642734007126, -0.22837736878815396, 0.6642481814745399, 0.9033797649277271, 0.8681299399686949, 0.9205541769745815, 0.4883573990777839, 0.836430479401146, -0.16451127380621186, 1.0528777567593945, 0.624213870864963, 0.19406780906754642, 0.6883352451646255, 0.9629765041424446, 0.9353667014979652, 0.63389148147695, 1.0963792030250423, 1.0301406021018926, 1.0210635187907628, 1.060305235348444, 1.139405472221926, 0.012639420513346235, 0.9061991221187069, 0.7749718493054907, 0.703291308887088, 0.943267497683898, 0.9149697201844756, 0.45860495776558186, 1.080084462440078, 0.21039430580553722},
    {0.8261967889751334, 0.951075315158073, 0.620679324496571, -0.040395065159599224, 0.7717740564770501, 0.9096203744279219, 0.6826818724397509, 0.8343150482857508, 1.1494783940872986, 0.85721962499963, -0.24378977130726615, 1.0335866033039678, 0.7064713626010006, 0.5915556287336593, 0.6192004703558942, 0.6634024223600326, 0.8657416299625625, 0.8041089652839342, 0.7903809066724976, 0.8082365905157771, 0.9984210961620001, 0.7064316668479407, 1.033419418909281, -0.2652766804898222, 1.0563858078167794, 0.5488725274546032, 0.9339369810023529, 1.1172122677072391, 0.9657688407472138, 0.44446486491034803, 0.9507929910766818, 0.5376855781405461},
    {0.627398039535086, 0.6047865399116683, 0.6496415986172969, 0.023141263505580167, 0.7195861638767709, 0.8255276280916813, 0.4447645136003066, 0.9577656851642448, 1.1038316796824135, 0.9468029433979424, -0.03406091929404142, 0.7463816858959649, 0.9019830346236865, 0.46392019948087204, 0.5141104650708324, 0.9873340622355916, 0.7924641030052316, 0.6401914772921389, 0.7748742230535685, 0.925555788647892, 0.8517930846911411, 0.5460290668657511, 1.0659680320772944, -0.2758665846710414, 0.6953180395199501, 0.7516770709042792, 0.9079605674960138, 0.91494653455409, 0.7936187139224514, 0.7199055979945622, 1.012921591948891, 0.46083829307270086},
    {0.9223178237768448, 0.6543301938792468, 0.5698073012346706, -0.18173837081630756, 1.0199662206002387, 0.6182914972532398, 0.8335802324057783, 1.0353953317150575, 1.0558237104470134, 0.7435559339177634, -0.3251311765528766, 1.0415268470813637, 0.8093650149880333, 0.6106840164773535, 0.6931427644591914, 0.6825929280261073, 0.454875476303535, 0.8868873448154005, 1.0325702154117777, 0.7251937785342231, 0.9212019332203449, 0.9179766667354193, 0.8379121886304184, -0.20826969214246632, 0.9620444006932855, 0.7317314699885806, 1.1258303826825116, 0.9108224988603476, 0.9083698220084279, 0.48801189047651017, 1.162394016728929, 0.5476697403294436},
    {1.0186409143557922, 1.07488565355846, 0.6406249720807633, -0.2755837559482626, 0.8824452362586522, 0.6318461810165669, 0.7337159423652214, 0.5381002082437719, 1.1707388553779525, 0.790381319561789, 0.13918288800878031, 0.9081731751743773, 0.7685307958312028, 0.4875355453668314, 0.9464753319390838, 0.5240355757906581, 0.738949004648278, 0.9403960542912858, 0.8035219522462305, 0.7799574176772819, 1.035765029642145, 0.6005223280372626, 0.9276596486834715, -0.12178464783533727, 0.818490561902825, 0.5169752426518127, 0.9668046393691732, 1.30571099058159, 0.7220231121740994, 0.7748887436625206, 1.2568958822917906, 0.6617559267864965},
    {1.024905772764781, 0.6962046902543263, 0.8340057669512052, 0.19175729691027185, 0.9721759920078916, 0.8177292828164707, 0.6336807648950685, 0.7413445759785234, 0.8003683680600678, 0.8670885828252506, 0.014773773390487566, 0.8913493455972319, 0.7841183730388274, 0.3505582184736704, 0.40608255469263455, 0.9264021818776261, 1.0736801039039676, 1.1564871103283145, 0.9334481206851114, 0.9890257147474886, 0.5419186480004815, 1.0179521462262238, 1.1464948238172317, -0.01821735520803704, 0.8342623755468721, 0.45703287241294577, 1.0176779817299333, 0.9979792059035466, 0.8650904847762261, 0.6672033890477148, 0.7274166205015336, 0.5384542343604012},
    {0.8922219023982916, 0.9210157629264455, 0.8328823974360449, -0.012698342740795955, 0.7493610213978485, 1.1156970036409357, 0.763537604022676, 1.0267955457755695, 0.6073376165368943, 0.8121785327592678, -0.19578738618876895, 1.132564269651335, 0.5678285638542837, 0.4430680176295091, 0.8006964066605455, 0.6199827717068395, 0.5592515419916935, 0.7523256586734027, 0.9931787061785899, 1.0803945230889898, 1.1306643812216584, 0.7023151153558927, 1.1176922370315545, 0.0011460904669362943, 0.7102814392687017, 0.6279813033727174, 0.9028202308258968, 0.8785302059270527, 0.9564120744111365, 0.7427827575518193, 0.8603587229319087, 0.6893290668411776}
};

static const float b2[32] = {0.7885513905371359, 0.7852107270522084, 0.7395203567234195, -0.07097798913996752, 0.732020742258321, 0.7915727678591824, 0.6938231547541557, 0.8193782249855095, 0.8880777670911292, 0.8544713815744992, -0.12898316342154337, 0.9318595616719693, 0.9185992813513841, 0.42828136550156043, 0.6808346087231975, 0.7834808386009119, 0.726304654664569, 0.7269251410290642, 0.8961464642330941, 0.9204511684881141, 0.7850116400193302, 0.7906225309230995, 0.92569312705798, -0.09584146658146776, 0.7846035498541964, 0.58933941152513, 0.8363060248165701, 0.9466919639524074, 0.9387318292410631, 0.6983332065739436, 0.8978871162238197, 0.6523685724473669};

static const float w3[32][16] = {
    {1.1561852773189727, -0.07382043539085383, 0.41463905060692935, -0.6572205790131846, 0.2745215153203166, 1.4499877468851052, 1.291558553512599, 0.06795884859303727, -0.1919559803015264, 0.10686871772295287, 0.9359063623657901, 0.08471074983282846, 0.8917807931611048, 0.01540593623551291, 1.2144437535532704, 0.7490148716084117},
    {0.7245830652300996, -0.006753749077624783, 0.9670727011498444, -0.18375369208294592, -0.07692875292631458, 0.906028826904652, 1.3227730074204693, -0.3295362505840536, -0.1154039219581006, 0.35302768502292664, 0.9194493906287285, 0.41567742345277003, 0.9045815934095769, 0.07252979881901199, 0.8326199732569144, 1.012789581446257},
    {0.7906975579032436, 0.3831156587415863, 0.953992057204807, -0.21086974508184123, 0.2575083453242213, 0.7533859458760807, 1.2493373645827341, -0.10332829314101967, -0.04679996676249738, -0.08834825057703236, 0.5064313462659623, 0.28122199813331816, 0.9601709924505375, 0.029930863162735237, 0.5070834518599653, 0.8450071404343644},
    {0.07980138499020567, 0.4330055912305242, 0.30649771991086083, 0.04300563520404028, -0.451066838087325, 0.15645929820641313, 0.322796373260439, 0.11143851298444497, -0.06499367047771985, 0.24449010705325866, -0.16865774555544183, 0.3596323279727333, -0.10716921977898015, -0.23568360453050927, -0.24369944686235318, -0.42666921191852425},
    {1.1356728541865508, -0.1644562123620628, 1.0695116114820198, 0.07558079076719335, 0.13240823301750368, 1.2252590772409375, 1.1155010315399125, 0.06643897688010422, 0.031861890771831186, 0.19730258444840426, 0.6330532671171548, 0.14609545263976184, 0.9709453512189345, -0.4187393309126591, 0.9298741939550016, 0.3550245243468158},
    {0.7707538035789488, 0.5087687192297703, 1.108999214043022, -0.015891029731628648, -0.1551612701831161, 1.3485396267856864, 1.054157664921104, 0.1384877580078195, -0.012619492833314101, 0.19902941730764556, 0.7167215797876242, 0.11421456720870533, 0.9489326194825358, 0.13587072315489487, 1.0571757778349422, 0.8365449363417797},
    {0.6745907432580724, 0.05848295825905923, 1.2784827081075913, -0.41501249799416856, 0.43215462843559405, 1.0768046240736084, 0.8108786175324635, -0.38135052496455535, 0.07783014051938525, 0.2674000308197287, 1.2032981496334358, -0.19447984418470748, 0.9816336631303341, -0.4118425934221475, 0.8157225157368748, 0.9354120838310409},
    {0.8215974719032498, 0.0423607738043686, 0.34525558331234396, 0.19246071034884168, 0.2664041268349826, 1.0854280760315196, 0.9149754209212386, 0.17698653747146834, -0.42823846721085107, -0.1047253803623378, 0.8692947050155727, -0.16941974217892675, 1.0502219564062798, -0.31202296390686396, 1.2756251215823082, 1.161319505605996},
    {1.0187502863557019, 0.10314419133453231, 0.7424940856446697, 0.2656518472419894, -0.1662677172031331, 0.8072768542148503, 1.2782582302425516, -0.10411286591056654, 0.06070219003948903, -0.09267895860012727, 0.7405439415403188, 0.0013880766354484866, 1.0930966553709964, -0.21599697989172936, 0.8285120148017175, 0.9614693881260006},
    {1.1649495680495952, 0.037008531489347296, 1.0203038771945963, 0.1656006748455527, -0.16744520143096459, 1.0142314183031003, 0.8607829786813219, -0.2996038178871689, 0.258414180973544, -0.35140978348923857, 0.4825488548853302, -0.16859231330504051, 0.7041049802208237, -0.10388433123571295, 1.247938170797771, 1.0670278665804376},
    {0.03537550314375197, -0.11917049580596921, -0.3952341669744172, 0.1504710511235911, -0.3910310823199199, -0.09640451017613004, -0.15861763246023963, -0.0738881572158178, -0.06063859968351008, 0.050723348786501435, -0.02847437803109149, -0.11087044100461783, 0.10470174653573666, 0.08224983003660741, -0.1292326229415204, 0.007638433034946886},
    {1.1943324983546406, -0.007450771022318188, 0.3825034953844477, -0.07544376842929285, -0.03768042506420093, 0.7955402571957509, 0.8603498763670486, -0.45196248876352807, -0.036455361381373286, 0.05760247089016298, 0.8671705203832937, -0.30893205968784043, 1.299386900135956, -0.19327390284259086, 1.1339819759913352, 1.0360793500752838},
    {1.1305616116647208, -0.5005743455232499, 1.1067136469696495, -0.10275606457157588, -0.34705155376899205, 0.7495933418820125, 0.9354456361711038, -0.15876345355334714, -0.3378192926561627, -0.021102140124301207, 0.5802814695081155, -0.3443298475638169, 1.194020008048896, 0.42179149023821105, 1.1906358306136844, 0.9534480622961888},
    {0.18615558283739284, 0.10598100466129307, 0.8121288246902255, 0.1281266947990164, -0.1495523236300603, 0.5208307826223887, 0.6648381868782376, -0.2088732449594209, 0.18123223302060676, -0.16189787919351448, 0.7352569330340485, -0.2104552838391175, 0.35030679919412727, 0.21550672873040966, 0.3956740672959841, 0.9321265909675484},
    {1.157359357135698, 0.15188247530952814, 0.726047311158567, 0.009073299193952679, 0.19491579434068262, 1.061115889060612, 0.7344859511838163, 0.31925850792074967, -0.19388961999562435, -0.05395818872635257, 0.35593864228587757, 0.20840082696993179, 0.997693347502045, 0.24300601087476115, 0.733255628300457, 0.4382773768059494},
    {0.664025899181678, -0.6993891865601971, 0.6878233127947518, -0.042241770635745586, -0.13494894884397407, 0.41089161748546094, 0.4841101821300401, -0.24869339614269048, -0.24213850302532144, 0.21998824085610272, 0.8521512278050009, -0.08369826922040804, 1.3647774627986555, -0.07683979208453054, 0.8881146496877944, 0.7216754999639918},
    {0.9455348695277058, -0.171835040185544, 0.9584716761706341, 0.38726805414703785, 0.0759911270304266, 0.9045694850621747, 0.5875836595317153, 0.042734590444422314, -0.32269259670510886, -0.12158900624362534, 1.2676187403170578, 0.03948506194538056, 0.9711629645781666, -0.3559733325274942, 1.230726919687521, 0.7797879997857817},
    {0.7811008007293804, -0.03871819385282093, 1.1635410169872173, 0.24710148971191792, 0.4728049562659432, 0.5344232841601432, 1.2077405445986045, 0.3703404939448283, -0.32547935216688284, 0.535906422744379, 0.6588780459276863, 0.2539583047305414, 1.0739243494353234, -0.1306660033361525, 1.361495501624995, 0.8356170537332349},
    {0.7561736722113471, 0.05710168458172975, 0.6124455040287394, -0.32900721676598194, -0.02493798628514069, 1.024554477733725, 1.1568428428038877, 0.02146463674982102, -0.011713179143489938, -0.08911650687836471, 1.1731604490600487, -0.28475911406711946, 1.2309955220864932, 0.04483932235447973, 1.373452861020398, 1.1178958678872504},
    {1.2788009939112353, -0.09933049704039447, 0.8452450677707232, 0.08149169860684875, 0.16482176151903122, 0.786582827993175, 1.4474719289575293, 0.2686078474645346, -0.18671350181930674, -0.03637870653111765, 0.4001232424578416, 0.05811520705095385, 0.8414162081507619, -0.616098417944513, 1.2132769587877026, 1.2452307511736975},
    {1.1306448073951243, -0.15074097647704074, 0.8134202333489576, 0.4008562168349444, 0.014573714658792246, 1.1645420014225394, 1.2309626737232409, 0.12691490847653625, 0.07671228714573419, -0.049153374090723304, 0.6256867454030345, 0.39237215702269385, 0.8652518284983068, -0.04364566621272191, 1.1387104028184933, 1.390606973323736},
    {1.26659568723496, -0.19638187424648532, 0.4893050862166581, 0.07382449992446705, -0.2840483149672777, 0.6729987423551392, 1.1248723420825648, -0.13220119262920313, -0.11619195058612501, -0.566326501482017, 0.5866600634326257, 0.29181182864678207, 1.0211343202705911, 0.022355347446133517, 0.6623174611438947, 0.8309250146649556},
    {0.8831543066292664, -0.3360827679015116, 0.5810630523335968, -0.3413473338823494, -0.09253026001317992, 1.1617609953191173, 0.9481794367707753, -0.6246484289215606, -0.23420809421238264, 0.013665550265447536, 0.8226312598347543, -0.26895402575715044, 1.14206731341683, 0.09026542018628776, 0.8786059235347828, 0.6036701708906341},
    {-0.11507057563632116, 0.5392160418304536, -0.025644074378239356, -0.17028603303189205, -0.0206547394731294, -0.3298292499032228, 0.09783356981550699, -0.3334381658979921, 0.18548599472339472, 0.1991123328001101, 0.3797303791702631, -0.15680568389789862, -0.01763488329041837, -0.23977174241765967, -0.2504287689973628, -0.11663704733721159},
    {0.7427291902659696, 0.4807827719884277, 0.8048101643727168, -0.16478984173382819, -0.14327931561461765, 1.1513084565053, 0.9534017527419569, 0.1319853237257005, 0.3483374485876642, -1.019595111447675, 1.0288055230068176, -0.12470378879461809, 1.2005185096132414, -0.039678601492307515, 0.8319875704804662, 1.4195362192901244},
    {0.46325120834253125, 0.34820615745136, 0.9178143180336419, 0.29759006338890903, -0.019167649683445344, 0.7002085546595186, 1.0736232715332776, -0.0405665652211446, -0.21582207312144466, 0.20477683016126405, 0.898689026931451, -0.38454620901265885, 0.614218582608753, 0.08146219354399373, 0.7343099756610308, 0.6559303977960935},
    {0.9980087779532267, -0.36232994235062843, 0.6330096425242846, -0.435342946117929, -0.6578056552241636, 0.8816110383642802, 0.807874029696889, 0.25763110255821803, -0.25282021352377304, 0.19820026560095974, 0.9385807161028991, 0.14017834931186482, 0.8974570493026734, -0.2281991420192043, 1.1680549988343247, 1.041575616794211},
    {1.0332560722086404, 0.034760235860300824, 0.7755094115839232, -0.17096665986655357, -0.03570427050449423, 1.3036310959355955, 1.1783049751042374, 0.23071835661354848, -0.18055758744379105, -0.3952056080032636, 0.39201336084893335, -0.09320114192489452, 0.6503642132010873, 0.0003335364733013268, 1.4034822323624918, 0.7733007887862433},
    {1.1075639202194285, 0.01007549869833405, 0.21540093411829614, 0.15035875906625012, -0.12917572489523763, 0.8219210765689008, 1.3700832368952838, -0.25236620549032196, 0.04536278469536202, -0.15107415711163927, 0.6367811146481704, -0.018958570026708615, 0.9745436156661157, -0.28425108496336926, 1.3855283879518734, 0.9904889920690886},
    {0.679187673701344, -0.2384290312017567, 0.22982088924812896, 0.09335503970466638, -0.06862280398928891, 1.378251587593143, 0.5653552508259284, -0.14256465135438348, 0.04419338422886995, -0.1444027599421143, 0.8485113762985356, -0.25207607306837504, 0.9678115307889651, 0.09080306616150427, 1.1134781415269879, 0.6285762083898636},
    {1.097642321495372, -0.08726366330648488, 0.9744320953280357, -0.19543358405185426, -0.022517634795426043, 0.7032596142192827, 1.1230847699617887, -0.39978270113225844, -0.14616479750995084, 0.10702889524925686, 0.7290308854281251, -0.28220063754352626, 1.4068220570230479, -0.27252347206789845, 1.5038800715287084, 0.9117955242710215},
    {0.8364223291186902, -0.30838461048545857, 0.6685044244961572, 0.0254902468693603, 0.2708066119625217, 0.8583325116057263, 0.5619437765870857, -0.008790292305648354, 0.2579487175513358, 0.2146086483518251, 0.8560467595265436, -0.1662296432542889, 0.6738242791837564, -0.2555906610105974, 1.1223238643059217, 0.7746621533912598}
};

static const float b3[16] = {0.5797197637692542, -0.04535302686798956, 0.4728571221279413, -0.03936021100419221, -0.05101692693376786, 0.5226371862628107, 0.69563491059415, -0.05166172100097449, 0.006471844765443338, -0.05415541866390944, 0.38770306423639805, -0.013651161290555712, 0.7540043520550607, -0.05898899290410001, 0.7034873970631591, 0.6535457183721097};

static const float w4[16][12] = {
    {-0.5724616005465404, -1.1573276234767191, -1.2155630390621397, -1.1968663095346086, -1.677019921528908, -1.2303977696514394, -0.5662111464508401, -0.24752405231209534, -1.0252391854626903, -1.1492629311772653, -0.3751433919340117, -0.7060622155845139},
    {0.19366295672563372, -0.12070944026099859, 0.684753305742268, -0.35268508911073676, 0.4862298580904722, 0.21512550149536724, -0.10659903834269911, 0.6188746193624027, -0.07294614681344971, -0.22255209984711236, -0.28731999907853695, -0.43059476272482233},
    {-0.9706338475906167, -0.8699050817129487, -0.7762934569988418, -0.19348238781496668, -0.37152485285644776, -0.00043795294480447285, -0.8227994877438423, -0.7549006105381277, -1.1323428853966415, -0.9280276302663418, -0.4461844059012037, -0.6135522572284613},
    {0.011245476126459332, -0.8590182346520254, 0.4714279357880204, 0.36591603661009503, 0.16976819578968197, -0.05870320878077488, 0.12126570788776607, 0.43810191322536685, 0.0236284716792021, 0.10082035379015822, -0.6607137270122077, -0.10195179461819237},
    {0.4112971341939661, 0.31155045633814954, 0.3301321491945607, -0.3184419886618474, 0.056180126175517736, 0.4148607375720046, 0.15723759866227105, 0.05290710956993206, 0.40852496436274965, -0.42874234581592185, -0.26938343427809097, 0.04524837185959336},
    {-0.468514500823263, -1.1731173405315636, -0.55429851392094, -1.09195921867264, -0.4321760934120488, -1.15871856683536, -0.994599990147878, -0.5772758142229483, -0.226395610638675, -0.7596749236040758, -0.30504541079275016, -0.5508521606475735},
    {-0.7863378933697199, -0.3774234703111173, -0.8587122147538775, -1.0397494889819228, -1.3248003614957267, -0.6554146385756794, -0.5105447790104651, -1.2057450674323331, -1.0890032627747523, -0.49781971304399086, -1.3029148553328733, -0.8703752974290464},
    {-0.010192668252678859, 0.1630062359706737, 0.4099604866293682, 0.4322569364993138, 0.30620269830314684, -0.33987042546108004, 0.17847741755313104, 0.18722716832722563, -0.19999749114164886, 0.3433772762137371, 1.0604656753071948, 0.1810605866913417},
    {0.5768753750704884, 0.5486696246769216, 0.2577770326049663, 0.14539825156642813, -0.16779550367089924, -0.4220452065941732, 0.7464705427285204, 0.5083734610557987, 0.21884629274475545, 0.401046563463429, -0.5180782533596696, 0.008243789877555691},
    {-0.6450359787145677, 0.7255906391024212, -0.6572457440072788, 0.16064530752018283, -0.8105378217016518, 0.2652834572001421, -0.37206560776529873, 0.7100949556666014, 0.4857406561010344, 0.5587424421860727, -0.11629912620440663, -0.06364879537096546},
    {-0.9306077087017534, -0.9228926001000709, -0.5858826628355772, -0.4503986833356535, -0.6579747447181118, -0.8966856538641258, -0.43609946756035045, -0.38457212520031586, -0.30592269863153776, -0.4550652511932295, -0.5414533464892125, -1.0187172973609055},
    {-0.3009671107174358, -0.06464803351650542, -0.5852860626662526, 0.5613956902854425, -0.47643421797438634, 0.2072933034377464, -0.009354507440526742, 0.003875999468862451, 0.22820751733857453, -0.4743295815146041, -0.06701129210453341, -0.20349279309930224},
    {-1.069968330388795, -0.8239066991592751, -0.6025578124557732, -1.0704820116642264, -0.07492590316037717, -0.7321014270682682, -0.5326764934021125, -1.0482912310826953, -1.115589413294232, -0.9067483574873246, -0.9705966799724914, -1.0303342278222396},
    {0.20031338000745078, 0.2765251210278173, 0.14032399119565409, -0.6563372486189571, 0.02395248706887813, 0.1382165854647937, -0.19254025595097712, -0.04085512216205949, 0.053546679510236894, 0.6704141654154283, 0.565417174723882, -0.35558018806096414},
    {-0.8346038432604281, -0.6164116227185424, -0.5287153209293073, -0.8929963298601324, -0.45574877618153137, -0.6491695996074833, -1.2513023255401474, -0.975571633062858, -0.8604077316352825, -0.600279194083147, -0.8412171822006818, -0.5872658888582464},
    {-0.6342755728979914, -0.463259292726966, -1.0331112125423059, -0.04922230822782397, -1.2068728073623463, -0.780725875584639, -1.0865238887306012, -0.9419337212695039, -0.20848591080658782, -1.0403074323550352, -1.2700140999458913, -0.7414250922824044}
};

static const float b4[12] = {-0.3624001022881142, -0.21274517683566835, -0.21336121930442997, -0.3564454216373361, -0.2996963748863149, -0.300380856191179, -0.2834093118267573, -0.3208746714290326, -0.34164728625453883, -0.2460801720538418, -0.36566226520013545, -0.1990030458805336};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
