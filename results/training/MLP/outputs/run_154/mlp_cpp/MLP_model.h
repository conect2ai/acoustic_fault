#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.3559285832636946, 1.4560998595717818, 0.986866627809602, 0.846773858991765, -1.7228314700954648, 0.07723208908809168, 0.6809419768997145, -0.9024128290132178, -1.6823280363385364, -0.3420932156609835, -2.4536046600864623, -0.4482715813832273, -0.6906754669944873, -0.9860323967672682, -0.9216423804795314, 1.5168591027642282, -1.366943161314904, 0.9416813594460736, -1.5930399085509324, -0.8312181789473454, -1.24050286297731, 0.061641570549371714, -0.04207955329152328, -0.2411756115755756, 0.6664759391850557, 0.2025414482872911, 0.15154602150971525, 0.1439520541730373, 1.011616423088819, 1.1794551820218073, 0.9957226480082907, -1.0296388020594682, -2.0495593380961306, 0.3605906970715904, -1.1990952620797004, -1.6840971108082454, -2.537117352905658, 0.9498199556345122, 0.8263567976228597, -0.7947003492473241, 0.6847928510870468, 1.2307868956183636, 1.943137663292647, -1.4363622088218706, -2.1833166457896493, -1.2475262235387066, -1.367137860836471, -1.1306472672970438, -1.9207434854659817, 0.1951902924008313, 1.2340825319253557, 1.774255166960162, 0.3896458190227085, 0.6130382264373543, -0.8760762388828576, -0.8219146107889883, -1.641119331034642, 0.4560277905397345, -0.18192889313789679, -0.7647108821658216, 0.27077044091606994, 0.4914532009912319, 0.5258117232479796, 1.5785428944080284},
    {1.584064307121875, -0.3462927528238004, -1.4779471068641499, -1.0973267988180766, -0.28259830547814246, -0.3204519124031273, 0.27664892018362747, -1.2895685123691998, 1.0204239360070235, 1.0730680102796268, -0.036052054168114224, -0.392816531239306, -0.15091294117283477, 1.1480422497565144, 0.5607958775828814, -0.7738769922124398, 2.1093934601633726, 1.1967437489602442, 1.013167371744352, -0.2241427083012601, -1.2216853093416673, -0.7358527859551312, 0.015362401953631824, 0.6711765928182325, 1.3276113639816016, 2.742287440930923, -0.14784424036817995, -1.0014704457103538, -1.1189586867677395, -0.6612259512209299, -1.360489316144378, -0.9890565948081694, 0.14803211536535069, 0.6592347608601148, -0.5399645974010664, -1.143008214642809, -0.57704334790191, -0.3097382931896173, 0.3860326440551023, 0.24005390863094506, 0.38436774918968114, 0.775670383548681, 1.5456938674783287, -0.8063300732450625, 0.2092304911877568, 0.5036427626289821, 0.4128403220076405, 1.5073983667101585, 2.0698704946044497, 1.2999032369234091, -0.6092738237472134, -0.9297899558811722, -0.3734846793915428, -0.3150349276877589, -0.8164319707596043, 0.6551493894516839, -0.8158536565554949, 0.2364975567634387, -0.5718871587242779, 0.3434585681808851, 0.1374658979706294, 0.25170910569908234, -0.20497044066386644, 0.24658766524745346},
    {-1.658422726790652, -1.7890000043599417, 0.26688939021968744, 0.7140811312818559, 0.347931890931375, -0.15652369816501674, -0.7093192286397308, 0.14561611698305288, -0.5786660570331058, -0.7479363082776339, 0.22603090621276853, -0.6305236590381856, -1.4924056210844483, 1.0225538434318298, 2.2396806963828113, -2.073289366125674, -0.17112165142365082, 0.37636486173642314, 0.5822743053003349, 1.3617107931934325, 0.24728504600163703, -1.5225308692469852, -0.3886226588514958, 1.0004200429273213, 1.9298036497756659, 0.2964771744606773, 0.9649592511698256, 1.0352067934934925, 1.350211146216098, 1.1357900671591996, -1.2488357693237624, 0.1887659472385591, -0.15683643271558712, -0.2865658063389274, 1.2246235955573672, -0.20744423988857055, -0.19604024885311808, 0.5110117565889719, 2.537209215334853, -2.041559075110489, -1.642942619251876, -0.28504618052887987, 0.3970700837286759, 1.2997984245641707, 1.5589102027586341, 1.2108630566139198, -0.6298369156819643, -0.2359464040895152, -1.1831236235092688, 0.9747392313767168, -0.6779150873780039, 0.8958749436340251, -0.8484897445576652, 0.753402810461396, 1.1265565458822449, 0.9474703080710154, -1.0231840968565433, 0.45477156001349056, 1.3493475565079107, 0.10943712673582885, -0.5925672149393997, -1.1910920277247274, -1.3391631125351042, -1.1807545338659182},
    {-0.733683941335403, -1.012388458261166, -0.12708685372614195, -0.6821512526186259, -1.086183911550226, -0.39654963242795527, -0.01997744119177534, -1.762055090901553, -0.8837413335577533, 1.5858352898753851, 0.5289529197742558, 0.87125594975239, 1.2532149958750707, 0.5005437355510204, 0.9244669446390742, 0.4652100179298382, 0.6923445282050626, -3.2852758915651945, 2.1025183477094003, 1.0798618536569378, -0.19558410776136212, -0.5288562049119577, 0.7994044383111146, -1.4363921372550315, 1.441953916430737, 1.7066795083282174, -0.8867445499761349, -0.2875522004670061, 0.5080769028865129, -1.594546806758194, -2.1921978402439786, -0.007130149825717996, -1.9693199162545862, -1.1876532010046652, 1.0546667007165462, -1.4829161347819493, -2.246153344780903, -0.7230055888138409, -0.022673280699782777, -3.5667261842400046, -1.0899265651375485, -0.6298375719298898, -1.0896672334191289, 0.7562089445109423, -0.002107869899486298, 0.6900417796298093, -2.401120809614021, -0.8058753607588116, -0.7860178266698383, 0.2152058222835189, -2.5562079593873848, 0.3298386930042766, -0.8340193387829338, 0.07991318626076382, -0.05846931586938, 1.4633243998005867, 0.20296454946572742, -1.8552252970219036, -0.39399115415174657, -1.221247851698414, 1.5448327942365472, 0.44423679183574183, -0.3658151838414347, 0.8676710119643386},
    {0.32910316457027006, 0.27206449475147365, -1.3024235494510699, -1.6243490915975003, -3.5821530478863144, -1.578902120996254, 0.1153583729430668, -1.0824320285500375, 0.7620924500181537, 0.5741857385069359, -0.8914160232768208, 0.04757176645857067, 0.34403855534460775, -1.3712727224099326, 1.8140967171792985, 1.2151501181063304, -0.18361492081503136, -0.44983341068104155, -0.5077107138667356, -1.29937491836718, 0.3529905623180627, 2.710839983555823, -0.13255768496980982, 0.003954990479717074, 0.4999144090283425, 1.8912082661581053, 3.400694595380648, -1.1663229011597849, -2.8081478530991366, -0.0238652636129021, 0.0231404254393662, 0.7056541238701376, -2.2685572901044018, -1.697670176285061, 0.2085880586340298, 2.5717206866180695, 1.102825419855117, 0.8788812122856006, 0.3497027368499225, -0.9389477695073223, 0.019521285326575405, 0.18804916909927524, -0.6742566575328064, 0.01984292112989402, 1.3226724243678187, -0.588449368949502, 0.39781623328096133, -0.6492025885312513, -0.8767857843537897, 0.9389480684807283, -0.18450252014346633, -0.00131303031254058, 0.8763088822124028, 1.329269315848752, -1.4754298976951141, -1.2672083813865052, 0.491063157586787, -0.5083972385907519, -1.2166242008621275, 1.258904970673622, -1.0765162176803096, 1.568674772350081, 1.8708569013207177, -0.5914231828503852},
    {-0.7143748219225883, -2.0854909237626766, -0.1115282724720337, 0.6501770742363295, -0.008318543146086339, -1.5616555767525082, 0.8133160137109212, -0.6065680896297523, -0.20636860265183757, 0.09758537540688987, -0.33568267088098486, -1.4377187598563483, 1.5414258802994434, 0.22709572700356598, 0.17896679858640663, -1.0226190513361437, 1.0689501407110877, 0.13896161784199937, -0.36463045195318106, 0.5700848794447868, -0.6894114322959921, -0.14995726361780778, -0.3712968993865567, -0.7046357064412485, 1.0776284321801248, -1.868483015704796, 0.6696388870136645, -0.6609583028636219, -2.328697568923965, -2.2069346322031556, 0.5037850193881289, 1.1451041444708059, -0.018347700966834274, -0.7723204857181768, 1.4673389386583786, 0.8971567769767206, -0.18864663214396063, 0.9744195106219227, 0.0995273483540228, 0.36359919048235956, 0.775647907487361, -1.7062063657210438, 0.416138842353019, -1.3293033268921535, -0.707041413538677, -1.1368536937069786, -1.5119368686803218, -1.231419800544379, -1.3494666975418899, -1.0666918841249768, 0.9892739527728546, 0.5793532242960937, 1.3082072678573589, 1.307039817340139, 0.514386595534448, 3.239065005131078, -1.2380259349564446, 1.4398316290282027, -2.9326372847756135, -0.6384856438877665, -0.09035394746864195, -1.7316102694745508, -0.0883591485770363, -1.6092867994011812},
    {-1.2141957965873786, 0.579714632879477, 2.2348459972643195, -0.41421483864267267, 1.7518531553070835, -1.6490730842678714, -1.9628545185470545, -2.1825806994311163, 0.9734767100836517, 0.8234987414953575, 0.3891266864431351, -0.7512176261900677, 0.6282051564000428, -0.8976257994689703, 2.2626067239469623, -0.9715529320040168, 1.0416089608489496, 0.7531386672904118, 2.2271808934124566, -0.8012645120183743, 1.4937059433831172, 0.02735699863998676, 0.6251336613753583, -1.0244697867632955, 0.8144443250705696, 0.03132453158656107, 0.09165127550737068, -0.2551560533920286, -0.3408233243441826, 0.6681022465910751, 0.15756093602752957, 1.9601041274565603, -1.1953818427502667, -1.147901819173818, 0.22871300681658593, -0.32481900504477035, -1.183320247769081, -0.4118152373836001, 1.2073776204892515, -0.9671535456314084, 0.5922641190680439, -1.0279598142144257, 2.2631838248188862, 0.6299218562389126, -2.248061280984201, -1.3649006398071923, -1.8531911399737138, -0.2620878310475034, -2.723860011567401, -2.2150825401831415, -0.8038293889876954, 0.4155972777226864, -1.4429221915261763, -1.0162110580664303, 0.3847434843697709, 3.6526502545754633, -0.9260953929950861, 0.5026406083298849, -1.4841220793646897, -0.0359238370772976, -0.04653786822859462, -0.8429021220780331, -1.990308627984319, -1.7890601486447903},
    {-0.8517277107914083, 1.3525333131029589, -0.08794250418976042, 2.528487611000323, -0.15794739831335383, -0.02371549632323132, 0.3121576029809947, -0.9315622602219807, 0.11265038012559896, 0.14611113787157287, -0.4100210255452864, 1.7648694783519512, 1.8660519697228564, -0.14190633627221552, 0.024146558204700626, -1.6147110859919362, -1.0886354236543143, -0.5987442631574861, 1.6546398907731785, 1.8144150991110926, 0.0559950323137375, -1.9009413438306113, -0.18445580650910537, -0.7841526580199091, -0.8524979631041982, 1.1051406994282118, 0.8452599147257214, -2.427518029613322, 0.18083469134209934, -0.6719716670174085, -0.05975996521147624, 2.6764729247602577, 2.111222846096768, 0.02962878325526177, -0.23870958165876027, -0.10340474893413636, -0.06973441990665552, -1.124281317861674, 1.1244026560836842, -0.6147129259925851, 0.28374065517107494, 0.7876476625544159, -0.827897451998851, 0.7800506612011073, 0.5610334520505227, 0.31948927198106725, 0.3620014871128432, 1.9063729888961123, 1.028358407378995, -3.63761985735674, -0.2945768487934256, 0.2394369563480008, 0.749957257603902, -0.9973383839911159, -0.009575180201106037, 0.2956878284290839, -0.1830113982186224, -1.283380168852001, 0.46996177011829326, -2.136568229334486, 0.38943308814339495, 0.8756747661404732, 0.2893686872215803, -0.12036410363837995},
    {-1.5185320824159303, -1.1691933066717126, 0.5881026806177087, 0.1088529906633128, -1.9277391145246718, 0.8145239882407541, -0.8834853932142012, 1.1665801093648895, 0.06991023569691489, -0.20432766700525112, -2.9307494182751066, -0.473270010682622, 0.989765747290084, 0.13213237095718472, 0.6696790938148584, -0.1100753119900222, 0.8016637193743343, -1.3976262773588657, 0.8745667209118723, 0.9656396715152363, 0.8439002516418874, 0.53276208934612, -0.5388096424670968, -0.4256042957355823, -0.5494472262801501, 0.3877578525413293, -0.7763025484925864, 0.4245932561247184, 1.261122935544921, -0.4567949110291073, 0.1504108768823972, 0.38496583194245354, 1.1806871962047407, -0.336734335343627, 0.952513555218527, 0.9688047342886464, 0.27928273640499557, -0.8612574588231906, 0.3591564029413131, -0.6536627799209673, 1.019587242437563, 0.2190131338849114, 0.37137762874378205, 0.5008535296279614, 1.0933143134924366, 2.2705816194717783, 0.26078262832839727, 0.04536754895979686, -0.09677938294248523, 1.5987831279122218, -1.6652769121100202, -0.9609486137966186, -0.12002054979227299, 0.899272206872242, 0.6448239399732859, -0.792843396684172, -0.7919555396890651, 0.022949721889029464, 1.0960619467917978, 0.5083370873796358, 0.087394733612698, -1.3879027756485778, -0.5036171594814135, 1.1612397946091182},
    {-0.10133326863981656, 1.766003571802175, -0.6283657545576052, 0.1221276341402825, -0.45335236827574693, 0.10315652069719329, 0.31087802031298883, 0.1142382781688671, -0.47692933711854696, 0.3367483261061854, -0.26098368075503364, -1.4589590318584518, 0.10111200584786517, -0.5219260795907935, 0.021328247221569837, 1.6116200994224021, -0.986881650052093, -0.09841333484779419, -1.2192788086998172, 0.7500793270481189, -0.1706930620195061, 0.3411336561144183, -0.4692432930449963, -1.0568718587774164, -1.4195110373491449, 0.3933554564747948, 0.698187745407612, 0.6153428442031788, -0.9971589874687116, 1.533646964095358, 0.8546899651749426, 0.4063650739796008, 1.5190859645853863, 0.918120267350028, -0.19298665723855005, 0.7481777120618479, 0.4399564739300672, 0.2643492341253823, 2.099295408173122, 0.513564617907909, -0.8034021361790714, 0.049513303699663606, 1.5613122066736649, 0.8636418918323591, 0.6429775903021092, 0.7217565106293838, 0.6306164029536462, 3.072801495108703, 1.789263926100515, 0.5491443617554239, 0.9938002390496777, -1.2973569127485132, -2.1640147541338326, -0.1368235202552752, -0.9987482533738373, -0.23064571621287103, 1.5876931078009395, -1.3691317992920489, 1.4297582796449548, -1.2633811031419118, -0.18741345519278954, -1.1290693379394434, -0.2660386238081193, 1.2328510147452247},
    {0.672531198728437, 0.7473987059251747, -0.7515880162879791, -0.29454945401077864, 2.3682060926422204, -1.134394897330958, 1.04725454969513, -1.1880648555579743, 0.07597867780973848, 2.409158692679567, -0.6844984070033617, -1.6158069144621645, -1.7976082775570743, -1.4239546331850956, -0.5663956685055516, -1.2194015566746528, -0.17463922496572326, -2.081168081642847, -0.16941441223208242, 0.5185739605901987, -2.923971013660105, -0.7762935796078066, 1.7614296916215246, 1.680418107148903, -0.9571162181125908, 0.4832108424423388, 1.459300490868177, 0.6699603278320875, -0.06767342987971565, 0.9929996400703021, 0.2112116998558035, 1.1256044503060931, 1.9091598004881714, -1.4493070651684625, -1.1948643421651404, -1.1791261561077808, -0.22423221385433367, 0.557013954683159, 0.8299494732209086, -0.3872078257890947, -3.369642153659258, -1.5029253154932989, -0.00766158390501153, -0.3929312550270064, -0.5621928994725215, -1.0974370949614267, 0.006682805145824734, -0.04371156467001486, 0.05553614629655201, 1.413019147584837, -2.6279982707978893, 0.9015591763748251, 1.339167026684207, 0.20254681673877528, -0.46167747518267677, -1.896528671195794, 1.287292096323712, -2.026995320873488, -0.054047749808818914, -0.0749988121120152, 2.0315325569774685, -0.4976826416431674, -1.18692460420103, -0.48104714920977276},
    {0.18666559752236742, -0.7815561379451407, 1.0790945915346577, 1.7329536692209575, 1.335194670001766, 0.9757767480748242, 0.8351309931137961, 0.7262454504351744, -0.8435727675911296, -0.9188058556816037, -1.040194462222207, 1.5007950402947634, 0.06332094611041914, 1.523297918276256, -0.8356556548597532, 3.106913945580459, 1.4286682378960136, 0.8236851348999643, -0.08694739876831879, 1.213279625226821, 1.4447837984642866, -0.8209664438495164, -1.855404624148977, 1.271895738052466, 0.7438213324340109, 0.6982270970639527, -0.44724678968644005, 1.3913174312715408, 0.9313666975066222, 1.670610436234604, 1.6227618330010474, -1.1917064904640053, 1.2493799726447299, 0.24051482082028347, 0.24697979496446668, -0.22412265031423917, -0.8718239886149415, -0.5613954623559305, -0.9793768949057677, -1.1194108204176991, 2.7067909623879203, 0.08874246564796234, -0.6881966318159736, 0.8733851691445776, -0.3192290897564306, 0.295887835942372, 2.2000678938674487, 0.01782639246387458, 0.12473539194172611, 0.8381045595738782, 1.2930983080334455, -0.8425402567043124, 2.379272602003895, -0.04840575545798994, -0.8978990584083916, -0.8308447565080641, 0.30555688344065934, 1.7559666760936363, 0.00955452200214095, 0.4508032956881946, 0.12115299045558828, -0.8085925463911597, 1.0280605689429863, 0.3205637403705924},
    {0.11141451218116967, 1.038381887958496, -0.012204629602480511, -0.03107879717913155, 0.7706609651530816, -1.7067530160576976, 1.6605606417863221, -1.82305426879935, 1.6477342517761793, 1.5072014428439426, 0.6136643741327922, -0.2904203251496357, 1.0519710384171066, 0.732877401001266, 0.8155004810352985, -0.4359993156164205, -0.02331238639146228, 3.3146634016665915, 0.3887646031220755, -0.08836178695237312, -0.1723198619885921, -0.8071943330928346, -0.49338792857091496, 0.3943057697884114, 1.0669544689723895, 0.5187974918529072, 1.5358338441803694, 0.5365233924624457, -0.3730478929036972, 0.3363686397326634, -0.2527956037252213, 0.9100827573351984, 1.5156263076632692, 0.7793176719485604, 0.6839693448956132, 2.6687195792927705, 1.3646235653672816, 0.6328324347191058, -0.1003174825894672, -1.0747711411958305, 1.4262757680099016, -2.3526750736082165, -0.7459576041936035, -0.879094416695221, -0.04560213638784927, 0.6205057930457993, -0.2592316916425223, 0.20635180820994842, 1.4629406035848003, 0.8294241164568482, -0.45150479043539354, -2.0056475205378383, 1.264801002810421, 1.361238486635845, -0.4121892558929807, 1.1478836619930335, -0.45903959961354013, 0.18609118733607316, -1.1613784315554656, 0.7731162580414417, 1.1736577042329526, -0.8100212191424899, -1.767894225966868, 0.24033354203924012},
    {-0.15125919960070183, 0.31131718233675076, 0.5270542857959885, 0.40087699381782343, -0.03283452576847342, 1.608998321720847, 0.047701038146069366, 0.2958265011496907, -2.4223641307862076, -0.7456204136779886, 0.012212371881562031, -0.729832536312492, 0.1059941902466696, 1.4093321372481074, -2.300341805884055, 0.8492174238598634, -0.27622994427524267, -1.6207108238080599, 0.7452620611626135, 0.7682701864811016, -1.4732893509358964, 2.6603391135686016, 0.913254849821649, 0.6380549304274976, 0.3347147644303959, 0.09754391286974803, -0.020944365736118704, 1.152414638198828, -0.6244975477609815, -1.2036604790033425, -1.046447370796195, -0.4859544308783606, -3.091683615139449, -1.0962537134305779, -0.8370818573507136, 0.46687226833718404, -0.3217991074646397, 2.1003357968846093, -1.2499666133923708, -0.15373919232377561, 0.8070341848065455, -0.4107371783250495, 0.715402499869131, -0.13905199422984724, -0.19983055400829033, -0.19533376656530363, 0.5302276347976183, -0.5811036270946728, -0.6607827485148791, 1.505693601915315, -0.03370164391093177, -0.5716425549119004, -0.5201437545418949, -0.4947534763961166, 0.08865412533130494, -1.537289638710852, 2.8414219335265885, -0.32933100745773874, -0.7651602503283755, 0.49664458530371863, 0.1596943998382433, 0.8833789482850074, 1.437603631708743, 0.35715560464050455},
    {0.23815327391058305, -0.4511210859852659, 0.16779479039356696, 0.5839712591595305, -0.8853639712365139, 0.7679094231549319, -0.2310082300463715, -1.4781843534690722, -0.2723414811286262, -0.4481080790031083, 0.09678058039104151, -0.3305280006993253, 1.7212774043128067, 0.9763157952782457, -0.6320150556326604, -0.5103979908825879, -0.31156095274944484, -0.723481697490028, -0.8396275767501147, 0.44622192203855376, 1.4256791659490433, 1.3506964424769432, 1.1927964687935122, -1.6993414029497056, 1.077731656599579, -0.8313132095043896, 0.42494516881026173, 2.4369337577523753, 0.505475448829429, -0.46385651021640967, -0.6640669305719131, -0.4699158873645582, -1.854739958976404, -0.5987103571548933, 1.9676079459340814, -0.22713868451530586, 0.5657605061747036, -0.05258221877957628, 0.06666409361556905, 0.8604269584956966, -0.006649559453190533, 0.11177149369223065, 2.3974817661430223, 0.28591393685018857, -0.3914180900256447, -0.09282266837443882, -0.03276440284329714, -1.7169139611541284, -1.440833696016501, 0.6923989707385346, 0.8786423189074332, -1.4557938600560425, 0.20558239885249957, 0.07372754995495066, 0.8267070154069808, -0.4948526895965582, 0.12961304478890012, -1.1008161915868444, -2.4831037658106623, 1.4216977222976674, 2.9410133761876764, -1.6283375467963765, -1.0675034262033471, 0.9982233085930912},
    {1.8327996048672777, 0.5045492458359729, 1.669851076585998, -0.9051307163634875, -0.48681531224655017, 1.4885444110039754, 1.385406570830497, -0.0557467873617821, 0.7311819727028067, -1.7573020084060447, -1.555292321248492, 0.8031986057751064, 1.1710223999382103, -0.4365470937785925, 0.6131068961087797, 0.9886365139646438, 0.08322158820985857, 0.6181708708654847, -1.1358254543780373, -0.1063037418326609, 0.10403145103614721, -1.9789527420064783, 0.4762775282935223, -1.137015153069125, 0.07207527326439148, 0.09551523535728407, -2.0229357772540855, 0.1068530505529264, -0.5837817645654175, 0.17292745798520828, 0.4481589134808147, 0.7969109467737985, 0.33312496731947977, -0.9207639203230762, 2.4366723331719427, -0.01003811350335868, 2.1512924043182107, -1.4182293074172805, -1.3981455605585456, 0.6547496891362827, 0.44613219511021324, -1.5144402060438282, -0.9411703154848016, -2.771996945701354, 0.20045620404453815, 2.002439228744967, -0.2869193505468905, -0.25761139655672555, 0.7003537939043687, 1.0301820577298622, 1.1231030634164, 1.6745203298294864, 1.413609028357761, -0.5876165953767116, 1.454126538099161, -0.36133322846762495, -0.3261229375275958, -0.1422675356561504, 0.9077646895107373, 0.46235476534173214, -0.3970221927995413, 0.3096294321056607, 0.07068009533836979, 1.5958864592338207},
    {-1.5392866320526615, 1.940066746184865, -0.6924322087398613, -0.11829934587704302, 1.4555429293676327, 0.9534937627940225, -0.9820008350778725, 2.714209815736894, -1.0011063985709505, -0.34860381742640306, 2.350710201303578, -0.6084062595417552, -0.8309375303320029, 2.327992016254517, 0.8906350392257129, 1.5614592464546875, -0.08867025616418457, -1.5225473020356888, -0.27563201662596765, -0.6239155549714921, 0.24507366513026985, -1.045526889663433, -0.08006650253777386, 0.7448108471070606, 0.19589705733213453, 0.3602856627120048, 0.8078669622101665, 1.9092256719614666, 1.3292607246132038, -0.515669730816665, -0.6563028098486094, 2.6462869226518073, 0.5850184450056761, -0.7329993546348775, 1.4566618004289782, -1.8914411458648372, 0.0778681682909487, 0.1517709708532427, 0.7407779354902715, -0.1265844497531195, 0.36558488546410045, -1.39463365489291, 2.302835108256131, 0.9408238394416482, -0.7853192929542889, -0.32726052983604254, -0.6815574111199605, -1.381907650140125, 1.3359530521967584, 0.9002175399086061, -0.4260407660801212, -0.37793883002688994, 0.8274120204978008, -0.6141775512883875, -0.19558378676241733, 0.896879616306433, -2.438353619026362, -0.5045083679796439, 0.2326398058948671, -0.3325759779133363, 0.911440367179845, -0.9004978073104678, 0.3205925073084103, -0.9668439613537501},
    {-0.9315034858432647, -0.49604646644813416, -0.9269574665665248, 0.7194229456778042, 1.021402395609058, 0.2770916943134634, 2.0733204626619774, 0.33053992034047663, -1.23586673598449, -1.9251016275556034, -0.8155317450207258, -1.400134759628344, -0.5519931427741459, 0.3296871043807177, 0.32069986650870136, 0.554469134963305, 1.3948914904542078, -0.1792764642688049, 0.15418066344530332, -0.34280378505683373, 0.27671471123676344, 0.8776646858874496, -0.3852610713040894, 1.9942122230182366, -1.2728472377139586, 2.236031934506647, -1.0598427403464998, -0.005175051612608327, -0.3802860094526542, -0.7783694905009757, 0.3401651046906857, -1.0314685546039961, -0.9794448539058777, 0.3029322704341179, -0.1264346501733142, -0.30293801553784827, 0.35181976337363363, -0.2736430941549032, -1.123854410042541, 0.13203056359813567, -1.0259908543885412, -0.5770075318421946, 1.8053872664408113, -1.9464248395032575, 1.0005144533883439, -0.8451400187487729, -1.0800681288297584, -0.12630985951683416, 1.1275705070149438, 0.1932548671325328, -0.3292045901972504, 0.549136473266035, 1.2932377586271464, -0.8230975372774025, 0.35845133382420097, 0.41632919409205876, -0.10290435275259145, -0.7829582627856644, 0.08970166137110495, -1.5396731950212121, 2.786300825963754, 0.22606827476586194, -1.503946647389754, -0.13149643541427197},
    {-0.5728219023378052, -1.8147578763708134, -0.25072483188085365, -1.1135579089289427, 1.171895635696238, -0.3937001715241422, -0.7591661019426601, 2.0871524806978856, 1.1933770800834644, -1.4326568903738774, 0.6860039398256763, 1.9723765683475702, 1.8734312678857616, 1.3741999354483765, 0.6630332587, 0.27226794111231956, -1.009823499936675, 1.3107751297407104, -1.4544541609004198, 2.6464693679011138, -1.480887020746973, -0.7232694359105012, -1.0233893983722706, 0.8579260468993054, -0.07776316233376047, -0.9796550320044057, -0.04759005643649045, -1.3963203841315865, 0.3866522851923064, 0.3893419702578902, -1.0980350915645545, -0.012674263987813574, -2.5325001027174445, -0.33090212489946624, 1.0613807735022407, 1.7934527670654634, -0.6435517540114415, -1.0404248904907805, 0.7992972367157015, -1.56822472035931, 0.03969940659421008, 2.0222381406025525, -0.3278144634849132, -0.8181052539707028, -0.3843997410179148, -0.42992330215590674, 0.7213041244312418, 0.8695096516200082, 0.10139611250486709, 0.7423767469745053, 0.7522884084139848, 1.7019395578165466, 1.17804278154284, 1.8537804797544337, 0.3072212005350659, -0.2598864073252247, 1.574083019196972, -0.3409254482680354, 0.5864560432865404, 0.45525553137688674, -1.423175349397202, 0.3911848186016217, -0.48911818828724096, 0.574606936111977},
    {0.10458075723316017, -0.20033338483135227, 0.005170787564523933, 0.6564030579031802, -1.1649807093818147, -0.7704299533120451, -0.40184833303563133, 1.0378766878653156, 1.2051846133703337, -0.7708487115440084, -0.21610238906432155, 0.16460303228104803, -1.060434682686252, -0.9438211396535163, -1.949984265635246, -0.8043786657644217, 1.9747562782489478, 0.03420135570134298, 2.721178697473442, -0.10394115651204931, 0.19668584338863532, 1.8496559519898093, 0.33693720029429564, 1.6172375910685786, -2.390187096066809, -0.7654452428289958, 1.3423651421594847, 1.2810939063729487, -0.4684188578946137, 0.021652248390196773, 0.7415525143337734, 1.2120929988373532, -0.09089161552693857, -0.48677527313004265, 1.805707388800516, 0.3859651201832456, -1.5344006044297942, 0.6347487637626417, 0.042249543560847, -0.683606246332218, 0.18580364989850115, 0.2915227294362104, 0.9409711592525404, -0.5218519824486629, -1.981208452502722, 0.9581291855372229, 0.3017942344818875, 0.035326389746380395, -1.1998458088185813, -0.14711609674952525, 1.3842658284705838, -1.324719555721134, -0.6667940079517719, -0.4836718759305269, -0.7726510167362932, 1.1870872457352764, -0.5801541968013827, -0.22901615732408093, -0.21419718235893104, -1.0515441367884115, 1.6581082275106136, -1.665113169772774, -0.1392129001320904, -0.18855304596401978},
    {-0.8261702794605149, 0.24417742483995586, 1.96360289522886, 0.5264793973005053, -0.9704744007712883, 0.8827920851328845, -2.5913918089362773, -0.3385549897772993, -0.18519802776740416, 0.871756870006699, -1.086882967544507, 1.0895808753765297, 0.4421280358138233, 2.6405670668059615, 1.9540266318006165, -0.8029360585630095, -0.9911670107497138, -0.7065021381155138, -0.735136860591836, -1.2571910185928783, 1.2769282097438204, 2.3643491901187605, -0.11712370718786996, -1.7432613380424637, 1.1759152865699145, -1.503698590066142, 1.558289495111434, 0.3069309548548697, 0.5584371658997515, 0.44568491159763746, 0.4765606877611823, -0.2260066048442272, -0.9828872710165504, -1.1707847797688429, -0.8846156702716623, -0.906987169125151, -2.334837871820452, 0.4926616103114128, 1.2813366467031682, 1.2290982828097705, 0.8899756759536089, 0.6111564129711067, -2.5873938996575934, -0.05209256988705078, -1.404939678496066, -1.2831241275195355, 0.5174605392322161, 0.004381676670661876, -0.103426638561047, -0.7520044852146944, 0.9933014917834194, -0.2755897219745613, -0.8270337992347373, 1.338521619269905, -0.40137029951742076, -0.5113078536887711, 1.4538922947824933, -1.205375442852902, -0.5449367613081134, -0.4308714865665414, 0.9635292280053541, -0.007662897791705663, -1.1930801760562388, -0.21043247153788344},
    {-1.6067353872949808, 0.42541796936495635, 0.5336002541721558, 0.6754316717093726, 0.36239474088925694, -0.2905557340905878, -0.7013928044262903, 0.0011938816659918792, -0.9522725176926191, -0.5919810685763931, 0.4914392877847956, 1.4315057167564575, -1.1204092524799607, 1.9559004513617089, 0.21498312090910876, 1.0736154334379013, -0.5587851471703923, -0.9383985218917671, -0.044212164753509024, -0.8686116373078198, -1.3485860549523452, 0.8840033762976043, -1.3694457185855415, 0.4593371926995152, 0.8798575908075514, -0.3226773871486685, 2.048671290972113, -0.24900902089181542, 0.023921528362171443, 0.8248200572674529, -1.7998466344940904, 0.5390330485625711, 0.7326185116313694, -0.7634236164223233, 0.5056804837958051, -0.18636814346826866, -1.1121825953002071, -0.004009262804087036, 0.8572992936371612, -0.7574102392025618, -0.9066959475631301, 1.205251941054342, -0.09203951857500645, 2.1359066327943994, 0.06292380155022666, -0.14033874085967757, 1.0074225752572787, -0.5343858523966233, -0.12760827521434648, -0.17970893716091416, -0.8191234876931782, -2.6623786678452976, -0.3401509478397697, -0.37314304465178527, -1.6810636184540788, -1.6982373590403466, -0.06878358400589434, 0.004902659423678479, 1.442357972540893, 1.0053248700397845, 0.20522889382011025, -0.71308811217649, 1.1012469962903895, 1.1689058386296916},
    {1.3695132775426089, 1.60049173234379, 0.6482262965542631, -0.04043707181684597, 0.9571643620339424, -1.6454520698038533, 0.06113151554301967, -1.6357364643329613, -0.6299682865882312, 0.385679354158872, -0.9628143408130622, 0.6861294615872546, -0.7881890246366388, 0.37736661375999614, -1.738483615938974, 1.7135792898639262, 1.5061869308143219, -1.2866194359922956, 1.3949290308446067, 0.32103439096573, 0.12804164322968928, 1.564664957765025, 1.298411745036342, 0.6219140269383554, -0.8183935453769403, 1.0576710494105068, 0.7786074470824406, 1.5345156224082823, -2.0617201640213856, -1.1290413098691474, -0.8893021890903908, 1.0316528974968688, 0.8053126736789237, -1.0211732137303358, -0.42130056839789637, -0.16840571222086126, -0.6191381519482747, -1.1052204376068626, 0.6720770002434977, 0.31300631206006746, -0.8592429275390036, -0.5371253163604752, -0.5530578551026034, -1.3194646066336744, 0.4237510993325987, -0.7454283900834106, 0.6342420338114907, 0.8112985171571698, 0.06127308079085214, -0.8186796349678843, 0.975368521092035, 0.5686041191502208, -0.34912630811097234, 1.1680089097068338, 1.7117698792576013, -0.8636652997007392, -0.9606097970312143, 1.587948595892716, 1.0696190926798168, 1.1732394079720612, 0.7168746783426011, -2.37315596254063, -0.6471941617966608, -0.5314915431548539},
    {0.10009725418027864, -0.7062319321425451, 0.5498294583123114, -0.8845089774646758, 0.13203966950737892, 0.20780267020402696, 0.4641824291763604, -0.6545194894363955, 0.3140426917872944, 0.8119673756513689, -0.0922566151856436, -0.37850720503581264, -0.8476352934974535, -1.9956877083537468, -0.1033863274866073, 1.5488232459556326, 0.978958223890079, -0.4298175559669907, -1.5648330712796288, -0.1097564142748567, -0.16183895665199857, 0.10792432200129765, 1.0083389025082605, -1.224912444042824, 0.5775221091918992, -0.06761822589805286, 2.385212162902753, -1.415528250545242, -2.354816512219493, 0.27562551884083303, 0.4631036067720451, -1.2702937793784805, 0.4377672472768147, 0.7159791635895879, -1.330795536044742, 1.4522001863297689, -1.303943562777468, -0.5332994475746872, 0.6408931097880172, 1.0025992776924708, -0.573867708725156, 1.0453784651607978, -1.0941871828303806, 0.5834430407222464, -0.6664522214324458, 0.5724134564891596, 1.6932189923731313, 0.8987698705844139, 0.15796570097401502, -0.7024535480406431, 1.295691047752301, -1.889694395201462, -0.4938267765066448, 1.0736714050453893, -0.16670291959893818, 1.972986725918592, 0.7234781268274546, -2.1448038237709897, -0.2077644352045625, 0.07263033655255934, 0.6927680675704784, -0.32060545913844707, 0.5008632256080268, 0.9936179965927832},
    {-0.9297744899143576, -1.181334261347173, -1.5581595177216165, -0.21473709656588688, 2.1590597156515363, 0.539119108908305, 0.2718885984539634, 0.5056800210275741, -0.645545536125321, 2.3795401176273216, 1.7162585913933188, 1.9427355886682725, 0.0031761691239246105, 0.3457931157573922, -2.2106985118265348, 0.9787160831121028, 0.5555398970676617, -0.10772666165214217, -1.45804923828585, -1.0231251962049666, -0.5787445825762904, -0.31363137380391015, 1.2246388448789283, -1.2793029871927848, 0.17701238898740912, 0.4053610497008679, 1.9173385552563753, 1.0973834355472674, -0.15565375605662773, 0.32944434393780053, -1.0925052357635632, -0.5449471888542037, 0.9600208146205446, 1.246469003761696, -0.4380518204692328, -0.6747603074694506, -2.376495693649283, -1.0681134911721077, -0.5804849825775602, -0.9973337823114917, -0.5948995234882745, 1.4994509632206614, -0.11777623740279716, -1.0838360499722346, -0.6455124991868921, 0.3065906681880904, 0.909147945790442, 1.799915631541364, 0.34161729109581435, -0.17461563786376044, -0.3425066064561246, -0.05822358265530429, -0.38743782180909414, 0.7264811815058497, -1.9239564007089092, -0.9352766313257928, -0.6113261565464716, -0.20469682374067563, -0.07497119919172196, 1.2033366055043075, 1.6102484195499764, -0.4369671450497586, -0.3522991625964512, -0.5615688400621897},
    {-0.7768050717990749, 1.7800518332545687, -1.00187841118064, 1.4619042106116595, 0.07043277158769791, 0.8812529229805102, 0.9693486363238553, 1.4423894176680367, -0.29281507074906066, 1.7417807955278308, 0.07455770111809563, 0.3925493388914679, 1.9547026085411234, 0.8300348259403011, -0.4203255177921039, -0.8299104149224321, 0.01773842798535166, -0.00347216898473412, -1.5925882844015253, -1.0641947347247553, -0.7417719918896383, -0.04774872304374511, 0.6938461824422828, 0.17454185333688135, 1.4595120023220876, -0.9602449405047949, -0.6302844253451172, 1.4751635124269988, -0.1512003864703852, 0.47294178191782105, -2.8263704438658754, 1.9409861124517067, -0.9716183214746434, 0.0847023848555394, 0.24400522265694954, -0.2533925657845306, -0.21299422382322192, 0.3818042576021799, 0.9556514929034462, 0.4090177862514662, -0.7023914425358416, 1.1261756338176176, -0.05745530963537958, -0.9354717404945041, -1.4807386741303725, -1.3499963016836545, 1.1098410615903334, -0.12904655444086233, -2.0006301304490695, 0.34631377202965574, -0.3795027688429083, -0.05561139374829931, -1.3776215277564974, 2.0637512399266, -0.9887217242784974, -0.8051057231890344, 1.646412871432173, -0.14435731351549488, 2.15220843727382, -0.7390262785606523, 0.4126394262859116, -0.5520502452029866, 0.7835387196720567, 2.6360370970254023},
    {-0.9612212994534732, 1.2057569898871647, -0.5214489984512646, 0.6373038094796044, -0.3292700396515962, 1.4023557902310393, 2.3287217250967447, 2.4921378600619035, 1.5943077289056853, 0.4777508690152118, 0.36182869169767706, 0.47825499725243636, -0.5749679029745092, -0.4646785788073977, -0.10728793246583382, -0.4542150398132004, -1.108033579937335, 0.4477404158155413, -0.31528595519223274, -1.6579964926657107, 0.7937045763149204, -0.5396183027942801, -1.0028473331239187, 1.7027221669569172, -0.3389251147482099, 0.5000236193297832, 1.5061504406668746, -0.30117201352597045, 0.730128471990995, -0.3906377853816826, -0.23166796383582997, -0.08993749469516747, 1.3572935654927527, -1.1925469604188261, -1.8004729090664426, -1.6244176409305289, 0.8068546774489853, 0.09112660766974703, -1.566106323398145, 0.006188038291756828, 0.6918522891235909, -0.9244966945983951, -0.5154247395138531, 2.055276629596615, -2.1397422735155125, 1.197822547327862, 1.0482078440744327, 1.011484378798445, -0.9898058057045217, -0.6039434851426703, 0.4382776678929133, 1.398372061835589, 0.005903731607516494, 1.4731685792253086, -0.05367895341597515, -0.38594684482970876, -0.41516565314604087, -0.3681002970506991, 2.0193072835088173, 1.3716714284618925, 0.9818463681413216, -0.5929872512086488, 1.0683603367008863, 1.1165163431979914},
    {1.5232475639163363, 0.5634426721475948, -2.143591336436804, -0.557674222343251, 1.903496617954757, 0.40719871920068185, -0.6253334890246087, -0.34638721864906624, 0.9937628957192968, 1.7065407361092166, 0.7010976025402539, 1.4658124946196531, -1.3076163722744825, 0.6574816727870483, 0.648966589956846, 0.3603046071048304, -0.8118722275378928, -2.30418566299421, -0.45044751215214496, 1.6616766380342087, -0.679583293963302, -0.236313267542583, -1.6275290197575936, -0.8986436225212815, 1.6771037033731073, 0.9968039682451065, 1.713789296832799, 1.3340930930278352, -0.364316114529558, -0.19314557782062883, 0.12983633530297733, 0.16479996051194915, 0.44879842547635396, 0.057847528924368716, -0.6178149075706431, 1.2467554338904345, 0.26686042104872626, 0.6837911654649961, -0.2721006781079071, -0.03704496403887742, 0.23605836028479765, -0.4936527587427352, -1.3499470468675108, -0.8600132826522334, 1.191989680270694, -0.42989547937586864, -0.6931455204677444, 0.4023417229940665, -1.397995023756298, -1.1642076238941321, -0.6140121963621596, -1.138753254174572, -1.4722973367808003, 1.1017450235755983, -0.47473653841520214, -0.20330085591960084, 1.4876914323792623, 0.3512045033954554, 0.49398351135189567, -0.6211838954074805, -1.5945657261120585, 1.6774938439812308, 1.4394297540910266, -0.7486545699130525},
    {-0.727656685707694, 0.7524678644968426, 0.7850703276697388, -0.5746430318855359, -0.35230319640406055, 0.7053158777317444, -0.012936690581369346, -0.24658028564103004, -2.338939217732293, 0.5070691100776888, 0.3014407820941076, -1.5218394293898279, -0.17257987659360036, 0.41386653507168003, 0.12203871774567154, 0.4251571104867071, -0.2249022592649415, -0.6359202019643667, 0.7702215561972172, -2.445504893478112, -0.3636994536202624, 1.051279587219095, -2.4380188905045252, -0.8076464023300405, 0.07103441269522685, -0.7409455166139464, -0.15305021634503949, 1.4725338416250855, -0.3173822456760993, -0.22774012810841915, -0.34789003520758816, 0.7026697570690744, -1.8580438603917384, 0.4307379633890303, -0.3052869655249384, -1.7078610932873923, 1.699652550772862, -1.7696388285758564, -1.9420545794498174, 0.2922431686328348, 0.44440245820952123, -0.8253910232093636, -2.106841479922341, -0.4125783611806691, -2.9178487631795287, -0.1252102331568443, -1.3547879766865574, 1.1309653190480624, -0.14022385749633132, -1.1205821120780448, 1.2091486595674463, 0.10199072429492977, -2.45014953450848, 0.8056566510719948, 0.05902405070958755, -1.2425921898364127, 2.512896001233855, -0.5378568532446026, 0.1580684282793746, 1.3584811079663437, 1.4046727222911775, 0.818316450018856, 0.6249723296032126, 0.6704794044122135},
    {0.6602687940161186, -0.7714493025642978, 0.5757671583467129, 0.6155165294819442, 1.305640897293137, -2.3610172213687965, -0.9318776166233392, 1.3096764779800931, 2.0880285320882632, 1.1160793837332634, 0.8038127115282168, 0.6983783635883324, -0.8347715128022154, 0.20943552881028615, 2.1448158200180933, -0.4305160101415116, -2.5373986624670155, 0.4214927686386146, -0.2239497087499562, -1.0607737521923017, -1.100371753786968, -0.49940094742742963, -1.341095441258635, 1.3835041188067383, 1.282329763881371, 0.16458248765598293, 1.2227722982184215, -1.5007763519112998, -2.472878279226012, 1.1604285669675622, 0.20515552322912292, -0.5077026857656098, -2.216491918757456, -1.2311749859882894, -0.6365873485685253, 0.35636749378203286, 0.11977612250016682, 1.6365356074044952, -0.46796231274349054, 0.26259993431889633, 1.216703800843859, 1.543396925192581, -1.9454820843695668, 0.5704054775357376, -0.6475005279799094, 1.1523356238966889, 1.5444938521281282, 1.5084283696501786, 0.049797397061446154, -0.8515542172256365, 0.4855089933943949, -0.7739268499021754, 0.12251726244235689, 0.028201455061296336, -0.05139454972599852, 0.5987973736639538, -0.9306335483434792, -1.7090394959367947, 0.5897394141656112, 0.7477360789543576, 0.6344029381519293, 0.3005917184757965, -0.28253041735897316, 1.3597829640421064},
    {-0.048960293699120236, 0.22202740028310378, -1.114502162502895, 0.387643202610026, 0.0381885054287023, 1.4639820976028584, 1.7625738806105617, -0.8818054076673902, -0.32245189722376805, -0.09541288147547229, 1.2993401156834643, 0.2966057696667228, 0.11425261989858303, -1.1451917041831927, -0.8458572189984991, -0.5168469019811469, -1.2942422727477823, -0.5035756908255866, -1.3410521306958116, -0.18985791217640305, -1.0969405591437569, -1.22275169060589, -0.016384402118686078, 0.9949277743619944, -1.5223212064718379, 0.4228370018460528, 0.81714462827197, 1.59348752513623, -1.6781336609844293, 0.6703045918647236, -1.0391245155687463, -1.8046385283415325, -0.49936150085395903, 0.38274840134393584, -1.4085140553214415, 0.03270947351562525, 0.42361047228597626, -0.04699543342675212, -2.2965106957708947, -0.022229426145363024, -1.38516068413859, 1.8743298808183966, 0.4411781404298434, 1.1760512215489591, -0.9260043417318302, -0.2732347144956008, 2.0850083226471448, -1.14633886462651, -0.8037368865822004, 1.3893953313156429, -0.28379996536548174, -0.39110988183309603, -2.5673723893757536, 1.4204577159587521, -0.6455784898819485, 0.9517503297261615, -0.32946390469117903, -0.5847013526504361, 0.03388418092811155, -1.7934365099363816, 1.5591821576240066, 0.7883989218653389, 0.6604326172347306, -2.089082411682963},
    {-0.4144859414867026, -0.5527146906921672, 2.2772592424815055, 0.018631912495348155, 1.209835926765266, 2.1394304865963485, 1.252797334481945, -0.5597420391700367, -0.7625650213357492, -0.11358930259840418, 0.9720526778404915, 0.4755970523896616, -0.8362531486560582, -0.896022522358108, 0.9980372162302267, 1.5646171968483642, 0.3400146182807142, -2.1753559864166285, -0.6140290169625592, -1.0928595221758095, 1.243040099570828, -0.9909431334294582, -2.4526833702081947, 0.17626590282458868, 0.03534486213013313, -0.3565036207676857, -0.18291610310260897, 0.24526217202952597, 2.819267912509281, 1.9407326736184969, 1.5255805527032043, 2.636544427566676, -1.797876014838251, 0.09575859737279792, 1.0402894532483213, -3.828991913584096, -0.2790841318883356, -1.3378054468952087, -1.4131207702803723, 3.2093993386626267, -0.9052118703600793, 1.7392454101413977, 0.11655778517739748, -1.5230446361068646, 0.345032034508283, -0.15436344902049445, 0.9827893880042916, 0.1711624227839432, 1.3937482867556101, 1.2821491672063683, -1.1273244852657351, -0.6772185206828232, -2.5663803912792065, -0.7223470465400275, 0.4826096996483253, -1.4724279071348163, 0.775819504769402, -0.9219751486281089, -0.3794816514033619, 0.5736173447082035, 2.878210016602995, -1.2029925017031908, -0.4987982126795511, -0.5535333233853004},
    {-1.2892104680143548, 1.879364654735003, -0.24585397202551967, -0.6131703548196222, 0.21274764502358298, -0.3126641323299202, -0.2580582417428292, 1.2155247251912604, 0.8913835941088938, -2.289189745399824, 0.40240245780788136, -1.3578669325896848, 0.5120834099973668, 0.5535543415013269, -1.4986391212018177, -1.849672666987332, 0.014982784812021484, -0.9568437273969114, -0.4499225336976786, 0.551006706289791, 0.4108211180059387, -2.1131344650991353, 0.1824535427703996, -0.9099893215846604, 0.25804771262317344, -1.2448336108556095, 0.45494601584423006, -0.7610564441185208, -0.4028208386981173, -0.864382714357234, 0.8683153105376193, 0.32521057635059253, -0.729055177581035, 0.3604967909644311, -0.6043062201374758, -1.1459852758163098, -1.1182981399522993, 0.9800986997469624, -0.5824299387666451, -0.759810398982141, -0.03735333989378755, -1.1372606367759535, -1.1853859966142006, 2.5923866567275686, -0.4804587566729699, -0.554377616590516, -1.5314091286634712, 0.49556554845149686, -1.031978557541957, -1.8298154052622835, -0.2772277843714691, 0.33414681597551615, 0.47773972650158675, -1.4828984006328285, -1.5191453615976604, 0.27372845072868485, 0.002007377427265931, 0.7328721931046006, 0.03365200121096568, -0.7253903689116168, 0.0964757133215969, -3.5463398729846, 0.6045770709774206, 0.9232645488586985},
    {0.16951449428892676, 0.7991169442214057, 1.2984539664626884, -0.36659471924546544, 1.0206678329248025, 1.0161379542431368, 0.1510837536050529, -1.627116128377027, 1.501530897205905, 1.3554514293646556, 0.5938709605222153, -0.8147532483904371, 1.1162136123984303, 1.3482386211954123, 0.35699442655350005, 1.8149280562739882, 1.0186421281983131, 0.989663399845626, -0.30188185611306617, 1.1539647622989015, 0.20645514035968568, -1.5527527835795423, 0.2865543747240594, -1.351561203544959, -0.9793179846605347, 0.7230215277148028, -1.3489230448551184, 2.3235214021122714, 0.20948527247536322, 0.4995167918968053, -1.2399611746331802, -0.7290466174745657, 0.9191595022335801, -0.10961859483001513, -0.881496012975139, -1.0769560501549942, 1.7898268004518008, -0.8632576634288155, -1.039648892572824, 0.7620152837911198, -0.07703755334621595, 2.217089687663334, -0.2430364620291731, -0.4469798071667573, -0.6877695499040182, -0.5206227879690581, -1.7894361546070081, 0.08380678024741191, 0.06228041590587006, -0.662163199654049, -0.023357776273668203, 0.8666121903715491, 1.5084140079644521, 0.6693317910978489, -0.52775174119795, -0.0976534655981596, 0.3202511063180121, 0.44097817137180423, 0.7921424274034033, 0.3018960568820405, 0.3320489005135317, 2.0307825096868726, -1.7123648479097637, 1.00699502596958},
    {0.32378993868390116, -0.027119818077223645, 0.7171706000349587, 0.4881177716740998, 1.651037527424498, -0.2631809319438052, 0.5415432451336624, 0.8890457846410837, -0.40270091866435126, -0.1974033868172975, 2.1816670667735, 0.04482705381194334, -1.6904310202697548, -0.15273573323905515, -1.5448010261106253, -0.999255599529713, 0.939263332614458, -2.323552688450586, -1.2515079624582734, -0.9479835796943097, -0.39764314727405736, -3.6437308452038137, 0.43740196172870655, -0.8355689504664543, -0.17788272977021716, -0.30528893407212887, -1.9844200657372815, -0.12086331513958382, -0.3071662179336354, -0.4789222371885372, -0.008876773285149355, -1.5949855330869376, -0.9309936596176555, -1.0152549055355917, -0.9444513651854914, -0.41609207157570005, -0.978927294581977, 0.0665399203844179, 1.0252202333112914, 2.29157127540716, 1.2180634585620278, 0.23668640169806923, -1.7322317679978783, -0.9039180067789976, -0.5929486648027047, -1.7852943459487047, -0.30585046159127044, -0.39447341456218815, 0.21905734665314228, -0.4241881457785803, 0.10048281821228496, 1.0239830764753506, 0.5890627378027921, 0.7461906954653933, -0.8929167865108877, -0.05359541881675108, -0.8243600923282226, 1.5941397396624388, 0.9132152211723085, -3.6322720923081806, 0.8366461457484163, 2.493308780530611, -0.09275686151598017, 0.03291775648602102},
    {0.932466882177779, 0.5761841718289018, -0.24626834202339026, -0.8600218205051566, 0.19290924674524193, -3.010827732315989, 1.812710948073993, 1.6332640712983373, 0.8870416625547655, -0.11962431345718438, 0.2781629267013632, 0.6002829837705297, -0.2940294773698322, -1.6559234896274668, 0.4280542640792166, -0.4973318103049391, -1.607721890174343, -1.1024616416382125, -2.3871496806273083, -2.6553731354068506, 0.15757574365594004, -2.206494674998056, -0.5698744746802952, 0.4962729671741242, -0.21508434650747654, 0.0957908821466128, 0.748237879494994, 2.0416313818992124, 0.3400731426544155, -0.2668657343562412, 1.2669534459689515, -0.8523965173717515, 1.040632636268663, 1.4471897833435519, 0.21051035453923864, -0.4462088958366289, 0.6073404574869905, -0.840693077686851, -0.32575504789443027, 0.596800804984834, 1.106924088379397, 0.11978184352044365, 1.448395383707825, 1.1546057132852765, -0.7520884298294698, 1.2035413839100408, -0.9004079582780679, -1.0586090387218394, -0.450721112560773, -0.5700002927782063, 0.3411238064392226, 0.1844568396053868, -0.2586966414968632, 1.0103494547477152, 0.4446113923326872, -0.09791778297629974, -0.010407711454589628, -0.01509228966526086, -0.9473336380083591, -0.462784565491904, 0.7723625331640622, 0.21525174146265302, -0.9459525895957378, 1.082515262353106},
    {0.19522014261115073, -1.1677643793323984, 0.21871521678049324, -0.03807937392072774, 0.3398298210546884, -0.14057720511896615, 0.5056555868384701, -0.24182204576114416, -0.7147628315067179, 0.8808853470857378, 0.2703663803517351, 0.0731220089776901, -0.17683611423513643, 1.0443360064637528, -1.8175011600847744, -2.136638090971575, -0.5840276474856236, -0.365312490492864, -0.5010089831421337, 2.5968438292526086, 0.5795536054250563, -1.264401038878111, -1.2753733232696234, -0.6568366557770335, 1.8782424942905993, 0.5679405545978575, -2.472812768308037, -1.198399361380788, 0.4281061588980088, -1.1753189771958614, 1.1906317907453048, 0.24418019400741192, -0.6859349570499731, -0.5955283147645948, -0.0632936327300122, -0.5595621458117165, 0.03045696523598548, -1.9252661301079466, -1.1444549854005954, 0.9892748990267428, -0.7128522618346891, 0.8846427052675707, 0.06549007542280227, -1.0701280448385013, -0.718839291625714, 0.6868839162717338, -0.9662042551714689, -1.594040280027912, -1.1446103672490593, -0.7377352823878237, -0.3816105995904071, -0.5395215928910603, 2.1902474420672062, 1.0492598377075522, -0.3764619210826343, 0.626829076086434, 1.3694213950205083, 0.05178775730047707, -0.210531602971717, -0.7907408497953617, 0.187327746675958, 1.4783786037426863, 0.2847947966911347, -0.4095106284751998},
    {-1.0258280320562465, -0.6892019484680094, 0.23242301161894685, 0.8409448242372417, 0.6975524893909776, 0.3913151623066754, -2.147019668750762, 0.8298665820542358, -1.2388571279674754, 0.6861220872024897, -0.5322720322735705, 0.5180193117783762, -0.5458912435159108, 0.37148085661688574, -0.8431480308056225, -0.09375968359325121, -2.0598946670937175, -1.2063008206119221, 0.06507840331597017, 0.23135496787108287, -3.2894942578196473, 1.5480548545778388, -1.5219415497649031, -0.3596531712133627, -0.9041718089627863, -2.0300600883423927, -1.0263245439577002, 0.18037095542266315, 1.2294520544847716, -0.8800750882467577, -0.032075747894419276, 2.8916046670522473, 0.871493530258051, 0.6658061294835961, -1.2035656151095708, 1.3602092784434319, 0.48376905229300937, -0.6596527792896051, 0.4744248419057746, -0.2824529368625873, -2.3396512284454998, 1.2262852829002935, 0.48505386073583195, 2.022021804408226, 0.5065633662207075, 1.106668074450938, -0.4329313349410717, -1.356727746294712, -0.7875332260386616, -0.09498592245737528, -0.8418512064813795, 0.1361487138943279, -0.5290259207993087, 0.8598692006896658, 0.7986317148322212, -0.29452278785969327, -2.0956536164691375, -0.24574971180346042, -0.041398535444035704, 0.10554581784199124, 0.7547184339547834, -0.12943861152619332, 0.7490105003637464, 0.5527290571000142},
    {-0.682889670323638, 0.7129316892539505, 0.12043872640521196, 0.872602875486358, -1.4443291932409108, 1.8960438307459675, -0.5377609217508132, -1.4389038175422182, 0.8548579248142726, 1.1889845797733039, -0.32336197896342556, -0.3479433471733616, 1.6921973444294969, -1.6051136848035956, -1.1145588394072816, 0.9809953776216517, 3.0718411442300972, -0.5085686019185605, 0.1447694920075957, -1.4895122028196126, 0.9044535005594563, -1.6846526947465765, 0.5997197691118981, -1.4996363186665012, -1.5880569030732385, 1.5314822463790925, 0.1071413971102068, 1.0334444979451487, 0.2451654745300723, 0.42936774234826475, 0.7284483879017051, -0.1957501934895452, 0.33383010283409414, 0.7692436847029854, 2.2237263593340915, -1.2445103496419656, -2.201547533249936, 2.333561867348161, 0.5648817849342791, 0.21999592219949982, -0.7405352928180212, 0.9807768285132296, 0.4386719613081873, -0.916347062215632, 1.419793596341173, -0.5818420566358092, 0.39389327595894635, 0.7498913837866499, 0.17534993991894213, -1.4849549849154906, -0.6054577475918397, -0.44827644733672667, 0.08453335118350061, 0.43065073527134207, -1.969650613996332, -1.3771636081722773, 1.2344339509404296, 1.3970593851083717, 0.6501514133966262, 1.0807477863183328, 0.7043041491160511, -1.1217719980383052, 0.7980413085559547, 2.0623080428967286},
    {-0.9470465969379965, 1.3626848914059366, 2.1627631007308525, 1.5521384003567738, 0.36684070648255657, 0.17109372256055577, -0.9484069772589991, -2.2734625737344745, 0.17421181723757317, 2.7544709722128413, 1.1320779836360457, -0.19331176669579078, 0.6082033256318471, -1.8847155581814976, 0.2563398374920043, 0.5588681892184482, 1.2789866773951895, -0.059408425532974894, -0.857088040759074, -0.3136053292594134, -1.6427737085102194, 0.10799900209939048, -0.3319611639290278, -0.37181549680157133, 1.0157328942141288, 0.41265306176899225, 1.418901805307653, -1.1008981115372687, -0.8752796488321118, 0.7859688190516964, 0.24765900254030318, 0.4889238739871937, 1.2668425522827056, -1.6069798620201423, -2.5110399741358562, -0.3508819147018787, -1.426003323250313, -1.8171477643821738, -0.11111246249018529, -0.6947304526905267, -0.47852779425865566, -0.7652393136248932, -0.5110331390953102, 1.5313291668344644, -0.8688718208364328, -1.6026680873510348, -0.432212466854287, 0.9418643934908569, -0.5701739434105806, 0.4739684899775097, -2.0647767990767862, 2.4141214930459665, -1.390862490538512, -0.8288068316216515, 1.032250194955279, -0.8524766174931554, -2.017250498930047, 0.8345862893861027, 0.4354402602214363, -0.8780839541010342, 0.40197379429912045, 1.4650392445630551, 0.8189949682762462, 0.5408667853594901},
    {0.3789636560940084, 0.22584122718847527, 0.17386903028255102, 0.41972892381937993, 0.8027752827105676, -0.35575935110630774, -0.8142956108217504, 0.44207551741095585, 1.858929274510591, -0.26345309800485905, 0.06797720998834016, 0.938275067885295, -0.4126926681992037, -0.8406750612916514, 0.7441678391539589, -1.1899072142055493, 1.495221143395141, 2.7388532476813303, -0.04406115784658665, 2.3181695641819515, -0.5241923146126798, 0.23136999170485434, -0.71720240877648, 1.5441688520285246, 1.5989215519732212, 0.22368271058356767, -1.585567264826024, -0.09357938428906803, 0.9972960107895955, 2.2152205978532495, 0.2033489751537874, -1.860144914184088, 1.4832781734303857, -0.9912745642409823, 0.17272838564285176, 0.8035771928072842, 0.5747089195410081, -0.45326184321899055, -0.7242240588660952, 1.0006984924849855, 1.502883882028679, 2.092497440632554, -0.20126964979992892, -0.938869618044516, 0.6264001119462044, -0.8012588100931677, -0.17191132056854166, 1.1193386775906127, 0.630094586191376, 0.19910922387257282, 0.3521136971197661, -0.40962105396688503, -0.8572607029470283, -0.43624017034954077, 0.636374335502982, 0.5388052421504358, -0.5470293137154817, -0.5266564574249561, -0.06114244088055399, -0.7542743434010977, 0.34450966684851353, 1.655623448881719, 2.1476562636704886, -0.3688222447036463},
    {-2.5448858836349624, 0.3314579562195042, 1.707686860012092, 0.5519811632824371, 1.024548417271295, -0.525579206899518, 1.6567843736478625, -0.3157362390802043, 0.036388239020013695, 2.1342625701969005, -0.8170765494959159, -0.9378101106113947, 0.5424290853064748, 0.8167663140179342, -0.009752019358907349, 0.5489583176137233, -0.8684332375400158, 0.049025039297624244, -0.8604176999323085, 0.42817298133232534, 1.3072420362129715, 0.16785532749151974, -0.6856816440245104, -0.5220526320898969, 1.876191766334602, 0.5934497352234425, -1.3705650478075568, -0.8875939442024616, 1.2476590327428934, -0.8754232846471826, 1.3037324512906523, -2.4644020487484095, -0.25757479586228066, -0.13047402210525802, 0.9540446952130536, 0.24799058654992318, 0.20221423405632225, 0.6539350631468123, 0.5873843300826146, 1.0991528728099786, -1.6145917887928063, 0.9111523727602263, 0.16901920794591593, -1.2704389643312166, -0.6993960450648493, 1.8037089465441711, -0.3856785637032852, 1.190268522182907, -1.0116468669690237, -0.007210861889605121, 2.5042809360963703, 0.24428587656310688, -1.1701448898308218, -0.009671435944441753, -0.16899017335288494, -1.181518758465531, -0.5198722181037353, 0.7534177855789451, -1.0754580500207402, 0.5343783266276491, 0.6871053656320031, -1.627862976719702, -0.46454929788771354, 0.7359247191259284},
    {-1.052308867836181, -0.28723394091867077, -0.35108719400080685, -1.4310978406424164, 0.1717670767687503, -1.8570765972689198, -0.4206481729473945, 0.14333841394471863, -1.2012019041034763, 0.7214111816304339, 1.0715973801424918, -0.1381706952261486, 0.6991510692305809, 2.058181820963415, -0.03994644237363705, -0.3001197953214918, -0.2720448621660425, 1.9835455582187234, 0.49167183079004695, 1.4948028155075879, -1.6362290243870519, -0.03713728789517238, -2.2574533571482034, -1.1656920549930265, 0.15171132010668417, 0.0933862067046914, 0.3397711519198783, 1.7296241278225026, -1.170725745457076, 1.1290792825693985, -0.22530250180976752, 1.0461187820091866, -0.5643298369029063, -0.5803631034311955, 0.967642368977355, -0.540100706935052, -0.3381544694421053, -0.25130957526524295, 0.22066529207731417, 0.5640519779752654, -0.05101585148916503, 0.5436558076730554, 1.56899592041305, -1.8063058742467941, 2.229003688395976, -0.594014135183025, 0.3170313075275313, -0.8603197625965952, 1.2862598331977, -1.7109043345179233, 0.004121010385760677, 0.24952309843609646, 0.8245774905204224, -1.0345148779192042, -0.6185539693711505, 1.1013403283855794, -0.5819153695108233, 0.9655867620010148, -1.4368712776461385, -0.9850835162678874, 1.6407570063701018, 0.09501390485605961, -0.004421145193535634, -0.2532043083119814},
    {-0.4620855671939594, 1.9263495744895296, 0.8914352701579211, -0.11633948635636396, -1.7626814776249777, -0.12655379455915247, -0.7108248300014465, 0.5363039005272848, -0.6726345683439945, -1.574858639279888, -3.909801658486476, -0.44872742847343783, -0.7537188946106972, -0.16212643183854958, -0.27170280275676195, -0.10374277899992337, -0.8575608098579007, -0.8595499329380831, 0.17730446153954513, -0.36492997271647903, 0.23709672756822958, 0.7416911952454097, -1.586450641490869, -0.9561471720173198, -0.620268783233803, -1.8240201730624845, -1.652136115423199, 0.15118385163061135, 0.20378609922643467, -0.8923242799293595, -0.6974043857141189, 0.4456723204795311, 0.6866951139201704, -1.014229491518298, -0.9235366756289666, -0.3719137740805251, -0.042657181474238026, -1.7421745023217925, -1.7668134976258691, 0.04421598248027951, -0.6271572891844838, 1.6640053676287516, 2.494979564918383, -0.733455940726932, 0.7849721276547641, 1.264307501946556, 0.4508794731832758, -1.1550998642740853, -0.15737263206101307, -0.2856273426984433, -0.6891432698636875, 1.0196218492249656, 1.3159787479461702, -2.4039630088525064, 0.6425868412155548, 0.2756398731800154, -0.3854553269154353, -1.1013258420803274, 0.5075367010443126, -1.0756535715750661, -1.7685894546811043, -0.029060467436336144, 1.555754881997577, 0.3159602929121168},
    {-0.3379675961551384, -0.1409562174475467, -0.3261442471445321, 1.4590744415346903, 2.543922073701193, -0.6258668905523388, 0.07457803848891383, -0.22289083771845702, 0.4460499699777781, -0.18735127407001856, -0.7630995090515702, 0.7406343166887982, 0.5343177459128728, -0.6102678757182102, 1.8034437419579012, 1.012351584220429, -0.1457323273299113, 2.413178325827792, -1.6050969069089913, 0.84078905416868, -0.4627419603392768, 1.187648150591728, 0.7447157549853407, 1.5310055563927722, -0.236478559786861, -0.7313454884841899, 1.9949977222804638, 0.8740656613374327, 0.27323973624366193, -0.15697379830949001, -1.045532952277318, 0.5320400559103301, -1.3877392420887202, 3.338652881137209, 0.5060854760463369, 1.0081659588752045, 0.6945149813869633, -0.3137238626990736, 2.4479746103487128, -0.6402177382746206, 0.18952169502082863, -0.09665423555143518, 0.4738259610491735, 1.1686599036495344, -0.7099196727965271, 0.5217510860394203, 0.13518416204843428, 0.5835864473044113, 0.2514344289332914, -0.24017436178632784, 2.2252677131020517, -1.0308418992846633, 0.16799401743807155, -2.4425308965929426, -1.4965118942170972, -1.1218654073357877, 0.6787644406729672, 0.7157955976354093, 0.778524495291054, 0.43535097401654604, 1.8191600692698668, 0.16508356900117177, 0.016563736593734207, -0.5410233635704012},
    {1.0323852333408354, -0.5280847482714222, 0.3683832151964195, -0.3183767214051836, -1.1561704634379282, -0.32917031808359676, 1.0782907484988575, 0.23800566974593731, 0.1255664290347964, 0.08195223110141128, 0.1502671715162591, 0.8209094215584827, 0.032790372476997315, -0.16818441598729067, 0.3410009372907992, -1.2677721727097173, -0.44863980479493537, 0.6253881471195814, -0.0844208058480733, 1.847237505807484, 0.5005271782352569, 0.29324671590888357, 2.026645457530378, -1.7630473394434814, 0.7652651975187911, -1.1525744913377258, 1.126915621672911, -1.6707963659458374, 2.5117173317784296, -0.05421240119395553, -2.1946575523176683, -0.4581420899774238, -0.5700911342706899, 0.5996763806222101, 0.047407800406773615, 2.1734871337090462, -0.255008343624085, -1.1932893608711577, 0.4171271391506067, -1.435125277540906, -0.3239141783699535, -1.074501598940316, 0.5328039948135641, 0.22071927547198048, 0.8736392749994811, -1.0224250107631028, -2.1457336287337605, 1.005592156406742, 0.6924500860752074, -1.1640064119238507, -2.283350668043961, -0.31260023370886714, 0.8571335041953665, -0.3586561683089921, -1.109426237190892, 0.22428199255179238, -0.4717905986507287, 0.6787634686191458, 0.6900402473849289, 1.0310207239079394, 1.0035890737188218, -0.7828720100618705, 0.12416917299333703, 0.27214631884396473},
    {0.27094099974015873, 0.5938370128087532, -1.527172979467718, -0.19605356725157583, 0.2989394225073308, -0.9117327297535215, -0.6951054754486002, -1.6170339320483251, -0.5101247568986562, 0.4252998430089607, 1.3872124172680382, -1.5247494448689949, -1.0625390961615848, -0.6585569954562822, -1.6006766374329353, 0.01499095102820024, -0.8912265161088996, 0.027319412399609583, 0.7188891544910574, 0.5433388268284586, 1.8296261853069087, 1.6772546573021603, -0.30808471202595417, -2.6770417070754076, 0.04978937147378924, -0.005576315576319807, 0.4871975490262418, 2.336553647861298, 1.2523982341958138, -1.6204970870697337, 0.22811206876365192, 0.1795097173968814, -0.9576696433887678, -1.824648548275223, -0.05813643881654616, 0.13910994859060524, 0.2091842527257517, -0.8955822013876712, -2.2092706691865516, -1.552452400616118, 1.27983267241353, -1.0389884833429424, 1.9156447230938929, -1.2737414316186828, -0.3620661531503338, -0.6781013882740475, -1.4904647449409165, -0.43959170383770374, 0.6423058778065672, -0.8392655326669507, -0.15574377971412914, -0.09653759664422316, 0.3872360987950069, 0.32493701099739003, 0.23364491498644466, -1.6479104019790238, -2.395987569869284, 0.34555288464838657, -0.4712167716477045, 0.4383461106005525, -1.3552067427903949, -0.29999809634416685, 0.6126031509788322, 0.20904307100190994},
    {-2.573268059024431, -0.9334168992326529, -0.23120395068441701, -1.9746520441200344, -0.14274088368645976, 1.228780185785283, 0.7880800755028589, 0.6065791835612103, -2.9160888201615958, -1.1663510745708352, -0.18726026305140403, -0.7693904885961746, 0.8038904737511293, 1.9480124926703914, 0.021257831198188103, 0.3781064511229943, -1.6706282569564388, 0.25045216960719874, 0.7250336670055736, -0.00297544289996153, 0.7108609891192567, -0.21038517207674343, 0.37432407791978023, 1.4805996740602885, -0.899586076087425, -0.00219511403700694, -0.02412764591618855, 0.2023999192007112, 1.00225713865821, 1.157331524788098, -1.289479737478695, -0.25663542046656046, -0.42934249096976823, 0.08652522893199498, 0.5219665155662987, -0.7411998025346799, -0.824499025697096, -0.5908840598035572, 2.4527085517043314, -1.6885904857275094, -0.9288829106930914, -0.7845984833437176, -0.837853262488876, 1.7090047901655216, 1.532818112972503, -1.0824040106995905, 2.1077888133258433, -0.6674314934229725, 0.5223648287777753, 1.7959273083555223, -0.8031625308138101, -2.439033379551661, 0.3661474394976248, 2.447202513616294, -2.8611764604966456, 0.8969791136705935, -1.147324993543251, -2.2319376377805167, -1.3863515053201356, 3.307624644494731, 1.081335303125211, 0.31998644144932215, -1.5291896311095166, 0.4073827452028916},
    {-1.1119456079612957, 0.5406340480358633, -1.2908146122309603, -2.859610059655237, 1.5345398199675897, 0.46025261388542066, -1.2030586837402262, -0.048684893895826614, -1.2462631676966167, -0.8945189968380137, 1.856657787099036, 0.42322663351964956, 2.42124462366116, -1.100964663655862, 1.3074046368532273, 1.018402955971535, 0.08328434570379863, 1.5690002408185526, -0.7858802973652959, 0.8251282274980735, 0.8168390606786077, -0.3248384672557527, 1.2920712510912242, 0.06294390823747102, 1.4985205565886754, 1.2972830672881295, -0.17594981112364752, 0.8097809770941001, -0.31398265654328916, 1.030823838289427, 1.5257651738436708, -1.2543730892685152, -0.38444583426019935, -1.8242580118958285, 1.4229743590811166, 0.37257294034880806, -1.1863089371408968, -0.7972838787661761, -0.4153728692216637, -1.5524690999534252, -1.792654639083645, -0.18108932260965152, 0.5114259026330622, 0.588597261916053, -0.9034177437303785, -1.1431115508030512, -0.6222899024899398, -1.4618089390979554, -0.20631700787835439, -1.245578688790451, 0.8844160242736819, -0.9513508640391336, 0.21350619493468484, -2.66013596742738, -0.29874550069597705, 1.6985765537196928, -0.5684026155261913, 0.6526539137730885, 0.9460585309631274, -0.21706529249790632, 1.2892889117304391, 0.20060548816612514, -0.7200533231386159, 0.09833233709462001},
    {0.6459087351072184, -0.8104357151219138, 0.13803797928380523, -0.6795441707119874, 0.057064107653905204, 0.6385357461638533, -0.2641848462862851, 0.8424696451277741, -0.9630529520950352, -1.5792192079444685, 0.288768956184386, 1.2233090765198988, -1.8219240456479069, -0.7941308747336708, -0.15248763251010672, 0.2364142506940228, 1.1679383639469645, 1.4657776240265445, 0.40891540102370727, -0.15811169541654663, -0.9404697988524804, -1.2269820586060611, 2.48027681311966, 0.42638242410595006, 0.9401244959411436, -0.48762244253061815, 0.146012595194362, -1.0443803850778992, 0.24942463909950954, 2.3074553943187346, 1.0567936673491072, 0.7282391496711529, 0.46275079602182717, -0.1944733663826729, 1.4235670842004597, 1.0567185133581705, 0.8029639686427862, -0.17723251570582674, -1.4648483898020945, 1.6128614415493299, 0.5308327214419284, 0.7606239132347234, -0.7324445989501872, -1.1010758732318766, 0.2090414246080755, 0.1970991339684088, -0.001184428141446181, 0.21095791944002365, 0.30963843932251717, 1.18969930779581, -0.36582581526718116, 0.4756559806944632, -0.9401585871773436, 1.8828067575634257, 3.0140652776662415, -0.6559271652127407, -1.6004706389065768, -1.2206981636997456, -0.8177633432123452, 0.02983775625433577, 1.5998149888080186, 0.4627798359635153, -0.9265897752952781, -0.11116021576333378},
    {-1.071559570292655, 0.10525591006430501, -0.2524991701476513, 0.45824676212511445, -0.1945713979471273, 1.7867331894922363, -0.556320303109591, -1.8698403288623568, 1.4786716839101388, -0.23177756236531866, 1.4350358829629513, 0.8467029229406133, -1.5374919454372697, 0.4396455568850531, 0.9270013159690548, -0.5341298556851961, 1.572990493375155, 0.10384251476230906, -0.5120085270174712, -0.6769771297022447, -0.18737923378421767, 0.2426043935797874, -1.5415487926542728, -0.5479062154004307, 1.8685094979581782, 0.7856226499129869, 1.0413802893225736, -0.17819791428711168, 1.172712837169769, -1.6082646698251186, -1.2864023422173902, 0.04047688938388284, 0.3433809469742403, -0.3853956887828426, 0.7078200877088968, 0.9595000131608052, 0.3516041457726937, 0.864828732325226, 1.4017952089403771, 1.3690697176239728, -0.8743102508990992, 1.0986457500409461, -0.36893640846795484, 0.5677007902481502, 0.13906027686203082, -0.2648005605293798, 1.1443103103766934, -1.3672631703962843, 0.5221160642541399, 0.18622663670834425, 0.6863929343141216, -1.5780339109505492, 0.36195552490209354, -0.40178403673622803, 0.08787955584123996, -1.895917015596592, -0.3103754190595609, 0.2179282037013616, -1.131352152549688, 1.081126035619696, -0.3026265033280069, -1.5742833727029124, 0.1538283580682084, -2.6877708870220323},
    {-0.30429863552139447, -0.3824322435812215, -0.7164799859981714, 1.0616455125621298, 0.505092712385279, -0.5056756620941492, -0.15630680161684138, 0.4326584631632503, -0.04334926326517578, 0.7297293948210564, 0.003288189202945928, -1.351678758329886, 0.21903814721669243, -0.9222029787813123, -1.4940316946175392, 2.102776096474311, 0.9643518826984464, 0.07164728164578121, 0.35294354793847965, -0.5826637013265287, -0.4447077104963925, -0.8337020995482869, -1.3267209121847887, 0.04270753173401092, -0.02709840423199118, 0.5213315278371858, -1.861293352872445, -0.6053616522140725, 1.5756530848012256, 0.9567100883029416, -0.05877193287024078, 0.8041617663724525, 0.24718131052185413, -1.7781397405858295, 0.4806638181631962, -2.405967480124568, -0.9048233304573471, -1.8643147658660653, 2.692786831947014, -1.1220588169965204, -1.0032176723599828, -0.4613943610658941, -1.736047630941747, 0.805850675159182, 2.6710365020675857, 1.6437875524210799, -0.6204129518582607, 0.02327735810102456, -0.32103753483749564, 0.549026161213267, 0.9115446045505479, 0.9074699282103188, 0.0968776860190063, -0.5430564014651631, -0.8778929835811745, -0.3859572933541376, -1.2313467266896674, -0.1744579303918028, -0.6577512356624985, 0.4346042635805761, -0.29865496736602404, 1.877586402385857, -0.7782504899037481, 2.562036475640089},
    {-0.25055438081420667, -0.8790201055125832, 0.15539073536300238, -3.3297292557383575, -0.5338556035068673, -0.4141341918475458, 0.1607967227826362, 0.0975802409963822, 0.6056908192864182, -2.213815519896949, -1.1648571237214354, -1.7354949136681248, 1.417648842897957, -1.6890884993898176, -0.703457971430437, 3.277262790069573, -0.9207950048976996, 0.8653460747315382, -2.5990692498969703, 0.1986921498594205, -0.06105691668600258, 0.501371913629603, 0.43112366977126804, 2.088617770333879, 0.7297124050268412, -0.27202326516144143, 0.0012615998808253044, 0.07316510271710276, -0.38085486346108666, 1.0277113152007344, -0.1339757324914136, 0.013306623277397678, -0.29560303432333435, 0.11797181785175047, -1.390590181569278, 0.522749723462696, -0.000746100780144973, 0.5781848780004295, 1.5654437449222127, -0.9417304193660612, -2.2655353653417647, -2.13197863539966, 1.4799061117413073, 1.0054529555225142, 0.261684510134959, -0.7929307175616317, -0.8416749224622567, 0.15821457417893964, -1.830542747477574, -0.15407501914534036, 1.3977809821119533, -2.0226592790076343, -1.065362711080687, -0.5385940519727358, 1.1111589096552072, -0.15636060739457655, -1.2532277539046355, -0.568413381295386, 0.4228572886044929, -2.0649756281824883, -1.630010563374297, -1.6194106412492264, 0.5499444975592828, -0.4561467126820526},
    {-0.5727004728338673, -0.051970740484365265, 1.0834358291248765, -2.2318956269596333, 0.10644428415440853, -1.9328244875294354, -1.2848258485160633, 1.188158732270133, -0.3771508109300617, -0.1701359833698052, -0.11668309563242873, -1.1163004409391872, -1.9730100007874074, -1.0206492733213248, 1.4770095985926646, -0.1828303083163607, 0.8426593221298169, 1.435975515854142, 1.3561355691963606, 0.4348676745134476, -0.4998091466307786, 0.5169671283655441, 1.3397646584493235, 0.8049516657236436, -0.5144562358589416, -0.60622927652774, -0.885203871729224, -0.046208473532159774, -0.37902954055660654, 1.1704489252960528, 1.3292343325522191, -0.08221241319658461, 0.7446374159437609, -0.9941373683349404, 1.3650741564325921, -0.20494118132186542, 0.5583290271368037, -1.669422602433891, 1.658636986953824, -1.3533033318993202, -0.9413939613562985, -0.9800806176233485, 0.20194469750121963, 0.44615165610021407, -2.370687200828081, 1.8476075435363544, -0.9122759609256715, -1.180354697345622, 2.1019980508599176, -0.899563613438326, 0.9151153499636537, 0.5856843978071067, 0.37707141566139074, -0.4687645258840271, -2.1293165748577985, 0.05531584551334837, -2.5874993016015813, 1.0189887976169292, 0.35866784064192603, -1.943309672829815, 1.380127054149957, 0.29325119371183567, -1.5085318405527162, -0.13024244459936538},
    {-1.2573630169604766, -0.8434104250073486, 0.6038261524326516, 0.615246515916249, -1.082107027341403, 1.0361702338038212, -1.6189428836824347, 2.0450288014941855, -0.8540762061705387, 1.2299243536569986, 0.061084451859201236, 0.46587062276221836, 0.9425622778710635, 0.4181436520251766, 0.36867829624279297, -0.45134478230539893, -1.3242533329685953, -0.6494225655452861, -1.280287330206278, -1.0959652524631849, -1.3807446456529584, 0.7933346073529195, -1.217050576618346, -1.484969711840207, 0.8819078791881674, -0.6019854312589211, 0.14722109873858918, -0.7954068207009751, 0.2000888676361892, 0.5852139111045273, 1.5095130945465327, 0.13716965345689558, 0.38683684588875894, -0.16222040635674836, -0.5652951686622901, -1.7346605908912924, -3.1090733048510546, -1.3829737044257122, -1.5519675274306346, 2.0271192366366044, 1.0408857519527965, -0.8255294891939112, -1.5921787971475234, 0.5428819255993368, -0.6855699239604436, 1.0481158749414465, 0.25098426819586855, 1.0131245876680544, 0.6171544351795536, 0.9439478840930015, -2.912811991682547, 1.719106999303663, 0.30643218671694616, -0.5931207639685566, 1.5846701063349053, 0.4186215339703952, -0.31491485123988633, 1.342726099561609, 1.3992395706133356, -0.3286407159132882, -0.3456486649898223, 0.14606448335981737, 0.435814326280993, 0.3540710087080147},
    {0.2186211293394138, -1.3716859320690034, 0.9045236826331408, 2.032366998927311, -0.5790787437640731, 1.597571785107774, 1.9800174153391923, -1.059505533446292, -1.4118428643000625, -0.05593959847895307, 0.6838093976257654, -0.3629972635517389, -0.8445499253794212, 0.16484095460659617, -0.7243298473923574, 0.2917112737551587, -0.7622221085579897, 0.294550716314245, 0.25841626681861307, 0.2864567390854101, 1.20131122993196, 0.054887433573208036, 0.10294199218970232, 0.8371444542206814, 0.743295936518701, -1.630618130135461, -1.5582228626783599, 0.8790274764892801, 0.5832099146435994, 0.9834472202388164, -0.26250046846147107, 0.9598147354505546, -0.6563100770635032, 1.4116998403876533, 1.3307033462499218, -1.0032890267954608, 0.8399910775072303, -0.13611899851678236, 0.02570679889992712, -0.1977394997980117, 1.6137617933398964, -0.6342925198582553, 1.3211884766901045, -2.1880531632681106, 2.115612638260417, -1.328235952908139, -1.0239095062688086, -0.3531133207016484, 0.6513596566801807, 0.959604873193795, -0.9308686742379646, -0.11700890946006537, -0.9665400238493019, 1.9052741712280115, -0.30968914379504453, -0.44972646192182636, -1.9899856531133078, -0.8765921395948285, 1.4468986595447708, -1.445935906844376, -0.07307913395038847, -0.3616026102012616, -0.6022682209058109, 0.9740661611132929},
    {0.9611579953579783, -0.25668606023198903, -2.107361380991263, 0.5576629291457551, -0.7248530961967199, 0.6682646185646739, -0.30276558420052374, 2.38327316708986, -0.33970432546231505, 1.2529112458177378, 0.36540867228834695, -0.7055660580749674, 1.304563659617726, 0.15963381908399127, -0.48392542534831146, -0.4041801651714082, -1.163597717108218, 1.5710601649209985, 0.1734002713889747, -1.1781330971066508, 1.732880549688378, -2.0735033790753734, -0.012564400832547742, 1.0231600210889806, -0.10173239086443261, -0.9660707538680571, 1.6426624205188232, 0.7895803925239572, 1.683195831304764, -0.5101718180033699, -0.43450498832795964, 1.6180860670842205, 0.5544504576828798, -1.7220094772299073, -0.2975708376051364, 1.6906888486983873, 1.8787834059142707, 1.1698771012660354, 0.2784082353630877, -0.37654725353203383, -0.19710920846327643, -0.6495745675971119, -0.9756545609879752, -0.4580484895269696, -0.10584118637426068, 2.1060908218393743, 1.0783461863333468, -1.6949055438452953, -0.24694834948635444, 0.5914787382861152, -0.2884003231929026, 0.6680687609105947, -0.2380780628622914, 1.2547997597386904, 0.469062813368199, -0.03397538649484085, -0.5971806802655036, 1.0841173672938926, -0.7629063265611712, -0.827105691149616, 1.8825521560581018, 0.8636906391081879, -0.5751294026989839, -0.046865519461853675},
    {0.11400437275450521, -0.019300926968204513, 1.1005127850239331, -0.19666534933341356, -0.12023063110280278, 0.13554855725224263, -0.23397905780336495, 1.9498219456839088, 0.1501742288433352, 1.082290360838891, 1.8614783224586038, 1.846724624304214, 0.6113781142085543, -0.778318950214995, -1.0998710109960428, -2.1956588180860264, 1.6608855605726598, -0.42872740275141236, -1.3732856788573586, -0.12345465800348596, -1.8868149744801008, 0.5102443857231374, -0.05946664626969723, 1.0452569873096538, -0.133479795582714, 0.11341935942212543, 1.982913969228284, -2.0526632984864155, 2.317021848415626, -3.151157099869835, 1.0125799384138652, 0.3548074057085332, -0.9146108169488786, -0.06452392523659603, -0.448086649162994, 2.0365130077307683, 1.1052269842057143, -1.14302210613271, 1.7490371993837688, 0.03152321384849524, -1.5370779581409864, 1.0248977233620604, 0.24224181846745987, 2.174836137303672, 1.9395908802749078, -1.0759018677400851, 0.0331328073087347, -0.5265683209824391, 0.6471710682276676, 1.9645031535072128, 2.9389641695429023, 0.6222685270019016, 0.13064843878958352, 0.503032949377857, 0.37266611688394313, -1.5314614352169011, -0.5383403590494588, 1.2100880578763904, 0.6512836567292313, 0.05227298962871272, 2.589799472727747, -0.5471726940793682, 0.4076915589439483, -0.1250374111517579},
    {-0.5994871126243586, 1.1962889429929653, 1.7275865090417064, -0.05766624167592194, 2.015058470904831, 0.767918666518125, -0.3722941557241151, 1.3972724097097027, 1.5650448999072537, 0.7492623082696164, -1.5300633196484243, -1.6595868030391367, 0.9190254186232938, 1.1461948957734125, 0.24503343028963612, 1.173117218345714, 0.13495165386871286, 0.8135805361833465, -0.5381815046645484, 0.05766425464385266, 0.037209564586503846, -0.21747057326351632, -1.126269220802908, 1.2865323253965528, -0.7147867076186752, -0.31747622245328716, -1.8240348962402584, -1.1789245543406803, 1.3332419324451212, 0.5773652525436244, -0.622832306615125, -0.5296459114138139, -0.6678671587683578, 1.0095709613975223, -0.8014507733457674, 0.15233405182489004, -1.8243536246566308, 0.16747046496043483, -0.5199919066252735, 0.7085502589234873, 0.7619166651419992, 0.39728713735449045, 0.22888468398227466, -1.0353882243877184, -0.9274495605771246, -0.2235535215688061, 0.02544081156756607, 0.5684083294712339, 0.15656729381594547, -0.062387118847499215, 0.8022542292117842, -2.348643774490268, -0.7767880712544621, -1.1433084873407782, -0.42593538341253817, -0.8638151533241212, -1.8105470873318863, -0.26399101977204764, -1.1288475375616207, 1.0295378829033217, -0.3264576162505229, 0.17310659566669503, -0.32306164835700313, -0.6840347787053562},
    {-0.922121881296756, -0.10273730187199155, -2.077558710789825, 0.46038893362850347, 1.2470920141004336, -2.4216399117404936, -0.4519435950214823, 0.7576758730672425, 0.201112585552342, 2.7133328450281464, 0.17880221157795972, -1.2279337262628853, 2.4235524660832426, 1.7644067325412331, -0.14878286623427614, -0.8711688830134743, -0.9533800675551822, -1.7051353138905738, 1.9841152877988177, 1.0489928712682608, 0.6366355539159541, 1.0150882799152423, -0.5381676854825218, -0.6205772439173823, 1.92044363805455, -1.265717486954699, -0.12594116748724343, -0.342773731986196, -0.09375739262409499, -0.8345719185121548, 0.28558907826842717, 1.8676824118522075, -0.9565642428833121, -1.2690266577863192, -0.5726699105635802, -0.2042326389089248, -0.14351551282621774, -2.2889060063701816, -2.003638387783087, 0.8273407567286877, -0.11834020376563892, -0.07409305562005485, 0.4232963850689338, 0.3537740450714736, 0.8966053237923859, 1.7951508510119747, 0.9054282050933262, -2.0253067426982123, -0.18808255452643202, 0.7928362164045233, -0.5820616285056651, 1.9282880451942204, 0.16744354435110045, 0.038312620698155206, 0.21511910780650703, -1.892272807068536, -0.8376577442333561, -1.7355076595232117, 1.2461419128384061, -1.6006526220921138, 0.41283209260648535, 1.5386126918481717, -0.17740004809647564, 0.20850143065720703},
    {0.11064748903011903, 1.5655500859751346, 0.5410999611381878, 0.4653515053208873, -2.504639921418165, -1.1006973977572472, 0.180522985023078, -1.7650891116256706, -0.09472679558119318, -0.8748812465139478, 0.3869130396758562, 0.659484999908235, -0.5617504758402152, -1.039781173085791, 1.9371962480386635, 3.13558627769819, 2.223437741072886, 0.6400100536387812, 1.4939694512721757, -1.2586178188346253, 1.5782684300728231, 1.1418123736681167, -0.8797830128952044, -1.3280904625964955, 0.4623486529621122, 1.1451552821591717, -1.1246263870804978, 0.6241095825913815, 0.8934982620540405, 0.4660361951990314, 0.040926203503655494, -0.5466745722344448, -0.07474533636740538, 2.287585088689151, 0.3296505943788594, 0.01984188236145622, -1.905870626100985, 0.024715532240300434, 0.6781264950947077, 0.41698872936084075, 0.21347203494360517, -0.28384972708580697, -0.8003216007857751, -1.4037804153336768, 0.4224713318035793, 1.2703978627984114, -1.2685306110379018, 0.25190909271628587, 0.8620348971222339, 1.1198000228557135, -0.9358976565903693, -0.31966978075804253, -0.5544423029579822, 0.23394729812004517, 0.0379888648944869, 0.013829343127448566, -1.2483465385546992, -0.16874166310230296, 0.8736235780455271, -0.5218935372251721, 0.36906873502216175, 1.1761226934310427, 1.6409588240321993, -0.6638744270237572},
    {0.16557361730488812, -0.8453468322472787, 0.2659867341084262, -1.6785036567962324, -2.119094861238022, 0.18387218380272832, -0.7511271860223605, 0.46549381674248136, -1.424680455641617, 1.5521957958536976, 0.4520026971502441, -0.5368057742455044, 0.4418423574660565, -0.6493475555717826, 1.376677475851557, 0.7757333604799512, 0.36770538296379823, 0.2530911973874608, 0.5285713700442158, -0.08714301242329417, -0.10268979419035945, 0.18316781741701976, -0.677811480716711, 0.40901941188331786, 1.065602691774951, -0.1038580331049744, 0.827944902730108, -1.351990807311626, 1.7643405027221186, -0.1165809373968926, -0.638405013269668, -0.2284880139851571, 0.4840373666259519, 0.30289180852245307, 1.9456991731294238, -0.7395693221161393, 1.4079710808097847, -0.38838045601698307, 0.8602343216628506, -0.006396282691594505, -2.384877995788231, -1.349944654193677, 0.24995501141125248, 0.5644103639941463, -1.6694828877518795, 1.2352387631788067, 1.1579812556352818, -0.1562352728632968, -0.06320099270252569, -0.4131544771164769, -0.22504916300377883, -0.9105281540125302, -0.27884738698279027, 0.26574688023078497, 2.5668036841606674, 0.13547587846660095, 1.2950906494394734, 0.5824305257703204, 1.0457385507250083, 0.1032405616052744, 0.14169584192367435, 0.932761204125553, 0.29796052716865873, 0.8190775528859042},
    {0.39751484819482014, -0.814810490622352, -1.0429643650545015, -1.334696347212643, 0.4191953224607833, 0.6748070341672381, 1.4563420094005364, 0.8655024112383117, 1.6728387021177507, 1.2280025363484375, 0.5277126677986624, 0.7049980612073428, -0.6206237713945634, 2.370890319077572, 1.904940600970632, -0.025150877427354584, 1.4736203939655603, 1.4175012612600146, -1.7515249180036638, -2.1866964063457583, 0.0006139700832877729, -0.5586435694248767, -0.9998715418496865, -0.45579813527010493, 1.0655735439816074, -2.3108496075318166, 1.3648621079318317, -1.463780943265416, -0.8848555028909366, 0.4185247105407658, -0.39834587901888796, 1.6466981692968194, 0.9605959093955733, 0.31339729198149413, 0.834900412177738, 0.2931563848961223, -0.24438509909193487, -2.0095373239121592, 0.04136014173777697, -0.9450403959667016, 1.03999587619179, -0.2982746917249665, 0.6430184816504796, 0.09563645041390124, 0.6780659363756326, 0.3553316078597461, 0.8453095252625227, 1.0443051310344968, 0.9397750130497653, 1.3229882703667242, 0.5208849206840597, 1.775293390222624, -0.9534349771070183, 0.03959813095984596, 1.1315832093396225, 0.8894520499735808, -0.44621088657066776, 0.5374894460520933, 1.5651022258965375, -1.243183115436666, 0.5492561259519709, -0.2232667674697578, -0.05751752368122103, 3.0859298872418726},
    {2.492742818010651, 0.0028383400884440233, 0.3923819070650928, 0.1364243081820669, -0.23347667529294172, -0.7786397024436371, -0.12880882231105234, -0.7848349740984701, 0.4235093556703219, 0.024839022580075386, 0.3505122797720744, -0.11358139813598882, 0.3323488873584846, 0.780534019480086, -1.3729468213449345, -1.4263192765724184, -0.4519056292827538, -1.471216946941717, 0.9204135477016585, -0.22973178608021347, 1.0242221996710084, -0.3229792700384154, -2.3520662124970566, 2.323168209458442, -0.7681829837343862, -0.45459075393701587, 1.1798114107213618, 0.2196409469584889, 0.9372553854256419, -0.07164384330287034, 0.6747279624780068, -0.05649890821133036, 2.261495278060042, -0.04467990189879606, -0.15683052854091445, 0.18335613844376994, -1.1611562718680066, -1.5539969022854334, 1.2635041777223242, 0.12175916126450612, -0.8663400347798492, 0.6414501943545711, 2.5334772836017647, 1.036473649497582, -0.14468606567843237, 0.3042432235119429, -2.020569313465132, -0.4084955058959286, 0.47641238504626754, -0.5834306598174194, -0.31534570517768007, 0.13924394675720098, 2.5509474463057065, -1.5413624834607507, -0.01627624318500401, -0.25855643953176394, 0.8446167470569739, 0.014102942998144088, -0.667115949204545, 0.4640494384577463, -0.18739692604147565, -1.9765281079012686, -0.13119353864662897, -0.9231562224298769},
    {-0.5037691379891353, -0.13582734604895716, 0.23629177983190805, 0.13680304418956427, -1.1919248335457486, -2.23156159006939, -0.18325525695306855, -0.4679347496064991, -1.2614207228321586, 0.3455090389864907, 0.33705217098883067, -0.915800581019888, -0.8666736463996993, -0.4280528617926927, -1.7456336672939405, -0.8923973399207319, -1.1602785163523788, -0.0918012995143629, 0.46831907726850425, 0.08844488013688435, 1.7147871533341428, -1.4534350311440982, 0.03441534283287681, 1.1374709103023068, 0.7113112656119011, -0.9240223454691738, 0.4299998988727077, 0.8900709484776027, 0.41276217774761664, 0.819176997189513, 0.04360117670100646, 1.2557850948897245, 1.0632251197784632, 1.5549123070690247, -0.790849467809519, 1.0974624010892362, -0.6669591925156688, 1.7429782600172907, 0.34200668153331476, -1.0038775258247252, -1.087430808364056, 2.4602490077249963, -0.5628172984151381, 0.6192442535360093, -1.3988929154794403, -0.9456108920374485, 0.45994849584783587, 0.23800478523812693, -2.8501552084210626, 0.8312835998004429, 2.3881654331783055, 0.4104359144158626, -0.5000555561336667, 1.2388981535638028, -0.8401146834748651, -1.941989636918207, -0.9822672099640238, 0.6104078865817765, -0.4115578553759341, -0.4192909438037717, -0.6543288418516471, 0.913785158862882, -0.6878580797157604, 0.6543769905795414},
    {1.0130114602301072, 1.014628027716895, 0.9614909809643165, -0.12888212622713993, -0.15242188054769, -1.1642535888321024, 0.026898717972428664, 1.6631129834054297, 1.2160929124010547, 0.4913077359241329, -0.2629070824946414, 2.143783072686952, -0.6800290438639158, 1.3035634023676705, 1.0021119821715556, -0.8946212807000923, -1.9650123552672487, 0.14384706848691137, -0.9272160851985762, 0.25515907576741276, -0.16959769448913878, -0.49103707346369824, 0.5232920811174687, -0.03797183748458544, 0.28585904429438064, -1.594667552609415, 1.4602798453956207, -0.20660310163395335, -0.5488721634893075, 0.8057087195349567, -1.133993925039923, 1.2631809306215531, 1.0857640358259792, 0.66945626895224, 0.08835676447620434, -0.7455702445676194, -0.5936702695498068, 1.8836197751794828, -0.5819925239033383, 1.044076087000554, 1.977846839702747, 0.6616551395354778, 1.8931611843190836, -0.11534926180376967, -0.6894618861517126, 0.14401733448783677, -0.09900402518952675, 1.141795777250173, 0.5125856501346248, 1.4397864514143637, -1.4574865510503487, 0.15505851725137154, -1.3194550381298695, 0.7371764835404554, -0.5237778819636426, 0.8793909314135503, 0.05022862517748763, -0.2338999067968511, -1.1738615663275453, -0.3769028538361046, 0.32088247116427265, -1.3135249092587347, 1.8490849132715919, -2.5487204393831244},
    {0.7004070088015418, -1.0378805615554554, 0.16070291005793066, -0.4590823031435222, -1.15035672797802, -0.6700135582606114, 0.20496471589178028, -0.9765578034897755, 1.380463836659922, -0.2764210178346496, 1.0347113901957818, -0.18230927209648784, 0.37723442049551814, 0.31871236941519987, -1.1163152849647457, -0.35353234992955224, -0.07756689435034396, -1.0043492466546833, 0.45840098570958454, 1.06364732579194, 0.9237733565841773, -1.937346788763297, 1.5851421859140726, -0.8039360739944518, -0.13632408288779432, 1.1797052973113904, -0.6337772938304765, 0.055151379379974184, -0.40548129938757166, -0.4323781784930719, 1.1209730934591728, 0.18461331453932386, -2.198757912803065, -0.5641723487062061, 1.38700497446295, 0.1585401643386943, -1.976724013837415, 0.39924162225202314, -1.4643556136379356, 0.20046985688843458, 1.3658688041072058, -0.5891006055911491, 1.082669024477426, -0.4084234349242414, -0.6394529691007641, 1.064891952473365, -1.9354824373648534, 0.99886192147791, -0.013083623459541845, 1.37336170717998, -1.836421336332507, 0.08781737316057632, -0.18999527684736334, -0.19075811216200103, 0.32625523107277477, 0.8495839204136233, 1.321566040323319, -1.5345294365427562, 1.1852165417050236, 3.281869391981988, -0.9798234852731333, 0.7826366831338175, 0.16251441271801503, 1.3148012352712002},
    {0.9096067526644307, 0.9424993154400768, -0.9142445613374426, 0.8644287959548309, 0.6489268035047869, 0.4290816306996022, 1.1111130100617286, 0.6128693686905409, -2.688704123884278, -1.0434153445635939, -2.332815821343703, 1.985841385031642, -0.6556197268081946, 0.27224899343895587, -1.468071764056914, 0.04440256482106427, 0.7386617015963894, 1.088558423026294, 1.8310325439066515, 0.008563690371572695, 0.6297851521127568, 0.9892959125230733, -0.28879716291158763, -0.03407033732869856, -1.6139779782381316, -0.9218069697883133, 1.0831971340775342, -2.153641398865579, -1.1466929369838923, -0.4888029617430421, -0.4261777698886366, -0.17115618287613096, 0.3133996955902607, 0.46676905261585117, 1.0173903379679987, 0.4853079089827948, -0.7842730740858797, -0.41228498809790887, 0.25629205406781247, -0.7106186503283162, -1.8287400298093457, -2.224277341535107, 2.3919234400556717, -0.39017982915651617, -1.0239685963208451, 1.074449347049964, 1.5076063872830339, -1.2817242488483667, -2.323148304680737, -0.6463521455049057, 0.7854894074796749, -1.7671075783858252, -0.9172359552209941, 0.9387070100339908, 0.7757708869936695, -0.5548254165536495, 2.179913844426732, -0.3272820635847181, 1.5503775520381347, 1.0453889139227197, 0.8462248780570929, 0.48694501948580665, 0.0932660446911813, 0.3578124682382265},
    {1.374559343902835, -0.6187712521005266, 0.22277616085664623, 0.14386923388622294, 0.24376206309374202, 0.9818771994316535, 1.2510906218308422, 0.7772078410014864, 0.5978787338256796, 1.4713076646168033, -0.24718841500923397, -0.06616093512987965, 0.4637832639273587, -0.21689049454280357, -0.6998340586628202, -0.08915261050009295, 1.2930990379107687, -0.012889056272361046, 0.27152299079372466, 0.4780186194310915, 0.27356235811591834, -1.8519220199098008, -1.3528506575887944, 0.7412911463160375, -0.09137916414467231, -1.2083694035732686, -0.8827192047867846, -0.4602583444312241, -0.7545020351038233, -0.619427642277655, -0.8055509573173795, 0.016326364226322453, -2.424330320170054, 0.6965926733293091, -0.07830058426611922, 0.6572959118254367, 0.45567942834067915, -0.14122346613584638, 0.31856464837917964, -0.09453114617861395, -0.49314855074509856, -0.27374514361380997, 0.7635731932703955, 0.5222269458820841, 0.4632481779503893, 0.26659644434981467, 0.4488489956240799, -0.1344493155849924, 0.2731663482766496, 1.6231149846018011, -0.29173988489394265, -1.5797153262182475, -1.404445367572957, -0.24456391214389933, -1.3827026982231956, 0.020555164345026584, -0.14593131815939078, -0.1176840533867405, 0.07402695203804181, -0.20532257109153015, -2.694933173444394, -0.5668558311149985, -0.373910844201149, -0.08003582824407153},
    {-1.316579777956827, -0.01875554822083507, 0.7841410991818637, 0.0205585909129922, -0.9105590424020524, 0.24813166041979626, -0.34244870428205587, -0.7237814749193857, -2.0234375159892695, 1.0041189532419346, 0.43979088814448886, 0.5351729021318348, -1.3302693899192937, 1.7024911541877785, -1.3568649151990229, -2.2126749824641245, -0.8213056615392755, 0.2981376571057151, -0.6757100529979562, -0.5991079557903729, 0.1264624073996898, -0.31885908492453346, -0.5856037342433592, 1.1510444936862831, -0.7405820283517731, -1.0110920555825613, 0.3721413207561047, 1.0794112917547696, -0.9717312995552688, 1.5688517698275803, 0.9821279097329545, 0.47810372429497194, 0.3820144558203401, 2.016768080540958, -0.8743032687899027, -1.0327530311209425, 0.24570645362901664, -1.1783601031661366, 0.24741932627641175, 0.1290786429121217, 1.7570607139671082, -0.32398519933047254, 0.17741983299518782, 0.5290843606908163, -1.103857885219655, -0.6308838064582303, -0.7383548659699615, 1.4714156303848118, -0.17874093397272914, 2.4922113991057127, 1.0174096504028176, -0.4679578115834153, -1.6258391649988109, -1.4914676907112199, -1.296604349879593, -0.2795342974438861, -1.2893107828852797, 0.15786604248026362, -1.3922292972374493, -0.2461249839022557, -0.6188714807208437, -0.3661773043073082, -0.3434605673930196, 1.4208649128983024},
    {-0.5673198572722112, -0.5661223666880446, 0.5081147515814285, 1.2065829601367009, 0.5846815997884032, 0.3046863460461989, -1.550166980263852, -0.5989632584727466, 0.41057948413612644, -1.2702970894436019, -0.5982405212158161, -1.8020100987364196, -0.15589522657447985, 0.8752063485325268, -0.8427077484260458, -0.1825796090536467, -0.9569906709787968, -0.8879254372810941, 0.08715894539811066, 1.1574664629214642, -1.2562702104827006, -2.4321397074010984, 0.049614435544870245, -1.0171278633276803, 0.30773998241444, -1.7774036292535336, 2.160380029167701, 0.02458406553240767, -0.1612182963196794, 1.1108814944806398, 0.7985985917773419, -0.5058733544527793, -0.20182795253626648, 0.5386024917011926, 0.29620846859895594, -0.2756280145741471, 0.6231492094449654, -3.9824623140011366, 1.209148433419554, -0.16532879782765128, 0.5489443145323379, -1.9547607248800816, 1.539644625615209, -0.565210999576558, -1.4128682993665205, -0.71646431906291, -0.518342978442286, 0.04904652595864885, -0.24349100750412297, -2.727087625473491, -0.5748133314623544, 0.6546012435724073, -0.27242948768066066, 1.3196046610729266, 0.04905123409136894, -1.9475236305471948, 0.920202426597676, 0.5195379977718709, 0.6695454802573183, 0.49812107656345495, 1.0758355060829314, -0.03330606846133043, 1.1213589483260453, 1.1949324850599254},
    {-1.5265673741106436, -2.368854262368004, -0.6781109261061504, -0.023077214360349853, 1.4671959660722564, 0.2491039817160246, -0.25940987167690915, 2.648402651763897, -0.09796691576083032, -0.06243572829951777, -0.0876603171175373, -1.7597204700510438, -0.8072895307338122, -0.921370535831982, 0.8165522334821932, -0.25035233503362375, 0.7448967702492105, 0.2027094282680354, -0.1663451527581065, 0.4638874467159075, -0.9813327165882033, 1.2093279582096434, -1.9287122314312901, -1.12469579563793, 1.9981825061198437, 0.030347807462586543, -0.4859353722747188, 0.38385663005705056, -0.27021241487836656, 0.3833871501525016, -0.6177262986792483, -0.3231246922972774, 1.8657064956032912, 0.6969576779149842, 0.11916754187483732, -0.9472262731914053, 1.8749247216485334, 1.3557106078217416, 0.547162620368792, 1.6980185193740192, -0.5505601947056566, -2.2436271028026042, -1.3689502700847418, -0.9875354002714446, -1.130974014600377, -1.0498215005247735, -2.1874572296933668, -1.1291046957558324, -0.3345249515619357, -0.08649044995968926, 2.5046366458962077, -1.03296026223596, 0.4891082981416784, 0.7693205893666375, -0.3814728398024383, -1.528943728833896, 0.20188617465307407, 0.24552517993334905, -1.1238387449576848, -1.3560293907925558, 1.5076449516432957, 0.48841442236683497, 0.35645862910295767, -1.7275738588271332},
    {-1.4666861421627884, -0.21152126021593531, -3.032718640179513, -1.275396786831931, -0.6064037330847843, -0.3358614224942463, -0.38630519816790754, 0.3289555619314201, -0.0070158111090474, -0.25622188326487844, 1.0971527048436325, -0.3635476691066103, 2.155129615815838, 0.16491747401597895, -0.7762254881782926, -0.6213221884804462, -0.6056351592342418, 0.9778037468472603, -2.774105804634652, -0.10734034439345566, 1.5296725541807792, 0.5373593306909102, -2.683408920743249, 0.5471981724605365, 1.655424566423252, 0.9702886544413699, -0.690059305842129, 0.47216984398852374, 1.0931644136557597, 1.1175697419451993, 1.0058823591608028, -1.987861408500003, -0.3329987552514199, -0.6883060663303444, -1.10538877287647, 0.7904293596164175, 0.3067702300462187, 1.1991329316195976, 1.3969444371354005, -1.0995131972738736, -0.2730459676039554, 0.4899380250969723, -0.01953809564150359, -1.0236641853852348, -0.13318778870128015, -0.40375756836947074, 0.003634752486375358, 0.44833055976117575, 1.4446906586368302, -1.7286197888040287, 1.2683694474836036, -0.17583623140347895, 0.8730255847097992, -0.39627465543715074, 0.9436767398916105, -0.9447974612901663, 0.9579547474721575, -1.085849705175133, 0.36145938674589595, -0.9605479606407223, -0.1675643240972871, -0.6267487570401157, 0.611699789392982, -0.6452934269057904},
    {1.4727326249649422, -0.8908247516701628, -0.49917983325900867, 0.5226376165988464, 0.7473620938313115, 0.5420910706997178, -2.3713809679372937, -0.8362135636483202, -0.39339517526000706, -1.6303967002411717, 0.40660893733270165, 1.4543314359472348, -1.7550593347834786, 1.3304722505228397, -0.623485124229703, -2.0121799961570654, -0.3591347039396612, 1.4574686496042508, -1.1063633577562, -1.7114481610305101, 1.482171936130201, 1.0516102844883959, -0.9562201271750772, -0.8393512931924269, -1.178773711734322, 1.9977677274923922, 0.07797164813219565, -1.1192041223790214, -1.5531543887972146, 0.18046802351058, -1.5328743173412969, 0.0061520984242859926, -0.3591885345215951, -1.0910583265731106, -2.2736550619637157, 1.4015560611242592, 0.3589970341833518, 1.1215419290251605, 1.6689158608416104, 0.3852591046296943, 0.12950519984649794, -0.46910108095921155, 0.7449975471601973, 1.7696921817128826, -1.5866392882099527, 0.2957755235181229, -0.5471383447763882, 0.6204853442346276, 0.03747790110482508, 0.8379077504898514, -0.6633858014292847, -0.12273586655376706, 0.6718815999035936, -1.394166662159693, 1.8817250395678469, -1.156809396406087, 0.5668917100286525, -0.9257657496129912, 0.8963916768445115, 0.7786635679190377, 0.04196013006323104, 0.6174326174883861, -1.3960447690391016, 0.7941687396030833},
    {-0.5601624983037095, 1.138129127376799, 1.45366406509533, 0.2075940352713768, -0.5622772851622406, -0.3415876633724702, -1.299022753100954, -0.3808174099465199, 0.8800785029451417, -1.9026509847588429, 0.4541245954545784, 1.911125755587164, 2.2971855669855463, -0.17370958654989702, -1.2551993835919926, -0.008530878147950336, 0.839926996738122, 1.2460457795736681, 0.581291509712323, 0.3731393810663265, 0.7361899517519201, -1.3734746938412035, 0.9698753249569869, 2.087277387872463, 2.2023874645993153, 1.3372076529414518, -1.318990073885032, -0.39826791892297114, -0.20206747336004158, -0.34554467404948447, 0.41248309988393894, 0.18009918712121536, -0.6495921788709026, -0.7274016955838436, -1.991396529887756, -0.30102359421210445, 1.3004529985890436, 3.4764032295776905, 0.021532315955163726, -0.03967381391995421, 0.7298361270721956, 0.8343451133137506, 0.2984164366930133, -1.4570549184238255, -0.10079093210982853, 0.6059702437207938, -0.5278005632303905, 0.5044035936481689, 1.188068841576361, 1.1714818090803776, 1.7816358378996304, 0.20762009405088483, 1.0236548660319826, -0.1063759613366077, 0.3162943750488992, 0.8744570395463332, 0.7059169047455163, -1.8368824091107694, 0.5784876286434418, -0.3138295245106672, -0.0026832653945368717, -0.52081633330488, -1.7420001364417657, 0.27570355727732276},
    {-1.1869999487305385, 1.9936120030681976, 0.7019259784955241, 1.0085152550262828, 1.716807584744964, 0.04992446889822657, 0.40365782824287383, 1.0262131357774973, 0.624745044657232, 0.3447599272329422, -0.4635290411066238, -0.07925878482836797, 1.3801861223826901, -0.7715145917883598, -0.27346454190159564, 1.5817165298168099, -0.39714424964178446, 0.2561836190214607, -2.9877294406244155, 1.5119229026007868, 0.011611013946683587, 0.2827267216383479, 1.5230925695244844, 1.3886795019240123, 0.12960946225558242, 0.5910488880294691, 0.6570852523215357, 1.858640969959718, -0.04736916803707633, 0.3353223652747277, -0.07731766117497864, -0.07088332065209417, -0.31295588556651355, -0.984882679270393, 0.4154789247518456, 0.011652967622174756, -0.7157232849371937, -0.09277541808642198, -0.5299437522228735, 1.266353748838686, 0.08193827382035623, -0.15985773089932853, -0.9433096874289196, 2.3693255945091334, -1.2493198513585255, 0.7311827691209837, -1.8646361617070255, -0.041301870157644166, -0.5531785310489752, 0.0525145498884629, -0.5120972325053138, 0.6296685693571369, -0.3200170756468514, 0.011728401936116097, 0.1561387212954018, -0.3211752311336937, -0.9126593357392616, -0.12459453901697304, -0.9903907985610639, -0.5763196829813675, 0.8631617229402894, -0.722280540712509, -0.9144262502378278, 0.1495332056586995},
    {-0.8474351578931725, -1.8187632533491371, 0.2973185351471206, 0.06969602641413306, 1.2353849732063127, 0.16216682844079588, -0.12213906406284177, -0.045837795752252275, 1.1432351895725474, 1.542416979932053, -0.4870502941180273, -0.5957814952092308, 0.9517217363432381, -0.16867769597468582, 1.5888040174269173, -0.8243221059294357, -0.6567781414863147, 0.6997652128316557, -0.7219102207176281, -0.9281586135405528, 0.6698847063013081, -0.7738941702368255, -0.13307291565914844, -0.9590414197125818, 0.8448352298676608, -1.7564405469474094, -0.11053142029093162, 1.201159223010626, -0.10117823448257827, 2.0068690033489225, 1.1706088010646125, 0.4502548887184953, 1.7328121150008644, -0.48688756052411597, -0.5655520993449948, 0.9852293008787373, 1.292542047329472, -1.8076268426944473, 0.08129900751021671, 0.8489867879402442, 0.23392745430831258, 0.833317155061801, 0.7781843579144523, -0.7365740997429331, 1.2308094656330177, -2.2410704438742495, 0.5543838683598444, 0.8995082884709531, 1.045932536105713, -0.617426510914146, 0.7454813028638334, -0.7230197404558203, -0.9071575115614773, -2.177879851461581, -0.7984344003839755, 0.043677789623140756, -1.530651481327137, 0.13675688388947732, 1.4227432791580932, -0.48490660193235063, -0.34972630971687846, -1.3617223835202479, 2.125245609345724, 0.401347932786064},
    {-0.9056122405699848, 1.337960730069514, 0.22186534608376324, -0.3326973372379183, -1.0886753471947095, -0.28863317831118884, 0.5107093464908565, 1.2637627266854492, -0.486318244027371, -1.0935831619102745, -1.9256117459267177, -1.6234304618370239, 1.4672130991035564, 1.6965340808379477, 1.9550471029116407, 0.32320936494757513, -1.1474763782102748, 0.24674571405359721, 0.40494390489849147, -0.09457039323290893, 2.1280789070228425, -0.40239762130247775, 1.330417894963694, -0.6694076057367873, 1.10053507386128, 0.5113499428690558, 0.09510245008980231, -0.06827522108722918, 0.9496859218447599, 1.2574010100306792, 1.0257067670831788, 0.3852120041011308, -0.6021840354753649, 2.8107445273760874, 1.798190041930954, 1.8848622607217724, -1.5521166285455725, -0.5105908767240112, 0.1326004689999285, 0.4712868870801774, -0.40791580570760094, 1.4180895667946654, 0.44067565915478624, -1.4613269040114492, 1.48444455348828, -0.32894354899595624, -0.4581230522725889, -0.7661152519845711, 0.4893695887747171, 0.18422509673772636, -0.6643410374401154, -1.8087267730814218, -0.018995957745286424, -1.4708254903627527, 1.2107703605726963, -0.16000133115918427, 0.9279334214667553, 1.585793258539422, 1.7362262911821122, -0.533261951260613, 1.5205224548180956, 1.1802029978094821, 0.1042547926950844, -1.493170680867699},
    {-0.9572893848975781, -0.12655241785934845, -0.9680681165249405, 0.5792719774378465, 2.0643214526417095, 0.7499078460040075, 0.9530952198889995, -1.1238703137768271, -0.48531688615825724, -0.17229597935433055, -0.6896418078414714, 0.1416472594488598, -0.724655227554431, 0.5727389015043635, 0.1216404280349287, -0.7547740897293679, -0.9522619039956969, -1.5756119505226267, 1.5633027775750152, 0.2982306860612012, -2.514261531070105, -1.667627628799321, 0.22620068247131106, 1.2243864138938665, 1.261443094565579, 0.016213294169911432, -1.7546628584340416, 1.6116156150360372, 0.21277767257550137, 1.7420103365792043, 1.5421661939636748, 0.2810485804742565, -0.7290948561363512, 0.5905555873687935, -0.5446183921818765, -0.15327131589743867, -0.537103871403359, -0.3856236081581026, 0.7421722736482455, 0.006379347785336352, -0.10159405104448817, -1.6860410793783382, -0.3513767364990467, 0.4825643649325812, 1.8214030775120242, -0.6913055608660208, -0.7181480849614877, -0.1563800375957503, -0.18082857542751754, 0.41990834510060027, 0.5568928258758008, -0.16449865736915195, -1.0102859048326163, -1.3002040870072507, -0.19345532013103814, -1.7669484720572002, -1.0951384662256305, 0.7977378426913756, -0.010614072873792183, -0.28866389108984314, -1.1699279142778176, -0.22991999275768202, -0.6522030051545751, -0.8670053887958447},
    {2.0006146428711076, -1.6941536133382373, -0.6310030261678722, -1.2895616367221403, -1.0690289198988019, -0.9586440422271915, -1.4237614832658243, 0.5755905474441553, -0.5366764460021188, -0.12620734976900688, -0.5001378860705723, -2.06140905015422, -1.2274455317174697, -0.37769180099762983, -0.1302154435347042, -2.6873724886754404, 0.9586034494566483, -0.033134826669904346, 1.1315177672028365, -0.9712599826525179, -0.027947892584763694, 0.30893298136839886, 0.31949351085909405, 0.9885272631086306, -1.0950004523838381, 0.6460993775128157, -1.6168557622319635, -2.0272866208256066, 1.8053132787203314, -0.14135794714474173, -0.11836881287600223, 0.6272078732814813, 1.2312611864837932, -1.357274340645772, -1.1930024727529276, -0.6261004999992931, -0.3720424380507932, 1.5150693890816507, 0.7679858887067705, -1.566211773350937, -1.472608360234261, -0.3784310593584108, -1.0496965112326844, -0.22197828605331105, 1.6414058171715455, -1.1909824644592852, -0.9383885989746954, -0.38863525956895917, 2.8552260457080294, -0.030169641282841306, 2.1683618580239297, -1.4698275711502355, -0.11750517001761612, -0.8587147964769295, -0.060410814433323475, 0.09129684050276025, 0.0568167852833126, 0.40486642810261575, -0.10816505001297397, -0.7729659641263171, 0.7080139718289046, 2.2076289581990878, 0.025078366276043568, -2.054401948748662},
    {-1.7975147002088445, 1.909015750220859, -0.27473273473703347, 0.5646572268961507, -1.1968897838336412, -0.4034272808003274, 1.0540337706746514, 3.025917166458404, -0.5845554094156602, 0.9136909258387634, -0.5643324310942727, 1.1128986606168894, -1.0685553960419791, 1.3363221824910227, -0.32639791717904565, -0.38142547323684106, 0.286721536839607, -0.2790532556627536, -0.3539739746651101, -0.8938964198950385, -0.22793784753795554, -1.6617996664055157, -2.127187426057655, 1.9908486094372762, 0.20808119189897772, -0.6112173477468884, -0.7279772759778391, -0.3113089138775589, -1.1598232888198228, -0.15734486717141125, -0.324132817446581, -0.011075625503486088, -1.780281115040193, -1.143480252487548, -0.20812448942064288, 0.07259730352242194, 0.2800044378434038, 1.7127695674747327, -1.2492511753412454, 0.24601739126663666, 0.5830393243401277, -1.0408075545634456, 0.28908270603832753, 0.022651389725656522, -1.3549331256832884, 0.4111335602596668, -0.6734543311760967, 0.5835072553159948, -0.6198147551238163, -1.2051673954020454, 1.7537945951160991, -0.6955415500846374, -1.1613698912682502, -0.9899011398316281, -2.4282003250138353, -0.44211904454493406, -1.2299108238336076, -0.16625042205296747, 0.5529120928803712, -0.8158722789567191, -0.04179968878322599, 1.1037283507780473, -0.24076096817573228, 0.3546410853457725},
    {-1.0735686886676243, -1.2486449693177173, -0.10518428357037822, 0.3362697859570427, -0.447389639505071, -1.1246220589633098, 1.6533119164804193, -2.650416727183995, 0.17253615151513513, 2.4539098754229376, 0.9936994245747455, 0.1866778527040533, 0.7530411804575653, 0.6474507967106514, 1.17279843458546, 0.2871787095266967, -0.5503531558071495, 0.542226358910742, -0.866415412133054, -0.3903064983273142, 1.302072255542185, 0.3655862860830576, 1.6956734168881993, 0.4243544384477369, 0.4553817554340644, -0.7678026552629105, -0.9876277616990928, 0.4635382346326754, 0.3247880571874736, -1.0722058175888496, -0.02609522658670249, 1.9979902433795658, -1.7434226806093416, -1.689690794965709, -0.25281353932900924, 1.8134520187569314, -0.4425080550789378, 1.8633399313632317, -0.9567567772206189, 1.0232622392737842, -0.05627553483511073, -0.8507962854532427, -0.08016985782503604, -0.09704600605529587, -0.6389662515731476, 1.6027459795966619, 0.6658981464397096, -0.7621862323496412, -1.3584339200985682, 1.4910921607207053, 0.5731133978778798, 0.4595052912212346, 0.6062661100105831, 0.33129507583854223, 0.9585202705967532, 0.7566688361759158, -1.5997664171890236, -2.2315091417335378, 1.0256153232582423, 0.8411285030280518, 1.2225093352568985, 0.43066141948529896, -2.0099013974388193, 0.9079600280999452},
    {-0.6217820622803262, 1.1212938858513413, -0.11661220069137147, 1.3265112273881958, 0.2262500032998554, -1.7875719759283317, 2.519374848655166, 0.6610196310213697, 0.22187332071228433, 1.0261099098883604, -0.4794166028248779, 1.0130406599576125, 2.3159351040535268, -0.7973337057835337, -2.5438549416678384, 0.012259236977445883, -0.09692756876234072, -0.42239186203324547, 0.32868146279720306, 0.25028894852154243, -0.2583481928054939, -0.9434214860128918, 0.5922998904969774, 0.339555037807138, -0.016338381921381716, -0.13074285750420225, -1.5563722725617521, -0.4713051017512924, 1.7430352714153945, -0.8552424402556406, -1.950380599973221, 1.7615323900673316, 0.02825492219286472, 0.2572901847995736, 1.124485364722566, -0.14445377574187412, -0.1882107195299326, -0.09944171907420654, 0.5682647880400002, 0.06238234397392239, -0.944582867830105, -0.5234537151304173, 0.48180258219819516, 0.20943431490583045, -0.6367833628996264, -0.07948864186501396, 0.8660790740436779, 0.47044534313574876, -0.3375570652535229, -0.6303938384414995, -0.7245310809508078, 0.39711782191865447, 1.8803153543773208, 0.7218923616208083, -1.418467726636367, 0.9501332584624688, 0.2843366167781396, 0.8781794543341627, -0.6120392806659859, 1.6400691831506335, -0.52466786358399, 1.6219764733548183, -0.6214734243949955, 0.8495724600358114},
    {0.09027378077982111, -0.2618289073729567, -0.46899111638043456, 1.9704413531609426, -0.008516022681873915, -0.21333140279185905, -0.8274062611257577, 0.5798527843217166, -0.5912104333269323, 0.7042107239158213, 1.7048708900379639, -0.32153079921443756, -0.020976380228766675, -0.7221741375171543, -0.8028342869953942, 0.9976095325969462, -0.9417325849049397, 0.22427645905914198, -0.6248759188846368, 0.40509547583559863, 0.03168924300155508, -0.4139463664602202, 0.05167646034491399, -1.0895921327251736, 0.7009357223853251, -0.36028794293355554, 0.03634735276616134, 0.4625687979402439, 3.938866813387118, -0.7805970185828978, -0.9187294130072404, 1.4359086500591225, -0.021808398080565766, 1.1501456394940524, -0.9233642599720958, -0.061983280926595004, 1.54930799557129, -1.3376928793190765, 0.5426924951185861, -0.9454135063391901, -0.9297364415367683, 0.7700139184222623, -0.5285025980698622, -0.8873907172148829, 2.7857807960613883, 2.231685917338203, 0.9496583080679264, -1.6727733480952185, 0.04523441467773634, 0.1521213770907246, 0.1947302390173947, 0.22097050889179667, 2.039673765791209, 1.2894845088939184, -0.6573732109357405, -1.2817144829750997, -1.4823337060850013, 1.6029927202111136, 0.19308708139011446, -1.5530892858987073, -1.4237260810862187, 1.3158291966156632, 0.11723537738182782, 1.397503106066628},
    {-0.8423678419723073, -0.9816845626314986, 0.5955126180944064, -0.3390176044687518, 1.3666901699252954, 0.8500208750383992, 0.6998586677533145, -0.7378644306417835, 1.1441968717690687, -0.3880645816533127, 2.416588562955566, -1.097126497642306, -0.6927673012120416, 0.3920230031573393, -1.8120023126446543, 0.3874307389814501, 0.03862592877521291, 0.7237841593968, 0.11931563766212563, -0.4769551378358509, 1.6462725439083536, -1.8854705968923449, 0.865205670558002, 0.7341568750402009, -1.0941586928599294, -0.7436957840715536, 2.1445511348607087, -0.18849088492512772, 0.3412206681194165, -0.1503193600945236, -0.2622348346010009, 0.2037413529383575, 1.674069239799344, 0.4188033433999472, 1.4803700208325954, 1.6312098341515802, 1.6615861760595367, 0.48193730077183844, 0.1788479051855262, 1.2878956903313588, 0.007545546455800313, -0.3573590384100658, -0.4317251501802661, -0.3614934649409346, 0.8881293947881587, -0.8591661640863062, 1.196956776289813, -1.008688268806115, 0.39142066631010725, 1.2149245603160224, 0.4532240073678667, 1.0278370420094987, 0.3835472685902746, 0.8449853034549529, -0.155827952402817, -0.1671439949133081, -2.02061582218468, -0.12182754984300476, 2.1912620990138323, 1.2813809242243377, -1.3156584880225874, -0.45204475674520855, 1.4981592656740301, 2.810504890955608},
    {0.40210272003413977, 0.1956652915898297, -0.8739624350517635, 0.8507068707437808, -1.8646400541184378, -1.123458883726228, 1.0803919610592376, -1.2169838911808755, -0.420168077800053, 0.29057948981487636, 1.6660620270680446, 0.47528405318128075, 2.042168499531594, 0.4018968553305002, -0.65048694729703, 0.01723444072767425, -0.19399594451765978, 1.4020327655860263, -1.1071437666575603, 0.4248213157425733, -0.5835181385639928, 0.6991318316232321, 0.785979528276645, 0.46002416913377664, -0.07948608559816848, -0.8091744691437882, -2.0312966757796853, -0.9960941049729565, -0.019063079151347858, 2.1430328121244315, 0.009409870644896245, 2.4705011486973603, 0.2617785409408748, 2.0857155197532564, -1.6362578446618916, 0.10355745386021734, 0.1868320696440927, -1.734393691302806, -0.30533865764420975, -0.8148108546170085, -1.5610004910272954, 0.2883401909654958, 1.0978169451278583, 3.147418329191822, -1.1181370342308388, 0.3376113974147262, 0.7481526519312532, 0.5422479414225129, -1.678684415046467, -1.226467176248405, 1.1528263237866965, -1.800687723775179, -0.3811326794898992, -0.1164691853808747, -0.3450337071993248, -0.503918180567772, -1.0948551564839335, 0.3122490164742812, -0.41035733429165105, 1.522427959743671, 1.6661663222030645, -0.5321469071706186, 0.4158067307914243, -0.6063823486381251},
    {-0.4609291432681154, 0.81401647796411, 1.366473640827591, 1.1410127762478497, -1.238114438372521, -0.21185172737079536, -2.2227995863617815, -0.9915054305064359, 1.3795691563857595, -1.2485905157913206, 0.4021435206232134, 0.5643859641669333, -0.962361008744119, 0.539584382047863, 0.1340312239340864, -0.5248459601439635, 1.101980609752045, -0.15408195990267803, -1.3740758360380283, -0.144506169608341, 0.7019607147575452, -0.05206907767756412, 0.18250775081951573, -0.6463797700732702, -1.2995149132363641, 1.3859691789230857, 1.583817294777791, -0.442116697337643, 0.3040420863423842, 1.65576678965962, 0.6369851587429697, 0.29028929488155253, 0.11982672190769701, -0.15771277601075273, -1.4226069513851511, 0.33103745154865144, 2.510010144343163, -0.40903035724791365, -0.2960256015381069, 0.19760135921260596, 0.5635420647862001, 0.6351064542639313, 0.6956076990590384, -1.7039694228259155, 0.9717930731486102, 1.5273301620834823, -0.34570440393530705, 0.43888311256240475, -1.8319363578344634, -0.9792005999425497, -0.48915332593505856, -0.07695976580612816, -0.030774976257304087, -1.1706400347403276, 0.39228588302218337, -0.7794151961846141, -0.2910468556206058, 1.6925731749985877, -1.0239291963316897, -1.8416251904874512, 0.2845026035359496, 0.08108035647925207, 0.8302375152061089, 0.17099128374025852},
    {-0.7179845222406894, 0.7984964915730555, -0.14700947944028084, 0.10637280115946303, -1.5006058260525097, 0.20960199988196113, 0.3454206866506739, 0.09263229111124352, 2.0237067176274746, 0.4897467192120152, 0.37016949698390067, 0.4108483660257904, -0.19487808800368564, 0.03242162446058828, 1.5246830110178342, -0.6801469158727396, 0.8120001368232345, 0.022914467164401566, 1.1350599355197488, -0.9593991401117894, -0.2337685294713187, 0.4169467883685626, 0.5377324557371645, 0.551033324141785, -3.181510853778819, 0.22822234028789953, 1.1192864786475385, 0.14151554104694583, -1.7642906292825589, -0.5786044161595152, 0.33035252552998534, 0.7701030369074799, -0.39504700032750495, -0.45576798868389734, -1.000755998641412, -1.3702768092769821, 0.05719617735947758, 1.9282684367907248, -0.29478150699995204, 0.5444315971597108, -0.807956933076505, 1.570938375718081, 3.733274244526368, 0.06128035454236378, -0.1562377295366, 0.9390371326030018, 1.1939036711044158, -1.6848400707002862, 0.8421624906751645, -1.519643880373794, 0.3961116818288304, 1.328102977451423, 0.6216670853865854, -0.46825588552682496, -0.030591607523209108, -0.1141817492721937, -1.3468145221706906, 0.2724347942158407, 1.2443140296809352, -1.8602559692193814, -0.22641093175529775, 0.6493820329064851, 1.1575199641833935, -0.2077181387996292},
    {0.25172547857736577, 2.112453449833006, -0.6301022927032419, -0.7356049166118327, 1.491389931214176, -2.590096760129485, -0.10443806437721237, 1.2157973286849615, -0.6352078894231014, -0.37881426799710133, 0.8321064686714881, 0.23500343693977035, -1.5821121304152157, -1.0580483168308414, 0.07022790791707818, 0.6571008049010671, 1.108100625329657, 0.15867557153379264, 1.9438678717411493, -0.1992967362187575, 1.0505205089690248, 0.17645917859155874, 0.8337450952806562, -2.839884105220739, -0.42957822593097866, -0.1018544424078952, 0.827015464344187, -1.2246664482753284, -0.26490720049213196, 1.0768876655402169, -0.9417873081145438, 0.9533570542050223, 0.47838549187734053, 1.6278816523663575, 0.3972717407974953, -0.052139812072872466, -1.1404340722240855, 0.42930652930953095, -0.3927062244251349, 0.40978626810640534, -0.5350520670569587, 2.178838224306184, -0.8733001396405882, -0.20515618845306877, 0.5289067748243825, 0.1058843828725446, 0.5498124748714824, 1.0606011620480964, 0.12016752314075364, -0.5579670928894136, -0.22048457071653152, -0.6018630448472393, -0.35221599367907913, 0.7678796950404868, -0.18765804995103558, -0.7543032140343168, -1.865111805289799, -1.8953501081457735, -2.661261891439312, 0.8421129492367984, 0.25768536811224096, 0.13672943245676764, 1.368496191966025, -0.10212361982782837},
    {-0.17877752740003508, -0.5757450829615107, -2.2727324335054644, 0.6809741811803446, -0.3052651208237473, 0.968408356299756, 1.0943393161464974, -0.30533284867177696, 2.403908328151211, -1.2767170587381231, 1.1768546589964282, -0.5989398658831021, -1.524612659163181, 0.9637349939289908, -1.521552767041179, -0.5289199109980173, -1.6845546385662018, 1.0449659627446286, -0.8181679497553824, -0.2267257322709765, -2.2395468427606753, -0.19660444016573705, -0.33675486131589816, -1.96742108603374, 0.4741347813377793, 2.4373316927721693, -0.7447378532225547, -0.5805403561989148, 0.11454241577218714, -0.3254172518232894, 0.2079210736045145, -0.09398551832681169, -0.3450388523032969, -0.3269161752585102, -0.2719178909626667, -0.6488444313962183, -0.12209932335284386, 1.2703485524923597, 1.0681804815987448, -0.44375322994754074, -1.0931308092117322, 0.31783980551477226, 0.4203061763641246, 0.28892598301109956, -0.7348885777030495, 0.4358328173726769, 0.1848144216999245, 0.8311761449737893, 0.19541467313498825, 1.0461457408581205, -0.302512230601072, -1.5280651952532651, -0.02653523138900547, 0.8618044785128183, -0.15674275116161207, -0.3655085284728492, 1.2461852283358492, -1.9502714476141065, -1.4575396530477018, 0.9811403320757752, -1.641619087354572, 0.7206326843327098, -0.33214225136814546, 1.0333115905557013},
    {-1.7861386716482928, -0.14888573243022293, 0.9862716459053446, -0.6079633151370956, 1.1238063530151263, -2.013221664688857, 0.126034421813089, 0.4944242814635751, -0.7956070629763329, -0.9186133319511786, -0.13518324864087156, -0.9156361550478839, -0.4447088455079422, 1.980492419193117, -0.6596179498464927, -0.11892846332037492, -0.47477103615122795, 1.4983640035140484, -1.1856867752854545, 0.4129329472893272, -0.9777080308407461, -0.4524369861431341, -0.2808229573990115, -1.024805465465959, -0.8407898977669718, -0.7520468167062444, -2.7647363082432728, -0.6264249351610642, -0.9479762392419855, -0.022192320737329515, 0.8638414417661762, 2.4265488919600258, 1.3750876815464963, 0.6690891255528585, -1.1764582854851227, -1.7614796713971939, -1.6790713011981508, -1.696827772555255, -0.006070830231238327, -2.2506690768178057, -0.4537682813211724, 2.0276918096246965, -0.9882207526847269, -0.6039337215099095, -0.2887856639967487, -0.4048223454380774, -0.6897218723494019, -1.7330390685834225, -0.47564821819963565, -0.4591130710565475, 1.7907391699148214, 0.9017243145452558, 0.05349799636199638, -0.5372111186442455, -1.2832933647741511, -0.5786021062870671, -0.5636180253450228, 0.29495526450117504, 0.6799204470915672, 0.5728253203141253, -0.20735328347122473, 0.3143586586983339, -1.0433759065961927, 0.10007699634379151},
    {0.1463948551456499, -0.21000150356947725, 1.8611276305209292, 0.5535471394131711, -1.7138005017446383, -0.6245013234050044, 0.8881019943238043, -2.016189709153204, -0.6521022287602499, 1.2252396680569482, -0.7174986969491843, 1.6789160177972786, -1.7681822435627585, 0.5893975991124336, -1.1641761374024318, -0.6430777676939031, -1.7587599301600547, -1.739228799142387, -0.9275574228572044, 0.9990789577947927, 0.08998261705663244, -0.7160666008752976, -0.0860360466030769, 0.7318464614211638, 2.5693036024460842, -1.6088570335543604, -0.9940050371933395, 0.8154770426787882, -1.2671943855416854, -0.3100956429017209, 0.19726853690343193, 1.6521910753956581, 0.15028574826095661, 0.45226639791526885, 0.028769325568368476, -1.8634403545130174, -2.7107016686945995, 1.437433872094707, -0.9719032227618465, -1.0582329990425554, -1.3443098978251933, -0.9450570400501925, 0.33214860161618226, 0.5081148226880359, -0.8204982300705516, -0.6665662201400918, 0.9335135695277531, -1.173186631575383, -0.45900681798383836, -0.012995042754518571, -0.35080125196225426, -1.3427843600358418, 0.9495425417073424, -0.3819586737992778, -0.07343094290759689, -2.6771026886052254, 0.8261504565018775, -0.41054850159658685, 0.8533784141558612, -1.2077072574550263, 1.828236075071333, -0.17518533929029664, 0.5725767118176841, -0.006160143814012686},
    {0.2539073597832799, 0.27496331059168455, 1.3180315902651225, -0.03445836189813416, 1.4375363090954425, 0.2881579315966327, 0.4015054032349892, 0.9068280494428671, -0.9040646021513884, 2.0969976617303274, -1.8354164527212353, 1.2245788283653565, 0.9036714641567448, 2.043285458339909, -0.1324588299698027, 1.5090414437145807, -2.8683204210414095, -1.326684898662439, 1.3838390054875267, -2.7028999150544126, 0.6208710640593924, -0.42446669663385844, -0.14389183064135902, 1.5305927369641377, -0.6803738575638708, 0.10613127283251521, -1.754882220721809, 0.49014989728467934, -0.2032501883618165, -1.0471994741770199, 1.2505372993878479, 0.7637398222640109, -1.6273163697404305, -1.4477326144571325, -2.8091930617855794, 1.0659827418573469, -0.15791364929171484, 1.1648602046935408, 0.5125196592581974, -0.928825100731103, -0.9475314232208756, -0.30785595882439293, 0.11459699359224856, 0.0839386166951439, 0.02598212974867218, -0.07010280142579693, -0.9364321962460227, 0.0954562578223799, 1.5732701700285192, 2.2647012193403673, 0.6393796962477881, 0.42497462588763174, -0.9805724784845411, -0.48328676752624955, -1.0371952080865352, -1.4612467069522945, -2.5652776029263045, -1.0573416913850384, 1.2881603937365411, 0.026748857446573942, 1.2821442902766167, 0.20872249779017138, -0.2679945696886529, 0.44799856646289316},
    {-0.2888667319191826, 0.21199181338002904, -0.8286818336526239, -0.04171140229812704, 0.8152898475965873, 0.9374118637495201, -1.0468518412191543, 0.013332827198780114, 0.59379026475215, -0.6278279450162121, 0.42347374150865646, -0.22432630137012624, -1.1994713050181218, 0.5654979946680487, 0.018347960308503698, 0.334282850681756, 0.32828853316604406, -0.7919792519098402, -0.06581484366054835, -0.9143947876178016, 0.43008077247602594, -1.695747822915357, -1.3703871745701612, -0.19473750517358387, -1.6610071917054898, -1.046519028780968, 1.1283896955080375, 2.0471375562786096, -0.20000607531227452, -1.7970226350096743, 0.13910112983477863, -0.9399101544785674, -0.3114214056389815, 1.529326960562391, 0.6470974138255718, 0.523108261617586, -0.7419021156209943, 1.2673921919478888, -0.38923777596080567, 1.913225576672993, -0.9024636830109668, -1.5564021872627192, -0.35481703925214914, 0.3252281813073897, 0.09256400268715997, -1.6645142862153453, -1.651993752439209, -1.0524614802935441, 0.23355337346399238, -0.4547312029572192, -1.7660497735504876, -0.5697874351014811, 1.6388819081495227, -0.7969233744871672, 0.1331216846357945, 4.0148262606699, 0.7799527840832666, -0.7012875224131456, -2.403437739905546, -0.9469194582797453, 0.4384416672266826, 0.7878910335213695, 0.09357131597294585, -0.7613660746924329},
    {-0.6131079548557143, -0.39848406944980125, -0.4256851356716191, -1.4189669214638798, 0.5254406030512753, 1.4930869479043518, 1.853374489314383, 0.7184862458832896, -0.446350649302409, -0.1181424640469221, -0.7738200625800901, 1.1778324073492794, -1.0554051882754816, 0.7769063167356811, -0.8965403998180671, 1.5498600644022098, -0.21390717408707097, -0.9087744922594272, -0.3430650044604767, 2.7321033246708004, 1.4873083852271827, 0.830365473790044, 0.8657495906201098, 1.3502845544127537, -0.9615246577849117, -0.8584877903021138, 0.19542967267566058, 0.7893745068558562, -0.5632239275862387, -0.24334732831988037, 0.44879768576182, -0.7599886147207231, 0.08813565012739118, 1.6832935448309043, -1.3578704772410544, 0.5029695031164633, 0.4758177950482304, 0.8696656257319133, -0.0017457826471546608, 0.532724518558708, 1.5315795559338548, 0.31592005502497955, -0.5248590763604009, -1.7177938414259688, 0.8725536891156913, 0.291644325355341, 1.22949672709762, 1.4297542934866252, 1.453467620489652, 0.0921257674750215, 0.6223966837846296, 1.828012675477996, -1.1356309790463126, 1.3580767641412068, 0.7514599694669393, 1.3835925282131323, 1.4683303298633938, 0.4650171977920487, -1.7541215600398519, 1.287511203013685, 0.5240539303338604, 0.6609889152218328, 1.0601887714161484, -1.4123837861552397},
    {-2.2784004275423286, -0.6011874678271766, -1.065755874665621, -0.15449770871559285, -1.1308814626165562, 0.260255468644992, 0.5642338128660531, 0.16892304709286962, 0.07681801683300334, 0.7079781109577846, -0.3477077969263802, 0.029656058652364942, 1.2431312326337796, 1.7344286155093755, 0.20111494876813177, 0.7986843994241213, -1.6921550243415677, -0.09938040877076615, 1.4105181134849405, 0.007559665266655876, 0.6265784061552199, -1.0286836313162087, -2.321415578592398, -1.8478874223911643, -1.4539276729705812, 1.0950729072311816, 1.8849244727107077, -0.33587683397736223, -1.3545274468128865, 1.213109252411753, -0.29272025163000504, -0.7331247976206006, -0.40826642591376433, 1.9035812450076899, -0.36860424273017495, 0.5318989547771372, 0.016106746234547397, 0.3052077311728585, -1.1182729420800614, -1.0020507990098946, 1.9726252172898082, -1.2548078040356547, -0.8606779087977843, 0.2871626812356181, -2.0081939235476853, 0.799075625900482, -1.6536974558686586, 0.528883653455838, 1.3688710397096868, 0.7810687029794336, 0.6302995868208503, 0.19266707511788758, -0.8425554045259462, 0.6931335480044186, 0.5541556173647063, -0.18355792168018578, 0.25871519453526076, 1.3254471349491699, 0.019184771985153285, -0.27570788895819826, -0.696032219111378, -0.574917878511906, -0.976663163735653, 1.587394170365196},
    {-0.36495043265066346, 0.7187153518168616, -1.261795269690216, -0.01765007485682399, 0.28929387665986694, -1.3797109334184088, -0.08347565118876904, 0.9335291910417661, -1.0548477013375706, -1.567928021706382, 0.37162754698186085, 1.9376857143373132, -1.5836345101314384, 0.48512467292027295, -0.9125823384202995, 1.0873622183948444, -2.2666309359713672, 1.5643994936107735, -1.4497705349459258, -0.2654398977278073, -0.21152825302090741, -2.8004685435924026, 0.0014980508027608926, -2.233741021787285, -1.1140194919923003, -0.03074070175521432, 1.6010303868026274, 0.4356919414187989, -1.389275112666541, 0.7510789892187792, 0.934307497100501, 0.35951247882542503, -1.4098126015619603, -1.122898218369192, 0.16781092298512296, 0.13204786103345567, -1.482470845401662, -0.1365763005850053, -1.123942767923962, -0.6200790475015472, -1.7188581841087212, 1.779017111778583, -0.1770912833426622, 1.7461300697578857, -0.7020814065918919, -0.4227480266587099, -0.25483116722454385, -0.8703569151287796, 0.693889496024426, -0.5685513451405929, -0.7462938262066839, 0.36415857583463007, 1.7058775263202648, 0.8967374818460111, -1.4069818113698, 0.9481400214169231, 0.6136239129030732, -0.42549127871912246, 1.174148411871088, -0.04448695853095656, -1.34266620615456, 0.3603449340847444, -0.23517917300727892, 0.7762304883976651},
    {0.8483003981041239, 0.1730340444895549, -0.9686705113468308, 0.4734835102003141, -0.18654159077315213, -1.9924450585577897, -0.5546115509190466, -1.5255612018571025, -0.01054404030014157, 2.073574077237939, -1.58730344422115, 0.3565725968141516, -2.118936449108765, 0.11836146432578175, 1.224525569134869, 0.017575932843524645, -2.439445408484342, -0.6561410450380575, -0.6954629990343711, 2.4043357954544726, 0.29794438057472133, -0.6327370403869765, 1.606259702111338, 3.631581842599283, 0.7691707556216935, -1.1191012144724466, 0.8018052097312599, 1.491925774838696, -2.306969908665437, 1.3437841757388487, -0.8651859728096453, -0.1755113088027266, 0.9954134743075381, -0.6243813830968147, 1.510085371879005, 1.7700760559726343, 1.6060912892364654, 0.21709880608708976, -0.7052431394572874, 1.1202193215515392, -2.0800397343240418, 0.09645682578997217, -0.7426520119075347, 0.5674002569212159, 1.389211530938038, 1.6225666831036645, -0.41571619519268366, 0.37323692472853803, 0.32405632218015173, 1.0941401273829992, -0.08816526307571206, -1.1949875033806294, 0.7397533437325756, -1.0451336900024575, 1.5782943553931272, 0.8549664861103151, 1.3287892479613794, -0.3026169181750793, -0.12645413961545662, 0.38832589362761954, 1.3097390913593991, -0.558113491406197, 1.2099295034447957, -0.3351434845663721},
    {-2.3083274887651597, 0.5165884001195324, -0.04928951826671275, -0.020270347831919243, -2.258039896039784, 0.752264615292034, -0.24136385647456363, -0.5437344682438556, 1.0427772780637814, -0.14002330985997377, 0.9385533774900623, -0.5140482586509999, 0.35747547703216587, 1.312488493033692, -0.1920369830278643, -0.4253286979827914, 1.4008820299967917, 1.616415199244685, 1.407673707186537, -0.4688078181933807, 2.329346116252646, -0.4997341558248421, 1.2967787991271054, 0.262795513478434, 0.479181288823966, 1.740682747652835, 2.0629245531170115, 1.3899990407189358, 0.9572261389786432, 0.049378136777762614, -1.2220151768427827, 1.7218018989138917, -2.362422931107083, -0.9968081993945971, -0.8559199019469969, -0.4020803012840186, 2.539764222650086, -1.2186535172416357, 0.9681794424906344, 2.344825846552328, 1.1690085326677506, -0.7094098303476096, -1.4195355199664046, 1.5549135157400302, 1.0722974966673786, 1.3453418784356532, -0.07078386882191343, -0.29876771796316254, -0.34850735936662347, 0.8167842942257427, 1.1752705944789517, 0.8023085100128381, -0.7371800611793202, 1.4837873507578243, -1.3775409308092441, -0.8833814661015114, -1.4544040125083986, 0.19372448886636862, 0.7098486138985722, -0.3357712872634969, 1.1781668756171153, -0.9872753119366889, -2.1333693111732903, 0.604661415986449},
    {0.6272519104278704, -0.9240532930543506, 0.11121642016620713, 1.0733523254603088, -0.05327748516611851, 0.4930448248252974, 1.2007062245431337, 0.004798752570603599, -1.0582844707657502, 0.9026351381774187, -1.6970745747649931, -0.10554820644462179, 1.274985441287405, 0.10462893099936582, -0.4596759327863555, 0.5960162435144133, 1.7036427691993115, -2.232832585869364, -0.4963660239745166, 1.034467373025339, -0.07610494927605402, -0.4643724727372403, 0.4725329297880145, -1.7423400126867732, -2.173432289621924, -2.0262308135825613, 3.033021598386381, -1.3109365977857572, -1.6378666824654347, -0.33564180438303104, 0.21458886914273845, 0.050772155499393255, -1.0521675862687487, -1.3779264431272273, 1.5606269307839133, 0.127776364670929, 0.29417563436195615, 0.22384727072136362, -1.3330267885685785, 0.7110583609512902, -2.5439971738329783, -3.3914356544082724, -1.567932132931877, 0.14388135621516648, -0.8718658490815583, 0.7043658959816721, -0.08413798671230599, 0.27104438166893263, 0.6048159525201233, 1.1917741472558054, -1.9882267291591176, -0.5924946214774858, 0.09491685600908711, 0.5703850937379084, 2.340515651258664, -0.990890273891237, 0.702511985323418, -0.4126856440028677, -0.36762040392995216, -0.5280506661365828, 1.0184740335630575, 0.22506424934591102, 0.41500463945853433, -0.7362281763795488},
    {-0.16085056391433167, 0.6124020958913372, 0.00020124063695075713, 1.2184253693019058, 0.8235444290692447, 0.7873076396484884, -0.9864759608400632, 0.27737005126711606, -0.3864403931415223, 0.6118315949748381, 1.1153270093384688, 0.42995822848288123, -2.3328923980035365, 1.1738433446013132, 2.342859048191055, 0.5627244328581118, 0.09996111791973791, 1.2867548521599974, -2.206252761751696, -1.4869629920407696, 2.2106085163618205, -0.17100810807848796, -0.854577073169567, -1.3380841369019625, 0.07251577119436442, -0.4965299100051474, 1.3645211147436997, -0.18465691419749436, 0.7297549175057386, 1.0550242338231643, -0.7946604479356278, 1.714715357168211, 1.6189329176472649, 0.7317788517619842, -0.41945043665179527, -0.28710519084112607, -1.189345061897444, -0.6916216452008122, -1.2519028192216985, 0.4286948684848095, -0.5696841193833567, 1.867169482884335, 3.2178604374863555, -0.5580755972612991, 0.521848548759398, 1.645971779901468, -0.10549070718771067, -0.38494795884069694, -0.1018714445803265, 1.3608860752811878, -0.4166788081154481, -0.5465905459069509, -1.1262827512015643, -0.8306616968335774, 1.606538211532125, 0.24484169518669105, -1.0654325220576837, 1.3091005943309622, 1.1371317728295847, 0.3504751135200067, 2.007415850691171, -0.7947330030604199, -0.47335140708139345, -1.4013970169901844},
    {-0.31267305913319293, -1.0092495241556307, -1.1821949732282517, -0.7832960647901441, 1.3164965005051323, 0.5290267675507222, -0.5699467757782973, -0.11364559083859016, -1.5134622318825093, 1.5880057429042358, -1.375694559463956, -0.34206404981734884, 0.2669388428073679, 1.0297223527957846, 1.8293621698915092, 0.07449733848057893, -0.809537819430131, -2.0463364978450937, -2.659300564999638, 1.0333804261658146, -0.09236154238176587, -1.1279726147483025, -0.4646810705191439, 1.3150096224139922, 1.6566250368319075, -0.22536582114558731, -0.5509854816377304, 1.0269702361651747, -1.1223881598595022, 1.4441859058134374, 0.805105184158627, 0.6780281005682797, -0.6315524715389275, 1.799661968712699, -0.5317835871322824, 0.660768286422747, 0.40324678966188593, -0.6766468030337237, 0.534467515322102, -0.4620820847793775, 0.6211561257852652, 0.3258438999196809, 0.03416497307632824, -0.4314424200188695, -0.9484156720799399, -0.5466560141072315, 0.8173775206305924, -0.1541049222639258, -1.53415269483029, 1.8668381762163415, -0.1257068945789174, 2.233139713196423, 0.9430018467742859, 1.3954449486629823, -0.7495121865105037, -0.7863450251846964, 1.2157670871837367, -0.9558927420062511, 1.1014827839982093, 1.006689347446173, 0.6068158669849995, -0.5130983279214494, -0.5432283986111816, 2.460027564948702},
    {0.7564302142578181, -0.1925699752575367, 0.9429679183863596, -0.9992291073584298, -0.8453289813649413, -1.1224028611162529, 0.3004561105533286, -1.7194815309674398, -1.2737921980078386, -1.6439860721236104, 0.557512953297532, -1.3983635948722555, -1.4547313803600561, -0.7332158864743988, 3.265830913833906, 0.1471233127500876, -0.5081249752337028, 1.3233514170659597, -1.4805940730172036, 0.24356294216408916, -0.005137751879019668, -1.139735513370606, -0.9734888374541919, -1.5690533021302695, 1.1672536789784111, -0.9041006485241107, 0.640883241209332, 0.5975756781090826, -0.2583699248944439, -0.4511659170892338, 2.4189595750677975, -0.8406519866415382, -0.026043233098962726, -2.4702662854359723, -0.9352190033172116, 0.1906996376862305, -0.8364953350828002, 1.6918412782560057, -0.09320868595174277, -1.6042967865634157, -1.4950830842903713, -0.7303500013536317, -0.2579879189764205, -0.8332646396232941, -0.4434199395815452, 0.42330825264432503, -0.2712605189113294, -1.382390501769576, -2.000221513928896, -0.48076395826805246, 0.4526015075325535, 0.4501364275519582, -1.699089598717014, -0.593932312504981, -1.5059163864462017, 1.123738081405815, 0.7570217228845578, -1.9277209711407401, 1.2398648388172784, 0.761225232850095, 0.30367325930325584, -1.1029489429754575, 0.11122695614421306, -0.3583649022660382},
    {-1.6584721105560924, 1.8042504994372366, -0.11421560669728059, 1.0027980679146804, -0.7346948385524152, 2.2343865799542795, 0.6974766056698519, 0.4140317857989971, 0.2045656350148711, -0.8132788136236856, -0.4106352359224915, -0.4054570687346982, -0.46401227200605344, -1.1513126207652418, -0.5036301352030779, -0.00818630383883178, -1.6639992113064919, 1.4444248603705867, 0.2924316962746677, 0.3053031204049237, -2.3421114770658793, 0.8065303800462995, 0.6733973905526363, -0.2663577955517128, 0.0022196320585670067, -1.3412805228865274, 0.38463891429647695, -0.696262665433427, 0.36643446194500845, -0.32602137350221005, 0.32347676794307056, -0.534047391651265, 1.4256083055000541, -2.153437792654051, 0.08693137236983628, -0.0665027628613194, -0.5545902250967634, -1.0509059506856053, 0.7832928005382583, 0.07356074204892425, 1.507797920862821, 0.6721854186144824, 1.183391363267058, 0.5810844668837224, 2.664092382574844, -1.2774652925609016, 0.8318991717538184, -1.411366591805921, 1.1540733612826564, -0.32927855318446164, -0.7047698449173637, -0.7083458546349619, 0.3913758785282655, -1.601190055241067, 1.7444946857561174, -1.1347041276689722, 0.060334723272137035, 0.9885413317454842, 1.5537811156629011, 1.1042119935405976, -1.5886375686881278, -0.6702017887977216, -2.0478603329434617, 0.6835821233050556},
    {-0.06798735719420704, -1.0002389901038617, -0.18667600032588594, 1.0721475495323791, 1.4028078587615926, 1.0523404639393252, 2.00718037828617, 0.4528579817720332, -0.36584175377971034, -1.68448711226109, 0.7506805001078009, 0.47315815587450233, 0.33193446140495364, 0.7597291014447336, 0.5430098513947955, 2.2191895629694027, 1.8958309184938447, 0.9901745245245132, -1.5121351407196613, -0.8962145821613422, 0.35300592059505637, -0.13089496317730154, -1.3251848505628177, 0.26273832818241555, 0.2504418878104997, -0.5120822522100772, -0.6419688951652732, 3.2683231276401985, 0.4728179035226434, 2.3390416929612727, -1.2294570961252724, 1.0678356830032556, 0.2291281539852832, 0.884182344137925, -1.417101901688897, -0.02261549507366985, -0.9811517767789947, -0.550383484111653, 0.09616467740861556, -0.19839404692437151, 1.388106188033249, -0.7995473344578067, -1.2672285800649994, -1.946984350655515, 0.46416956099005663, 1.9280753988406902, 0.14503829713968372, -0.41646857578988, -0.22730797976550796, -0.20265854047818266, -0.08489858877843459, 0.5334302630699768, 0.5120990502374363, -0.5094128960859005, 0.5516958134573074, 0.4950808311850339, 0.5348785482126758, 0.15540725846788575, 1.7443732329605681, 1.0850478393282301, 0.6745268406694394, 1.1186441082868315, -1.0704508119739373, -0.16908024636398658},
    {1.0236851368257678, 1.8717092233953612, -1.2014170663907902, -0.15957556227658676, 0.5837656476194474, 0.42935850706815876, 1.5686387214540591, 0.8064050479894666, -0.29467508893236194, -0.1087494768922513, 0.3597282415637269, -0.7163871817676828, -0.7382044388552605, 0.10494551505264134, 0.5262374546976011, -0.6584905544420494, 0.561144151069015, -1.340171297244652, -0.41347230851511074, 0.75653366605615, 0.4113178275056631, -1.2035341538747901, -1.479207593647917, -1.4159318788743525, 1.7331628612082322, 0.22773553755644685, 1.379251870674239, -0.9836274815200688, 0.3406707647039509, -0.05556793155336383, 1.95962992412803, 0.23246047971700617, -0.9212460174573304, 1.1117618634020092, 1.0998258052190695, 0.053025726124112715, -1.6907077000284276, -2.6547612441187383, 0.7784825104887635, -1.8997735078316222, -1.5790247025486939, -1.2375455345250603, -1.0911660807046506, 0.10469803987774576, 2.853489557813795, 2.108166712090835, -1.4205888965003053, -1.1076322956108013, 0.45216849568718875, -0.14886235766633107, 0.6751269689320762, -1.6670754586099292, 1.3660262913408998, -0.9636217098524659, -1.1522557783993874, 0.20228070435635293, 1.5101255488203105, -0.5461035777638036, 0.1886752997468351, 0.853561854348351, 0.20934989985601707, 0.27863983557159544, -1.665935343092366, -1.694743476438036},
    {-2.101318983834579, -1.4498671538200472, 0.13087527449830913, -3.385016739349561, -0.02586882323886735, 0.8515944348304016, -0.9030859273419736, -1.8589624036018964, -0.9134702677452018, -0.1825065701893146, 0.8268161033546442, -1.846975612848153, -1.0188839517610846, 0.13997897826521336, -0.32197852547239325, -1.3814759602620565, -0.9876541923207472, -0.2510831528760395, -1.0661225034191657, -0.3008087713520172, 1.6292417301600908, -0.1526074061825027, -0.748965424569911, 0.12273716158097896, -0.33356455846182836, 1.1576705579932516, 0.22370670260126632, -1.7426050227376721, 0.4336425578055217, 0.7103416432017068, -1.0623544992108451, 0.21316557931020655, 0.7547562975418096, -0.583329634612575, 2.322198732660103, -0.017009620127976143, 1.5940687122873805, 1.2820350199395085, -2.5062788111465855, -1.5562583242236692, -0.25235656637735404, -0.910741619229675, 1.526909625690926, -0.6427386222690671, 1.3872182513957718, 0.2693171556857098, 0.4146507789997853, -0.5613332869036258, -0.8397984414759198, -1.7630633276235144, 1.3951420547015012, -2.0932666639466126, -1.6675007046424686, 1.7667946700387491, -0.7907060934606192, -0.17562848886439578, -1.430092189181734, 0.7312705585117834, 0.04638893593542968, -0.2805187146744599, -1.016764493631431, 0.5133257839892686, 1.076719175473169, -1.141834765309165},
    {1.3707073590508743, 0.9079746252359543, -1.0335102479485818, -0.1382752673324499, 0.5245631371003249, 1.0048174273978734, -2.492214809134116, -0.4539050114386469, -1.3795708603703016, 1.2604224019216892, 0.855321004859957, -0.37175999020169764, 0.8713953725231791, -0.6292283544686014, -0.590890317376836, -0.30570552297955533, 0.871057548498794, 0.35995001761359363, 1.1389644369235046, -1.2337172267295955, -0.4260363421278903, -0.47634037901330634, 1.0055522468864924, 2.222154937525177, 0.065278138392668, 1.113976370627348, 1.6886534233041623, 0.5956674543236694, 0.6695669535195609, -0.5166088860712563, 0.5543333663058171, -3.178331957226269, -0.7193843442300667, 0.8074398879400801, -0.3104969503120128, 1.0827731030439802, 1.6237377285432624, -1.5185885181515124, -0.7567810840451206, 1.710426037522378, -0.3507145964850408, -0.4376742367549706, -0.657010337921379, 0.9111122155357333, -0.4793050515615324, -1.9289392087559947, 0.2487408415121035, 0.08747041050826394, 0.9286503666735526, 0.4225552453929492, -2.427270066005758, -0.2788925763527386, -0.2954903934334109, -1.5502261184575028, -0.4351753953509755, -1.3802689225047786, -2.5863346187012017, 0.12180164337696164, 2.1895629500348024, 1.8389190417308314, 0.6662082233467843, 0.8039647236208272, -1.8184713404378976, 0.6104070754935323},
    {-1.253686020541761, -0.26050683121286555, -0.632242858158762, -1.3437822005732434, 0.5513644641672224, 1.1898105932975647, -0.9118534659548881, 0.6419251261022985, 0.8834018975740795, -0.1125911093647892, 0.6613206509519799, -0.8525478634227733, 2.9948784380871385, -0.0035548419915795225, -2.6734701396868346, 0.5455200395127947, -0.7655799570049895, -0.7169268714256953, -1.024673348153552, -0.878343096949235, 0.11232775300500647, -0.3204124421294292, 2.0984334287797344, -0.9618005496458438, 1.121560748332004, -0.11560580877777805, 0.957160121094048, -0.4091150589143769, -0.7420950980167523, -0.2745052968104907, 1.746432249727708, -2.3039881167641916, -1.8459450038412093, -1.4613951109407406, -0.3005879169457081, -1.1228158665039836, -0.34975884842195704, -0.40707265794912906, -1.2695316412328106, -0.16477054689112003, 1.5612762673772167, 0.15483961129896123, -0.8819208415969018, -1.326816618650205, -0.9471383537403166, -0.18296081246612733, 3.241914950096302, -0.8585172219959242, 0.8135261038351725, 0.3291764466186781, 0.30148693054111186, -0.2607920867184898, 0.5659364334638619, -0.6319586764399238, 0.9180552240657007, 0.6225156426935936, 0.22980782899710117, -1.0760543585868814, 0.857281483810816, 0.8731998595637186, -0.49999814034851464, 1.5959909719877703, 0.9991779449547008, 0.4599580102971423},
    {-0.5646514051431892, -2.152460491054903, 0.5996325525821511, -0.09269362121191312, 1.8565334546852912, 0.4412973779192065, 1.0085267502761055, -0.5553516471744798, 0.0063053767149020045, 0.8016575776787321, -0.7244213692491794, -0.8388064052737202, -1.47262585391096, -0.28988430339423704, 0.14375846446024756, -0.023490772298402636, -1.1136373921185525, 1.5174208793171287, -1.318657807736048, 0.8027888199142701, 1.5061463108874025, -0.8622187523404246, 1.2734987116384822, 0.18019062260656576, 0.31951871957447797, 0.7214605021569425, 2.0945949951380842, -0.8797805823401682, -0.7622950256593677, 0.5812182782782814, -0.8546807643803596, -1.0546432810176316, -0.8954879118838576, 0.09776250305003104, -0.3822181701512603, 0.09443486441654773, 0.877334324050632, 0.2279922244791735, -1.9790358554670293, 1.2547406213452281, 0.0935359997252867, -0.5128365034681314, -0.0629087787435381, 0.6255705668415924, 0.7672619790023546, -0.8032027049928238, -0.12388867802931257, -0.6646685386547705, -1.0233045450952662, 1.723810006630685, 1.5982724980763157, 0.28998118013017693, 2.2458749752412555, 0.3089741679230734, 1.1666117269535854, -0.49226198907187346, -1.1078432948061838, 2.248993246445308, -1.0308650293848622, -0.9144326967279534, 2.169579416052695, -0.1881576216283535, 0.24055741304832012, -0.4541062742370129},
    {-0.3530224940295235, 1.5482427513443755, -1.0293204753968102, -0.8086513603619548, 1.2178029414407157, 1.4695014814309437, 0.12478771648462304, -0.6316637798190182, 2.134168825533691, -0.9874401554609319, -1.1585904624912602, -2.8698524145937903, -1.0939062415724536, -0.806198287300798, -1.4667449694549495, -1.4859933902675633, 0.49632669177284083, 0.14828636325882363, -1.1791530343340464, 2.0286867937262247, 0.713357864274086, 0.2235268298192397, -1.0812265713148033, -0.778600889162485, -0.5747972554122913, 3.072265030023752, 1.2694112688491093, -0.3393905324947524, -0.19913865014235166, 0.015993859712803093, -0.7691997405921271, -0.18003802761137863, 0.08471197128651688, 0.014522942686421588, 1.6450999438063767, 0.39050311529776355, 0.6287315820465094, 1.0475718534560627, 1.3116863941880608, -0.2594209414998488, -0.9870113973907985, -0.08899568087223794, -2.1538744991966428, 0.5369553541656644, -2.825200196215594, -0.4314291038462012, 2.601394301026293, 0.5115846956754575, 2.2461542093801556, 0.3239671556433391, 0.5841813249209389, -0.3277155972101445, -0.6154862560297906, 0.05882546132765895, -2.1309123192719883, 2.4102059372970794, 0.15184296060980615, -0.08546418497479363, -0.266464871171662, 0.13015772284543986, -0.1824576800265468, 0.10565598638482436, -0.8389212041937352, -0.7267804977417565},
    {-1.1672875789127266, 1.531435805290457, -0.7139171000411204, -0.603546181263335, -0.9731324277834924, 0.04982410391178592, -0.15224951948183363, 0.5098291840833385, -0.35590483334145373, 1.1887178970390688, 0.09502413487489904, -0.050785787031769954, -0.821153798300205, -1.1912471867989896, 0.033650614991441584, -0.012383662382118915, 0.06891755703322114, 0.7554372622553568, -0.512397118032867, -2.5950865717484466, -0.8311136968992329, -0.07089584692190441, -0.664845788442973, -1.1193224133636719, 1.494691557884045, 0.09017036171188904, 0.5286364950459301, 1.0932935362353104, -2.5941582396045786, -2.160021382733267, 0.5276404015103721, 0.4327295593676792, -0.2893668704543393, -0.3570290655457434, 1.1946808499025534, -1.262621380284198, -0.2017794422037611, -1.5207194647422306, -0.34250225085958297, 0.013888053961417977, 0.5197666877587873, 1.2283245011500419, 0.4719329030960756, 1.1110277521254976, -1.7143236316405477, 1.6541911704278847, -0.7826043809049629, -0.7235858858487643, 0.4913681267361359, 0.9585442909229839, -1.6645146643526756, 0.3013005251219964, 0.9204165791101562, 0.6545847776336127, -0.31127690287682225, -0.5825148699456335, 0.4651634374384467, 0.2951283442488953, -0.34630601399767813, 0.4827903935822911, 0.3221717340932851, -0.06962627289334111, -0.18463536357831847, 0.3280344276838018},
    {-1.9008928100988347, 0.6005115797971384, 2.740902414233878, -0.1402710703782525, -0.3367488022380671, 0.6580262841378106, -0.7945722021898748, 0.33936319822473987, 2.052086961426958, 0.5070147410054875, -0.9357001778587516, -0.6760895373507073, 1.2452734539290597, -0.8561546760380631, 0.7364432853796599, 1.3471413187570218, -0.5833375122718412, -0.251573613267317, -2.63403381678696, -0.911844569994744, -0.0689045932622083, 0.5375000691921571, 1.5577094922854011, -0.4749315804756073, -0.18248688361470722, 0.033907437030634036, 1.328476691638024, -2.0897340464951695, 0.13965736385092223, 0.40577281987615627, -2.465318408183918, 0.8640491913624317, 0.7317640098861024, 1.0729059472479083, -1.405547280073429, -0.77984530478785, -1.1577570312309782, 0.25728587343439147, 0.8053643385630098, -0.2581285506728593, 0.8280162732946436, -0.247858425266766, -0.2709708046393045, -1.3702649625511834, -1.6688637647099227, 0.08950420353468645, -0.10440812114662912, -0.47850801230171514, -3.404837851533944, -0.8540106773221849, -0.015783518089868984, 0.3685601667994657, -0.4570132261834171, 0.7060403527406901, -0.4699944573476689, 0.664956540486864, 1.0879809603640496, -1.2874772124042309, 0.1615937698725372, -1.0913479890842586, -0.9239661971495647, 1.0363109107621957, 0.4637863520812072, -0.676651465392599},
    {-1.6415019998507767, -0.8313973991049416, -0.45498658501691486, -1.490192169812737, -0.9846810725312188, -2.408417631477149, -0.5461572666314982, 0.9825880194746267, 1.3116770434063167, 2.8423721069332193, -2.2905327513249363, -1.4819964245667323, -0.7812760820331399, 0.6027914919583617, -0.8239182923733515, -0.3697242078111791, -1.2398576597248043, -1.438955840765872, -1.0858447018341435, -2.234750834342785, 0.25646543134126226, 0.0731928919083876, 0.09800491635414472, 0.42961977568317594, 2.295306277428869, -1.0367390090026132, -0.9829262340842335, 0.21740282601206398, -1.6365007717247064, -0.4239817617146113, -1.0808347111612666, -0.7308208319069814, 0.37678062934312284, -1.367349869543069, -0.1976456724536214, -0.6203650167293444, 1.1362551414535045, -2.463765819368207, -0.359225509658925, -0.19354765910000588, 2.6448913018949085, -1.0632468993446171, -2.131716686835054, -0.4248966325976892, -0.06949772502855182, -1.0571521277744693, -1.3916637885587813, 0.29841355423301585, -1.2921529326408039, 0.0645044566344746, 0.22217563793093098, -2.0743434003066623, -1.7527848771259038, -1.6061354678621549, -0.014478987779622065, 2.373914424879634, -0.8081455269972022, -0.18238996455721723, -1.979201787762088, 1.3747063735994813, 1.1085172870788762, -1.020784602720769, -2.9246889927445094, -1.589234170663816},
    {-1.0032852811580786, 0.8313392462805744, 0.7912875598060302, 0.4407871101194565, -0.7526410707021284, 0.6704001170003824, 1.6396423261993185, 0.14632449917830506, 0.5547716860936183, 0.6166800630411616, 1.6875167740713435, 0.5140733724083836, -0.9776132376148682, 0.9371873106929275, 0.7985389918197375, -0.9070408078993021, 0.8120780444783611, -0.2928591686537642, 0.03034344772704817, 0.7103843707750258, -1.6589703581180293, -0.4715563912910153, -1.090191985242036, -1.1107176503230938, -0.51402918992061, -1.4714441353213426, 0.29100116416321936, -0.3886095802553093, -1.0031836003935815, -0.11501013864895558, 2.6059437171865407, 1.7265616651516875, -1.4296377912347198, -0.03265442012773765, 1.1335751276783856, 1.021593677847196, 0.3992984038355755, -2.1345062340006917, -0.908215010224822, 0.05950070177899425, -0.32222294108773325, -0.2254885082772704, 0.6617286885221333, -3.081905983142635, 0.798204033875502, 0.660192331801923, -0.8132386163453258, 0.10545725127427545, 0.007536181219670647, 0.19607241428462172, -0.017425507074625052, -1.992205891041047, -2.1257844867685076, 0.696312257094686, -2.2357587063853397, 2.3428862314747847, 2.318581063746087, -1.4817332734415058, -0.32282904889707537, 0.7501393906841483, 1.197814682690147, -0.5606469464248232, 0.22831952456992974, 0.8877918800490514},
    {0.5154976722476421, -1.1398173010210368, -1.4911330489821655, -1.9150756126779283, -0.05548133415096302, 1.3890810601183112, 1.2105933941395586, 0.5875566937002824, -1.2101266326201559, -1.4509833331867854, -1.0193825452113456, 0.5781004779895818, -0.3256785067706213, -0.2594577000042284, -1.7223005138980247, -1.2703167839706613, -1.4610531650269851, -0.0032209496265907206, 1.5592978071317327, 1.045736662237356, 0.45000461468711206, 0.6272047863496336, -0.49770030390217285, -1.882394954116014, -1.7221457937330773, -0.8264567265524634, 0.6206424997059721, -0.2865922316914131, 0.33789851274956273, -0.007449550633490082, 0.6964402811528858, 0.15276192582926032, -0.04411240952519011, 3.4470439416255156, 0.09499321357772621, 0.5159828565546236, 0.7254088764092828, -0.3413152680776082, -1.3109447638660896, 1.1439834519226706, -1.5876692251825186, -0.39895326076507365, 0.6847004510019787, 0.4853705541976345, 0.0749110360025586, -0.07702704918369305, 1.2769265607263034, 0.1373519519634375, -0.27057002486439735, 0.16159893457005392, 0.6470643429949021, 2.8596305757043736, -0.9767920144764569, -0.06429045959234421, 1.4029050468434627, -0.9945328453210333, 0.10188240810062413, -0.5271056784991499, 0.30054609431833396, -0.36130126190494805, -1.053843044650225, -0.38058461107027985, 0.9132467786267201, 0.9933971250330033},
    {-2.077989553125261, -0.5889839453178074, 0.041463245672806036, 2.536473915184309, 1.4303582097005545, 0.6185569013478032, 0.1886489804545807, -0.5213733653875973, 0.3030546814434602, -0.506371047772268, 1.7845095051101805, 1.197721816083299, -0.21754543675022356, -1.3454531009034392, -1.6527479721165732, -0.5137770365471267, -1.709697755216756, -0.6323161201251433, 0.8403879215282255, -0.029733431988450538, -1.322463730142412, -0.6283113433274162, -1.0612577590436227, 0.7547524772670561, 0.3333015085785068, -0.38414410678337924, -0.7049761496424061, 0.12045843244105585, -0.5762687051189297, 1.3152771004542505, 0.25819235540480384, 0.4425464719183354, -0.7486759346598347, 0.12135950199331734, -0.7159448141427718, -1.2826274770306065, 0.35807645883014005, -0.6678499575069846, 2.0082151832301873, 1.8057519095910464, -0.8659915274975735, 0.9070823728524439, -0.838655524035648, -0.41066262002604964, -0.6946501231917056, 1.1943713227226969, 1.1057607291620541, -1.5535711644822987, -0.8032989162103172, 2.2383261150688, -1.5407716730765546, 0.4494139118540854, -0.1810744285847852, 0.8651263718192524, 0.04200580778515858, 0.009103912874004664, -0.48771200510449864, 2.4031299281414253, 0.03004889554246013, 1.2065608065163507, 1.0781472912242767, -1.2016259087060344, 0.18198974739310708, 0.9167262623357035},
    {0.4835839454981711, 0.483611799408251, -1.3698112575952521, -0.056022248939261325, 0.7947934348068687, -1.1547688665784137, 0.499762694066086, -0.7520851971577212, 0.8011648890674304, 0.7416226631901572, 0.4385734851696663, 1.2276951174267539, 1.104535798180699, 0.7435354820402093, -1.4415551885903297, 1.6001753683147546, -2.519378290821721, 2.374208913837151, -0.4573293944226638, -0.8299677355581423, 0.12244132536472793, -0.836915763509476, 0.9484054263047987, 1.8382735889490174, -0.31150645220837997, 0.35286443244516924, 0.3737897199114352, 1.1227279047388194, 0.8465962578891566, -0.9351498678115893, 1.69737915546428, -0.20885185921993024, -1.3772781141172248, 1.000682914998745, -3.0820662258297182, 0.34129834899249933, -0.6253117499129164, 0.5458297937645522, 1.6674504322310355, 0.7899105621498077, 0.02849109004475812, -0.21610927246565292, -0.2886251157657826, -1.1229739107646983, -0.8611901796460882, -1.0566254783711289, -0.558035805467963, -1.5441961910959148, 0.6449262364435594, -0.4949243138785479, 0.7084718414766138, -0.6639744282754778, 0.14293454683844772, -0.2201049387138548, -0.20518306511198578, -0.5945861191641783, -2.360935938900933, -1.411688577888321, -0.8256562886212687, -0.6017116054939228, 2.1659428101871985, 0.5462983582337757, -0.349291983185158, 0.8051192277090667},
    {-0.9173815162846642, 1.6476437564451658, 0.893761232562832, 1.2157648461532637, 1.099510243443932, 0.09386285664420355, 0.2722778499247579, -0.201455478738393, -1.7902803867499195, 0.7326577036904564, -0.3203983797208294, -0.0070931646159309095, 1.1224527171101104, 0.09709205527063516, 2.0518221322795456, 1.1642374534364213, 2.4053641379243564, 0.6059391847247806, -0.38575516375728663, -0.33805105372313443, 0.7664719925848386, 0.13336169641266313, -0.2932102075469918, 0.6492533431040002, 1.3290131517129018, 1.0377751929090675, -0.6474433323991193, 1.2066728159169262, 0.7641486550879021, -2.002994085713439, 0.26592340511529156, 0.6717265417418901, -2.2012827716669627, -1.9133717333981994, -0.7400489580989218, -0.18315976312953147, -0.03804360321674953, -1.3029201630208271, 0.026739759047383006, 0.03896209058156322, -0.9184348265200738, -1.1884950201354596, -0.7530110972016978, 2.1544544880446015, -0.3728745377050711, -1.2749559317142367, -1.384126958263054, -1.1539944633808619, -0.06172981461460308, -0.583063379198097, -1.4683174215691197, 0.39631184457032587, 0.2840858920386866, 0.24459766887959494, 0.10960045303800206, -1.0008163695084005, 1.4529101266520785, -0.8423684519843216, -1.6368534748141692, -0.6487354830345842, -2.0661199324464126, -0.18765904339099287, 2.0497250904502007, -1.9618841181003424},
    {1.0594562608674087, 0.6279704213335404, -1.059448040096825, 0.42594203645354417, -0.5259847739704313, -0.874499511730063, 0.006045089193602161, 0.10044437939320039, 0.7554274832727844, 1.00338784365301, -2.2441390912526167, 0.4016042436533826, 0.061312905878179405, -0.11151702720238926, 0.0780765333609548, 0.42297369713887545, 1.7027342687145686, -0.37959471490484165, 0.22460025323977634, -1.544551819515283, -0.6603711365432249, -1.4768540324450599, -1.216726779493006, -1.0512038437231233, 0.36226496891654225, -1.174946698207698, 0.7149634021735021, 0.9221341507710379, -0.32324718964169186, 0.1698553951425002, 0.12051757815396595, 0.15282771887325136, -1.721614166782432, -1.1551058055609622, 0.37427758161726143, -1.1066767760136513, -1.9077269103891767, 0.0105962057191925, -0.669975457863607, 0.9441944848484156, -1.652604690488494, -2.074516141488929, 1.0309146737954438, -1.3937919072493747, 0.6042505971701629, -0.5251847143431118, -1.2506929918766667, -1.738054556501867, 0.10497739118723683, -0.38025250158567253, 0.8395834869610209, 0.4484470577245725, 2.792068416424504, 1.5558184434974123, 1.7853409458919904, -0.030739260349727543, 0.30848323558838076, -2.276248544370849, -0.9834566098047345, 0.40941643740932365, -1.830941121525762, 1.4209345135183578, 0.9698184322350402, -1.0293444373134384}
};

static const float b1[64] = {1.664002321057474, 0.4141282660025383, 1.3106763889395252, 1.7705330509963448, 1.6347344158981665, 1.8943716993354391, 1.7934433420381473, 1.2836616178484235, 1.7028945943033622, 1.0783608553738147, 1.8879376680706883, 1.5303573978403515, 1.8772414969905815, 1.1772449206243267, 2.0833368110995267, 1.7479310491949844, 1.90023041579773, 1.7371690216233604, 2.057935369379742, 1.4358388905021335, 1.5921634904953155, 1.909318094465345, 2.110577292353859, 1.8724103845062061, 1.579400785607587, 1.6366410009574603, 1.8699789065994366, 1.6585832504732534, 1.5160135842221372, 1.105030400538577, 1.3625435088244058, 1.8564754406724446, 1.4720866946776616, 1.671498347282161, 0.9589976213560935, 1.5328616462616216, 1.8429011595971714, 1.758176049993203, 1.435815759952762, 1.5144045220634534, 1.9477754002221468, 1.763055736627976, 2.148074484497401, 1.6745314986359547, 1.668251137710516, 1.3064856924750414, 1.7412461259945553, 1.8992887780873433, 1.4559324840103878, 1.8744929224024873, 1.1645307669897162, 0.8404701370149, 1.6240313840384664, 1.6720486949166204, 1.8610230141750905, 1.2088978450221062, 1.9954435500760184, 0.4443563432140842, 2.029727928525738, 1.6057926258422608, 2.0644261246500593, 0.6473882814178046, -0.2676228766157292, 1.6855286894323296};

static const float w2[64][32] = {
    {0.3323714423046802, 0.6565646928314035, 1.382103635224562, 1.228477934679389, 1.6007842623048254, -0.5224143136303194, 0.3365041699076229, -0.9163006312340083, 3.124615020629315, 2.851404922765038, 0.09798393398562133, -0.2138293146936254, 3.6529279582275564, 2.6386909255689655, 0.3285431888613113, 1.3667120593036302, 0.2820036924823419, -0.16619112823305615, 0.7967233261608172, 0.4976776999469269, 1.824534279099285, 2.9841570785264437, 1.5344662884339892, 1.911698094466373, 0.8423815171649591, 1.4861654516068008, 0.13872972053314497, 3.9692295541093934, 1.705440349341981, 0.6608728454679367, 0.7085571987560672, 1.4660480382037722},
    {2.090201114563517, -0.39374239980341613, 0.13937398000729587, 2.0259830125512783, -0.4956508557001595, -0.43376490126047196, 0.5736377664648639, -0.7433351755810103, -1.062870326703734, 0.3680525260029481, -0.1203514612813899, 0.06814972390164742, -1.0111777900065748, -1.3076761758260202, 0.8948772033820469, 0.8824439762523135, 2.5807430743554503, -0.864084593275426, -0.31203176084880263, 1.8201159533812306, -0.741395556767732, 0.08691082895224778, 0.2742656215762665, 2.0738050338135317, -0.3124918252114371, 0.33358808872595874, 0.2943702504377106, 0.8976483797047974, 0.48860095205731796, 1.7484314829009546, 1.16925887104171, -1.1093063629548061},
    {0.4733590161412582, -0.780131395493992, 1.4154999261873087, -1.007226532997262, 0.8561524437761286, 0.9984380014551086, 0.5824516469528093, -0.6849791080530605, -1.3565378356737872, 0.3001673232643094, 1.3139464028036671, 0.15503859585910093, 2.846239114495989, 1.7464332413892392, 0.17789972965736897, -0.5078997252310654, 1.8445654332688017, 1.1000156550263056, -2.6588268034905758, -1.3858188758428045, 1.923779981920446, 1.0602322375597502, 1.4749948576128118, 1.7202470177246705, -0.8867849470667338, 0.8375349025098245, -1.0065427265293154, 0.27525380710688324, 2.4183447971420162, 2.942428585915194, 2.51746716101802, -1.628666674574795},
    {1.7094593916298568, 0.7160556300534423, -0.3064393090171686, 1.2037777921035944, 2.27788036929815, 2.601184758523226, 0.10606129178278245, -0.36835264689751, 1.452658814882977, 1.3481921894641355, -0.48860255477539866, -0.05166654210514101, 1.5655687392367612, 1.776523724723219, 3.460917421506482, 1.10117184251741, 2.139119495225356, -1.6156225619000892, -1.7281066788427626, 0.699227623290126, 2.0699434334597884, -0.058011289679609127, 0.47615527339475505, 1.7085006332526493, 1.122685345090261, 2.014239553807791, -0.40870619814657716, 2.9234961113193663, 0.5918259365260644, 0.6874919310746219, -0.02053221072835142, -0.9712587048334402},
    {2.226966454065642, 0.8967035043569367, 1.488266897048134, 1.602436605582851, -0.2263515901819443, 0.4436826525008517, 1.865507226369706, 1.1323953336773547, 2.3435737529375396, 2.709134940019012, -0.277490538367113, 1.9178356135693386, 2.274227138579722, 1.6082563390477902, 1.9969279128001625, -0.12941986420790372, 0.7431347471153634, -0.18868500086860002, -0.2481595438548135, -0.7047038052020497, 2.9128499236507923, 0.8475695282103143, -0.6468692791681914, 1.406256337507577, 0.19094549432222133, 0.4768834607889963, 0.7347808257130582, 1.7801644818198, 1.9043585948552626, 1.2878441562390712, 3.055436240336928, 0.2013286852047826},
    {1.2756951727972752, -0.4698952257415667, 0.6858420209503989, 2.2155351887714803, 1.6834189892129723, 0.9239827134996429, -0.08026946571464798, 0.16253013122833157, 1.292510154539564, 0.48327369852676216, 1.1305629294676938, 0.848196559289247, 0.0038386429364171367, 2.7132587708543783, 0.6512755139027329, 1.65137082603603, 1.7761962815798817, -0.6307040453340821, -1.4248305709668296, -0.3018827123373267, 1.3684768842886, 1.2118615023032464, 1.5028984196271074, 1.9344294765327406, 0.3400621420133632, 1.6841699975184803, -0.5274835369824851, 2.5713923045987124, 1.2326792607666472, 0.8703038605268731, 2.0142877705625213, -0.30545000581353554},
    {0.3083487889544864, 0.5096355252803897, 0.4603816098487662, 0.9037123220411114, -0.7939275385765628, -0.6687980674615546, 1.1245948516865716, -1.2368263802434423, 0.8422796568358693, 1.6077475467075166, -0.038186326348962754, -0.04655731425660285, 0.7715403914583255, 1.9501260511360405, 0.5749584510444957, 1.8035052067015298, 0.7669255896943644, 0.5640551779649665, -0.9993067837988249, -0.17618849556936278, 0.9758892202457756, 0.6454138031972749, 1.24105474818016, 1.2076967427079222, 1.2884651921344854, 1.0761607625446774, 1.2590434841132545, 1.464328377543809, 3.222665129974799, 0.3416971368036083, 0.4440455786484461, -0.24850144773065977},
    {0.7803685607497406, 0.03232030401191515, 1.8107344697099879, -0.45023562486968, 0.22421174103000702, 0.6233521115589776, 1.3873219688733494, -1.607577136685962, 1.7712095890434023, -0.42276205148564766, -1.1664735175664018, -1.0588642233377679, -0.04955199062956534, 2.0554143351873044, -0.11362482879537658, 1.8610373255807569, -0.04850834511216739, -0.31777797578954936, -0.4901608361282511, -1.007339240448148, 1.3855953478220568, -1.1166387154822024, 0.8594471585942719, 2.173364866384858, 0.523861869466212, 3.81449488908634, -1.5472038847939205, 1.238178295709611, 0.01651398974315228, 1.0559857506737973, 1.0069545840649796, 0.8548257115221282},
    {0.7816419100485269, 0.5297253402495513, 1.0645654429969786, 0.959929268956364, 0.7292210849233535, 0.6007729972861293, 0.7122201652211004, 1.0158220872340535, 2.5355641023058717, 0.26556771008100793, -0.25548610807839284, 0.7925572690245902, -0.5685271018952008, 1.4592004029112655, -0.24248426476226645, 1.730372774101083, 1.0516832486501166, -0.07437927184224864, -0.9888699860307194, -1.562377818445821, -0.7913409951715059, 2.8797569532684255, 1.4169912849809991, 1.9054943292839186, -0.7208799516397928, 1.8315818713911174, 0.9017000158949526, 1.5203201915178206, 3.1615862841988656, -0.9298992837077648, 0.11509416402926242, -0.02807418795880639},
    {0.03506604115950208, 2.0069871087663476, 1.4221503804256668, 0.2463159739141428, 0.5679974007394167, 1.1327435788849467, 1.9640925928481032, 0.1644473920347147, 0.3486540606984481, 1.127851103695108, 1.0289538604732988, -0.17977902470129212, 0.3624906022033374, 0.4322240936319852, -0.39704866852075743, 2.360152102367387, 2.136339040321878, -0.6635704086533899, -0.5516952163858329, -0.41313453584485976, -0.3002965025019557, 0.9436726861101394, -0.028785680991344063, -0.1991257984266429, 1.0306471245149365, 1.2282523952594004, -0.1894608525364842, 0.414395140708697, 0.9046491659196335, 2.6445801162279845, 1.858113147438831, -2.0644629863400477},
    {0.43178895099324494, 0.46137026551372706, -0.40632370039347127, 2.3536363827563562, 0.9045925077239914, 1.4928617891952278, -0.11444393254820992, 0.7204293565950671, 0.9037886397212057, -0.46181168484867224, 0.863020295531527, 1.422884567658342, 1.8354370220014062, 1.0514883753228017, 2.712065078447675, 1.2510606944016214, 1.9199441298704611, 0.5056183546101063, -1.5432046587388808, -0.12046240162377508, 0.6952970943670699, 0.5910913787460633, 1.224800345991345, 0.6625251715731627, 1.5403801122566119, 1.8982622727524407, -0.5589292606132824, 1.7648101155209894, 2.759888893920108, 1.3692110629031808, 0.6092049707070158, 0.03086485830007598},
    {0.46860733970891605, -0.07989713308891709, 1.614248406058182, 0.33382638349068217, -0.461423316390115, 1.8135570821136102, 0.30244072792393134, 0.13056905960426465, 1.6337108227366695, 0.5401099698179382, 0.34604799065400504, 1.242240217160117, 1.3568459867879386, 0.6941518144837331, 1.8305193620973998, 1.7136237515767263, 1.3958264327785466, 0.4924120897279088, -1.21086034098604, -0.33306366003324595, -0.009024677074841631, 1.7513767786615875, 0.9459495651392417, 1.409086960281288, -0.2880655424455014, 0.9097557742455191, -2.22722991668969, 1.034753469398644, 0.3415356082658297, 1.6830605611316878, 0.3529833375861691, 1.7094058249549355},
    {1.620590391449496, -2.0172771450920908, 0.6363519225048374, 2.172387476510207, 0.22148737860777323, 1.103194641225716, 1.1472301423625917, 0.7571285631704735, 1.4628895570063694, 0.3524905729433343, 0.37595496527826466, 0.6302694666493383, -0.29177674902360806, 2.102967606556814, 2.555520789659774, 2.0441194498608697, 0.8817317575222229, -1.9537056901028045, 1.906718231993083, -1.234762272354133, 1.0904494755171548, 0.01389851480829016, -0.6744913688487274, 1.001527489183648, 1.5742317059713582, 1.1516670967067406, -0.5141718278027938, 1.0947787528458381, 2.2160195852787536, 0.33739953413568347, 4.269941834981197, -0.7830493478468494},
    {0.20417497472379015, 0.3173778556046363, 1.4233820518563491, -0.3692736267203125, 1.1426120025505517, -1.0007173964925733, -0.3120969935034683, 0.28913207906345106, 0.697762108686397, 0.6021452467320713, 2.522567131469107, 1.9451106595811452, 2.184091959562975, 3.009799693634227, -0.3001734406603981, 2.029839204157522, 0.5887808501405942, 0.1514159404114015, 1.6629489460081321, 1.229400427860334, 2.3592516931787344, 1.1232453352735297, 0.5978580642599128, 0.8193455283875485, 1.8845636596484487, 1.2489565521216281, 0.7418179315427859, 2.6337611840833386, 1.0960402170526458, -0.8677991807440609, 1.3725397804600756, 0.09737891785850264},
    {1.3162355636464276, 0.8348544378376691, 0.5150915480411565, 3.5406791278924934, 0.4341881288563343, 2.1501588409901555, 0.028885446559287944, 0.10659851772484528, 2.034817108672048, 0.9534570213131981, -0.25080745144171956, -0.40016597558443473, 0.7039773068472286, 2.2840020179329077, 2.4954841435550357, -0.05349381645162739, 1.5862005094240752, -0.38835463457468533, -1.2532468164857218, -1.644026064871549, -0.01646555693949703, 2.5666789924186357, 2.860618547551115, -0.16827189012865437, 0.5305214669981142, 2.5345955134514444, -0.21006109935585335, 0.7533295119933681, 1.7400995933040022, -0.4393980853688263, -0.25463791637335476, -1.248357267505156},
    {-0.18347938785618706, 3.034346151754681, 1.0611303506659453, 1.8190592900104883, 1.5320749660201274, -0.3645423204715912, 2.4111692104838247, -0.4898196355517214, 0.3859814443518234, 2.1464636291975094, 0.8353733463887559, 0.7539059549957927, -1.486370755201621, -0.24298422625523364, 1.3481674477288093, 2.2133664596531846, 2.8461276946244847, -0.7532617874920103, -0.15159261525170128, 0.46561990945200066, 1.4133685179500972, 1.8462441058456476, -0.12155437106167898, 1.3440453005314934, 1.0250529212587045, 1.6417949588889489, 0.6754269297375114, -0.6071868655171361, 1.5961269488835736, -0.1725821056186907, 3.1105867628701054, -0.9489245490793844},
    {-0.1580027901599922, 0.3050619657041124, 3.4554972424009742, 1.0949706837584572, 0.5631779079786322, 0.19387146851321962, 1.1310474353099629, 0.03654848277754961, 1.197099848442113, 1.4161812474581914, 1.2811395795936575, -0.1774580760684279, 1.1089451009546216, 1.6730942904958699, 2.570921849317395, 0.6473025538350884, 1.0183300503603963, -0.29355708371214284, -0.8022873498810555, 0.6212393525547549, -0.7219654767704856, 0.9510626074311611, 3.027944683719348, 0.8144124216119359, 0.19795146326917443, 0.08815388276693306, 1.894679239987683, 0.875733846347492, 2.1140486963716016, 0.25991526677911386, 1.180291695114196, 0.8383273094878932},
    {0.784021248842425, 0.8894936421817587, 2.140757976451926, 0.8013541924256509, -0.09307154814332833, 3.279892924046452, 1.2179985625687606, 0.39761008732611547, 1.6761518817662953, 0.7338078692292997, -1.215911840024348, 1.0270579102499087, -0.9112836344144619, 3.3681890978230635, 1.437081783762562, 0.9268336110371928, 1.3222251416821922, -0.22902015774307138, 1.132607336246175, -0.6077916118829672, 0.9215980445088793, -0.013603081422836009, -0.05466195201210414, 2.549927470958912, 1.906599653634596, 1.8089332038909147, -0.6987032836978969, 0.29971845266902136, 0.09162568742517646, 1.8749974396897802, 0.3389766332364977, 0.4828745336575895},
    {1.3185206631646964, 1.134290737531484, 2.6291806578690613, 1.9005707752759142, 1.5262952446762967, -0.8844022878289419, 0.927007680513445, -0.850548443474837, 1.2590194500776084, -0.07733473687379197, -0.219963227260294, -1.1054328176165964, 0.439242326178837, 1.5314868676163196, 3.0479647572346638, 2.029900365541167, 1.6195512407795702, -0.6350624010408333, -1.4054434371220137, -0.28718831481568213, 2.1652542606667082, 0.5938026327536019, 2.184546843587512, 2.0421742536066523, -0.023197834427832107, 1.7393186919216577, -1.332489298136749, 1.438404613612248, 1.8317647552379037, 1.4460206155728859, -0.38025283883401667, 1.4026837512524613},
    {-0.23674576192935107, 0.7994274004949681, 0.7324691510076055, 1.7382504108583943, 0.25288933912013595, 1.722152119530613, 2.933732278638783, 0.7328568755650963, 0.4294383696701627, -0.23864137884061687, 0.7208885492591878, 1.6896329003836197, 0.8193570103996226, -0.545259458811491, 1.2998194894925528, 0.762006941029835, 1.66109680880833, 0.8907374916815145, 1.15638056677775, 0.7938400692870732, 0.7916357223886791, 2.4496901711369556, 0.42758763285713935, 1.7063496674221508, -0.8035591198245121, 1.023401461358986, 0.7437378938387499, -0.30409153126337235, 2.147479229946078, 0.21211309022929176, 2.0804411424841276, -0.5834473704601536},
    {1.5914631871597351, 2.4184792036292238, 0.06405676411306417, 0.29551317910787256, 2.324774549956738, 0.9405847605965704, 1.7695537998097128, 0.6646558604418954, 0.7448597800050009, 0.5880094620728537, 0.6144453335852283, 0.004828432323628011, -0.47230467249285835, 1.7632664384801797, 2.997993506374323, 0.7399560471260443, 1.413471877311316, -1.7804002992852912, -0.3121170408309562, 0.6517598483699338, 0.6960542939748259, 1.7065968672888674, 1.4390378818889267, -1.4064216645270908, 0.36044036230420856, 2.859830336349809, -0.7308286073109997, -0.4617468416164427, 1.8001552800850618, 1.02803211589444, 0.17947153008967942, 0.48966587661452265},
    {-0.5941157208336124, 0.7018689204029995, 2.0982396029543233, 2.0170619613682, 1.3577873693354034, 2.4074647553978825, 1.234219979020211, -0.506462752267089, -0.8712092560618732, -0.04821282418259224, -0.45853799438139087, 1.3155432866779997, 1.6697897471633383, 1.8012202744054866, 1.262650634974598, 1.437823528938535, 2.4172211206180516, 0.22199199847170753, -1.110848131506192, -0.25157205776500513, 0.7176521047617309, 0.09416026435628098, 1.0342343994802672, 0.3394997786996395, -1.751500506449302, 1.618859455990339, -1.5117908652865228, 3.9115205022069786, 0.5578978797081241, 0.7456121961933757, 3.2488024307268555, 1.2544491005338425},
    {1.8177420080792182, 0.15037487645461628, 1.48048888921278, 3.2922839928622674, -0.3927192298076272, 0.42020017062987525, 1.6382826288948715, -1.3546196114337228, 2.5037364813022673, 0.9313826847785559, 1.2303377753593219, 1.2344984615288017, 0.6258175535870041, 1.9590392544193158, 2.504259166687073, 2.6943258149834444, -0.06671883095160046, 0.37558874170566553, -0.4762924623441599, -1.392078687873988, 1.949279993027639, 1.458962739045325, 1.4315760206532586, 0.6151223994620195, 0.3689517226372037, 1.1133394978229156, -0.8360980768144081, 0.8485157158147061, 3.5846279062003408, 1.0499339495713986, 1.1837758504310785, 0.7181046185373573},
    {0.599176392936059, -0.6901886988134389, 1.3753170786249733, 1.9586381720780184, 1.0388390889752868, 1.1426027297613524, -0.016772729876685193, 0.8618216415660546, 0.5459824980574809, 2.596391585448617, -1.0431311143626194, -0.10725186879646327, 0.20125461094831737, 1.4895204063935399, 2.129415644154717, 0.5381931524786571, 2.07996663533019, -0.4148174095340033, 0.2239345370340517, 0.5906020251884131, 2.691310120187521, 0.6699115858859345, 1.2838569471741563, 3.331122636381017, 2.6123264468358247, 0.9527666988571556, -1.823020196392801, 2.2120176796307724, 0.3265485860658522, 1.0286906556917894, 1.4548862357733454, 0.7168873957654807},
    {1.7378598468696786, -0.2410764005882485, -0.5361853206646003, 0.6343245024397344, 1.2749692876366105, 0.8758409554085593, 0.087500827668614, -0.793537945499086, 0.9909848789786561, 0.5469933299477757, 0.5848540422346614, 0.7825172527051616, -0.3187941211136003, 2.4385305854197936, 1.2961189893284324, 1.1554121395751278, 3.3785726764159256, -2.7813450885914808, 0.322005002017771, 1.2908366973934908, 0.3815485019337765, 0.2537803986188021, -0.12121669363154017, 1.6160245610435242, 0.9705118806968067, 1.9118013797329414, -0.4203703147659298, 0.41089037420940755, 1.1568257567285092, 1.4574189653986156, 1.0001256926607742, -0.6322347248569973},
    {1.3703499658396403, -0.2859059409618771, 3.145976141363502, 2.9783502149333065, 0.4401243246860847, 0.1735513082696657, 1.6352176153201492, 0.9872809173504856, 1.8806109861145157, 2.350681168414548, 2.110013135412456, -0.8596735666546442, 2.5244019891584983, 1.3232648007181755, 0.8408535492049389, 1.9471977914698413, 0.6636675821789428, 0.2764847656929756, -0.5172655613029606, -0.6656541822909142, 2.762045831466322, 3.2901268760199143, 0.848877158321058, 0.6825411945164063, 0.38123971134197926, 1.1445719727780874, 0.23552565226596545, 1.6440576859419962, 0.9889922093917074, 0.5160048650287954, 1.1413291750791237, -0.8454890387345513},
    {2.1364688918153227, 0.46938087477716967, 1.5258103496838096, 2.414170181401322, -0.014272238383527164, 1.5866365607326771, -0.48346733867424524, 1.1373882999630518, 1.4182634341904268, 2.6374882146981085, 0.7968007404691003, 0.5149900926334338, 0.9612828050025141, 4.0637986499590175, 0.20157472057312933, -0.14605961521986446, 0.6308621491392102, -0.6644410558507728, 0.3318968308818242, -0.7319178913997165, 0.9011367995968376, 1.9985609095679868, 2.267531503126191, 2.046458131897965, 1.280906271469889, 0.9604748769830874, 0.5444635891991564, 1.7708043456371945, 1.737789440214402, -0.6816806421651928, 3.940218491238931, -2.309781347651306},
    {0.32295897968771176, 1.7478869568963904, 2.2740146950173705, 2.8859920771238956, 0.09909372816885512, 0.4946910794164104, 1.241740346281032, -0.8512495305833786, 2.6600587236053, 0.47272154500076446, 1.4382048106275058, 1.1216446425081894, 2.622093089898601, 1.1804116495042578, 2.782405416584991, 0.10653989457483312, 1.0196588774631081, 0.33471114798215595, 0.4424286625878948, -0.717076100627104, -0.28124344004425755, 2.527984469715841, 1.1379620265477766, 1.7943442573448172, -0.2891199744861228, -1.4667139647020415, -0.14918975419522337, 1.663518246076568, 1.227064082089654, 1.72678674158514, 1.0566331616417681, -0.41149842700663886},
    {1.040940847868227, 0.2211240771534005, 0.8631915450534008, 1.0216582478320049, 0.15334852462941093, -0.3635981273421119, 0.5237445846783121, -0.34036415335798414, 0.2989548569713052, 2.9627073191031483, 0.7504084416116716, 1.392926649601433, -0.09423122637625925, -0.1021982092892303, 1.5325605124920145, 0.6367467174286102, 0.592107326765079, -0.475630711626764, 0.44501104603708364, -0.17253822751698564, 0.8470207781029602, 3.3436164603427048, 1.1284114768599798, 1.2567979342164692, 0.3042044236759604, 1.9624870226977706, 1.2229045105620608, -0.2546656595135143, 1.710608122213832, 1.4483350940543274, 2.0566928460639584, 0.33988171990298305},
    {0.3762644671054834, 1.1105450784554893, -0.44649771539289074, 1.7149662113626905, -0.7897511731703399, 1.6285692793771813, 0.39164733896075016, -0.31311377852770006, 0.9570236257052428, 0.599598120052018, 1.141789170143022, 1.8317701399117603, -1.166920765129199, 3.2442945089697512, 0.9268886002404588, -0.12201637753025604, -0.014404089131911005, 1.610806783359319, -0.5868890717021075, -1.7330836500520286, 0.9860607746092295, 1.4957082101868748, 0.22885242092961652, 0.29478725256675764, 0.6056335853707022, 0.8708659826289012, -2.939219401886798, 0.48524416247339536, 1.7828640731680605, -0.1798289057873239, 0.0680165820312754, -1.377390002850956},
    {0.41498596197179993, 2.0200027416352415, 1.2122622192776582, 0.7454425204199867, 2.0201739253626645, 0.6631495522616722, 1.4529798695257552, -1.8250324887991776, 0.8149028915231408, 2.4190421571229543, 0.33201522951105783, 1.0000649552666763, 1.2119246919377429, 0.3052872724371683, 1.8560507072748684, 0.8630067275726744, 0.7926383808828318, -1.362594235153849, -0.6039277846152129, 0.10227741549895941, 0.8454927325929061, 1.3145083065157601, 1.4293330897578265, 1.4156995776282355, 1.6946193864435144, -0.8343639153375884, -0.1927450149271421, 1.9862559344443922, 0.9924644747781748, -0.9552426147847967, 1.3691504453535626, 2.186847255253488},
    {0.42351864177438703, 2.0009004989567516, 0.46360760227283676, 0.976017667938142, -1.217924895977167, 0.08317528096064578, 1.8845657885516707, 0.01250138203569476, 1.4745717717404592, 1.0472046605390646, 1.375221762032409, 1.2189868641373727, 1.4192811530402059, 3.3839943951169595, 2.542940734890972, 1.5464050817754074, 2.050675382636253, -1.212800097271848, 0.6667193932887875, -0.8839223080175301, 1.4573088432238026, 2.3217535984002393, 0.4841478112866771, 1.3218228909099035, -2.2276410903334067, 1.9597442896022632, 0.2539062405367661, -0.11928659866244518, 1.1984928791435805, 1.9468445616777108, -0.5417426933661611, -1.589296988718688},
    {0.17928630154016414, 0.33587957958939235, 1.8959804941587441, 1.0198771144797092, 2.5633288446002567, -0.3072419038601194, 0.6194981920211042, -2.261191351639515, 1.0347404559735354, -0.4892043336492976, -0.08928694415298276, 0.8004828094992891, 2.4249475755995507, 3.035450503451044, 0.11617135964321933, 1.5386469972338677, 0.6567522557010863, -1.167781317183939, 1.7423019638072266, -1.8510797259148093, -0.7166424431250431, 1.3834392309616539, 2.218414072014936, 2.6833331483471334, -0.8393125864348256, 1.1374796053881322, 0.8693894868833489, 3.140404545696341, 1.1059021921504193, 0.6990345108546479, 1.3277167553876172, -0.9531221114302952},
    {-1.1334329634752696, 0.3971089175383338, 1.3320011304085464, 1.7950265905625968, -0.2603771354642671, 2.4019406871425115, 1.7393104321815083, -0.6360822032998505, 2.493981283779451, 1.2953030796789282, -0.31385763822010726, -0.9269561210446429, 0.5662754007971441, 2.3610285335947494, 1.3908070358199431, 0.8183711485661129, 1.1555163340884322, 0.05482750372266828, -0.007231928550443387, 0.661485066400728, 1.0411534042800066, -0.8906584577696, 0.5569677774973294, 2.0943349052273397, 1.4118841576634305, 0.8311853639329398, -0.26614999640287035, 0.6094130560584207, 0.7584096110052798, 0.5660784281178126, 1.4263340624596517, -0.9004210374795661},
    {-0.4770438498892103, -0.5280447218194562, 0.405779596313003, -0.6239301868311922, 0.7857624270497245, -0.673699786037698, 1.7706066720425895, -1.7399908748260018, 2.163601963133058, 2.247019460640816, 0.32064684355012385, 1.4270741618151157, 0.1660755099224738, 2.774307832534242, 0.7313790293023464, 0.1364602845896755, 1.6264534008593003, 0.019316490924624344, -0.15742635816872969, -0.7194201083220164, -0.64584172470495, 0.29205708098256267, 1.2328609148479512, 2.5789298212089973, -0.11119089002161986, -0.35440180182938286, -0.8580726644389863, 0.8022070171388055, 0.5750505422965441, 0.03956813729008732, 1.0822375602388306, -0.6545363164865385},
    {1.435553566749533, 0.34917332567382775, 0.6302033087414017, 2.352183484336047, -1.1033401790708859, 0.7019958892412117, 2.156556918599629, 0.9274786455248174, 1.213735086566675, 2.133165411339113, -1.1341724209654733, 0.04792872291731791, 1.3229330482000363, 0.9796909960027511, 0.654517436191307, 1.8429618379013615, -0.5897180993311386, -0.9428476582386781, -0.9569353067148718, -0.9137513936773207, 1.576879602752453, 1.1708424648335132, 1.1329331080797633, 2.699127467638493, -1.1009259294688762, 0.2064443382845805, -1.227511560041105, 1.051806513463247, 2.1243067631803636, 1.3367480323416363, 0.36007250191581325, -0.38472496456472144},
    {1.339304067971617, -0.7497728842282282, 1.4867867874189193, 2.128752742320202, 1.0406664653407753, 0.9412721715852472, 3.7026368578884807, 0.9262559046393719, -0.4009762247138322, 0.11401865059201842, -2.3272260234213995, 2.5209314403391687, 1.1105110807324508, 1.6407858082203506, 1.7807854086692583, 2.58050311923683, 1.1080601525454288, 0.8501908009237066, -0.015505782255560733, -1.2622014164924302, 1.4984399778359743, -0.12285643398475563, 0.7119894645347089, 0.24503145555666161, -0.6706347641466787, 0.2090656728162581, -0.7466567896718928, -0.16915408867563467, 2.9610583811367834, -1.487811324531525, 2.14307523973658, 0.7807510007278698},
    {0.4576859291311505, 2.5931838401693983, 2.678568734391598, -2.320451254176105, 0.07689515180898626, -0.39943607714425, 1.2698133965239597, -0.04708261146102117, 2.2698454299189237, 0.8224177962203922, -0.09550481081174977, 0.6091628258090136, 0.5633001255373177, 0.12209805187817935, 2.2562991415597544, 0.8289464817629358, 4.066058419976564, 0.34491452936004036, 0.6474668064843907, 2.0304124560333965, -0.2967698279325584, 2.091741585655055, 1.4297533193697674, 1.165644109660699, 0.7023778190293568, 2.7317260426014203, -1.1636587142275807, 0.29533885224103035, 1.9587042138654644, 2.2825781541097943, 0.26992127188194664, -0.5271685029716509},
    {0.4816017336597069, 0.03221146174440317, 1.8095220100391853, 0.044600045676274507, 2.3395521681777, 1.465109209907931, 1.8752863615993718, -0.8957150914634374, 2.5817739479891313, -0.43044542900297905, -0.9077929997893871, -0.08729285416447542, 2.54744239128145, -0.24692966037602948, 1.5222390363728135, 1.2687042000719937, 0.7783918667377283, -0.13229346613843715, -0.7436724231676066, -0.6977443231469579, -0.40961751592029877, 3.1346859057235785, 1.5687919899599088, -0.8030864604762594, 1.5893930214753627, 1.3792382251449233, -0.4320845634928319, 2.3574737269942116, 2.0447905060871103, 1.757826010667397, 0.9790950195910763, -1.8646928051654161},
    {0.16243267499767722, 1.0369901934850283, 1.094751042849425, 0.4605195611840668, 2.0988888802241, 1.0607046309617636, 0.0893494507661235, 0.9867128331749689, 0.5508761534152757, 0.5952873250318904, -0.2017636595696242, 0.32304474708004577, 0.9814913364177138, 0.8380943394607466, 1.2509397005692502, 2.1664051015838144, 2.1178324125373886, -1.3177092099352705, 1.1711299763795413, -2.0158057238751326, 1.1185521322487195, 1.867245905261232, 1.0342430858371257, 0.17905931568552536, -0.3703006556494692, 0.019261892969018167, -0.5806454325478667, 1.940012545370071, 0.9349747546161771, 0.29678221624984963, 2.632373011509607, 1.1646463220934147},
    {-0.46811288399809003, 1.6053569953280793, 2.2760183380417867, 1.2846850067766216, 1.6043513532026497, 2.39735702985176, 0.3826749580053655, -1.248457563838905, -0.030399246949626514, 0.8873310723521521, 1.083339260232546, -0.4266576033956671, 0.3437952618865552, 0.2719138544312344, 3.0807028731855657, 0.8079502580867821, 1.0467526837188694, 1.0618614456025786, -0.44524034246460265, -0.822017232386589, -0.25353183188673106, 0.47570747136031677, 0.6793196394835102, 0.45649254552947505, -1.1996474118175742, 1.6226389483543353, -0.11698211588532542, 0.4315335956145939, 1.2557454526622676, 1.2423269211707024, 1.7694132928995916, 0.21502174206379052},
    {-1.3218069454286427, -0.06786962770978881, 1.3219068506894764, 2.187323424790667, 0.27501922776899684, 1.6154184956738127, 0.26887798152839276, -0.9174457198071942, 0.606342307355088, 1.5527783706623897, 0.13445697341117374, 1.3069061628172502, 1.0375183279652973, 0.6907179092754943, 2.2781605417527504, 2.394302641282568, -0.05149013542852485, -0.3334343855081463, -0.40877585946818745, -2.127546366660387, -0.11609172426022005, 0.7704732000708424, 0.7289864924767757, 3.265866177809813, -0.8045146955739118, 1.4890881754318566, -0.19254124799881436, 1.7367565445893487, -0.7803325482299321, 1.4330393030451678, 2.3980930781569216, -2.2925634355638036},
    {0.9506860504508283, 0.8468790701315817, 2.031128974660444, 0.5081979752902558, 1.0395381580680292, 0.896965239124859, 2.1462302380555203, 1.9451919801585962, 0.8025722574461824, 1.8086244053223144, -0.04857569619188864, -0.45785995749065705, 1.3333036764527741, 1.5292031148084568, 3.7350260719842066, 1.3079284472957111, 3.5719058864904807, 0.19102015876930328, -0.7691622221863221, 1.3951990453993026, 0.9118072209716392, 0.5881224196278272, 1.2939137640926686, 0.06115581229064524, -0.32555941242858943, 1.5014403084813719, -1.1090510451611635, -0.4543555727028351, 3.074582705572864, 0.5408395892381833, 1.9481760337341893, -1.5068546462971575},
    {0.7424757123769934, 0.5017081012293992, 0.5427547002930245, 1.9813814539034238, 1.525739504489106, -0.2917134980342634, 2.134288639587698, -0.3366463263203537, 1.7946419111784977, -0.43618599974057554, 0.3172966273340201, 0.6659778493561671, 1.0416621452726929, 1.8999048755593468, 1.5508908970459505, 0.9237113050664327, 3.2184901423372265, -0.4529461123354524, -0.96902113059686, -1.7062154880658256, 2.386198185858877, 2.2432091164281096, 1.591633272101892, -0.3162411964645832, 1.6828246391132338, 2.6410466227120626, -1.2101796384383223, 3.00254940081998, 1.5130974911935258, 0.45802445846664347, 1.5439100905682477, 0.04570837721510692},
    {-1.092991473800025, 0.5470001800804053, 1.3774315396540002, 1.0670030718700672, 1.826273651028394, 1.4956764614246634, 0.4874043659367393, -0.21224300910141414, 2.0522266745308313, 1.8297703028274221, -2.619874094244897, 1.631921889385229, 2.2090451034144336, 0.28605888546690567, 1.0114760189812464, 1.8044278701500933, 1.7469097260470234, -1.1138158850612838, -0.07312994854089717, 0.09851120473100039, 0.08248135605563783, 2.4073074096483293, 1.5858929247624751, 0.8970098007719196, 2.0804795354616794, 1.9877761767541564, -1.0880894301715545, 1.115519795972948, 1.5729755078291747, 3.084020377780947, 3.1859604745964067, 0.40353484305834575},
    {1.5209522015951873, 0.3891473712980965, 1.2728485135326155, 0.6651180291248173, 1.1499037535220062, 0.22682445737553203, 1.3138603387819292, -0.043321013427438985, 0.467478956792623, 0.6465359100217427, 0.04304895053284245, -0.8067800447836222, 0.39641623186799435, 0.6192000995282793, 0.17040596062105526, 1.5403482800772486, 0.07001464843052949, -0.2168510390074269, -0.16608537879641488, -0.34897581958867263, 0.3438790002465984, 1.6163821719777687, 0.029413993166679357, 1.9416095817272134, 1.4676523145801317, 1.2277890622356324, 0.5631220683281694, 0.937581113571478, 2.5217714420291437, 1.2397660328751452, 2.3552684477000416, -0.7830751683694966},
    {1.6504036386748586, 0.4335268930179579, 2.0811674337928223, 2.264787204250994, 0.7388792151461009, 0.13128633889730235, 1.623383908614214, -1.1124091651837709, 0.19005586963721982, 2.6913463136342384, -0.044091552952359274, -0.015529913646921053, 0.9627731386156657, 2.0834868435900162, 1.663252135033279, 1.6775273306425909, 0.44715709088349453, 0.6356226961808761, -0.6554122962635842, 0.8903353965882659, 1.0094738766940687, -1.0826595213404642, 2.267195911276283, 0.6167727553865991, -0.5128865904547181, 2.136457569783851, -2.013028435324249, 2.096852063412421, 1.138551252366543, 1.7777535293938715, 0.20161209768641333, -0.496816343956117},
    {-0.813740909051119, -0.7542955086364682, 0.9013124304038282, 0.9536164638724632, -1.1860235856213797, 0.13701787608290852, 1.0101277576564802, -0.9481993629370319, 2.9830287488142506, -0.528336622648232, -1.5472784605518477, 0.7617456104165595, 0.2225921257284892, 3.5383416279891593, 1.9450362985605758, 1.8283141911670826, 0.7990548621164005, -0.7379648978815136, 0.6469535472309484, -1.8127981174498096, 1.0530498576095069, 1.4793286056559858, 1.7290684279393, 1.7059507006386188, 1.5622255916025996, -1.6222218319189035, -1.5041283964587118, 0.35329528744049965, 3.9138132858156736, 0.3885910808928445, 0.3842047241825407, 1.9703903252354547},
    {0.6066002252184377, 0.16122624676403013, 2.5760352868357046, 0.3908833670522736, 1.2858755934590542, 1.3325757203252555, 1.6350130983155298, -0.5599121822377888, 2.4329242778491156, 0.07630961403764658, -0.2421971207605125, 0.1148004867482722, 1.2279238529932859, -0.1698903354153707, 0.1582614373575437, 2.1094536801203243, 1.4660618756618526, -0.191361628066899, -0.8373543812948444, -0.569910337617102, 1.071038470688897, 1.6282089044709602, 3.46350211714405, 1.9274594460209147, -1.9485245055920648, 0.8030260359912972, 0.1750991459860708, 0.960232694926738, 1.2398663679637132, 0.5773499056183998, 2.3344251339802677, -0.5353393525516726},
    {-0.5804123600057528, 0.05625109293763052, 1.150256865379103, 1.77635058112223, 1.0960757926843216, 0.39717603387419914, 1.6285749955354136, 1.197000886834754, 0.8511778172182529, 1.4137777686619921, 1.7661610537146537, 1.2852836026958274, 1.8587960619415003, 1.591536886839306, 2.054513753389582, 2.2613364269910377, 2.1816912057881153, -2.246396871150135, -1.6160598512376658, 0.17890073729482667, 1.2603500506024132, 1.4634499054905623, 1.752929226736375, 1.219967223111838, 0.6234856860028787, 1.424738270934441, -0.2656224517823353, 0.8180709334767445, 1.7707148830676263, 0.15357357767058596, -1.2824435410371482, -1.2560798964403819},
    {0.343909898720672, 0.8303274068412456, 0.9360647697577873, 1.3496619779481651, 0.9751138180221349, 0.7531433467001153, 1.127623855630394, -0.24287806593107056, -0.6189306091555753, 0.9770939574622449, 2.717000423733686, -0.9282578795917199, -1.218255944109076, -0.3282411852800747, 0.23441721676937438, 1.8663201531120914, 1.6607394232656931, -0.5826998580081022, 0.5668895141729736, 0.031702689788634525, -0.3605949377560619, 2.869444402870423, 1.9595407607237276, 0.4124595285953115, -0.9780355597362571, 0.6862557860944559, 0.08813827076297963, -0.03146365854160291, 1.901248419240012, 1.9843933323870417, -0.24119459305111535, -0.4770728331924182},
    {1.2586313760327867, 0.1801532343851123, 0.3169848543422321, 1.1711263154696891, 2.1388893489208014, 0.5321609592065505, 0.5814130205778468, -1.2561938234637593, -0.02436814607472988, 2.2597164435024686, -2.446730641327175, 1.2410732341859667, 1.4022841813168883, -0.10811206003037707, 0.31937010211413014, 1.1413949374631895, 1.424779620372038, -0.985463568275743, 1.6515224112515916, -0.7158143779999041, 2.4666457304678864, 0.01718618336922665, 0.9568454733838866, 0.32018678832398406, -0.0821793608948486, 0.6097152022663432, -0.09359185714165236, 0.883981495771227, 1.6750812358932194, 0.3740973648080472, 1.885780733091142, 0.11471385556739035},
    {2.4658133952864363, -0.2924482305733727, -0.34205249241879737, 0.9084655514147867, 0.498764265454414, 0.4956566718575383, 0.2943874817374232, -0.9199559934919314, 2.0115009169353653, 3.06709673199609, 1.7635718605015134, 3.1879692299754465, 0.8380582869689936, 2.012216447463681, 2.098880280882261, 0.037171217547631454, 1.490593388726848, 1.0191094694512237, -0.8492124194926014, -0.5887510787555116, 1.6682726591565424, 1.5615615610123565, -0.37729043757081204, 0.32499237636756345, 1.055045973827596, 1.7335198409903019, 0.03941422961852496, 1.7608211510598564, 2.4940686170964392, 1.5885395858956404, 1.2654629768573724, -1.1549680529070696},
    {-1.944836171780885, 0.5075194320388539, 1.2158265218519815, 1.7779084775413738, 2.291362930104788, -0.40375266755781825, 2.3487723887405334, 0.7535441641583966, 2.037348179032377, 1.2161059009510504, 1.8733901017154533, 1.6807919744751536, -0.3955120157604963, 0.34199624671567097, 1.748909065678718, 2.4040113641551666, 1.3206243993744542, -0.16996207609661673, -1.5783508650995146, 1.2230621033639515, 1.722005886123641, 1.4149737468153611, -0.344680105435353, 0.7121844438344048, 1.2035187505727747, 1.4513855426444568, -0.3927999520848868, 1.8414967143668843, 1.8388264385586408, 0.6350135822128005, 0.9243316345274616, -0.9767785836522658},
    {0.8566215610989825, 1.1978139196535083, 2.6069775634591883, 1.0109059478760962, 0.7829554650965189, 1.383239236426309, -1.4329699565412597, 1.6893451394209678, 3.4433531780458995, 2.4790175038806446, -0.14381294528485974, 2.256715804979372, 0.5587394682454526, 0.4511587447127066, 1.9525999375335374, 1.658582111897524, 1.8764421776513387, -0.8461634007449863, -0.46725858349694166, 0.9332723331875811, 0.5036208388842487, 1.7939590313638816, 1.9296797511480674, 1.6464108727852917, -0.0846692194527176, 1.2003154239821505, -0.03187392883723238, 1.1051514323076606, 2.3746288665975173, 0.030175457161589984, 1.743738036543809, -0.8635212456991983},
    {0.8688245055077196, 1.066842789149825, 0.6494493342840089, 0.0898492129852749, 2.3149777101635824, 0.19284649262416928, 0.8691601246158506, -1.2537962914917604, 2.1252604827917914, -1.1094214262958326, 0.12300234121387235, 2.4566368267492784, -1.3985002069309127, 1.2022068768938794, 1.2620342602102848, 0.47814154340424064, 0.8235137653781134, 0.192303329154297, 0.0689550465472578, -0.06533979554294478, 2.6285559953020043, 2.2400076916703062, 0.9364187100644041, 0.48387013605643736, 1.3388731951390704, 1.8693393391515278, -1.6059329968501705, 0.7866825172034875, 1.1297468883929598, 1.4578958490849228, 0.6425757128197281, -0.5104873822525752},
    {0.06730770689115542, 1.003468467725231, 1.1752894754220038, 1.2191584914444893, 1.1517013865322259, 0.10792400947782564, 1.8540697562403814, -1.5444261727223547, 0.19302685282141066, 1.6887055202760244, 0.4167520756666017, 1.2145105254102397, -0.3529315647852743, 1.4476169127816645, 1.7762529408936583, 3.5198663607185403, 1.5550627248756494, -2.302703188191311, -1.0464132958115568, -0.15532731728442184, 3.7682731395683975, 1.791397782289626, 2.043261314611134, 0.9237766079620126, -0.5124010304371939, 0.19746321250705512, -1.2555986992395187, -0.2397465877693319, 1.645860735750808, 2.250893393833323, 1.070141048273082, 0.24155864945891906},
    {0.6558454377868397, -0.2211657294312915, 1.7309410185341016, 0.29315828085203105, 0.36707075699859687, 0.3487847597380431, -0.2971577552288516, -2.002430065783707, 1.1169124915664488, 0.17649259506297948, -0.013153245349819258, 1.8229335289076822, 2.773054950296319, 0.771899030138344, -0.5652543115011553, 0.9092538893380957, 1.0797252226810392, -0.42608987986936664, 0.7972779943006322, 0.380150237903346, 0.5138899949117511, -0.8296443873224447, 0.5086004604973389, -0.6871948889356426, -0.2194785890590394, 0.5732961744619721, 1.3925515132947772, 0.7487186741273913, 2.782485265229054, 1.2394430246222183, 0.9489527724126607, 1.4468808977551118},
    {1.5820677485712689, 0.4337204481006748, 2.1886650812563713, 0.1105843224875294, -0.429691983788881, 1.9278816980074835, -0.32831985063377944, -0.8630170360486774, -0.0012293289606095754, -0.18857064887603933, 0.3213628504470957, 2.041762168287036, 1.409958115418466, 3.0172664556793793, 1.6841154651003984, 1.582401829398916, 2.0618250274638577, 1.4688047364731347, -0.10389869119083928, -0.5536924897230157, 2.4851146181443466, 1.4424891588328248, 1.3307982326662502, 1.9716722384934622, -1.1280254529334264, 1.9604261252296837, -0.907943033787897, 0.8155557717534938, 2.2407552797747834, 1.0769793332632605, 2.7247284424222165, 0.07777689198319493},
    {0.9801812018778019, 1.288191316653527, 2.8452989981984116, 1.3790775867465688, 0.8931348335665561, 1.5097188755394544, 0.7797474717329531, -1.210842881836575, 3.0328325051611604, -0.24165465176027712, -1.1150365966249822, 1.0953975434399694, 2.2772273331631854, 1.9520246789850133, 1.4153940039740693, 0.28258989781277494, 1.4482667087443868, -0.23912412471414696, 0.6523152331740434, -0.25069012093439136, 0.49244197719205934, 0.6910317340762239, 1.1051205189718518, 0.9722493880990144, 1.3788195771205773, 0.5259468336970743, 0.9824800575605596, 0.05794879461007504, 1.3883702645695084, 0.9812390852594698, 1.0888113176053702, -0.5998260919104864},
    {0.9692656813448769, 2.763174601789152, 2.1022856825630654, 2.924382579620365, 0.42309469254398246, 2.218138174027487, 0.9226829867118185, 0.6108829322049458, 1.9466415046527694, 1.6756472333875052, -0.7054381389330305, 1.644357185490159, 1.4602434872308843, 0.7755425632955398, 2.3876564830791502, 2.944077444721884, 3.88115340269811, -0.9664721221566439, -0.16641052067566034, -0.8908027541523097, 1.512086179519778, 2.1441619605302975, 0.4058829789740048, 2.532846699679218, -0.8188354545782616, 1.9191349651843792, -0.009054089498662507, 1.5057528086167606, 1.4019908675414903, 1.7372567717999077, 1.117065507610368, 0.7769376692769708},
    {0.11412182223180663, 1.3776950242553563, 0.8140769634840388, 0.522247123386155, 3.321156394064466, 1.657622600816996, 0.1559173620751433, -0.42593247259305755, 3.2387791464349203, 0.5289549260482237, 0.21513088729610777, -0.4347275258536514, 1.1800710996718669, -0.3349714490245012, 1.4088179819250022, 1.2434008702956783, 0.14147697625610875, 1.2322323661972794, -1.5718666945254567, 0.22168472093067068, -0.965872032221588, -0.11731340750423014, 0.7260686524416159, 0.9615539951527801, 0.03710823491120681, 2.164272561615303, 0.0704262993274644, 1.3815338054329822, -0.7592158643942618, 0.8112896360216115, 1.241620111019748, 0.41888299031780785},
    {1.8708567605952287, 1.3851852173390449, 0.28397945292443705, 0.8667517815749541, 1.6432250392216046, 0.6085620057323262, 0.3486614392941513, -0.540538902306838, 0.2820207181783356, 0.5868955131382383, -0.5910650026660533, 1.2091574754589953, 0.9907519617230521, 0.9324025072153767, -0.5670478029497175, -1.3766728973561064, 1.0848169006881354, 1.2738248401668917, -1.08425050649186, 0.31320580347866817, 1.6601350784786102, -0.127558561999328, -0.013452395471044298, 0.45331806483397413, 1.660369934525963, -0.07184196766440892, 0.5283534047309115, 0.9667802805886917, 1.7432438230825649, 0.9945186308857822, 0.11133535854939083, -1.045945394694672},
    {-0.5694571051072366, -0.6159999515126902, 1.0659967412095546, 0.5047862312006115, 0.2489802133977806, 0.6838860127450087, -0.043826452398730203, -0.5664216568007294, -0.8929576704772253, 3.0122483278682504, -0.8151279550690701, 1.5065547208898156, -0.6730611974436657, 1.5410312318455508, 2.1511322953620087, 1.8729659185051082, 1.1173627957395864, -1.1799799522024017, -0.15806172379568945, -1.5700807469812912, 1.2969915552954157, 2.4235966616347704, 0.6227359518303904, 1.1656258308404963, 0.2900959679676079, 1.3049082834440158, 1.6139130265944344, 1.830937034788501, -0.28160508043821014, 0.5859175428423827, 1.3170582851979695, 0.2953843020453754}
};

static const float b2[32] = {1.0076024628973348, 1.0566114437310385, 1.9397240454009381, 1.9230139218403013, 1.0652099793075738, 1.6059596306042787, 1.511350887295535, 0.10046623761309027, 1.7348950030201262, 1.6299362780347675, 0.4127244902683757, 1.1593575024653822, 1.2367198377609097, 2.2769129297814787, 2.4671611972483047, 2.157905293785989, 2.256904836528308, -0.3810377048579232, -0.3159457961862457, -0.3618890635620718, 1.6145731597149238, 1.733000621527168, 1.9590728982857337, 2.2254070783164206, 0.6317119540560473, 2.1836205883468356, -0.31407410961291854, 1.8247879237402895, 2.4130380847428605, 1.174926857104443, 1.7244449333719547, 0.02840624920194579};

static const float w3[32][16] = {
    {0.15633747279005747, 0.5197268755683068, 2.241381742400802, -0.06829097769730515, 0.30339984171587114, 2.263715995085973, 1.4152878756969216, 1.3450584242190196, 0.6620412828913382, -0.27286693599770406, 1.0208017225769719, 0.1657156886557037, 1.907734836506403, 1.8303397127857148, 0.6077829755107483, -0.7818322734759782},
    {0.7565732111263617, 0.9449727575191933, 2.027454967616139, 0.7634681461443741, -0.10721260777240164, 1.1593458945274735, 2.6202496911687456, 0.600236880793892, -0.7296784459860446, -0.43795306109115767, 2.4831063838744702, 0.0859128724610076, 0.9487132543981553, 0.25772212528204136, 0.9533288882716194, 1.141944242297014},
    {0.7959140805626216, -0.11063792888103478, 1.6137116721740523, 0.4366437718669346, 2.670289947297457, -0.19118399663026434, 1.5137624424886063, 1.4424679342227495, 1.3010223846392641, 0.13476456183545998, 4.234790006327411, -0.8461475966752698, 3.5374860369994106, 3.1583996355050155, 3.5906885041074594, 1.2504118404381677},
    {2.0867273085986993, 1.3012437213162837, 0.4036151071519852, 1.0540155467289847, 2.1378656966588743, 1.8303054835095676, 0.5802590029086974, 0.7084379837166492, 0.2176384939080346, -0.9290314882538546, 3.6856986956666624, -0.37453510201106316, 2.2588270298255755, 2.4217323004128044, 1.429351045560531, -0.3505442941205411},
    {3.00563122592729, 1.9108528746796298, 1.1600025050347917, 2.3994793673087953, -0.15429640901816719, 1.7348807696896373, 0.7220319778186248, 0.4052684108528566, 1.1574834452633826, -0.9967762697940288, 1.853857748737394, 0.17998237246070753, 2.4486592977027706, -0.034151126857673325, 2.286907298308131, 1.686819329651935},
    {0.34159650955354304, 0.4657413750253183, 0.6854630266868261, 0.6729993250810783, 0.6020263399561788, 2.163354243655889, 1.3389236493365424, -0.9193981394360816, -1.017975974181317, 0.05454676085349563, 0.28671112581721886, -1.5693779027523016, 1.4630642502198252, 2.2732005351121036, 2.585974600383068, -0.028865791026449754},
    {2.9721763568983643, 0.40872236929641803, 1.6199575681573302, 0.2163690589216667, 0.6957559155067135, 2.4708620893495854, 2.8411524837808475, 0.42012512726368756, 0.5515238394048945, 0.2831086211222066, 1.0072367567919434, 0.9095887975537957, 2.65817357801756, 0.7001556255563324, 3.237268627456445, -1.4157629388864301},
    {-0.21513322726212386, 1.321971791455923, 0.3379185636074737, -1.4621249016866562, -0.7401643258380644, 0.7336683936648867, 0.8808791671079267, -0.4734019948485274, -0.9976597563811539, 1.3253711198396942, 0.32855624902391084, -0.2334279166828951, 0.9297676205537234, -0.36100862733739925, 0.21751632600121937, 0.12154256253863512},
    {1.5377990779624755, 1.7782376645889928, -0.3487038783910748, 1.1737452960932775, -0.609157681607435, 0.23464415838789154, 2.040170788100556, 1.036446495480096, 1.0624609259622964, -0.6919514287495722, 2.8149043156209097, 0.887143950150039, 1.515635994319397, 2.898922600018768, 1.254961484812628, -0.9798050944971631},
    {-0.26362621195501157, -0.37814755197026995, 0.3349148510060839, 0.2686197608144439, 0.04389887009748964, 2.359538703344786, 0.5089362841021337, 0.056178909667890235, 0.4601631037416778, -0.4992237808792081, 2.0095586526517804, -0.40786136355001656, 0.8372235954474238, 2.744905710875697, 1.14882666662877, -0.2501230749124622},
    {0.9832271842171857, 0.7578997874226854, 0.4510917204157481, 1.5640746004781607, 1.1621939030413881, -1.5161727792390296, 0.8456091534870969, 0.6693659097714211, -0.8135494935395559, -0.9268488302874531, 0.909383715066112, 1.0751434837495184, 0.4952734062532658, 1.0308649361344788, 0.5573501145092282, -1.066819234406833},
    {0.7417889637584316, 0.35524847573401275, -0.05904830699962912, 1.6708313981424041, 1.020776082852589, 1.1161894731115127, 0.0014450647555261356, -1.102042743944335, 0.2747822161499746, -1.614153759746795, 0.8956900520780661, 1.1295244786305312, -0.07499280185291564, 4.202649748869129, 1.3598485479294982, -0.4955416932302243},
    {1.0596145291015993, -0.2901050189176996, 0.5299663158813247, 2.2397495161670795, 0.8442820902498451, 1.7287530072074762, 2.182482657118501, 0.5999695075956771, 1.0608194893394514, 1.1381031025563881, 2.343893512914318, 0.4564466000347199, 1.192748349272507, 0.736552218445923, 1.6758584702476726, -0.27504356155892246},
    {2.373365164030821, 1.4999782609026107, -1.1263398528883808, 0.9129981060208131, 0.8930592114856254, 3.6007668970975293, 1.694411748538762, 0.77960487798175, 0.17349007034775293, 0.2873196690630989, 2.3050163521065397, -0.9094106709322122, 3.1335165747695557, 2.169823011866988, 2.181305302712784, -2.5808813193147193},
    {0.8284654125663039, 0.8802096273452457, 0.659495896041561, 0.6630926623303854, -0.002329970000726116, 2.269096100667159, 4.461666117000568, 0.0800648788119593, 0.029117347942047504, -1.5563924333182868, 4.78985278367027, -0.5457979093842137, 2.6423381320325894, 3.550166383708949, 0.5127982138219369, -0.37181268836847997},
    {2.676999644327783, 1.5340916342433664, 0.6309130346471027, 0.6679232946893804, 2.2169329657946593, 1.33227711465814, 0.6531410648054352, 2.3947700096100335, -0.35441971840556863, -0.8944119769651765, 2.6433600155446424, -1.6287118484812018, 2.876184497357264, 2.787573027824575, 2.9248589797117965, -0.4230340145848306},
    {1.8639276745891773, 1.3530954393966355, 0.8467064712576385, 2.1294631933459582, 0.8036646396938059, 0.2787000030070422, 2.4645870632005034, 1.188775955270483, -0.09411858795872656, 0.7662928631220858, 3.2614553587095267, 0.18654212029079398, 2.9888293514424493, 2.199329140751608, 3.3464928738314956, -0.9720148120970545},
    {0.5283154391472719, 0.4852935495317706, -1.8636522724396545, 1.5276673802985525, -0.2496125443870062, 0.4419726807525947, -1.5769749787006475, -0.24207655603740788, 0.02635438481357029, -0.026964127960810363, -2.4107450021774817, 0.24223883930193615, -1.1598083505875088, -1.229348571480534, 1.1004500931266181, -0.07220900868027033},
    {1.2586583901425576, 0.9107492306983992, -0.680605762812568, -0.4040782320983231, -0.044724901111826636, -0.9366979060358875, 1.1951496707504603, 0.43496249008681154, -1.9062934485236926, 0.33933338087579895, 0.8482025296490455, 1.2514297398805265, -1.1424954328699533, -2.011834630285443, -0.35416852296186496, -0.5747844611148255},
    {0.5741059738554539, 1.1367807114825221, -0.7482017761465244, -0.9628702297682028, -1.4372845107819099, 0.8188359757710961, 0.8372896517704741, 0.4915366878496614, -1.158871541456368, 0.1318915730767761, 0.1622320533393897, 0.036063157226306146, -0.4662258506672445, -0.67438540295727, -1.4657068759092116, 0.5666918201155743},
    {1.6449391413036458, 2.372889120176114, 1.6840647202433325, 0.27873118550235243, 0.695896997970842, 1.1561413531897462, 2.2539025791775247, -0.9049478461070357, 1.46810483896495, 2.650045179750952, 1.594984503733152, -0.9659118769931423, 0.9815381358190964, 1.7081404659626966, 1.8585670837028332, 0.36948871871296574},
    {1.5235549615909243, 0.6208221605466697, 0.19655162399246548, 0.31391450552563055, 2.103852157935072, 2.587002399171567, 2.9979547624983343, -1.8527273100655015, 1.2411740324296052, -0.6286662069997833, 3.9648255199194944, 0.987798642514959, 0.9576740710653168, 2.126848819519333, 3.4352577668740545, 0.755322252908912},
    {0.9858456261431908, 1.7808395498252352, 0.927302243775389, 0.11265085783499955, -0.09773519578910599, 0.30283656163636474, 3.3329268799360974, -0.7456491257064876, -0.17361344236821852, -0.17104079459952667, 1.202436066213252, -0.8620801313101669, 1.8007740863180226, 2.7597773247684176, 2.2430247862456074, 1.1380221767798173},
    {0.6951637148234789, 0.30963067062646954, 0.5165675889972594, -0.19056814575602807, 0.7832032415293668, 1.7766866798275305, 2.7832591687160346, 0.5729945049994283, 1.6668968890328963, 1.3229217084162812, 3.3896152842920206, -1.2909574526309946, 2.8752841116826, 2.0750608391951224, 2.49014792454871, 0.6533036661042118},
    {-0.052575639144963444, 2.6184800939651796, 1.3218221394002811, 1.380584525860102, -1.0672094128943634, -0.07528815278591268, -0.15383906363894956, 0.42179074363295527, 1.7736446065593672, -0.9169260865760614, 1.9586300299256778, 0.4174279824257631, 2.2140197400913073, 0.7801385245028134, 1.2900104456709074, 0.14039549105200466},
    {2.9685039060309593, 0.10032420780341655, 1.76036276488607, 1.326590625057523, 1.4451488255572418, 1.466317536687212, 1.5289876336405401, 0.2298923344646351, 1.121448945359382, 0.5868650739937191, 2.5955020943414375, -0.3194871970671449, 1.8188380643275426, 3.580608178316121, 2.5036084038319353, -0.6988290008991637},
    {-0.9016753699088621, 0.8990092884066441, -0.7071312494569074, -0.0808711894368058, -0.6478476456158725, -0.11571939064809646, -1.0242977962928255, 0.7643088708641808, 0.9332252980412818, -0.960117316451596, -0.5743618820951164, 1.2480508150916907, 0.5000833430235194, 0.7716719143748139, -1.7195262182157467, 0.05758603011043542},
    {-0.45699729085317015, 2.4728592647051175, 0.4181305171851605, 1.7793176281168825, 0.7123428637578061, 1.863341329193043, 1.3856555349844442, 1.3057612814931228, -0.13095661492233937, -2.2422622067600027, 0.8286538617208243, 0.5507460749531309, 2.607557933008872, 2.5920349033179266, 3.493533934978757, 0.19103253720919833},
    {1.8885205584086255, 0.34075918542377404, 1.186719889711663, 0.5034583625883233, 1.6330934453485346, 2.652417766313854, 0.930667978736866, 0.8348476421367026, -1.4731523561469775, -1.921244119249077, 3.566626159389706, -0.1528304156792425, 2.1719979308749653, 3.5151988139761365, 2.5533034113206554, -1.3509283969306554},
    {1.7812949129725808, 1.8598061410148805, -0.12005443466394404, 0.047177342829645426, -0.7447239216529528, 1.9917357407266585, 0.4766033840448636, 0.5844838288558916, 1.0588433790078933, 0.5472977976571475, 1.9677723443593635, 0.06708515221814103, 1.5203836900388075, 1.125848743615442, 0.8152838763678695, 0.1759255868380364},
    {0.1859947185524491, 2.3418339757300286, -0.7450332807377327, 0.9092646099173185, 0.8011873739069647, 2.139549268718433, 3.2223561544835384, -1.1537275413361696, 0.05276570597624678, 0.13673790924905033, 1.921637341986585, -0.2987584758617356, 3.5430381191740943, 0.799398624608975, 2.279465957340289, -0.25195493755357573},
    {-0.25662788722769775, 1.1682802830306471, 0.15591335305161338, -1.4975133558647316, -0.7185672042119766, 0.7310857068430494, 0.07006470406038254, 0.3069938034921475, -1.3104564612610865, -1.6323073057385775, 0.29525321655945974, 2.0894906905040616, 0.5678304682903639, 0.1869535668149379, 0.5931462655943466, -1.7029803043318468}
};

static const float b3[16] = {1.1432124282906788, 0.7342426096806323, 0.33370110430066013, 0.628583877692365, 0.3984514423762315, 1.0586399171852126, 1.2846806189069027, -0.01207749867360508, -0.004872493250444349, -0.03137275261450908, 1.5692585868855609, -0.3585073245917526, 1.302767412190687, 1.5893794896525382, 1.5339772050683391, -0.1670822681538909};

static const float w4[16][12] = {
    {-1.2876577608958555, -3.224428164220613, -1.2226814383073452, 1.03592301989769, -1.1768562518831704, -1.3873969192347029, -2.7852895349506266, -1.2938760652536663, -0.09602069949534431, -1.0516270232425744, -0.8898643906737405, -1.0440539977156227},
    {-1.5703478980896572, -0.5052090209371799, 0.688913778863768, -1.8979385845615822, -1.5058531452704509, -1.797102701300357, -1.3828713971619904, -0.6838964580567964, -1.509093006505457, -2.5255130151465877, 1.0456888592015108, -1.340507020609891},
    {-1.5408428072371114, -1.0240905855079485, 0.750163563903792, -1.5584949867000732, -0.5803208274453994, 1.1727914869353233, -1.6596281839938172, 0.4824897778097298, -3.0600771796007504, -2.212338759201588, -1.2164324292353377, 0.20096447384457725},
    {-1.1678296511730035, -0.38108593927957407, -0.06958535206318646, -2.272043805396353, -1.0429411269498994, -0.2770251017280626, -2.3375451043061446, -1.4761975216991656, -2.186798638803755, 0.25842501716534017, -1.597859297050217, 0.343213796854419},
    {0.7793261226424812, -1.0435865692570516, -1.7269397421073105, -1.6763320952581635, -1.884388400780919, -2.757994640924387, 0.042836263991898146, -1.256751807870524, 0.9581277358519363, 0.014720996736070194, -1.2264385393836146, 0.6970927739945467},
    {-2.068448422549707, -0.5850613305241581, 0.12146174327518898, -1.9210663921587139, -1.8957683687385234, 0.29356267070480035, -0.045146250045377506, -0.7661095361891292, -0.8794592866234544, -1.9965857963618634, -2.9999161594941475, -1.5587774006049466},
    {-1.217042642413942, -1.2576155011470809, -1.323731372399339, 0.4990052073952053, -1.1525255050457452, -1.804090357943271, 1.1290978320567875, -1.4989024539517875, -2.043075391968019, -0.7601515574333176, -1.8502587197115306, -2.0611715985528316},
    {-0.2892410819521829, -1.140725259272307, -1.6859257651239503, 0.6094531436619793, 0.06811487862252452, -1.6578714485075774, 0.8479215501525578, -0.20409607947365746, 0.4295974036693015, -1.2617735958040805, 0.004606151886121494, -0.6291118219337907},
    {0.20861730854311666, -0.09280768798340647, -0.5278853809190804, 0.18086111027076907, -1.2728174258591678, -1.8508703135772282, 0.09649375133979929, -1.2900491554115956, 0.3146432839622556, 0.8045599673037556, -1.9265930768411421, -0.3229766347173785},
    {0.5066502526837456, 0.1857435421973073, -0.7947088136169047, -0.6887808465731993, -1.8473814834380897, 0.18804315418570736, 0.07903880401886176, 1.537483147583837, 1.0846884305737103, -2.4316030960656536, 1.3030050107061146, 0.05050893360772674},
    {-2.6803380404392008, 0.006374282676590103, -1.5131985482480441, -1.7696853028612776, -1.9056603962243397, -1.2348723845704264, -2.4000937670345874, -1.368217269054863, -0.015482477393177011, -0.7434593476887769, -0.6210727090224197, -0.990646399392111},
    {2.0241605621944307, 0.5977933629399378, 0.25859976482903774, -0.3128522330441011, -0.6008851645117737, 1.2592000301377004, 0.8929744776386384, 1.4646357211538903, 0.7387472583531925, 1.8896115843748835, 0.22355389480746715, 2.55952766466753},
    {-0.06997692794595779, -1.769137529480004, -1.467532182542052, -0.6835963716319675, -2.1102728856541915, 0.5676518156475182, -1.5442382881670451, -1.569416170272738, -1.8204957732138527, -1.391473986933134, -0.6137841246434087, -0.5389107233575063},
    {0.031495680710039005, -2.497145368335072, -3.5455850339888606, -2.568342579591485, 0.10330903546751012, -1.7329399865269381, -1.3601940022280754, -0.683699066276453, -1.7344973277131812, -1.9886741264578212, -0.7476374870946786, -1.2783667982515166},
    {-1.689529082674943, -0.5692943463857382, -0.5371604751593687, -1.175956890803244, -0.18061584331775943, -2.502715464596172, -1.254426158891722, -1.4383734446686065, -1.604194179484599, -0.6923705579642402, -1.952053278065331, -2.676521133904183},
    {1.4142875322363384, -0.19207118105532095, 0.4628803077655123, 0.8194175848352592, 1.8871363635334892, 1.264312182224769, -0.4217575738115008, 0.7622982436530076, 0.9265306570367088, -0.4589328160968183, 0.6971790432938552, 1.3079977138208265}
};

static const float b4[12] = {-0.7922123894037625, -0.772349321743397, -0.9482665195707477, -0.756146815895147, -0.8031485501076625, -0.7687980120415268, -0.658604172799072, -0.936681138865391, -0.6399706884363398, -0.8381155934568418, -0.7725734114033672, -0.6920298178335357};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
