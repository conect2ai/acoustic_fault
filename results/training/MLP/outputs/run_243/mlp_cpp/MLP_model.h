#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.8162518078962175, -0.6733775480472536, -1.9463073634902657, -0.8001459788206634, 1.2613062526589802, -3.834811075524857, 0.9688936015410605, -2.296533743969631, -2.20623123632579, -4.533233299058698, -1.7537548692947533, 2.6116805223333084, 2.4228111771724925, -0.22301237005477054, 1.1046745261036022, 0.07137216043201747},
    {-2.723404494565859, -2.5825326374830575, -2.032424700428485, -3.8693533225203587, 2.4741036057474193, -3.995206958545112, -1.469750172409473, -1.4660446043960436, 0.42457693642644484, -1.2236312945629446, -3.790577016389014, 0.825485776744197, 2.669900743479394, 0.9421348799717282, -3.142716231172733, -4.235014705551668},
    {-1.7085004737794065, -2.236830442822629, -2.388279286120879, -2.263487778606382, 4.567965637837749, -1.9306099722198775, -0.2015465577986691, -2.110204828373067, -1.077604927436191, -1.3535855478255454, -2.1212674329238075, 0.2861966220485626, 3.033401955360472, 0.7365197944107054, -1.3847340522561975, -1.2248364545593233},
    {-4.6621806737979, -3.3072669548177545, -4.670984192587088, -2.693838011386416, 3.7694792127535743, -6.163024040289943, -1.1600331650535118, -2.6057507439859404, -1.7093940163778731, -3.204880559653529, -3.3025013295528476, 0.13024692434796467, 2.9979914930772043, -0.04604382054475034, -2.5577416054023563, -2.414667686132894},
    {-2.3794685760338945, -4.6770501605701815, -5.612707094596583, -6.369102679563469, 0.4957621274366307, -4.585823895549284, -5.404825030720147, -5.315046968278446, -2.1787924069605213, -3.9717576147873332, -4.667981374381583, 0.35471122927731846, 2.261006795107826, -2.297854042801242, -4.590101234722219, -4.692956808213328},
    {-4.530823709279202, -5.027232103233756, -5.694335617770425, -5.112470339145773, 0.6594333181372241, -3.034175220873335, -4.966068772205088, -5.530813779212729, -4.142240627675622, -3.604824150015218, -5.880418741906678, -0.42080074266101913, 0.7429409291931518, 0.1872313700370935, -3.6697970287978565, -4.345750824315717},
    {-4.7508435280349115, -6.487676497094325, -5.416798769881934, -6.402482054862402, -0.5022235319556649, -3.565625384733674, -5.661695079622791, -4.578265992913149, -2.527057647412545, -4.051531023974347, -6.817975665547823, -3.0824361283446886, 1.9164571487184172, -1.4532302300581943, -2.6861834018455526, -3.3445081159240977},
    {-3.7869452159740633, -5.903777806015478, -6.996540857475732, -3.7561410595004205, -0.7818222687688616, -3.779286487397002, -5.751784849292915, -3.9912619613251, -3.297208663132359, -3.0143180433502246, -4.795671966148827, -1.3499208025793856, -1.8987596245578975, -3.215807739653675, -2.545904435320621, -4.797106332090304},
    {-2.5359127185000605, -2.326097446129353, -5.927483088570404, -5.432194986177182, 4.179572045662985, -4.042154522510327, -3.9282346778685002, -5.492260754589338, -1.4618218134841423, -2.7506669813129236, -5.9998886123399195, -1.7473668040395745, 1.8386469740468607, -2.0921072459275605, -2.642058691999171, -2.778879172245068},
    {-1.443811187186277, -6.333329404625964, -5.621811861447485, -3.551735606410715, 1.6701811488677387, -5.4872812227544925, -4.534637309596611, -4.184474420011138, -2.6487874355961742, -3.286350018166768, -5.10799089446423, 0.8513134456820534, 1.4112635706776182, -1.0486612648552867, -2.4759487164781855, -3.0092700947320328},
    {-3.1428340012540725, -5.438473894735637, -5.638799968445635, -5.29205238172314, 0.6523840473282468, -4.320897082197863, -3.3573955543431135, -4.127574476615674, -3.3839332505578734, -4.645393869198338, -4.30974074082435, -0.7962824859574043, -0.2953605257412792, -0.6058702033056215, -1.9431387629205483, -4.492257830336737},
    {-1.8390089625735473, -5.909575858878318, -5.775068094548984, -5.202945250269079, 3.40886773672929, -4.257069396978177, -5.049397612351261, -3.064737415752302, -1.5712964355911259, -4.902090822539003, -3.648856986055299, -3.6711989129811653, 1.3871404790369906, -0.8795733505857614, -3.239852926679574, -3.569757390017309},
    {-2.491773548610504, -4.447155208447865, -4.606609497618897, -3.297129252933801, 3.319792278269492, -2.8150718918766833, -2.1275975662428337, -3.0420767675530445, -1.24986930270316, -1.8104245658206906, -3.2193514743033758, -1.4923682719975047, 0.9386664452942013, -1.0500756654973256, -3.183392540296705, -1.649763625300124},
    {-3.4033218002151218, -3.55546405078134, -2.294209051671923, -2.9920499162308283, 5.286845682919249, -3.835571114327243, -2.713229099136189, -2.4288040811495297, -1.5309569024252327, -0.7586351549996041, -2.423390974343969, -2.0343434389687323, 4.952605616799281, 2.8938237130463604, -0.9113216344624349, -3.2942315730709284},
    {-1.9083528619696053, -4.486906926611837, -4.177493373318821, -2.6187917894138315, 2.5031506936445167, -3.178872920775546, -3.858103472828392, -2.201402942913648, 0.8124434839625632, 0.2031579851570018, -6.005072903273656, -1.573080826030023, 2.258566971152657, -0.16415123918679017, -2.220338017727367, -1.1748576348042128},
    {-4.271817135122436, -5.772887855169417, -6.364530405883823, -6.55196003934192, 2.295968486914737, -3.1745843908001645, -6.0033094271571, -3.432959196006129, 1.7076253648812434, -2.1888143005846903, -5.984611636166177, -1.8551184013919586, 1.6545641380597134, 0.3300777500050994, -4.773886705521881, -4.6572505190660936},
    {-2.2866282333312915, -2.615947366254076, -4.8284842341482195, -4.4671099586662795, 5.427498999823547, -2.107514243538754, -3.9253073746286655, -1.43365565013742, -0.14191276760313706, -0.691477146990555, -3.982116682258406, 1.8165865936853376, 1.8558504506194553, 0.3962600900738392, -1.9085844879215021, -2.0965972141750817},
    {-1.0375768770499043, -0.21990471944104403, -2.54928540044768, -3.01700377823799, 6.272258092403775, -0.5604873215367475, -2.053050070060223, -1.8222549945083086, 2.227442194911543, -0.6726083164257953, -2.9499552250722645, -0.629913178758072, 4.3557091411076385, 2.7971262397076746, -2.1270607936700223, -2.2754265300077376},
    {-1.5978882176546954, -1.276713358927749, -2.037891042767812, -1.3821526838598817, 5.794277924667426, -0.6064907249688979, -1.7957850977645193, -1.681843584104497, -1.8609457371392657, -0.36507199873487256, -3.058833201014117, 0.13418485482856177, 3.0896234610888977, 0.03529340383844447, -0.5967448895304812, 0.05424302258990894},
    {-2.9029319179917876, -3.7435366012573423, -4.39438673459157, -3.563938228255082, 4.5706087036006, -2.885662784868658, -3.2124605427379436, -3.9806907901312267, -1.1676470659311435, -3.4979214133343377, -4.781925819800135, -0.8562620957869578, 2.405793229251477, -2.576150245557969, -4.425033159684258, -3.580316416531611},
    {-2.2010905470935684, -3.0152217084577435, -3.091729899603872, -2.968119484396484, 4.3541936202867, -3.3419974801804586, -5.39735600739128, -3.2438957093671346, 0.21476831419932935, -2.6438412839617453, -4.767114376695714, -2.7545609720463595, 1.3786060993687912, 0.24810456382844906, -2.3217627952008226, -4.775102800258673},
    {-4.523982171295531, -0.7030420138169842, -3.8896208237087238, -0.603351687882943, 6.570467892112399, -2.7310160258720395, -0.6424373691822096, -3.1992995614235684, 0.7972679230441425, 0.6748727658555432, -2.2512700433684945, 0.28638965625585294, 4.071316797417876, 1.5967789365095564, -5.142745779939772, -1.6953295139539348},
    {-1.3646586678272312, 2.5843373471017657, -0.8396375216129195, -1.742858471058964, 4.042640484723355, -2.466110679562979, -0.2711762452810377, -0.6576818836965751, -1.168944645284636, 1.0337525749409366, 1.6529407688893503, -0.8735201364190874, 5.495697624093119, 2.8958994484601406, -1.1988039178403749, 0.9904456773311265},
    {-2.028417167697984, -2.1133893482082393, -1.3782035381081632, -0.5155114591763573, 5.1039565436370316, -1.080876522989514, -0.8339330047406736, -1.7507005537029146, -1.4922084592172655, 1.9575320799047065, -2.3992177473451854, -0.6378946126017625, 5.2893581685991835, 1.6841474349210093, -4.0747542396956495, -2.2547959510224396},
    {-5.241714248467725, -4.17523551944919, -3.170646371871865, -1.750486380246958, 3.9944739655363373, -3.7772023107805173, -3.388503697311641, -4.392106383328696, -0.3070943297963961, -0.6786649965478182, -1.9313698464892817, -0.8750362170115528, 3.600023776888084, 0.8459071125755966, -3.0769670612411493, -4.143185902647988},
    {-5.144777490828389, -2.901831384554444, -3.732300067764785, -3.985648007060296, 5.429471559748619, -2.6817796838474828, -2.9190653728620064, -3.555971099637939, -0.6000853052094449, -2.2782901156211777, -1.6008646122785553, 0.8886090778587001, 3.5148511828120608, 1.4033387991275115, -2.9529796507003185, -1.9405773388909673},
    {-3.0865951662815543, -2.6716451594159163, -1.3435875917097266, -0.7449326227681686, 4.545750329142895, -2.194222305735306, -1.566117072831936, -0.9434397684655038, 0.6734448684254861, -3.2102098074377574, -1.255649067156984, -1.3501810368483997, 3.91220983281698, 0.7786689062584893, -3.489934297809275, -1.6265160636315354},
    {-2.8989849991034826, -4.249784001104956, -4.363035571307101, -3.0131880253154253, 5.894295031586051, -4.101758913305508, -2.1116604675564026, -2.9315247430340405, -0.42367455110155494, -2.949665316292178, -3.8799741138286095, -0.5465981182641729, 5.6373728275754615, 1.70582596138061, -2.391996233612388, -3.3352474064656845},
    {-4.468824540717538, -3.4930277195132713, -4.650109676599972, -2.8042252471999007, 4.480048799674311, -1.4705593779853123, -3.4609045082102545, -3.7722292037269756, -0.6710975511709381, -1.9422426288750185, -5.240285445141622, -1.1099757927671168, 3.917695493783631, 3.77929296610937, -2.8046003635482046, -2.644770400581878},
    {-5.036771577690251, -3.8374687638763096, -4.244638987518798, -4.896457556848979, 4.692578149920419, -4.118786814493853, -2.2374552661692184, -4.12612010716438, 0.6928970408768881, -0.9940544396924369, -2.8204602566174772, -0.6228486486038435, 3.4739944194374752, 1.311648332436853, -3.389446857767178, -0.6717556063744625},
    {-1.5406428557724423, 0.4526582785406878, -1.8221124829407571, -4.496247547435376, -3.5346321230543456, 1.0639721064581746, -1.2242270532937607, -0.5988542839546637, -0.9781010437048512, -5.50731593406709, -2.362573666865878, -0.8546781689783854, -2.0803782014061407, -2.3088179390670454, -3.7179870166246514, -0.562998916722483},
    {-2.9292974397718767, -2.1896723792589374, -0.9111478138211558, -2.1777564431154586, -1.6777647329489962, -2.9962644506647096, -0.14603704917615984, -1.8312875675503404, -2.773629361874644, -1.0409813715809937, -0.5019656139017804, 0.9152572374793961, -0.04468452676309165, -1.3873037559983084, -1.9852178542997063, -0.9612571895426193},
    {2.0096460660294553, -1.340920638764736, -0.7112243696574511, -0.02423798156224998, 0.2318032331356711, 2.06821572712712, 1.8623756485334306, 1.2476966933900155, -1.9032107828656468, -3.3926246440115935, -0.48873897476613753, -1.6520566481643937, -0.22896489427369845, -1.5672349580385712, 0.7247899985596279, 1.885668332085438},
    {-0.7240075781544912, -1.0142039350057908, 1.4474766360757279, -0.27962718399438624, -2.757134417584007, 1.9642530448754605, -1.57439363418332, -2.316066669948779, -1.995273458521557, -1.1348308262516282, 0.06755764722846123, 0.88658263889149, -1.6276341850487526, -3.1835681017585062, 0.5527406981639362, -1.1555240308740546},
    {-0.746944571440101, -1.091771988559758, -1.2860336295924444, 1.4512283585858712, -1.3039737871759853, -1.8379464694533734, -2.1399759893250874, -1.9634988392533232, -2.551453787652774, -2.726903208322347, -2.29980084527715, 0.05296570383297372, 0.3271027493016586, -0.43144683193657735, -1.0919166028461662, 0.672578812098106},
    {-2.7628704902979395, -2.963434223450969, -1.7513814734416076, 0.23342909091490643, -2.10674044699263, -2.2233075384843755, -2.639610643814704, -1.8724089140239641, -4.274531251804036, -2.883670340623314, -2.1588650493784143, 0.15020286922853515, -2.218273159993895, -2.4846943554306016, 0.34835504365394837, -0.9203920698167734},
    {-0.6050103247246481, -3.799988992377911, -2.495214553402638, -0.09055595476553341, -1.9369057920274075, -1.6169553799571716, -3.349507168038514, -2.4373147611199983, -4.108364351735523, -4.6777651993807785, -3.0049792695041937, 0.6061878873425532, -2.571616543486218, -1.4659420388370066, -1.1747299914175653, -0.9833237780841153},
    {-0.057811478340540005, 0.40319632684140855, -0.198689269100414, 0.5123504947776926, -1.1701747619351008, -0.48501085016480927, 0.7897245606577132, -1.4223595265025815, -1.4653541072598517, -0.7802376193566793, -1.4977297615875291, 1.3001325158990724, -0.662714719758231, -3.5858729942300878, 1.4204938932119662, -0.2608384010875499},
    {0.12144100233865283, -3.0748106105573845, -1.819577059433013, -1.2157394394516035, -2.833152336465847, -2.877816198147286, -1.5124109493678988, -1.2253007296941316, -3.607481240614905, -4.1908114512352785, -1.2911303712254554, -1.0911588899161084, -1.4752955403850287, -2.403887915166835, 0.33189199350928933, -1.7557325749921036},
    {-1.3159581642253557, -4.877670414026111, -2.456428249765616, -1.4301862928969888, -2.2115857186191223, -1.9706600058822623, -3.34588578425793, -2.045497897668768, -3.0502518868967177, -4.047166145786138, -3.3674691645355064, 1.3181310232840455, -3.235187335220831, -2.848325850922506, -1.0674306029537464, -1.9920788142136965},
    {-0.995008382736524, -3.883072412520756, -2.2525773389895645, -2.442670563563112, -3.6432444626381746, -2.6027699950138614, -1.5114417031966212, -3.8238272895362693, -3.418093027244965, -3.3186270192233063, -1.8315985243485533, -1.4394447792142104, -2.9785427894456835, -3.5763089775117636, -0.0010537790032988696, 0.24831450867239163},
    {-1.8326088658299817, -1.1655051947384503, -2.756454840812589, -2.0167727770717567, -1.8526837866367138, -1.999593826959608, -2.982659706348819, -2.2254968929285437, -4.35087806970892, -2.69731247029121, -2.438980643195969, -2.0130123688390906, -1.7847377951543113, -2.6901629054068232, -1.3335548146088896, -3.412335586644825},
    {-4.058982383953264, -3.0278608395773254, -2.5128071551773, -2.404638184547881, -0.8588491236689011, -3.0505453701359313, -3.980284716169107, -3.5447836689511307, -2.704378997947773, -3.8141927989853976, -3.532756254546537, -0.9016505941165623, -2.8501868126487175, -3.310559446348741, -1.7643795860771312, -1.0879269497623},
    {-2.1555414068956966, -3.097742334092777, -3.632859206060439, -2.704325641221715, -1.650909821440655, -2.97268063713176, -0.8836189037395593, -3.0642519711486056, -2.3481326807182255, -2.7891125309462694, -1.708329262531609, -0.8929733084407776, -2.3522185556759343, -2.6260054708094156, -0.6771848699487973, -2.0459740708187737},
    {-1.6596679762137951, -3.521484469019055, -3.8170208739588696, -2.2132383372851883, -2.883933479812025, -2.376031044581357, -3.928967075999681, -1.3502906258545058, -3.2811338082932395, -5.5084125932506, -1.8866285389161421, 0.21828357450113778, -2.309409334042796, -2.3686977131757767, -0.9348527941049694, -0.3616046020568846},
    {-2.692350471568593, -2.610851081746735, -4.1339244159269, -1.7904547941233582, -3.739311979546969, -2.7434167359271755, -3.4591344155526205, -2.432966792826636, -4.349687097838331, -5.976810227270613, -3.269200214564542, 0.22638971923011372, -3.084676195303561, -4.896049322889373, 0.048947427150740914, -1.2315808241726158},
    {-2.308957118475401, -1.2999293726415015, 0.16694458150441865, 0.3804399966900444, 0.13998156841775541, -1.210409502181499, -0.009978605359198993, 0.6537669078032151, -1.3932977910716133, -0.5367723362566301, -2.60110862907217, 1.6175520737857247, -2.6902674997728435, -4.690097945774637, 1.488669800483354, -0.3825573859295297},
    {0.26447471911904497, -1.8554820675609973, -1.0025174744118615, -1.0233080772784784, 1.6273195823865094, 0.9330300414056772, -0.8509767379682714, -1.9052553715758236, -1.76381209436865, -1.5801898086810453, -1.917710435340577, -0.5041140084273469, -1.2463431139227046, -2.4204349016876376, 1.4809253163866332, 0.954581017410999},
    {0.4170051820276498, -0.4848147402277437, -0.6403614989203974, 0.8213478429987598, -0.5495789332570106, -0.027064025358024397, -1.1103876378859776, 0.20252081041646217, -3.0939233319974164, -2.7812090602458794, -1.288175435305258, -0.06683834649457203, -0.3945979150467522, -2.7437591557301237, 0.2691349241505067, 0.2660422963103907},
    {-0.13073061010480969, -1.9672341584294777, -2.358964528970421, -4.277092319676452, -4.9031636543835, 0.4829539542766125, -1.869477752480539, -2.8027959236008866, -4.184010515450753, -3.6160778359497265, -2.128710765347711, -0.15884170809159068, -3.1509260665990695, -4.245751480682635, -0.14101082095799128, -0.33778045488482344},
    {-2.7629788103647552, -3.4540577897912783, -2.8603717268440296, -1.7686254229066292, -1.692148647606783, -1.6463184045002008, -2.9810925012743876, -3.292251338574995, -3.5938691029205607, -2.3520887539582453, -4.1194120695318155, 0.06578594886854858, -3.395066444443297, -3.509017874273513, -0.8154042951084087, -1.684985538483273},
    {-1.4587054812617557, -2.5899950265397034, -1.320234948951987, -3.41797598742916, 0.003080224284533008, -2.136895406629788, -1.6667730409521566, -4.019652769886632, -2.958051321836415, -4.411580010837491, -2.300273730068689, 0.5099895390323751, -1.322145824687976, -6.386548051970312, -1.5262878877759822, -3.3694710644391304},
    {-1.796863898028617, -0.1136958768783831, 0.18914739047888782, -2.59421024634377, -1.852248623635028, -2.1064376543628804, -1.197262257072191, -3.9259895347161353, -4.627467630568454, -4.867185093917692, -3.821573212597304, 2.2353736317386046, -0.8942650723190857, -3.425042807523297, -0.350395967032902, -2.1545084289824525},
    {-0.8277713380301249, -2.825489455579684, -1.8442064057806007, -2.6188361467181434, -4.208362694087935, -0.6812226834805571, -4.126950659495939, -1.6914143317382886, -4.664910252002973, -3.5555192058494587, -2.83528182132627, 0.8132631637613181, -2.1282311708365853, -2.32177232015537, -0.5022593459279344, -1.4023690175782686},
    {-1.5550323559601513, -2.093712433948336, 0.641217126818744, -0.7210272332815149, -3.3138065269356263, -1.591058246750719, -1.6898242787834838, -2.5621845599099364, -3.140261201358869, -2.573850668695302, -2.888908555272118, 0.9927108254107052, -2.4457506639679547, -3.4465616856558903, -0.5613936466561117, -2.614793696510857},
    {0.0464129456225674, -2.337312530046114, 0.13676501001077151, -2.216122904165119, -1.9977175644077685, 1.1149657707338188, -2.733160112090619, -4.154606847690908, -3.772811711742362, -3.367149867719592, -3.934001932993767, -2.288145539882388, -3.6072202367602273, -5.947100059576014, -1.1730713988559394, -0.9183584241576762},
    {-2.7742809441374567, 0.19826915419124652, -1.0735910781092253, -0.7159513090551687, -3.504978267694628, -1.1520085880098965, -0.03661235664746235, -2.7399587934184364, -4.2255788568210395, -4.193122427677964, -3.295063049968831, -0.6324230342404811, -1.741835630482847, -3.7228421239885536, -1.9551178425926685, 0.8565209745004546},
    {-2.31673151631602, -2.6668871372529015, -0.6094618946440351, -2.56843459492043, -2.4054008487192893, -0.9516900329977975, -1.7681170184422699, -4.244726583458962, -4.412072912173598, -5.645533894911472, -3.7167715218212307, -0.6690748296382362, -3.2614594552209097, -6.094955440613252, 1.405441263946686, -2.5516903257551267},
    {-1.927065298993106, -4.242252213887412, -1.7138425390694867, -3.564394802666378, 0.05438331435483166, -2.4397495688755853, -2.144345360104834, -2.4194378312236875, -3.88353477348575, -5.765769430874843, -5.115107998878111, 0.22069836895712516, -3.0178112129932084, -3.679925058960369, -1.0299212408051737, -1.4251481190349031},
    {-1.7903270541974357, -2.8331747901686946, -3.2852577253797226, -2.8970975041830638, -0.7236787225087922, -3.3807984114492227, -2.6041439863742917, -4.6162589721422345, -3.447709193064291, -6.2134307618572615, -5.1059074318924695, -0.8070543795718295, -1.9949570314205272, -7.311983103709228, -0.37167257582390656, -4.201763740245291},
    {1.1844982741827654, -0.5504146314725006, -0.002992777765770097, 0.2862472095580682, 0.46892646571933594, 1.7958814228095823, -0.6085982885825727, -0.700531174236911, -1.361922387504316, 0.46317759147914567, 1.1243597432851653, -1.158261442711545, -0.9649915509436371, -0.5397495966682231, 1.7301076380819207, -0.08623183929222646},
    {0.5827595954514956, -1.7615559583456677, -0.7717662471018303, 0.3012232917435495, 2.133350517894232, -0.42306938807121974, -0.23012428137913932, -2.2267184708052907, -0.7020391003785584, 1.4875876945415278, -1.7529892795620592, 0.38791413455233364, 1.1886787078813013, 0.5197755991798011, 0.2917765149943533, 0.38264117480851934},
    {1.327343070950522, -0.9550482263755897, 1.181653728354801, -0.30886360153512926, -1.1273286579499235, 1.5731933561458977, 1.8286214609440976, 1.8884621559312291, -0.5281597577260558, -0.053112965353152033, 1.1083498325561871, -1.175582568760723, -2.024689126990157, -0.8569344294192012, 1.2614449710502968, 1.3019985134772425},
    {0.5931903750808478, -0.9374146707634942, -0.055793136619637744, -1.8226173655076796, -2.1228947383199164, 1.5801661934325089, 0.28479829253611555, -0.5513653646840352, 1.6194339175451198, -0.07168012568137364, 0.6879821820015363, -1.9768622870628083, -0.3243046930792021, -1.9765650049989512, 1.7871255462983318, 0.39628344343073535},
    {0.7090060234160893, 1.966252793886433, 2.7532658746489775, 1.2802625912015753, -1.9862037966578736, 0.38159156672346345, 3.193498928926355, -0.9468943949761567, -1.8027937876153253, 0.7325273554757177, -1.0121957703321063, -1.1220151204122093, 0.004449257813754177, -1.3790346286985693, 3.172498920612458, 0.05086074684480532},
    {0.4709559301914129, 0.2722714988025062, -0.030610318747285654, -1.2345097499205158, -0.3686766491431725, 0.29323690004369773, 2.669374473480822, -1.2005022307032729, -0.7923579710761105, -0.28462706119163245, 1.3603102221403462, -0.9363614994719569, -0.13864101394191009, -1.309154849891635, 1.1941378625128147, 0.7869823968261971},
    {3.252854189313569, -1.6811768349857372, -0.5019895277070747, -0.7247572496146376, -0.23280842845353272, 0.8720188887327484, 1.589690917156102, -0.7356814262986209, -0.9776966702381155, -1.5097903355625624, -1.1594743873238247, -2.6956101064254243, -2.1884621337192414, -0.8574720317594043, -0.08157388531268571, 1.4837095631099324},
    {1.5806197707557423, 0.10532690809671137, 1.9472886948730306, 0.1802006469924336, -0.23933568732398267, 1.1884196436625856, 1.7607515190961227, 0.8197544240857263, -2.145624127544143, -0.13774910705478807, 2.514461993873055, -0.10134693874216916, -0.5415940243835884, -1.8312137081988091, 2.8640514520967875, 0.8080060213955841},
    {0.8690381385279391, -0.754307844260365, 0.04793217845788778, -0.03943515087167068, 0.06831404684010711, 0.5687775537472957, 2.1732617984386184, 0.744882361278309, 0.21255325938223993, 0.1373498260315164, 0.21457446968686114, 0.19960202417786121, -0.6200797620611996, -0.7142413678953464, 3.1545397267533115, -0.6352007444743101},
    {1.9125322632671637, 1.0180012144919615, 0.6787772662609209, -2.5603378811731776, -0.24140712455877208, 1.1945228040001596, 0.6947369269065591, -0.09707283335628179, 0.6555014974191776, 0.39595617255522625, 1.77253006463013, -0.3679556525350272, -0.6983990490573796, -1.649704038022521, 1.6620355606833122, 2.6302860123155534},
    {3.3696452128546652, -1.511913539884235, 0.2369267837454934, -0.6759568685252936, -0.2799929281037418, 2.5005884046756153, 1.6364319202773507, 0.7692388035174546, -0.18356092993826784, 0.4200575201306545, 2.1938619908366346, -1.0328739616897626, -0.9319864228643134, -1.5684966295358271, 1.6895338217347335, -0.7083571753371772},
    {2.9335670908291793, 1.6734550991649406, 0.9747067743128609, -1.707731092829139, -0.5152104580795613, 1.600749764339267, 3.126226806269989, 0.9703928871526055, -0.2963914678503551, -1.8449787013867696, 2.4337476156668485, -0.6199217621636532, -0.7878152070805453, -0.38011169530801814, 1.8741436216543819, 1.682433829151498},
    {2.7852943508955703, 1.5049795584194554, -0.2925757844817434, 0.35160414997685613, -1.2864174780737605, 0.40239426953754703, 2.391965183913898, 1.6815784969848604, 1.0456203207265076, 1.0685671832187977, 1.897174993083943, -1.2053166950266991, -0.6696593296549292, 1.1787539396104176, 2.4690881441263506, 1.2206099740206011},
    {2.09383613135695, 1.8175400757021978, 2.1927113239168707, -0.4988872979684305, -1.3213556751499698, 0.18103380700789162, 3.046788818101135, 1.0986212872773256, -0.40347830552838554, 0.10933893182189643, 1.865719645041688, -0.47186399806781804, -0.8134641344445805, -0.6726953510254206, 1.1776538488439543, 1.1967797716999888},
    {-1.1781410172257003, 0.44905448594770364, 1.4515874264639863, 0.07875210836984793, -0.20276702061827104, 2.095313694713558, 0.7283561839895147, -0.17022203356423624, -0.7189280045609863, 0.182842331571553, -0.8689608634636505, -1.4559707839227418, -0.010559417392788012, -1.1556739704008314, -0.22104912716463054, 0.4737031511999138},
    {0.024837705419878127, -0.7066291651475599, 0.7514475542899842, -1.2379103223100125, 1.2572609090273896, -0.4078655776863179, 0.8615880443572468, -1.0043669996294737, 0.8793263068591659, -0.26249999563000437, 1.0122321023014098, -0.1650647006256414, 1.5823664201136511, -0.2709106450154542, -0.20101165115739728, 0.5997535223726728},
    {0.9024761910472208, 1.6263675247998868, -0.15299694083719986, -0.4381773645462697, 0.9637928522205245, 0.4484252905714473, 2.076849712906685, 2.31301291331748, -0.12861034939369437, -0.9986878350091274, 2.045476852410255, -0.9901071934949401, 0.6941351826693124, -0.5848956347321119, 3.056786862039771, 1.190863595028945},
    {1.4681611277014466, -0.11989614916789729, 1.493530462152009, -1.056517013232992, -0.7896580148144098, -0.4549004299294425, 1.4317669117126923, -1.694625878228033, 0.09369643446805587, 0.40256002117157524, 0.3875144196341274, -1.6090579103667317, -2.245791582455147, -1.7082127955263031, 1.5941750392378493, -0.07606529177146347},
    {2.5182078599773496, -1.032349745007677, -2.3029176741506032, -1.300963496306679, -0.09856323904185729, 1.6268376585959203, -1.0371122232132994, 1.0589255874214445, -0.14474829337745657, 0.4259465235049751, 0.9228613941616588, 0.7549296100743693, 0.9122324650758489, 1.2459434776294678, 1.3981062182390158, -0.1722234074716261},
    {1.218238718330516, 0.6529991478455426, 1.2698653642298037, -0.0375128280777624, 0.7434459060329293, 0.92836754094152, 2.7969934840628334, 1.4278781649420977, 0.3432989453810631, 0.7364320461989403, 1.7687700177676469, -1.9071837131082565, -1.1469313764548479, -0.20819412636813753, 4.174941648675065, -1.116038188733819},
    {2.466372922489676, -0.5405002845539791, -1.0647677243206417, -1.3513957792818718, -0.13043432942410635, 1.1272091444725698, 0.49174412377249854, 2.8826191309280023, 0.08230685269435825, -0.4322173942828247, 2.9984590480809543, -0.40912401659592124, 1.2866037610428287, -0.35982217303792685, 2.444758514207415, -0.1389895875584739},
    {0.9247786740890075, -1.1718628764783146, -0.26594427917521096, -2.4024623382007713, 0.685490438251799, 0.5794882270385399, 1.4327918430662896, 0.16540715927034658, 0.6200901158781975, 0.023919239190740554, 2.0461046477836726, -2.987125601589288, 0.2568232699397556, 2.0046706548370943, 3.0334336550901004, -0.3178682792523427},
    {0.898532208757364, 1.301868568583652, -0.0855222134820516, -0.7911368742344644, 1.2045532488325088, -0.04307471522653465, -0.02360867140250216, 0.2399083368029424, 0.9759100177253807, 1.5477587352930213, 1.0510986785773802, 0.3449344386551937, 0.7837354864724256, 1.0920400562265034, 0.9382298857711335, 1.8924791630304476},
    {2.820135456182521, 2.102390442788326, 1.0165742672101785, -1.893325897590585, 0.6026730921114721, 2.122285490541526, 2.307357154593604, 1.2856273702894234, 0.7061612935744674, -0.38485639006700373, 0.5518619282610214, -0.8232181258677541, -0.0551102740732843, 0.16172299743976054, 1.0506165290725873, 1.6750641563658732},
    {3.173659101090842, 0.8893443762822281, 1.3613018250729076, -1.2109096278615028, 0.9498741545180153, 2.8793051258074716, 1.1382065037028541, 2.3509134367348246, 0.8498573700811402, 0.4142143261172048, 3.2833978546816467, -1.062689526005555, 0.3255138495450963, 0.3731955175241692, 3.6193609317242355, -0.27065062217776403},
    {2.0208480505091817, 0.5246758844646804, 1.7318235111247258, -2.895204334750385, -2.74229713476047, 0.42616205413482167, 2.9463262054153003, -0.1836008589394254, 0.4789111042737037, -1.756908432516344, -0.5206178800442927, -0.28564049906951733, -1.660129531905389, -2.866947903555723, 2.793205917865636, 1.5882169910581483},
    {1.4884068496596132, 0.9342331460836776, 0.9655283496899485, -2.788460464604799, -0.10350997797549034, 0.7991385896846984, 1.4392520506304796, 0.6356081020178713, 1.1585520815248003, -0.14574319660813712, 1.3876304024969408, -1.3590738386903118, -1.1467483117439286, -2.2489260870022276, 0.20912363513676027, 0.4716368452860347},
    {0.5536074307040784, 0.22652977682329128, 0.5597867418715871, -0.29836360407931684, 1.2948364163236414, 0.037227812739420184, 0.7977307496709564, 2.2672763811503343, 0.10077162044268695, -1.024272203566963, 1.8193888027713732, -1.2412295595769232, -0.4128883093359702, -1.1608922341586214, -0.6145115871389738, -1.2660654177057358},
    {-1.117912060807128, -1.0235732038273262, 0.4699477648862796, 0.2714547869358221, -1.5672614591778282, 0.9079444980662177, -1.6414294053908267, 0.4470886562416, 0.7605877339167064, -0.21627931682602344, -0.5708506280712361, -1.1889904550784045, -1.8313841871700791, -2.9511655341417926, 2.8168196119136857, -1.575884540508976},
    {0.785180159536219, 0.8632523266417638, -0.37017741226235956, -2.489835450533445, -1.5969925104293399, 1.3215745830402614, 0.6311443707348181, 1.56384330058456, -1.2961912232239312, -0.4183442859884469, 2.69764246553229, -0.8871486222254891, -0.42044826748619873, -0.7486249603166202, 1.8664501510091238, 0.7652606508681277},
    {1.1525099568013597, -2.0076821275323113, -2.0970549803860083, -0.4605269262649026, -5.015388085719156, 1.9020686424720856, -1.947103808843269, 0.39277679553010664, 0.13689713724984756, -1.3564577750272488, -0.9356547868615698, -1.3081900291527522, -3.034815417013949, -2.0706708386122674, 0.11649952599255466, 0.9358388324495958},
    {1.8905333321632924, 1.7364184944753023, 0.8598402065863621, 2.1446661522205046, 0.4807038275556052, 2.397367759346754, -0.9814792225225137, 1.997323402550704, 0.8986070730723014, 2.9624365337261866, 2.8297440553048463, 0.6101717360677149, 2.4889479300918356, 0.7503870813314258, 1.8583534278195255, 1.549902099167794},
    {0.04719923929222752, -0.9007495265140081, -0.05964977934832401, -2.095499729458507, -1.0928440782373436, -0.1486299618346769, -0.9592089502631133, -2.612263538242321, -3.242295391134472, -1.706840424168154, -1.9943971301209422, -0.5729115346874798, -1.4470105506144462, -1.4372425132435633, -0.2516726016104494, -1.367489868646917},
    {-0.12850626203777274, -1.981214699589866, -2.3217344491954393, -1.5743625683993456, -2.391736587782981, -1.3665310200190879, -1.9868089776443747, 0.30178430758305813, -1.3582102045038398, -2.734797513419682, 1.6592484537949748, -0.6140576051113417, -2.9227653480687676, -2.4020126187881305, 2.2891474181621856, -2.2733980879808833},
    {-2.0361935884648923, -2.327083248990881, -1.585877486187194, -2.5855198467538387, -1.165695198443924, -0.33464862763873326, -2.8783874667821916, -1.4978125621125709, -1.2193843580105337, -2.621292984228932, -2.3318784609089396, -1.033842426845796, -1.0389147830948429, -1.517491250787571, 0.320152411128817, -1.1506768221884054},
    {0.24689308187713155, -0.8551794033086799, -0.9709871076275974, -1.731560422325973, -0.4011563322286101, -0.5903013995867032, -1.627060624532174, -2.6172859937687663, -1.6918966699072522, -2.215497908804089, -0.9212897332402896, -0.48622503749824875, -0.42158674843258565, -1.4820944670090508, 0.7621781322117293, -1.4141818688701908},
    {-1.2042572891870738, -2.1465177748097855, -0.13293101863675286, 0.36282397997182386, -1.2393148096413724, -1.0349686320050626, -1.0561705845897427, -3.234623705548236, -3.330260690201831, -1.9970674632268788, -3.6330721686599423, -0.08421128442443002, -2.372213707423835, -2.689673809710644, -0.765491938667535, -0.27650181952360026},
    {0.9410472586605776, -3.1259605219158577, -0.4660285589392013, 1.496833298839675, 0.1879485454865614, 1.366662124296419, -0.23976892679651632, -0.5581929669063254, -1.6790071112300333, -1.903929632127328, -1.7955002014318044, -0.11870616075912171, 0.523186758971307, -0.9063157191866873, 0.7087400613586856, 1.5824808277359492},
    {-2.4988961030454178, -2.2912197991964325, -1.759921909846674, -0.9890196205233328, -1.510069322153399, -1.5455293454142471, -2.3874923976347917, -1.669429175195188, -4.0909510260205195, -2.1885647707749087, -1.512251193013032, -0.24699796401343474, -1.2065218498982107, -2.891150491359524, 0.6239211916499453, -1.3679719304716635},
    {-2.7170726358607835, -2.7021055758342682, -3.310741980524406, 0.6103834235481093, -2.3195300459566197, -2.126479522782925, -2.5018777206651146, -0.9998518832427161, -3.6698738005154055, -4.083571576310601, -2.56405428010139, -0.05259545868010681, -3.365343416792583, -3.163730107153746, -1.566386387392997, -2.3192717353359797},
    {-2.5100634728930395, -2.5951817274731352, -0.8300397601574498, -1.996875729950539, -2.058453351310224, 0.5216190742251143, -1.2869665079100312, -3.0841331200325084, -3.814476902928493, -3.6646502366877387, -2.149761670268888, 1.5532508022089218, -3.0782387959389723, -4.875547259367523, -1.0771824210227217, -0.5365752151871291},
    {-2.8945308929146183, -2.794054536532421, -2.6828005301691644, -3.1887069532464127, -0.9894383141412048, -1.225183845201556, -4.000054166108847, -2.586562930967094, -4.3918218309086505, -3.101169152675301, -2.8559695075764635, -2.310375009056443, -2.5364385294144127, -3.3625257510972233, -2.0801749027819687, -1.630850671787739},
    {-1.279961024600236, -2.0885026434477805, -1.6918450869114625, -2.360304827687342, -3.3147076267582487, -1.1788095746776377, -2.640318586594053, -0.805913139785646, -3.5530323830603296, -4.583473379328772, -4.204710198411953, -0.9101621531354679, -2.5248036596034877, -1.3310918828116733, -1.4787317950382861, -0.32588203404547333},
    {-1.05485989887134, -3.118418697788785, -0.9637867561545893, -2.238383120594754, -0.2098415360553625, 0.7255510749621928, -3.8737244958013166, -2.2116261116380587, -3.7114424188494426, -3.6619434374795112, -2.735484719901695, 1.2875155994256893, -3.618510778559842, -4.9514322412244365, -2.2947480532206908, -2.37581562758128},
    {-0.8775651933322811, -3.50296932310851, -2.912175687403637, -0.6321801475458654, -1.6771568053344803, -1.6638061041087235, -0.40983752392847417, -2.768011858934775, -5.262426451378565, -4.670146789623215, -0.8011024253217943, 0.11213986514396337, -0.8877077416102516, -4.387803860285129, 0.7998635207611153, -2.062292285472475},
    {-0.904335726779458, -3.8402510866108406, -1.7079846046659075, -1.090467890984368, -2.1227192795907928, -0.31595811375649907, -1.8502087476002822, -0.7021748382229761, -3.911098945362561, -2.8118569772981266, -2.6738567016835475, -1.2468680601089788, -1.3177204322107265, -2.866504731755886, -2.2935730071122884, -0.2545087935443767},
    {-1.0790410803390404, -2.454963455145457, -1.2060635696116142, -0.27323619091748147, -2.670778169492498, -2.1852411970802117, -1.665079748891058, -0.769084089714626, -1.5976923902527704, -1.5212873398673503, -1.1493189037876879, -1.2629535299623662, -1.2786610239027838, -3.3503971746495083, 0.05990193432435672, -0.7222248693167395},
    {0.558815195776935, -1.8628893097244241, -0.7394555611799624, -1.0908311401300075, 1.8116598862057367, -0.04125597832300192, -0.7151950092072706, -0.5233849957727412, -3.00255576217289, -1.207841876736242, -1.2206926687382054, 0.29952352560824175, -2.032137478066462, -1.4796468769867108, 0.0021878433933194934, -0.6307081165573319},
    {0.18932062073368294, -0.41619679473765747, 0.5838853223768293, -0.9607178621013669, -0.9004537301274184, -0.07927402027248517, 0.15678250347496026, -1.3954712072090523, -1.8082084349575755, -1.3172503968837213, -1.6032912098507721, -0.6613222240584771, -0.4940358560216881, -2.316661370553611, 3.0949615295790505, -0.7639644102309485},
    {-1.8371673174579015, -2.552140910393286, 0.8000931406249597, -1.2564128031421817, -2.7821646769381085, -0.6081058033616816, -2.0504266840221144, -0.1028891032404842, -5.146046446117802, -3.360256272186192, -2.88820964311048, -1.2121560707727272, -4.650770779020844, -4.187830459617981, -0.3514589386597259, -0.8741823793386697},
    {-1.3324058549891327, -3.466892191337243, -0.8166791589574349, -2.8528684316263404, -0.9760257769966918, -0.7539169606936819, -2.4627527539350442, -1.9028117250116947, -3.315459274793888, -3.9327487598588347, -1.540791436257871, 1.1899725253865068, -0.8159148761076603, -3.418116768051871, -1.2500491035447499, -1.1195492702021435},
    {-2.181304611322136, -1.6056634016450224, 0.6372597987930497, -2.212287395342683, -1.882038834014456, 1.2243746392917247, -2.3172915532732037, -1.7538742421953557, -3.414884796830453, -3.718699907819861, -3.7954077447468766, 0.22683421813361396, -3.2453066855513897, -4.970385156294845, 0.4148171930921938, -0.8734326527728609},
    {-0.2557982475757679, -0.5063634990539909, -1.5199548033453445, -1.6931040999767926, -3.6177170880938383, 0.8468311976595778, -2.847976295207532, -2.7301605046876136, -3.393658023814242, -4.774738923697523, -2.332998429802015, 1.9356331959664894, -2.4846528948521596, -4.09275016558276, 0.3462583198495725, -1.546298442074106},
    {0.2611149527919196, -2.297426061048613, 1.8870279550010984, -3.2636014978364543, -2.200863332760829, 1.4821412144446444, -1.861395267625093, -1.5364051733430544, -3.8339158268411935, -3.6404931853413873, -2.1008408636740388, 1.254807001719765, -3.3520014517892927, -4.3791064187682505, 2.0061792826453, -0.9878456777316157},
    {-2.1874711446428465, -2.316706013003913, -0.9220314110156865, -2.938978813758053, -2.27778085823027, 1.9830928455626657, -2.903887237177931, -3.1335504615815544, -2.587559406890653, -3.623105547221596, -3.500433164579381, 1.0082748150623912, -2.976223881123609, -4.140028204226979, 0.23916750734647468, 0.36448639766395785},
    {1.186341211657626, -2.3235997391685634, -0.5679305350134033, -2.7162275469733594, -1.8358904314196234, 0.31436431910489643, -2.2361678219801964, -2.436260532467825, -6.597358987668585, -5.322552551553415, -3.015819022840782, 1.710144106302466, -3.8840121140860706, -5.42213416685129, 0.6492913501920371, -0.7946866046169798},
    {1.4056574816715068, -3.358403925987384, 0.22047961837716762, -1.9065916098090632, -1.5390302899345583, 0.02363171015512435, -1.9695560772727412, -3.8473211071647513, -4.798364342938781, -4.322659396965034, -2.9082278888368296, 1.0726078198373892, -2.352411591827157, -5.318300185975534, 0.922170531380479, -0.7204831406597394},
    {-3.132513440683155, -2.397195027146952, 0.05439653862527505, -3.1536847395681082, -1.920445775262631, 0.6112196831058481, -4.005348997786899, -2.9645346847037337, -4.885580057892996, -7.535135166177883, -1.9551469045525665, -0.30588140315750645, -1.7055835224906046, -6.075274095574805, 0.5589788353015119, -4.162168670414733},
    {-1.6781037568969315, 0.45726553448610624, -0.7654130917980375, -1.9062508953832424, -1.9703092341389719, 0.4455164848747913, -1.1190308890803, -2.0995745239200203, -4.094646446976072, -5.576366863446552, -3.4093223844311304, 1.4789851419372386, -2.4974011413674138, -3.784526013379245, -0.2509256151973449, 0.3890853697452001},
    {-0.3101384389805951, -0.5949637378831533, -0.6102300461090319, -1.3063728088903632, -1.386739971379684, 0.4859344855555509, -2.6695896946776583, -1.0369627015001412, -4.555916123419124, -5.751851344875673, -3.9927694030701484, 1.1011430585250306, -3.9707930223369763, -5.1160115055126445, 0.23442407560328193, -2.737473080706352}
};

static const float b1[16] = {5.503731121412775, 6.133896892395266, 5.99388642558875, 6.3842395171075665, 7.170174439562672, 5.3399242604038415, 6.475369639425299, 5.216109193696431, 6.6766920541380435, 7.176922172948759, 6.298850085634176, 3.4725202170885843, 5.588866378995171, 7.149511459561078, 5.770589340378597, 4.433112936763247};

static const float w2[16][12] = {
    {-3.07744622623821, -1.7998184194401428, -3.4403543302184696, -3.5091515137073177, -3.4831149121468825, -2.1697571058585963, -5.143012925797657, -0.8144072065269905, -2.2940840024523905, -3.9934387790837746, -2.638226934374995, -2.690732432264932},
    {-3.6849175902131766, -2.28046870426272, -3.856012046329082, -4.5835399078308425, -4.823991222346771, -3.7329735752355324, -3.747213611814242, -3.637449268650763, -1.6192375732076303, -4.254180394095547, -2.8969161425588723, -3.9407810995445556},
    {-1.7477981451347782, -2.818234678430545, -3.287585452304132, -1.2216422495493258, -1.3568912156036181, -2.0585731888417227, -4.57620507453712, -2.5326129738300103, -4.614947876113057, -3.850590783503527, -3.7148688975069395, -2.898309547979054},
    {-2.9698558702250875, -4.113352569252677, -3.14020409392881, -3.7283375432301615, -4.044661839252137, -3.428186831483348, -2.518824382182518, -1.86853025944822, -4.434934594639388, -2.547020928401167, -2.6197555415896083, -4.215138377972902},
    {-3.4995823830904693, -4.123678559137468, -2.632362306571158, -4.065983324866098, -3.7807096358065673, -4.83741565431004, -2.625386787814776, -2.3703954554609954, -2.9601622560438137, -3.7810578081135904, -3.140016324955312, -4.4541178844994915},
    {-2.6882277228275817, -3.714777650872788, -2.4169745027648424, -2.2557957153307986, -4.43539197223645, -3.4778841253947417, -2.086575648569376, -4.02936588122559, -2.2659624733767108, -2.5331689019019286, -0.5600290367822076, -3.002522363567625},
    {-3.6055352591539704, -6.267256047462867, -3.1622505671160432, -4.0262605840647065, -3.7746561313473945, -3.120534776047339, -1.8689242141036588, -5.635323787858557, -3.5268515430694016, -2.384291343016967, -3.2761123129684373, -2.312613705144793},
    {-3.7604108282049893, -3.187402331830071, -2.8529329873413323, -2.0243583849522238, -2.6760639173737615, -1.7506192166097658, -2.471993223794312, -3.8119835307890026, -2.3414814117683513, -4.597189047540855, -2.9063519191017377, -1.7285010278879647},
    {-4.77319550392519, -4.070899494010007, -1.9059100458701586, -4.964425081420275, -3.257139280518394, -3.601779262369044, -2.903789890247085, -1.3250870327729662, -4.765421330745079, -2.824500735396436, -3.3689289544902077, -4.62884253874628},
    {-2.853217277207637, -3.8709436092385854, -4.411174971742487, -3.0302389477295057, -3.9394300527219226, -3.777163250696461, -4.201850155721775, -4.33037969403432, -3.037793715344694, -4.863984666479684, -5.738646473184312, -3.92601995584458},
    {-2.689662982740185, -2.9759756837534233, -4.077790413257178, -3.3324022618767675, -2.396796517534574, -4.950772121742128, -4.265343108656246, -3.3263793914385835, -4.571396962104638, -1.713066869351387, -3.243512596663152, -4.057053340711359},
    {-3.0846222782249146, -0.905373463982756, -1.7461257784519437, -2.5460744966597004, -0.9450709930438979, -0.8972293640643714, -2.4991139206179644, -4.275281272545425, -0.0669159306454225, -1.899535481740654, -2.381236596291598, -0.4927946397478243},
    {-4.238739341474823, -2.30764147547353, -4.8185184741619125, -4.889132996094157, -4.220601767675429, -2.121952757682306, -4.150320260902946, -3.7913748707000816, -3.4480698770551474, -4.408320886429696, -3.9104486414346677, -1.9851787540641552},
    {-4.572096692248005, -5.058656368497757, -4.597903215770786, -2.1720332475976902, -4.566112368590897, -4.927909994093115, -4.731807201036456, -6.279250237532543, -5.307444320840918, -2.954259476985673, -4.045869655412876, -4.2679425661374495},
    {-3.780263082322786, -2.088661972995376, -2.3794436750994334, -2.742213187029597, -3.2967436851004117, -2.6369862507676505, -1.8457050812465807, -3.1381426905977623, -2.58673452140953, -2.208714914992324, -3.977322065223017, -3.1580040959463593},
    {-2.926788915464229, -1.133510967047221, -2.366503580952934, -4.6239872580460455, -0.8205516631127655, -3.3445062755185693, -2.8829696346354314, -2.5744164555767717, -2.850328968521952, -4.081943195748341, -3.9465837328949758, -3.2051042183010248}
};

static const float b2[12] = {-4.144726913573839, -4.385354764837869, -4.495484931856293, -4.10851440333307, -4.2825935148549945, -3.8856719537464888, -4.281520295158238, -4.5920096645462545, -3.588252262853614, -4.131368387146335, -3.524452538627053, -3.7589909015164316};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
