#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7305043906369446, 0.07083362052901092, -0.6704844114376958, 0.20851971647050419, -0.7376635814163652, -0.6139756801265114, -0.5529442358550353, -0.7186303796008411, -0.48572356611792405, 0.2643200913708633, 0.3042898244418761, -0.482411555504329, -0.3953109008934966, -0.2139412860141971, -0.6739071412837061, -0.48963553573383, -0.8611736034556048, -0.8321723714419099, -0.5723496296110973, -0.028379773035494306, -0.5613928642069164, -0.008892023882991639, -0.5828780788058442, 0.4475805460433156, -0.7286850625818008, -0.04510729063247137, -0.608009958585723, 0.12037677251831773, 0.5581854168611483, -0.33534949579291873, -0.1638514937648943, -0.7337872473412997, -0.020507726374342998, -0.7187190114678622, -0.6881118007775268, 0.14030891058269673, 0.18990557900054067, -0.6104684385138348, 0.028094361698482815, -0.4791601923877682, -0.31932509295835565, -0.33844579601011127, 0.011090705425551113, -0.7326875489395522, -0.32112288503236314, -0.35386909828883295, 0.0730286844574846, -0.772857003509531, 0.09063631265683793, 0.24706619143090666, -0.6591253948687266, 0.3887862006369048, 0.13721453716437051, -0.6792684951503483, -0.3472099087837299, -0.38371277158433004, 0.42898056227681197, -0.41638285362801086, -0.18035564081605165, -0.35766158653443836, 0.27208257227765564, -0.6350629564262, 0.13967156249722695, -0.5327604296331592},
    {0.3264719772260153, -0.08950855997659674, -0.39514137272590705, 0.1494648889408616, 0.5462843667018175, 0.05709259676905032, 0.13226005007689523, 0.588594203944774, 0.18824152359437168, -0.32743526442763365, -0.045693652924110775, 0.14224836281948453, 0.4227751992219557, 0.01942416501275697, -0.4174395552036132, 0.27738962124210814, 0.35312377741962786, -0.06754844818526079, -0.3072038297410555, -0.38655031548206126, 0.6188821654113981, 0.5806174156245323, -0.12122877661740175, -0.5040530180320189, 0.5158710446714001, -0.11018571994349968, 0.23660551512310787, 0.6212899130807428, -0.4635696177327122, 0.89788080144859, -0.18410313322984906, 0.4781151473541235, -0.19293343655398185, 0.5132945049444699, 0.20498723576141561, -0.7038939673219687, -0.08977491615024838, 0.3793156379745448, 0.6942496641830943, 0.11336110295866339, -0.15361627774562295, 0.2802430700989253, 0.1321192323851271, 0.3494208382308708, -0.36013536072234176, 0.3784248874659227, 0.6813425554401805, 0.50957528039203, 0.2854020678650386, -0.3995125570627082, 0.6161549456156644, -0.22597503426963292, 0.344106294032908, 0.35457318353007306, -0.25796200535975083, 0.7208661308647406, 0.4473008494851807, 0.3443568026906861, 0.7969654018823634, -0.045505095973496, -0.01787986500783294, 0.7831266473637309, -0.5971652510534454, 0.43011710609969567},
    {0.3388242804620244, -0.378580259104689, -0.2001740223740794, -0.6905322375179708, 0.5003036778522779, 0.35168845577438823, 0.5555790550780502, -0.1335814637503471, 0.39223988175154967, -0.4890856357362567, -0.1650180398531581, -0.5610343045490748, 0.28292517925931, 0.46770003563798157, 0.0018604428862535475, 0.6098557022341782, 0.3183547488848399, 0.11418609110300311, 0.13040739172411686, -0.1980105464374978, -0.6528501375415392, -0.4872591547425985, -0.11358772081238284, -0.5188118008512443, 0.011891381206363525, -0.7667716303178924, -0.42237637614219575, -0.22788274938551753, -0.23981435836937795, 0.13376547416413812, -0.22546977575188296, 0.5922774552148338, -0.30440414402400173, 0.10858667439285175, -0.5916038652636827, -0.35453317616126073, 0.4303577193432546, -0.06532905982774288, -0.44466428923780943, -0.26332435281732913, -0.38915657269583104, -0.3554633110493906, 0.022965029928248767, 0.1115136851303652, -0.16571253108993614, 0.14278087327284844, -0.42874762745168704, 0.6184913791904681, -0.4400151793759931, -0.35212409569542524, 0.010897173491153335, 0.5036415827170068, 0.532669235338189, 0.10385280613480107, -0.46214691423975474, 0.027099141522041865, -0.16429324064239423, 0.39036367933532456, -0.26096872898630197, 0.5232857592380971, 0.11591814284833492, 0.00630035358958749, -0.7874164972135389, 0.002276235906953081},
    {0.2532515164380585, 0.4068295289841162, 0.5179924341398253, -0.5823278013153146, 0.35306498328095354, 0.5137660323229027, 0.9480393817540126, -0.41774552841418744, 0.498614011424048, -0.1148490174776011, 0.0686582038257862, -0.4238552671372815, 0.11300900030620495, 0.36113655023511787, 0.684982743720325, -0.26315959361709307, 0.4481989044623251, 0.5451270767361674, 0.6319782319351954, 0.48790485966451735, -0.4790271036262763, -0.6976696907280574, 0.6214218537651798, -0.29856807566732957, 0.27977369817597975, -0.1573282673144068, 0.14185486590670118, -0.8121049975659328, 0.08773958389666059, -0.3129197239290089, 0.4347492913288376, 0.4160850274391971, -0.14477924200470116, -0.4214085143044308, 0.21699838328236956, -0.18870470761522104, 0.20768297299032715, -0.10189431539339154, -0.7969039485908221, -0.5201870426488779, -0.04469825422038196, 0.39131929825064227, 0.19512633824221506, -0.4994786771077937, -0.13916980337372956, 0.3032393405835316, -0.7240423021389615, 0.4377325368833893, 0.4274691942286456, -0.16626817257693657, 0.06415578433720112, 0.5292609975045447, 0.0678630920346165, -0.17689433163354576, 0.6622278535386018, -0.49713232827766735, -0.7403102451578758, -0.10674057218463222, -0.187998886739125, 0.5017791837436524, 0.17651706831127875, 0.6824747581276305, -0.33046856823960713, 0.358909762389895},
    {0.5910414385157907, -0.0015609673642318048, 0.5763657624358275, -0.511714571200197, 0.22000515699524092, -0.16586587714814494, 0.15687284393682768, -0.3247893958971485, 0.42120239480813504, -0.4260662634760366, -0.3341105949378779, -0.8610957576790413, 0.22311175823867938, 0.3120679505347101, 0.45087462794676486, 0.5259119939765444, 0.3652531510210105, 0.694780875007734, 0.31251081082338594, -0.19293410428591784, -0.1651812379766608, -0.868423008500355, -0.0531699760449006, -0.4288998661810656, -0.09872151186899135, -0.6213987614886886, -0.10176245868141957, -0.24039084399875132, -0.4601218236833607, -0.38782632838854836, 0.5593443410485014, 0.3123070968104609, -0.20625399673492262, 0.12500368900086192, 0.4030908396969448, -0.47019740964794, -0.1513549889703282, -0.0007760788388940538, -0.5930585274514871, 0.07721651399592472, -0.26171024991193576, -0.4052764852107668, -0.37155831647789017, 0.1252099342814437, -0.2052405749497512, 0.5216998396303572, -0.4841096753555228, 0.7466529032667577, -0.42646720752336065, -0.26988334056172725, -0.17610367690691223, 0.3658920211597123, 0.4422289980696848, 0.27515802557111735, -0.25388773182149643, -0.21770513960453472, -0.4143983475754717, 0.3207886020392076, -0.2307348725984903, 0.21594653228160954, -0.17406013834369677, 0.14931225184239988, -0.6106219521279004, -0.006458031705841125},
    {0.7304016938576611, -0.07475260518838149, 0.6135343341936023, -0.03433215286171076, 0.5973061531078316, 0.40663484605546923, 0.8219279881345408, 0.5080871042911042, 0.4339572245218176, -0.24575568686917226, -0.13634812087154527, -0.2645775501155724, 0.4228744886735759, 0.5272786430984518, 0.8321175226346712, 0.31278890330750536, 0.5823569416345056, 0.6375925913536835, -0.03679382971317157, -0.057874252707551914, 0.4882202584560289, -0.3500983028613874, 0.29693725477653093, -0.3659247613992074, 0.4491592048992856, -0.5981952498720176, 0.10292464813917182, 0.28822693183569675, -0.6465715640432529, -0.20728196933980353, 0.3933886157191557, 0.0788426875735474, -0.5694750028434307, 0.7342856980743618, 0.6181307151477431, -0.085893850049603, 0.4091623370096134, 0.19957648546903398, -0.3892514760472647, 0.6161272265243521, 0.7732629980176138, 0.28484254340398824, -0.18643693928365035, 0.2098737049857839, -0.043928593477251913, 0.3268331108009793, -0.29456894645089987, 0.8491384875912801, -0.23842672206486834, -0.18406023361694174, 0.006043161725180914, 0.1773002973831217, 0.34279400548139966, 0.46407465579076207, -0.13983419557185914, 0.2741123672930179, -0.31905148889422325, 0.7414232751923442, 0.09287774124093436, -0.07574966165343515, 0.2881932410965261, 0.6151027518477707, 0.06595472603265773, 0.35816267350701037},
    {0.8594702976796016, -0.32865763006520105, 0.5304153328871624, -0.008508224421067878, 0.8217160440215256, 0.2667821696923862, 0.5762211331519846, 0.2859763465755565, 0.6812758943660714, -0.11890685584075324, -0.3568486058844718, -0.3695517157765443, 0.5972483430249792, 0.35878207864638945, 0.38329654159574494, 0.09771232638569673, 0.6999671979225974, 0.6356651594685172, 0.13473043092443143, -0.4538042760572562, 0.36042267042038706, -0.668190820818337, 0.3896311018132689, -0.16472225505991137, 0.336134408578747, -0.668385281067597, -0.2533144945100317, -0.336791544662628, -0.40442134816898706, -0.11474002236612334, 0.2793727291976107, 0.011697973130463103, -0.6263119324422667, 0.5603913371747642, 0.4700972171922954, -0.22537899075569248, 0.3036492039466388, -0.24291386550444957, -0.7013362071286896, 0.5077724045329322, 0.6905916754031861, 0.39906460361334456, -0.028141507586679868, 0.232277890259753, -0.14078593575402776, 0.4273839372742324, -0.7052153157416698, 0.6909938334887898, -0.3730164707921127, 0.02038477775713677, 0.22388832899531091, 0.2677507921300473, 0.4109023744351844, 0.019307175661581577, 0.4059118930114968, 0.22530676835236887, -0.38581744694400233, 0.597917612662472, 0.23325869570489197, 0.0024898663721950112, 0.247909699362376, 0.921803041174959, -0.4364489325694386, 0.4491320293150325},
    {0.6087564485200689, -0.22986923738773726, -0.0922299219436949, -0.18189698259408693, 0.010359773333339704, -0.20646707962706567, -0.018736904976662368, 0.017012740197527437, 0.07102595255775564, -0.28230168417862905, -0.1533833766886304, -0.3447281055156666, 0.12123740574708707, 0.20503483657528776, -0.1181487601188005, 0.1431431260378408, 0.5279976866368727, 0.33472800460359003, -0.21208050748509896, -0.16594707183270752, -0.09419405775836456, -0.18777449380362143, -0.4912478678379445, -0.4002597451936621, -0.21377876377293095, -0.6259014563999935, -0.39834659330461425, -0.13320359444688024, -0.0821973058251311, 0.1859233619780867, 0.15065867695260124, 0.2901739672037158, -0.7126878187663096, 0.23966891155446898, 0.14733106260420972, -0.5860324857894056, 0.1396143436360374, 0.04053986962134021, -0.2505436932647696, 0.25600401150166213, 0.02481716383770697, 0.1375618476629641, 0.14531587394838189, -0.11812929522604548, -0.38488745889939824, 0.2216321190259324, -0.206365407582679, 0.561078446249808, -0.3537135217088151, -0.37124894552867993, -0.14959340654832443, 0.1651307608389651, 0.5116164741411101, 0.466445103356889, -0.40249317431877957, -0.1024305176791777, 0.082510413928478, 0.5330573308266746, 0.31569481464022014, 0.20812970283994717, -0.14114845615577098, 0.24603223885705552, -0.6059299209632362, -0.10535181090517717},
    {0.5122583011050178, -0.30419822144706216, 0.40115456207814093, 0.03395944419383287, 0.6147432751608316, -0.1402947745849183, 0.0711980911327892, 0.4195489616557351, -0.12217394056017455, -0.35897417299787904, -0.03803384239262758, -0.19403095469171014, 0.44825291225855224, 0.35266484469911563, -0.033671691966106844, 0.03122684720295267, 0.022715620752514043, -0.0528118982624141, 0.14196916120068293, -0.039124687915785744, 0.30445064188439525, -0.30487429309922626, 0.09350798113591699, -0.17727376274569528, -0.35871187210269284, -0.42363442707402954, -0.29081859048965064, 0.27988522443752967, -0.1726534834000731, 0.5349669283490531, 0.25045325000482954, 0.3568905094645366, -0.5749136205034794, 0.26770473787723775, -0.125971243290441, -0.19186817893072372, 0.11891838833203598, 0.21663204734753239, 0.3358650646361279, 0.3704836032796821, -0.07567255635302882, 0.010463609864355204, -0.2607981324404373, 0.4160664095265507, 0.37540266193916155, 0.36275101446085745, -0.0012972822904991127, 0.5922846842762293, 0.5762372234328104, -0.07911048754604919, 0.1362620287060136, 0.07277787114025276, 0.3719956257452079, 0.6028001508420453, -0.3807145151911075, 0.45732778236331856, 0.31756055029641606, 0.5376503519874819, 0.0072035128594667795, 0.3709571479630978, 0.12467308459584724, 0.6099609049725485, -0.4055302602805978, -0.13999379068615245},
    {0.5303835773645179, 0.1800354734742948, -0.28254698224067004, 0.4609770006032595, 0.5979426854970794, 0.25911568216708947, -0.6111685615544996, 0.7150273654113816, -0.1537261449865507, 0.48922881700814447, 0.22214014248783248, 0.2893887876237126, 0.5823934546847858, -0.4974138080394784, -0.18037011674316028, -0.04296976920176867, 0.08430020506352333, -0.013132845878999435, -0.214261762960966, -0.349020753278016, 0.24368936402934607, 0.3731493574434185, 0.5333343126805127, -0.17483259278666885, 0.39456929812559605, 0.50505712682444, 0.46729699625413357, 0.2914209233204392, -0.3372322809531219, 0.2865369143208073, -0.18654316801681997, 0.03703666326634559, 0.05682652751346295, 0.5569957050864481, 0.4100549257146722, -0.1627814757288997, -0.24768430542895217, -0.11466711795569381, 0.31523015925351094, 0.3619715407560541, -0.07649361981744143, 0.5287385727156495, 0.3963190657162276, 0.45019622065699083, -0.06397994522583506, 0.11922989381947469, 0.46439524946912397, 0.27091335196057226, 0.49696809208175674, 0.1745544757639487, 0.08389391271578567, -0.47065528320327665, 0.01507051349664965, 0.25358150777966565, 0.2757457643005035, 0.7711350828929325, 0.47034856481647513, 0.16454371674572063, 0.8577792297938897, -0.6456790397823494, 0.3449285327524036, 0.4126327107656449, 0.056796962867302354, 0.03510180964204059},
    {0.4486477706831684, 0.22915577543635474, 0.3761673137171639, 0.4216371783683276, 0.16889647352555423, 0.23460772102911875, -0.19866751149534145, 0.5657919136310915, -0.3497575148580124, -0.16003056739308805, -0.20251222648450865, 0.6795826629286369, 0.2085319323447161, -0.30063125687297415, 0.4153108664577671, -0.6015402151571891, 0.03843598244379728, 0.38875153705026033, -0.09063739257416493, -0.4623595880638267, -0.056965568592224874, 0.1518451910211502, 0.7143556302761501, -0.39777485431402476, 0.2662826618437936, 0.08316114014408622, -0.0003974265680807298, -0.3090542603578173, -0.484940242071323, -0.1854498161676962, 0.11135329192250654, -0.17543959139268053, -0.11596315252085124, 0.33171818188982305, -0.04456748959574951, 0.05740557676619942, -0.06640580242426584, -0.44938599614823, -0.08358505272210971, 0.2901118501990506, 0.6937199365672219, 0.3126164847883002, 0.3805938752843508, 0.2752790560282833, 0.30462617298070166, -0.8193422061512813, 0.3014959904001661, 0.2938365880202063, 0.15349940741744567, 0.021470447397082634, -0.05452947713476009, -0.46041759883901534, -0.3036828509953279, -0.09288397062644575, 0.17636577263952036, 0.21931739893995314, 0.048861825959194145, 0.009284654275503115, 0.4928955430727894, -0.6413808084352493, 0.06134911524334886, -0.22015391277330693, 0.10046028279918705, 0.06980606321090894},
    {0.314614515761834, 0.30886806058082744, 0.0014663406894031682, 0.059769542782629644, 0.40835205429708193, 0.41863661132069063, 0.26049019263570056, 0.09732639768764152, 0.3758570085996225, 0.37224457625381213, 0.2896027982084599, -0.11877926320321358, 0.271973455748684, 0.24463615264692976, -0.191720831415713, 0.09585597199483382, -0.19508727610021273, 0.030856273922656864, 0.42523016411192555, 0.2168598526353982, 0.23513424963581853, 0.4565494211824767, 0.19045509474092445, -0.050068530190957, -0.40380963399975006, 0.292095899275659, -0.07157294710164616, -0.16583847147973027, 0.38727065372786634, 0.3618419473795821, -0.18503797594701077, 0.541638406620688, 0.3777860451490512, 0.07279685295766501, 0.3353189718563751, -0.24551871095239758, 0.22072261452180925, -0.2631527241203343, -0.0764159713776056, -0.1884080780343863, -0.5463542690012354, -0.08272973119981862, 0.2152078452329057, 0.15080545553041408, 0.507346288351976, 0.674192708953458, 0.36080118781335346, -0.2317063457948932, 0.442801406123445, 0.27552304035569497, 0.41120498429935043, 0.5714060910828355, 0.13463757168797374, -0.5611182540850305, 0.4664458205704859, 0.4317021401041805, 0.11868929407517761, -0.19668815542168505, -0.11085586393733712, 0.23418221903667286, 0.4699294608918499, 0.3067652162692562, -0.03841674431256459, 0.04457634553717233},
    {-0.09747082689316698, -0.2270470504783689, -0.24498400729987485, 0.24701903659629396, 0.09744743384815374, -0.4704438480810017, -0.4006478617667132, 0.6890575169873361, -0.09140422205855514, -0.0494458439374114, -0.5568362945902974, 0.3605965390174804, 0.20592274623538184, -0.3911397221663785, -0.5550995496796979, 0.0564755327672795, -0.23502923310214874, -0.35290042151711054, -0.5702187896153459, -0.29101736739594175, 0.37311603924150405, 0.6961252152879838, -0.11917583051369414, -0.19798278543791756, 0.08696625087259248, -0.47847858329614373, -0.2935819800460217, 0.5323615504784891, -0.545038934453974, 0.42727998961069136, 0.09200909396807562, -0.6987769795833217, -0.6468787341405001, 0.25750218470120756, -0.06766904414153552, 0.31413146283312193, 0.09479694802548001, 0.5054868490163549, 0.4899075137581952, 0.8388941372430399, 0.2503607197023544, -0.37302693148031896, -0.1964345616619791, 0.762811845431271, 0.5650230360686225, -0.3401925350404571, 0.6214611734546805, 0.08971693664884084, -0.4550919298210197, -0.09799517999572244, -0.3365522831022788, -0.6368610164067922, 0.4412975687132036, 0.26673975410167844, -0.45009992089452555, 0.8296706286224894, 0.28537420252327145, 0.5022770726391185, 0.6480674126567446, -0.32100980225806214, -0.43174652713906225, -0.0638859941825239, 0.00823048838071124, -0.1459735104716212},
    {0.5292064665809959, 0.5036374122896141, 0.7483216822232187, -0.4157110122959201, 0.6561136863333551, 0.6134156305167497, 0.9115908798329777, -0.510954243969031, 0.2873800900896168, 0.07162463092142099, 0.41195344603928985, 0.34097880522183993, 0.06286712700113212, -0.4460490282267527, 0.6354854298494947, -0.7077680275673067, 0.7628125620211208, 0.30334335892177033, 0.5262059571664788, 0.48005814459243484, 0.28458719817020683, 0.09113804513385264, 0.9024760576948074, -0.1995432403305009, 0.38367560122127037, 0.5832757840546513, 0.48293671335456956, -0.2499102840819286, -0.2445783032689731, 0.17840020141265733, -0.232618842369678, 0.6049925310209067, 0.5285433293446218, 0.4439412342843249, 0.5242471359555726, 0.0627440986214837, 0.08382141700619919, -0.021172491714003084, -0.45934297663795, 0.4350774249613462, 0.4439571622800991, 0.5517786118762141, 0.5298874221661611, -0.22788003437498427, 0.25116773800073877, -0.1971873089386859, 0.040700878268917155, 0.10807012810416255, 0.6075534335271463, 0.4911632198255798, 0.7075112919953569, 0.25888486609257266, -0.5853905332371413, -0.14420634311548466, 0.8174593621443738, -0.60291356135835, -0.5501110459703119, 0.015577039049113523, -0.18232832209241684, -0.18281316857911234, 0.5890034773110463, 0.6309694295374263, 0.49043555134454614, 0.4166602790254447},
    {-0.512645023835844, -0.018059681481650495, 0.5267596477490747, -0.39777041355573733, -0.1865842991819303, 0.5317786431350484, 0.47723565113893024, -0.06655117300357408, -0.016453616473887732, 0.13059106628241857, 0.1737985861231261, 0.2520253244600116, -0.608444823472897, -0.6034140583638972, 0.693682355938059, -0.8291446387009096, 0.07860606410816075, 0.1277630615275519, 0.04008619337931741, 0.43681594938720103, 0.35127095851727463, 0.09732749186664708, 0.36551210454163374, -0.08364844076047152, 0.2798393420406032, 0.23319526494808704, 0.8445335495274918, -0.23190482885966163, 0.33871579956309555, -0.137495608811456, -0.060893549941472516, -0.589655347463642, 0.2956588703572694, 0.42434931535805376, 0.5072357612629961, 0.8146737618136409, 0.4293037823402968, 0.3055458660327406, -0.3201772403388582, 0.6103120975593999, 0.6029228671743182, 0.06327187641723479, -0.37634614436863484, -0.20697663590789445, 0.34185473043223946, -0.5282095595619684, -0.4534321158108692, -0.29627881742949985, 0.25958188240539126, 0.31206238736190445, 0.4856189228112182, -0.32077836598904225, -0.46189372643576504, -0.4375578805454635, 0.7012706911787568, -0.6769876817391477, -0.7295136271951705, -0.013591894324399351, -0.1588798479166894, -0.10495020160357325, -0.3745229169964357, 0.567164974272253, 0.4115429558026372, 0.2768578838951796},
    {-0.003150906563031592, -0.09379385916218361, 0.5100332648842382, -0.5234996602718531, -0.15803659127388117, -0.1928011762360438, -0.23970549945138636, 0.21406194338785314, -0.050801913873052953, 0.15756834058288557, -0.2806543038325447, 0.9910764485139125, -0.06043310426180283, -0.5804976203276452, -0.10942349677969197, -0.4947495439180957, -0.04485862303612788, -0.3142481269979276, -0.5425234253780014, 0.17539141320415574, 0.7095308162342515, 0.7868142677477497, 0.09304371711937205, 0.05443769127049725, 0.011115311196635948, -0.11678381980671922, 0.3721002877000023, 0.27893309772961294, -0.13097111883545567, 0.3699006657970098, -0.36163013257962057, -0.5325499025002193, -0.2681488165375606, 0.8726449979758246, 0.3998721201716765, 0.6396696652902165, 0.11511627009987557, 0.7426762543430914, 0.4897257476817198, 0.6524705577898713, 0.7472285216711597, 0.07746436144993207, -0.4212965056449544, 0.38470755980716453, 0.517089490685794, -0.4625120581088466, 0.29378990421077816, -0.06026210871095298, -0.19471261942071652, 0.006022975782490325, 0.05985700357152679, -0.81393461286459, -0.4280743928782445, 0.1891786817931837, 0.12855898616443576, 0.10895384221359498, -0.0019964310309408613, 0.47524132775047395, -0.026983352814638515, -0.03402080939235367, -0.6532730898917644, 0.04759663563900004, 0.622110670050674, -0.20222072467527383},
    {0.21369698393556702, 0.3973286589287561, 0.46407929754187466, 0.11927209463629031, 0.5184124862187707, 0.7147814073148865, 0.6896023651105548, 0.029245001962125202, 0.1572443168978997, 0.32324753598957345, 0.4175215047287109, 0.9050991778042852, 0.28488944423635765, -0.5535984636391992, 0.5147409104749597, -0.7958622797207727, 0.5498622868445462, 0.570490003612164, 0.7359585244827096, 0.2962651252676662, 0.5225079895643626, 0.17222796562677073, 0.8396449100957262, -0.31122927318945637, 0.4434123645665883, 0.2976092793664251, 0.4073191026767537, -0.3901991446948055, -0.016541041580269998, 0.07033800503878301, -0.6023124577324003, 0.199065149904662, 0.04862431494722071, 0.5580343848889935, 0.6591870967338546, 0.3452239400516453, 0.17642859337988737, 0.3328398169168754, -0.35797228497787414, 0.4024724343386235, 0.7380025521393748, 0.7040332860683577, 0.6560942159180686, 0.018559188545671984, 0.07337607460958868, -0.19841676535452538, 0.07554233340509876, 0.4695132888003779, 0.5318503825218125, 0.6245571410178791, 0.42618083593812944, 0.5395499212994285, -0.21420271615823475, -0.40366220077328147, 0.7438474939436317, -0.5348702004616552, -0.5052045563230151, 0.21886946030011567, -0.19323356847841666, 0.19559852552116205, -0.09407795405349764, 0.6188315869503243, 0.3701026954079312, 0.5049349042985039},
    {0.3599261633035096, 0.5021160086178672, 0.7757909343391078, 0.23533421765221663, 0.6372352515451069, 0.5071296358308965, 0.3351226610468591, 0.20766711388444786, 0.4098747753529404, 0.6867260076438493, 0.26942645466796394, 0.6682724285046228, 0.12626261143202477, -0.6546473293999207, 0.47889408636321185, -0.6589156844695018, 0.6466328715852072, 0.3638524134837165, 0.5615637643895625, 0.5433821080649606, 0.5693667795913476, 0.20230117197939057, 0.6044547971682537, -0.1949294492075122, 0.38632920065630105, -0.25678029903093136, 0.297613520270424, -0.32724441941357185, -0.16086648554349287, 0.42590511831855876, -0.547291788986559, -0.017316213986153545, -0.23647429960227423, 0.36947338849159345, 0.653218205585728, 0.7075640927128621, 0.23884847116575428, 0.13485185716273734, -0.19394557116627384, 0.6660452922689614, 0.8568344495436562, 0.5932551365686186, 0.17636116108281807, 0.5375757022023817, 0.18755023071763718, -0.2686352029134145, 0.3317258532580308, 0.32661936794727303, 0.41181617805482695, 0.1768190217179864, 0.6041275660958625, 0.21118778337218305, -0.4855600765473669, -0.3019027129812974, 0.7692726143333901, -0.23346770356329927, -0.6206229038064921, 0.00032165296569852333, -0.3186961018820023, -0.14092088376522746, 0.253328706639958, 0.5096114027860544, 1.0889452352977091, 0.3832168821747971},
    {0.3943854969662182, 0.3500960670094636, 0.2692794647956611, -0.36231815511733517, 0.01240628578070927, 0.48028840534801864, 0.43203162177219845, -0.033894624397814495, 0.25158390412360343, 0.04378831169169191, 0.32322867635855296, 0.3137825962771094, -0.20216094283829936, 0.42917848977251427, 0.2698126710462321, -0.29552414446965625, -0.020169794211973627, 0.09042215002522373, 0.04233703381323799, 0.733351308370867, 0.3803607830030456, -0.2970356264674457, 0.09555254983826177, -0.1002194094173658, 0.10975238076353734, -0.17485502975257025, 0.007383059659948691, -0.5375428318998304, -0.27204868818984396, 0.030212994364213715, -0.5917449687480568, 0.30664422068428243, -0.24461141044894832, 0.028882219147694083, 0.5245420802271301, -0.013293386174964117, 0.2697879489817924, 0.5205850129924353, -0.4396238750354287, 0.11664173424366986, -0.0754953335674177, 0.4583604060844035, 0.2922549494003608, 0.22252594157608105, -0.36964202088145653, 0.22224660977239447, -0.16619187916908337, -0.035811336008954024, -0.08622453334518758, 0.2355121352630691, 0.5139705636970896, 0.4793315860783647, 0.17222077598131616, -0.4565745693625928, 0.44275075238701733, -0.3990584850750958, -0.42707209253713174, 0.1248166817671218, -0.4964297080674843, 0.008597593238526487, -0.14027055930367557, 0.1318746519001569, 0.388506304349555, 0.04382572491014773},
    {-0.36383772083558413, 0.6298800961274975, -0.5020475719659618, 0.21463316836741572, -0.05021329497024441, 0.10588212962033934, 0.4726285460418129, -0.11824995521343198, 0.03243894614402257, 0.12344386244824034, 0.019443634945126187, 0.023442386842840477, -0.08869293300373994, -0.04549526489570462, 0.5284494236600351, -0.3721866073881254, 0.3836097383877037, -0.350082358427344, 0.18761353905039524, 0.24501109632806387, -0.21533768321083038, -0.2708720582027701, 0.40172757483695454, -0.18307994910131364, -0.28441605490259153, 0.42210814557857157, -0.046970250428878355, -0.5889806706469518, -0.24987458457483136, -0.25220151904681504, -0.8543624987918069, -0.542477324706121, -0.07635676511748608, -0.26147950430304284, -0.21835171168906656, -0.09540599957772737, 0.24950641768417353, -0.05969372267972343, -0.5900112569566335, -0.14010241149281766, -0.11294233026693958, 0.20613497124255617, 0.4908842319338482, -0.5752228800103256, -0.5264963866127098, -0.6173864910826331, 0.007980257649034445, -0.38492510972229876, -0.17240034637982873, 0.3638442822102683, 0.002979706226061849, 0.7024416520198946, -0.24569450027147668, -0.5388298841217484, 0.3297754235143861, -0.24339428585864226, -0.5698069914489394, -0.04035515144883246, -0.2693117995018631, -0.49245573585674823, 0.10812675908593444, 0.43921182729886243, -0.019669025394598767, 0.3926512426511483},
    {-0.4714239694001525, 0.5524266071428204, -0.09256868861419379, 0.032329467461271785, -0.6007103934179554, 0.6217258706425596, 0.2855584283385239, -0.3186964200558111, 0.3423249930748307, 0.22712763704760347, 0.08888180917081759, -0.019960051013844553, -0.18046938064647086, -0.1702714376466868, 0.4677142591723513, -0.41335136769375025, 0.31878071855299744, 0.24986203018758077, 0.2496430928868021, 0.6324116114177547, -0.5079686687585903, -0.20955820140577, 0.5509965574659258, -0.2887164637720845, 0.476676937374669, 0.5425035737579904, 0.18511740382967978, -0.4458291706956329, 0.5754688589676362, -0.1993479211149111, -0.5431709415413342, -0.015209745973091616, 0.33306876422578974, -0.2782933147038879, -0.37720024317718115, 0.6551499221862213, -0.7936383611257198, 0.26907351209364483, -0.45813196480493956, -0.24087967158317478, 0.2816510041846666, 0.42272552377995304, -0.2886456229410411, -0.4183595663991988, -0.2623546902740096, -0.2755272987603242, -0.1186480197992425, -0.1286495043262381, 0.3328997103881902, 0.5271510334570912, 0.3564038997122694, 0.35939840704155296, -0.5750761785762342, -0.39350675718084926, 0.7085970950879658, -0.4810784239616925, -0.5484259814936057, -0.014862123010451466, -0.6707516118619303, -0.11647371203171296, -0.16056051106989405, 0.6748805247982488, 0.35077822196149455, 0.40076095238983755},
    {-0.1011837191736674, 0.3543750956482259, 0.2159192453498401, 0.12367088703503931, 0.24839914620003234, 0.6604757300799635, -0.03955882163202982, -0.4879812611920206, -0.09677319879961106, 0.5147004746880646, 0.4981549855543629, 0.5316121662706592, -0.3197148131543909, -0.38525878200476477, 0.6014659933359568, -0.7246257157223, 0.4382823152954414, 0.4757857814236875, 0.1191437575104699, 0.5663378153533919, -0.2962526784517287, -0.25096719892039104, 0.5312622104317148, -0.1403523177518059, 0.4089307123910483, 0.8838865525361301, 0.4228686760248042, -0.36083780727819, 0.5230012740715426, -0.5152139114016846, -0.1111197469654881, 0.05268148109347157, 0.7577649699375257, -0.4846472783762054, 0.37528372149352907, -0.04918065192428863, -0.07319101522020895, -0.41317524514451887, -0.6490359685911007, -0.029374653140185933, 0.3420387479007194, 0.3861342571502738, 0.19222154441976802, -0.4007921781129707, -0.2310128879938098, -0.18562668171305075, -0.3669036948659007, -0.1844867224264416, 0.382753335035279, 0.5038798798602756, 0.6893579740927933, 0.27153469967210286, -0.5536284509647807, -0.40358841464162737, 0.6387638983490099, -0.40859671944684617, -0.7518364695770795, -0.7301147768305423, -0.14871353866825773, -0.020444701446224834, 0.20167900199616037, 0.21852357037176187, 0.6839623471308542, 0.38134858079269823},
    {-0.05753638268579515, 0.6685239437670946, 0.07546978246067088, -0.20592582471983054, 0.0665477430490653, 0.7617894499054956, 0.6944944272070057, -0.5351591091370381, 0.7665410931372113, 0.22430071125784268, -0.23038211617851645, 0.021844145797096884, -0.607460559732453, -0.11650995372155747, 0.5890081104812611, -0.5115252007221989, 0.07481637674077986, 0.31926028973711523, 0.4844104415504233, 0.7886157146251516, -0.16926321771552313, -0.008568755482920338, 0.8148637229995775, -0.2976492626329328, 0.4898562450351529, 0.2510651613663377, 0.5341881907703193, -0.18839176250536854, 0.7382647917315539, -0.42317444294285583, -0.45320647633118427, 0.436614901686794, 0.35884286294639395, -0.7057757866805064, 0.4153639065078778, 0.11354136532424171, -0.30628609549679836, -0.14326441348404945, -0.27756838728372446, -0.3233692772884174, -0.04429401463826981, 0.3843038279208795, 0.15671519134896833, -0.23405029409733077, -0.48671245311080696, -0.1874143788161211, -0.37903458627929776, -0.014366059003618724, 0.2155654636198943, 0.5981097040192771, 0.12806744628547648, 0.5644875853042811, -0.691195992543642, -0.09386069580091458, 0.480748518205668, -0.36408987551199345, -0.49338007211584944, -0.47721295182043505, -0.6297602193054379, 0.5082045268566984, 0.3096953815661517, 0.006390591408289626, 0.44043792169721957, 0.7826907117736186},
    {-0.04605847970258497, 0.6230758638436978, -0.5564219740572113, 0.36693872611273765, 0.05244198217642226, 0.41788943540302703, -0.15868826712960996, -0.5306945007924775, 0.38365926353693786, 0.2152859521218162, 0.07560168650084058, 0.1947786750605637, -0.5089296817414302, 0.22210173327407784, 0.39149100041249457, -0.0078224120629412, 0.24711293738467505, 0.2998485622325011, 0.4511538175236958, 0.28876727450546874, -0.16406184326119005, -0.04858647257203206, 0.7594003866418613, -0.138029502990119, 0.5270716683065872, 0.7665374699936993, 0.2311470474509805, -0.2753449305835127, 0.49513764132719135, -0.6364424374688084, -0.5342698472869349, 0.341280395157259, 0.43290239032341693, -0.7610423168552166, 0.022713540451268575, -0.34635473221039753, -0.6451942968642105, -0.38021792046242675, -0.436408687532757, -0.3156244585443654, -0.49183425121806107, 0.42853513907848, 0.23368851744296695, -0.14230905332072724, -0.6567673817939375, -0.2421317572869287, -0.47201395403859875, -0.01350154669183819, 0.1763122500563439, 0.29027795652615307, -0.2007063547506307, 0.12648608051785734, -0.6406715067429475, -0.25147908651339707, 0.3826307928612089, -0.37213499524038085, -0.7183550113916487, -0.6140784767189561, -0.8597519863418336, 0.17487372058226108, 0.520299742424866, -0.1443904492178992, 0.2816225175473272, 0.5945006453302442},
    {-0.15979244494284514, 0.518801127469288, -0.3023338938806803, 0.02870977955073025, 0.3319291578050038, 0.4746763483703287, 0.4459862419413672, -0.6005329223610552, 0.6071809343953666, 0.00184741773403113, 0.6292310919417028, -0.3309361458625921, -0.3936400770371087, 0.03400604390198462, 0.8301680764445645, -0.12556484887531205, 0.07398875534245236, 0.5937319090051554, 0.6120417532001277, 0.015109924324510107, -0.5447295465482688, -0.20015551985168248, 0.5842026301758412, -0.2504362863944078, 0.38827118322175497, 0.8118598928945697, 0.06640070201251382, -0.5499328561815752, 0.42449398135085303, -0.5645456551186849, -0.33768532491720327, 0.6218940230771347, 0.36451560870616717, -0.6861024384140788, -0.00940930124068763, -0.5612617282559477, -0.38229923718806197, -0.32459508962152445, -0.6299835570450679, -0.7399822446965444, -0.09711885758656562, 0.5461700209676608, 0.5848827519031876, -0.3247978655514113, -0.35252761962527945, -0.12771186922882347, -0.20864510384665078, 0.29666960547039317, 0.5104854991221435, 0.8507292567265297, -0.2508806894698923, 0.7998513217197828, -0.44549151403904613, -0.5143559061529419, 0.6041112230200826, -0.196687177353522, -0.5151212728819907, -0.5996500821651103, -0.7105534762954175, 0.37829494294506194, 0.7622519519840851, 0.35877634536799985, 0.35487960165009347, 0.2813353707716224},
    {0.05059061315728339, 0.656417429651134, -0.7624756588077034, 0.16745173636915647, 0.3010144062905405, 0.6172836024538343, 0.3814198690444019, -0.5852166872861191, 0.2700122238889409, 0.6483557752626975, 0.3475307836629131, -0.5983937316315137, -0.5387917877706782, 0.4346020830299419, 0.43138468400410407, -0.09934663678915648, -0.09306916269702173, 0.4533160014151246, 0.4654439980715592, 0.2763379874764322, -0.5410531988729157, -0.24660502517735464, 0.7198001131141033, 0.26241131202247664, -0.1405973713537755, 0.9080943288040967, 0.02358280403104262, -0.7671201427846598, 0.936610514490841, -0.29279981983288855, -0.3932644983666032, 0.5339749553971168, 0.7440872148437013, -0.9404843862203803, -0.3364300424673649, -0.19433695782270263, -0.2919201772315043, -0.3564383428688626, -0.1908917216124194, -0.6715561908467653, -0.549154044466047, 0.39878469390839855, 0.5199029004623904, -0.6189602137766992, -0.5683995493772334, 0.40774416646126976, -0.6123345039208447, -0.7372437037476904, 0.35274382254699244, 0.7463472120177423, -0.35862231748148643, 0.5312973538048708, -0.035649276649788446, -0.5251749783368402, 0.45008148226952166, -0.48691059834575334, -0.16743611270518519, -0.5090286717328234, -0.5775009579797802, 0.3507051883866235, 0.6586264665084215, -0.02444016594681169, 0.14262884218419572, 0.30444110866148616},
    {-0.1676733316243103, 0.48271780474804377, -0.40279135100295954, 0.07933459209984976, -0.2379517424316179, 0.5699028297349175, -0.031575014681470365, -0.7616116318979667, 0.1166222982617706, 0.5764249488434953, 0.4555256317241514, 0.0638825627272255, -0.7091549581428384, 0.009048093562689116, 0.3314685035180995, -0.3757915166887293, -0.2785729810091182, 0.20374320709474986, 0.2436623220627002, 0.465914850003397, -0.07756920926606257, -0.17466596657809982, 0.6479241999284503, 0.42414211876634056, 0.1779968983107305, 0.9785612003954167, 0.5123252373882196, -0.7261434317934821, 0.7210480986708919, -0.584541790368354, -0.055440862134851096, -0.2130514705969955, 0.21652723865135187, -0.8129565536306497, 0.08419314545594649, 0.08861214043094533, -0.5020486306399233, -0.4066931587319603, -0.23699305188193878, -0.5461743255257021, -0.5635045042065674, 0.3765385856342709, 0.3300474679945984, -0.6150902221816948, -0.4286877834060785, -0.4146938434071542, -0.2311109668738409, -0.5982008592520609, 0.26548003402610154, 0.5624782577327101, -0.3625090399714256, 0.47053573903660545, -0.7215020328801289, -0.513714826594384, 0.506006113174686, -0.424064000930414, -0.6423543319593973, -0.6623907584820348, -0.5079484644546199, 0.13200587312532006, 0.5072950047919641, -0.25677547691738556, 0.49863332311227376, 0.21907587610234464},
    {-0.16589772977651088, -0.10555391807045292, -0.40773256545075676, -0.17383154106632884, -0.2239162934324464, 0.10241923667115946, 0.20870850826858767, -0.3690170249357681, 0.2869931113243345, 0.046426117688410956, 0.29650072601856814, -0.45331576580986227, -0.5218246024600561, 0.5291642907169914, 0.26999864934691226, 0.4026443416584847, -0.4514380119473262, 0.42199218923199217, 0.07596323953399776, -0.047672660229343, -0.5464709285131483, -0.4801213427792106, 0.27473715848222147, -0.20094220643806684, 0.18184305325189315, -0.09171453560373292, 0.05724885270132833, -0.20018918391573776, 0.35548928373453265, -0.6246149344215641, -0.3844740720091757, 0.06185889773349999, 0.1522303310418814, -0.7235439329798914, -0.6872602016965197, -0.10548873008845544, 0.07203361794810996, -0.6048910663322252, -0.06658100133624882, -0.8113410102989603, -0.15055260273110152, -0.35933591827692213, -0.22275486069844572, -0.41855498339291575, -0.5731765713771294, -0.11219188356066652, -0.3408406364255637, -0.126336525037961, -0.46670884434552923, -0.1590933799001949, -0.4137318223380201, 0.1402135403547707, 0.025300093795899037, -0.1832123373875551, 0.053918696849392246, -0.400964916209436, -0.09018430401299385, -0.555941251291756, -0.6061313985789434, 0.1693924465956933, 0.36408093755675563, -0.23544519862022087, 0.28210594539173334, 0.45920126061159067},
    {0.35927430584060693, 0.6185792528051525, 0.07344893837950277, 0.025091361475074094, 0.15913823223004864, 0.5356010470653825, 0.3459565079007375, -0.8514612115406196, 0.3192042348304382, 0.38090958489612814, 0.611763514820741, 0.08614128975310151, -0.48160834662265356, 0.05684568199347159, 0.6717827115487915, -0.5275983010856735, 0.18156808715526362, 0.5248762098914534, 0.6958000632690631, 0.7237965240899334, -0.26866143808756293, -0.4426895178662655, 0.6376633657564644, 0.11550122771248214, 0.7020926385093481, 0.530122583220096, 0.3175247273544201, -1.0640623356069114, 0.6193568921085859, -0.4599969302404217, -0.15988268533600217, 0.31400980722820926, 0.4282261181154917, -0.4112119546822221, 0.5596277739800215, 0.17836993113459823, -0.05360572587067768, -0.7424263504072302, -0.727917359908409, -0.3211488189627283, 0.060396087875515314, 0.5188568718060944, 0.8407569026690773, -0.5529167295840651, -0.4729747689150753, 0.27390677637802185, -0.6506531517783491, 0.12720109389429415, 0.5942221412433997, 0.3866969033721993, 0.052454169390103736, 0.47718162681529264, -0.7498183351874469, -0.5704323801023888, 0.9173338414224416, -0.5768244861828887, -0.6956546294074338, -0.5616120970874879, -0.6426048303319487, 0.13367816216057243, 0.6836917012742565, 0.5478869676804513, 0.22862492844903376, 0.8261351135637914},
    {0.08515991696321958, 0.6943523557302818, 0.44634139377238996, -0.5673789353542226, 0.25860090523696594, 0.16908794035464458, 0.44110854139077427, -0.5372569576679241, 0.38257016477460143, -0.12117323006413944, 0.1806527095670859, -0.05406917026819101, -0.5441734556150626, -0.009626779442959022, 0.6447289442041555, -0.43397715321999475, 0.09653854814547101, 0.6267821035246632, 0.3598519941820063, -0.12791662407163873, 0.3588852824173936, -0.34417415859747585, 0.1860557200978269, 0.09304410956972542, 0.3109614188534166, 0.35003599049441525, 0.26686203445369544, -0.618684002968744, 0.41223750219471356, -0.4870033873082321, -0.1843473464102199, 0.40722682227748586, 0.20662188008337687, -0.25366844459943366, 0.11960833928014451, -0.04469400912554444, 0.1608559703666842, -0.6624464306044944, -0.3693241289780147, 0.11681662851823069, 0.037362846058532, 0.13795547093823163, 0.6135544525220781, -0.10591354675575314, -0.6018585583176622, 0.0016177666318444347, -0.46826468946843036, 0.2841618141534747, 0.24345705101696277, 0.29482679700365877, 0.1641922485950281, 0.33001329967809995, -0.5966541010261864, 0.0015945346703705027, 0.541856003420275, -0.3095921196633957, -0.5724953771592729, -0.7628717268289471, -0.6255847308171644, 0.32328102360702804, 0.5221439547115965, 0.11175757297386668, 0.3114039608362204, 0.43043649408661794},
    {-0.9069565349114173, -0.05519228059908673, -0.6847646299053228, 0.05738651777043905, -0.3690192132138171, -0.2304950673514044, -0.6351060660985034, -0.674804947868047, -0.7341650662741278, 0.33230928846571084, 0.28349405683159545, -0.44436472661533094, -0.6981607377541146, -0.7007843725209949, -0.09074247955410235, -0.7112066139896268, -0.8054960405099852, -0.6704163558645322, -0.736219287943774, -0.3202573681845805, -0.799150308848332, 0.03787985762441188, -0.7682526764474563, 0.06638484738658681, -0.6986628177201689, 0.23747995238742697, -0.9448515375238644, -0.4776468714210438, 0.5675665138538882, -0.47606333656205246, -0.5218092406052363, -0.6596097253834832, 0.14895586030520272, -0.402072633564407, -0.6597613812762191, -0.2187767131132322, -0.12608687017813078, -0.6370843719372808, 0.008174832640478817, -0.421976945075929, 0.13871212967380286, -0.1000962080785106, 0.357568777915954, -0.681690363872547, -0.38575789896268997, -0.793177229710931, -0.18150648202939149, -0.7800759328337415, 0.17982887577951506, -0.13069965858647464, -0.8178556366521367, 0.4415338599429923, -0.08980609781964205, -0.9071386132943109, -0.2410164232041737, -0.5210900079436876, 0.05596279345989347, -0.5012214213481578, -0.33604000351669994, -0.776288556662604, 0.3219090391906883, -0.2674961247501841, 0.04791208597523726, 0.07815767953481395},
    {-0.5256015542360635, 0.06388569407786897, -0.7392565608918062, -0.28105013029264897, -0.027656163572239063, -0.17171152052969604, 0.11703085916848564, -0.6526810078138853, -0.7097708036411873, 0.4341938579135845, 0.6574799923434745, -0.0935045181586415, -0.2579877842736846, -0.7403164638169717, -0.04274505508464634, -0.7873650608736023, -0.340417678166911, -0.18967198291202386, -0.25315314490440954, 0.11086389305759302, -0.9351510183439864, 0.04963623585029311, -0.12965065603179685, 0.3916831390501969, -0.4580032051895601, 0.46723823365961853, -0.8184534198993049, -0.6811293220075105, 0.4851804944943321, -0.20999008947298106, -0.7080762160821041, -0.3007999748200195, 0.5591452483870545, -0.5017881551511431, -0.46338803061133377, -0.1239694533572451, 0.2200792961664924, -0.4573097062730263, -0.2797970231156684, -0.4592190142364487, 0.02291414463230415, 0.4241505699495603, 0.4656106181477979, -0.6312602424681846, -0.7827687552087017, -0.5958729684575451, -0.33011934038562646, -0.866575836825234, 0.5507658256373661, 0.3433558655111252, -0.1176061528964863, 0.5978813046450795, -0.1674433460369274, -0.6686088796704369, 0.18314505781085672, -0.5716608997398691, 0.23722550222572836, -0.5989978030047878, -0.33812871257907895, 0.044865984008882615, 0.5671527332497436, -0.2739935545350986, 0.261448041157191, -0.1874434337998203},
    {-0.49993401070723803, 0.18805129991535885, -0.9317333987995406, 0.24200166906452786, -0.20650262123452984, -0.2976560680973955, -0.4495147178562733, -0.6710417227973093, -0.4442474773965664, 0.13731345761965008, 0.4851633942109416, -0.36645704280582025, -0.04080678936040653, -0.43466781995008924, -0.6276579148426341, -0.24946859248324033, -0.2210711607216319, -0.39072066076400946, 0.0016034182350869964, 0.06385038985612025, -0.5187764597928856, 0.4118926030824154, -0.575430307158693, 0.47983600982168007, -0.3428695294808218, -0.1147218625945872, -0.585608418198691, -0.6436769719939964, 0.4634896298247195, -0.42184324117370614, -0.12076452807631126, -0.5844770260023858, -0.31675665944505377, 0.01416350648275882, -0.478223164497194, -0.274957061951151, -0.022325302850637014, -0.4541584965805743, 0.1678964786725835, -0.5748653712968117, 0.3098865404191214, 0.10244263752316338, 0.2598596835531659, -0.29387845415170694, -0.543778711695925, 0.017556555995108723, 0.5655699982880689, -0.541789799596116, -0.07888228465250406, 0.1318141143594603, -0.4827164360834183, 0.3655351358958863, 0.25945815529769206, -0.45881305513964205, -0.04353582402469434, -0.4916049076003972, 0.39778940434042215, -0.59544387952413, -0.08393257351778875, -0.29288922035273557, 0.39293945776261174, -0.355401176893718, 0.1693989934805008, -0.33710368454692524},
    {-0.3288513767265325, -0.4531202540783355, -0.7668482761685395, 0.09509382365314886, -0.0714120488630726, 0.08824138067949795, -0.029816849171597517, -0.7188565707671078, -0.6542007434301634, 0.6037094274739889, 0.7030546124263626, -0.2797789871712829, 0.035311811755471434, 0.05350829368397413, -0.5760348803969487, 0.04182135366506297, -0.5640849337595, -0.3079561018902614, -0.09984668985517993, -0.47314193036466806, -0.3763595129140001, 0.17560148543165352, -0.7968961418550038, 0.4128525370349373, -0.16435907669649508, 0.05873868903121286, -0.5994556634721524, 0.17463358736788548, 0.36486480381821973, -0.408150295943008, -0.19734562055695704, -0.42835505709348104, 0.37346867138291623, -0.09120949615392049, -0.6426652433598811, 0.20754921167824822, -0.07200715876251998, -0.23826900517887523, 0.10605751000440836, -0.4839838952463292, -0.21776680808257487, -0.23668838157531374, 0.3418274822843408, -0.38795656329506145, -0.7887182886979532, -0.1285640067747391, 0.30288252419234196, -0.9325910047132359, 0.4206658352992396, -0.037060124968142726, -0.07004461292108874, 0.45061210134909824, 0.07518328998184805, -0.6426743394918103, -0.22621134575161372, -0.5885146885620945, 0.355726575034594, -0.49422927555268237, -0.26222309307875735, 0.08652139237196603, 0.2945068425452882, -0.43374929517024247, 0.09311285860847589, -0.28072469712289444},
    {-0.43836707917414525, 0.183931674775578, -0.5609567414374809, 0.24596024162421457, -0.5659876826703545, -0.033794100554640376, -0.6168209069077057, -0.47339048336188977, -0.3178196117107792, 0.3124701257418997, 0.349225485593549, -0.18573158777889504, -0.20761472814481027, -0.43464573905222387, -0.34422154719022624, -0.22849499390907535, -0.26320993455242875, 0.01606523610400404, -0.2367181484073813, -0.4461993434944312, -0.3011452651931364, -0.5601800899639808, -0.11513090590022769, -0.01053069386299589, 0.11454222889914788, 0.32945417768082574, -0.08215155042025202, -0.11460731068732312, 0.4921852901528649, -0.6265328574748956, 0.14755451064941807, 0.1451421451630232, 0.30002798703955946, -0.21215471787666573, -0.6930736292313763, -0.4016520250409994, 0.10451811093991564, -0.786726611724701, -0.09542470121127786, -0.23523920583428437, 0.34975349890340907, -0.5390131375406084, 0.3359625235922768, -0.05292697245339811, -0.3878403020442857, -0.09243272274425034, 0.4286753918654438, -0.09813435574450464, 0.365852730520361, 0.12976998014132873, 0.030244094600359817, 0.26775373246696915, 0.24670663729124112, -0.36431233435953503, -0.07566665214578454, -0.5460838570336554, 0.4014181335139688, -0.330903800450247, -0.4145509813307345, 0.010396567351411524, 0.4575342043566137, -0.5596041519519998, 0.09984869004783894, 0.20788597801184627},
    {-0.35736206448297614, -0.11689471459861771, -0.3844192342772681, 0.5966267203783052, -0.386470685683848, 0.022656572887625345, -0.06529539970932505, -0.4598365219835617, -0.5895797130074951, -0.21597477395363116, 0.4498702589552588, -0.4787103344989632, 0.6960361314419259, -0.4767201874325268, 0.08950702066019946, 0.09499681224357338, -0.24022520055124563, -0.23548197746912444, 0.04052706111562227, -0.42772306295006723, -0.00409083264941813, 0.1823828670918803, -0.5300032600865735, 0.635080588417812, -0.5306285588374912, 0.5581316497595628, -0.1751647527967695, -0.45259988732232315, 0.334121970384289, -0.41103557035689087, -0.3504945499611753, 0.06469891080580749, 0.534635525791204, -0.33202664508907226, -0.4874210057654373, -0.463200263458937, -0.2783884647444801, -0.5872367202223339, -0.5850010469667866, -0.7139083714026729, 0.28835474617935447, -0.1820081937701277, 0.3257286522014896, 0.12223587578621271, 0.07794058587802849, 0.07440161498855692, 0.818455484364538, -0.5283041485612786, -0.04356722575304892, -0.1522176080052298, -0.48595697678334454, 0.6368572091889607, -0.22825808799294162, -0.5598940605437122, -0.2657093248644212, -0.20751457361209869, 0.14585419477796846, -0.5570763279418338, -0.013225136562599604, -0.6930040807765082, 0.6270915283567133, 0.7500846353971081, -0.30511827391227053, -0.25327033225452744},
    {-0.6239610149209592, 0.010321784028274366, -0.08232211095315724, 0.12253454032723311, 0.07730028373820935, 0.18151463490994355, 0.2644356067129107, -0.3901547188569805, -0.40414153996868607, 0.2373257664445455, 0.09884014530625979, -0.020250903472625925, -0.0388716154930117, -0.264504341364996, 0.08832142567965053, 0.21051146367899656, -0.597502607535162, -0.1477731197961025, -0.5514634991622817, 0.3146122721161676, -0.395261984522281, 0.10900630715729492, -0.2619076347641627, 0.1699145094929621, -0.5587940580671861, 0.3506663510267494, 0.17469135047969034, 0.3322082247947309, 0.3382299460724327, 0.1147037710822077, -0.2619802271097473, 0.049772098368161335, -0.12109408493478764, 0.4668817730677609, -0.3835435226581288, -0.4518242237874711, 0.18632990035032188, -0.32898150057090975, 0.30365250806310995, -0.07298407081386729, 0.3813059342019872, 0.04859768509736045, 0.20248656838219267, -0.2822483693757128, -0.3851931359004962, 0.16726233500531867, 0.47438762424339637, -0.36517939526252713, 0.10895196127833616, 0.036856208520680035, -0.6979740221011315, 0.4282515791720885, -0.09656657983495522, -0.3405399811806475, -0.7494486457888574, -0.33395664059453944, 0.42942291245831377, -0.2312144748158866, -0.05560121648501543, -0.08029571629280874, 0.20425448599126336, -0.19420367749082482, -0.06687703579269172, 0.08884258554120131},
    {-0.19012676489761063, -0.009905784382326914, -0.21037648860836808, 0.01826118817269622, -0.1449381413924168, 0.6016741137044136, -0.5760124396793176, -0.5735259346237995, 0.2883927155293636, -0.2357440508225545, 0.2721194588334393, -0.11661895447778498, -0.3620260268764546, -0.15326084639285037, -0.22736280622194363, -0.08041813432464667, -0.39579683739574595, 0.10767050694151147, 0.02736890928055358, 0.16558950641881853, 0.05093133832674546, -0.24342680525222882, -0.20115827582523543, 0.45600211119100587, -0.22570978711303114, 0.0625335446060645, -0.19901092529022948, 0.008008538341174865, 0.42524907613799423, -0.48205453021851596, 0.00817833410972677, -0.0647334579236658, 0.5598017120716418, 0.24421037901073256, -0.6237649429576275, 0.23403809917176302, 0.092763747965221, -0.597548169614493, -0.5731570893948313, -0.09833401448904795, 0.07782111673935442, 0.03053836437967297, 0.05534447491581305, -0.3456803133048659, -0.9133248670145212, 0.11161234316827763, -0.04288178063539469, -0.44745501364967954, -0.3940966147478006, 0.26352587376049746, 0.004752828721220522, 0.38866967720282636, -0.0347294538680468, -0.4536017331633163, 0.019271748404656126, 0.051532875460812796, 0.2771129006490294, -0.5029310131851235, -0.3187944462268645, -0.24440567593336887, 0.10188156951258551, 0.034628436871503826, 0.62762193808799, -0.3483534046694055},
    {-0.34673759664961284, -0.5896912146287591, -0.1392572582947094, -0.3206562564384612, 0.06267746391288136, 0.32572856167253594, 0.34617512751847207, -0.6665204104141808, -0.030006560839598087, -0.29364404551436324, 0.363346294728177, -0.1274551786634799, -0.4072839196724664, -0.3001883766069761, 0.44609602561000344, -0.232949409215741, -0.08843428272588154, 0.018978249991699923, -0.09295343729674581, 0.023892976920615854, -0.38015993272281084, 0.25807024988623917, 0.03515787096361467, 0.0020985823460509755, 0.10079966229080302, 0.6749381900025898, -0.12257093822052174, -0.2715011055987356, 0.2745840612299086, -0.39938561743108847, -0.010249124236442766, 0.05883640080179183, 0.044500678536164254, 0.1830292788140577, -0.1786330340903706, 0.11716431285133806, -0.43382684705048835, -0.5091971087074063, -0.20626593214030847, -0.21063192109898968, 0.12986727771185155, 0.038212928268295, 0.7180712753815308, -0.5329372214502163, -0.2888332807157325, 0.08016806878951027, 0.0628225967163984, -0.019739632631978483, 0.24078736040729343, 0.22643978152665245, -0.5063488488126021, 0.16385140136608692, 0.06793227356374817, -0.20577611060905962, -0.26867655600095053, -0.2711554090272236, 0.07332163602251422, -0.49224441352161663, -0.25124457979115755, -0.09227673647141409, 0.6556451964025068, -0.32651782907616833, 0.02362790106382735, 0.02569251122456291},
    {0.133431621001324, -0.5200750581896727, -0.18716546317970312, 0.2446512196355686, -0.26331551685255256, 0.32326090571721194, 0.5867167030307631, -0.09440845038799975, -0.21289453391697447, -0.1361446825205351, 0.1991568705156647, -0.588221373957605, 0.4028177177184771, -0.5674526557225731, 0.39364519742744614, 0.146026184811972, 0.0638496133698509, 0.2215252541576724, 0.07373284988054515, -0.402603321411616, -0.24041515807525715, -0.3831400949278179, 0.05587609897994345, 0.2881703724447829, -0.5656447935759722, -0.14231332975324218, -0.29591397632960165, -0.23805182663394786, 0.2826342106594628, -0.19645870222971942, -0.01883125760175184, -0.17770575680114647, 0.35611486893144184, -0.3625087210489064, 0.1328960218449037, 0.21410024654296245, -0.5003688084648371, -0.4079889705228531, -0.22845215634245047, -0.20734032259583526, -0.0708135795766291, 0.21951275023028485, -0.07054593798491522, -0.4632762933792407, -0.3496990878532883, -0.18515867893698756, 0.1068002851719453, 0.042752860128042365, 0.18561355463920282, 0.14829724613582615, 0.14708690218314727, -0.20313432720349728, 0.14828559137373998, -0.17172857716448486, 0.3225227313761921, 0.2681550736986043, 0.014378195850853157, 0.172651535557217, -0.3838423456269904, -0.14230589411538197, -0.2055522288693011, -0.27401230564232104, -0.23722871962316, -0.5247916366621254},
    {-0.5192312291439519, -0.35648603223309727, -0.5064770123602738, -0.09453271451582328, -0.49629924357793903, -0.2647072608885041, -0.2825353208417201, -0.33833352041749426, -0.3117303648997356, -0.38116473195487593, 0.41081373346482725, -0.4992568545991681, 0.2653212497988722, 0.10490034354615059, 0.08473601920790655, 0.3180118069110232, -0.5301749105578865, 0.31875476526906477, 0.3736488670279048, 0.4546526781378148, -0.10014162264518948, -0.020623537065497483, 0.08407391736839696, -0.33041267426956367, -0.005161503707847446, -0.05499479451671972, -0.7836119802841974, -0.20092621895797402, 0.752627651048801, 0.1722279814144169, 0.09238674769740948, 0.014242676951465682, -0.016882093745238715, -0.1274056064428481, -0.6479647422054565, 0.36545530368944223, -0.28796627726273744, -0.502388910849355, 0.3767956441824985, -0.08274190254488449, -0.3988526387113273, -0.03917345390205195, 0.3589226521309698, 0.42768316508954196, -0.07116955855829574, 0.41043590820737813, 0.2506450994266063, -0.285574529038361, 0.10433091189134115, 0.20313710105824093, 0.23814296905853174, 0.22621212199577218, 0.16723355176761465, -0.5567578701683167, 0.0280339338097352, -0.09107117383587561, 0.5850369428235577, -0.23450504812050105, -0.09005083739663966, 0.01928447603924022, 0.1943851034327996, -0.25008974299963, 0.7087472446171235, -0.10811751258695608},
    {-0.13105121125612382, 0.3745135520392754, -0.7501545479255988, 0.296789710780186, -0.17268416338734863, 0.1805053608024944, -0.29422176247305265, 0.06336652792487188, 0.37237851238413033, 0.27396294725570175, 0.03838770394702766, 0.03247741403414096, -0.3498667135764873, 0.3859754586526071, -0.013624509938834142, 0.12150219390933398, -0.34756769935775933, -0.1993674037982359, 0.4722179199090117, -0.2188921941116154, -0.003536253285440461, 0.04181495416664772, -0.06307385467233823, 0.1787512181523256, 0.09244049549620097, 0.2678753426178595, 0.2467297261134246, -0.3104364283349404, 0.22713731853986951, -0.4121757268987328, 0.28449299775273246, -0.2971642472166557, 0.09618099943161772, -0.33531761592183484, -0.5325168692163333, -0.1590358340694407, -0.064328572426721, -0.11781551728963592, -0.40973725150846296, -0.5571393548330565, -0.5251048140142208, 0.2290511898913187, -0.0934294937484128, 0.44174913021426726, 0.2197909321640669, 0.2669200114130878, 0.05682680094966286, -0.3336962203904486, -0.23476782054120898, -0.12288045080324661, -0.24765711487253397, 0.37933117184504034, 0.2629215635482233, 0.10121535639966642, -0.5232151674736046, -0.25345374968971623, 0.17343224222444922, 0.13478808771476883, -0.2245965200355032, 0.2946047105095512, -0.12113548803224078, 0.18078093473383075, 0.4158325111704149, 0.0025712659054852927},
    {0.5265728919945643, 0.3206733083566624, -0.10480544562419854, 0.13625663216021727, 0.36036376828771643, 0.2648922433788166, 0.17148831581165272, -0.2981147161479557, 0.24546752576744285, -0.22809843509702332, 0.4342947579647879, -0.01982055085865018, -0.32477259251919993, -0.36947164788874315, 0.005354736664783159, -0.16526159089749648, -0.05419160588294975, 0.6758805932067906, 0.17785342888146344, 0.2794899522119568, 0.12208210402258772, 0.5158084983454566, 0.04793974758551816, 0.4071586248957904, 0.1473477207419165, 0.25389591419452, -0.06714333049998929, -0.679476030888416, -0.1041851231472405, 0.11319427707150564, -0.8308036504104546, 0.5948101697608993, 0.3783073493878587, 0.05237962278765538, 0.2531327701605294, -0.06381746723201707, -0.5299676497538983, -0.43037058672990003, -0.18292160191919457, -0.17105587674079953, -0.16498027833209367, 0.043583360576215625, 0.38306298290127405, -0.31895603484489654, 0.01970150884289597, 0.11684503268983326, 0.03551941084865748, 0.05803179486714411, 0.5375947632868603, -0.32592087223462984, 0.2650406898113793, 0.014579320825482543, 0.2168278314309389, 0.05940248046494094, 0.18189636987745159, -0.4893071528992468, -0.029635579781158054, -0.24494005646420644, 0.3374278102359413, 0.44798525375987186, 0.28512091122964284, 0.3343507117597705, -0.06611565683739376, -0.003512698335515315},
    {0.03576847774094963, -0.14048601680560205, 0.016939566807259873, -0.22910411310588788, -0.022353681684081788, 0.17839103157993733, -0.19159622664545822, -0.07169885612226748, -0.09236003071889065, 0.6530013556062892, 0.09168500039852048, 0.37956191083076074, -0.45156250283307564, -0.2791046014873886, -0.36156485172319985, 0.13218952393853997, 0.3434722176813568, 0.10849938170402876, 0.02215549988711543, 0.06034303505873583, -0.43918633484554875, -0.1141811046593749, -0.2471152271878325, 0.16171916578944828, -0.4193167831693041, 0.1887743774662696, 0.1905988500560466, -0.023492700744532344, 0.29025013391480897, 0.021596179945818205, 0.44535946808221766, -0.16038958972153, 0.39419503410975176, 0.11598008176640356, 0.06709562775592756, 0.2745435962669214, -0.4962412170791833, 0.2186033446955062, -0.3742712684579796, 0.1734089545647989, -0.4491803067601206, 0.3094976069006215, 0.06549210369013882, -0.10871592429182879, -0.19037658777710265, 0.28246066797508307, 0.47384644396476566, 0.003050609438726225, 0.33879536267617316, 0.5190966598882781, -0.19549936583639266, -0.13209819354397193, -0.20242045098833755, -0.4958264228221182, -0.38594160639640784, 0.06540426047604037, -0.08910310745774777, -0.3011735261541408, 0.5388894211582975, 0.06316102337621142, 0.12362076453576454, 0.30739501106478007, 0.2744009566255985, -0.32856734909376095},
    {0.24459744956123408, -0.11170253033885522, -0.37526063523453945, 0.2214135903909772, 0.3008281232578718, 0.09068015373513558, 0.1413053595532782, 0.364182909637127, -0.011698760892204722, 0.2839983910260424, 0.014520061652613244, 0.014960206815832012, -0.2995300965804372, 0.2617345112842957, -0.3610116425106628, 0.18582813268642465, -0.35931724606254895, 0.5675665397267462, -0.6528445330230292, 0.35354801439067374, -0.04621172740489808, 0.463476624168976, -0.043994551964843344, 0.1031451432071341, 0.12761428316934348, -0.23397409708527317, -0.5654200089051501, 0.05150427131336595, -0.23961308044314095, -0.17332055733697224, -0.11478938189355313, 0.12256743084231066, -0.3561788161146648, 0.0751269971611235, -0.4969413203948826, -0.9287385399070838, 0.31156144922468, 0.02470036649385409, -0.3720214209034884, -0.12095457663587773, -0.18290115244167193, 0.41235875193580895, 0.45730836625065296, 0.33054353736322695, 0.039193943293681185, 0.667916662175862, -0.21807725639805828, 0.12962965991771266, 0.5467535826626281, 0.049197618994775046, 0.08186287952041375, -0.2738005322550407, 0.20888377117581583, 0.1550830608520766, -0.10916980194805384, 0.038482603118606254, 0.28556426773953986, 0.3345147456106668, -0.20390850216234763, 0.49394326269412214, -0.1033635761403329, 0.25017689258523634, 0.27821080396775666, -0.27705735233550993},
    {-0.4629948386106423, -0.36829071165912036, -0.1771896551866149, -0.35815485891125237, 0.743668945549498, 0.007714967289462355, 0.08529100318158062, -0.30971466848942625, -0.028144278313740643, 0.34663559523210874, 0.5840232509136143, -0.5299261290180171, 0.2355397976908863, -0.3282536945951851, 0.0028199514324254186, -0.3283281721378848, 0.5315977873102387, -0.029765340319665757, 0.3013304189531029, -0.1253655287342387, -0.08607454653593972, 0.05283173685748469, 0.009877076571589793, -0.09535377603486389, 0.07874021825725991, -0.02123763982724512, -0.4308193153678011, -0.49560084324309156, 0.2252878920493676, 0.20456401193953241, -0.3156468379425432, 0.4916410762704759, 0.1270940794546707, 0.2326743724328617, 0.090550273508501, -0.31722635329102433, -0.11681953741871831, -0.25309648323271033, -0.5334559771566793, 0.09411411617930539, -0.05035585488574171, 0.27042126939841904, 0.5547891187853933, -0.5488378342655275, -0.2978570418752858, -0.5845569275499573, -0.2723994377579532, 0.09564956658023742, 0.15194190846812008, -0.061024247279644, 0.2183656807951804, 0.4102228721774685, 0.15004386616183074, -0.49962087526190585, 0.47099502837509594, -0.45192428140502977, -0.7645972817203158, -0.19045587950449747, 0.14641540845868883, 0.477830352958985, 0.1642522043159502, 0.051936267473913625, 0.019888295059787734, -0.20849357386828246},
    {-0.20357389657735592, 0.21601725468626176, -0.3727191445404279, -0.034542644805721216, 0.4175497606132304, 0.10556401175606299, 0.298572068151182, -0.15969189594938768, 0.009442117941108476, -0.15802383337008188, 0.08390951238379378, 0.2657144795141053, 0.1758635481219048, -0.4125381469166724, 0.17421059130063896, 0.14288390692744993, 0.5769710986368187, 0.0214047840739483, 0.1351615854610057, 0.49406956754849446, -0.410651925475384, -0.004127812486812134, -0.2359760468250077, -0.17847460471159754, -0.01662872962840523, -0.43031370986529566, 0.03387997744624595, -0.35717955924425976, -0.35993725871112847, 0.2008888451880806, -0.1361530521968931, 0.5404409715981727, 0.2254453420324283, 0.26507710681580443, -0.12087234104229103, -0.08507909437338489, 0.23451200809893152, 0.15594373377664308, -0.2631161756003977, -0.480787084954884, -0.2851538683341881, 0.5152091093080016, 0.0748081453695841, -0.3751583747691767, 0.22636236376031998, -0.542815677257444, 0.07242585234293858, -0.5374377413367406, 0.18513137391476267, -0.1651016816274555, 0.29598754084491696, -0.02969183638396561, 0.17128024891181723, -0.07318978996161453, -0.2371772999287014, -0.1916941041307446, 0.5128403920344287, 0.28031020721396055, 0.39248743298758276, 0.317988771916856, -0.11132590681181646, 0.18908962785820174, -0.41881659250302306, -0.44033895437325843},
    {-0.1663543383942821, -0.17800590536413569, -0.37947966300435537, -0.038942608246189864, -0.25474302505883906, 0.5114730577122251, -0.1918682778700725, 0.14292218089521375, -0.07285113920018821, 0.01211491880065367, -0.02205987150757044, -0.06812915741755891, -0.30565419830788915, -0.07849059176598251, -0.3477471683220845, 0.384489998655033, -0.11266083049307964, 0.06916199445172035, 0.2822129414299682, -0.44398339637917145, -0.10454275158553666, -0.2023986013569357, 0.12142316498603645, 0.003557098180972176, -0.6071772667577496, -0.2862359694867194, -0.01349082136261698, 0.04108589184084267, 0.14588512719450736, 0.054006210228676875, 0.1841606175702842, 0.3754538191075088, 0.21832503455186386, 0.1775734789436696, -0.27023492418286515, -0.17255235177580347, -0.06500605804282086, -0.18505131438179206, -0.6497561025168608, -0.6131016680816788, -0.5966470620984127, 0.4865791207892578, 0.24716156361056688, 0.31327853527840477, 0.25559585695409853, 0.019845908251064658, -0.27907228390921124, -0.06939564402406159, -0.2796275711275839, -0.17849324949858406, 0.2287114157633854, 0.14755347731384277, 0.39013182727898826, -0.013529692347941064, 0.2649553584981002, -0.09675372685919699, 0.3519577965887436, -0.05836174401202056, 0.1955220582819716, 0.3553361332722407, 0.010805255024758292, -0.11003275958150577, 0.0005591669295841315, -0.30888364481879754},
    {0.03502384108710191, -0.0784770067949277, -0.23524638404551002, 0.2275488744396946, 0.5605780134519873, -0.2728867810569212, -0.26687424326764847, 0.05575047160921349, -0.24274743871118087, -0.29654666373003874, 0.3607527961920829, 0.18046101988778937, 0.7646153879428451, 0.21793736975775221, -0.17069848190712233, 0.4799820095435367, -0.32299650066933916, 0.04522976403590491, -0.2606921676254491, 0.10387749108168519, -0.4895200921947907, 0.5726561178666594, -0.2825182390352033, 0.1611409952231197, -0.14546087999696766, -0.04758040022585068, 0.027660807311608235, -0.39116397694784355, 0.044308245623384514, 0.0973152115393362, -0.05542698098096368, -0.030361779344844148, -0.3544155737327165, -0.10739900565142631, -0.2926927235744703, -0.06356210161906184, 0.08464382628301881, 0.0318713089813762, -0.7078471887418992, -0.2863572420230601, -0.03996305842204126, -0.3642749985203121, 0.35314055116052856, -0.007531087316447646, 0.17001591564054155, 0.432765316683405, 0.66640481346175, -0.41400053160769956, 0.052103375204817066, -0.20283089073940705, 0.18421286217106933, -0.5723409418958799, 0.5514378118857672, -0.02305088837793065, -0.7781330445008979, -0.30779460051438673, 0.5533658221071897, -0.2753507334863045, 0.39999075098593156, 0.051369801394287026, 0.26888042410863483, 0.15858813773076932, -0.22988285179372844, -0.43935607505028},
    {-0.2736928826955328, -0.59009760598659, -0.605125623615813, 0.2706083747451262, -0.48754258795033684, 0.03421661445138718, 0.2000551523159111, 0.46421622735595197, 0.13252696139611567, 0.3496282875979968, -0.4175025554709786, -0.5662598663410516, 0.4353861770041855, 0.1306637475253568, -0.05898564935314278, 0.40379135120779563, 0.0045881178668990075, 0.004325166567863141, -0.3716298543519003, 0.10674317856962103, 0.2160447034822833, 0.09828333973205718, -0.3550818129247343, 0.3859086338020178, -0.09124322370426682, -0.33618856353463505, -0.22163682297610646, 0.6410894932018615, -0.005678797253050468, -0.09016609907284903, -0.24570857954143993, -0.2655041912320269, -0.2165195619112781, -0.07117695905301699, -0.13290635649007437, -0.49998622953694244, -0.35972099068305086, 0.23536701600856502, -0.3210249594607128, -0.4913674438104803, -0.2523429291650873, -0.3178963791825649, -0.16811040657418716, 0.11939643423010868, 0.37308638086239504, 0.029309467195178695, -0.5324876188411847, -0.07821953391573139, -0.1546925437985342, 0.09401441395517672, 0.25492772620813026, -0.1521891210534893, -0.13698627629782897, -0.2912062520931656, -0.7037284166515232, -0.0002478792667087534, 0.6445173476235573, -0.2222810897938809, 0.08318519060743973, 0.34836584158566747, -0.17034786514098438, 0.23483428625973218, -0.20080844240281964, -0.1572251107121278},
    {-0.232038975257693, -0.1958746923926739, -0.2581979279312477, -0.18641007037057886, -0.10812917887015944, 0.40983163327281796, 0.4585448564887327, -0.11300229712063696, 0.20180021513879928, -0.48543052737899056, -0.2682539916337159, -0.3573087648262614, 0.4436488930512216, 0.4297697928889261, -0.11499667692340557, 0.36983357902128916, -0.4467055497892425, 0.2808793837183625, 0.5705214670675356, 0.08604929367166196, -0.01949296904221967, -0.1985649433840723, -0.2795727039254146, -0.33497542317921286, -0.10730496563902948, -0.3641432930426455, -0.4763780181728641, -0.18732895488160897, -0.28368326969256, 0.2813651599370737, -0.29583777531580363, 0.24186308223597194, -0.14432354228068212, 0.21644798784522368, -0.19096919932678538, -0.14522331618403023, 0.0274958385336985, 0.07358643766712634, -0.3423448237509878, -0.6906572786414046, -0.2400082488599327, -0.6035098221400355, 0.6359288759185562, -0.20391845430592812, -0.22088067159400124, 0.5138992238965479, 0.5870193788304472, 0.09752121504532765, 0.006919365975830615, -0.7399523318610673, 0.45048678822104304, 0.2667769730738478, 0.12535496876107013, -0.021081962559536763, 0.010689018816469048, 0.3858020697596708, 0.4320754941528571, -0.22651120277190143, -0.12538345434182513, 0.58327283481885, 0.32272964919399555, -0.44120355346034706, -0.4200078883356655, -0.01104975169243355},
    {0.4511972052127713, -0.1885358375078392, -0.14374688611793315, 0.16176885707483157, 0.34998969879704234, 0.11765666783304991, 0.34472993054400936, 0.150955248852427, 0.04654550771267692, -0.3527312993843439, 0.4587019824598343, -0.2875475523364885, 0.7909127754734386, 0.8083062562292436, -0.26402208050619275, 0.40711755865123317, 0.1990138017520335, -0.1508423745953718, 0.24254573803258217, 0.40246050744728795, 0.6162637480328689, 0.6149494376646992, 0.018575628688260775, -0.1017694490025173, 0.009948658855229801, -0.3343368059153532, 0.1161349397129448, 0.29481568863405405, -0.38233686668892586, -0.24340929767064873, -0.11402440283336204, 0.1649793398753044, 0.11401252033622017, 0.371671826896354, -0.07850866906041869, -0.30341508675442547, 0.029494381312902017, 0.12199129102575254, 0.18387682122866647, -0.36442568160984656, -0.15018410538961738, -0.05621595417762094, 0.36088103472265837, 0.40335682828475905, -0.32111022674385875, 0.0020942636002546566, 0.4320935613265208, 0.2295702643829946, 0.45770371627087586, -0.14451572698628956, -0.13083089569553993, 0.5723980358599995, 0.03518639259059509, -0.08968078602874789, 0.02818297895002244, -0.05010186918268012, -0.3428584153176528, 0.5973988455006346, -0.25113366504778967, 0.2606500886636504, -0.15323221175248364, -0.07995267315900345, 0.02853299906488844, 0.06949211267546139},
    {0.32874531201300666, -0.5638268681883315, -0.01941572677171607, 0.1527513898732528, 0.27495364586024007, 0.3117121267257816, -0.060129790835944684, 0.3004753158922533, 0.24835619309459575, 0.19013778908386547, -0.24196953871412794, -0.2279306917772636, 0.06737993903168109, -0.6955924315513253, 0.22899078899156064, 0.685584041986305, 0.40165373648528613, -0.019895579173099785, 0.46409741284899586, -0.3067059191954081, 0.1189962462484703, -0.2899763491841823, 0.011283644959390608, 0.7445492234941347, -0.16397692776939604, -0.11657856982866366, -0.5071028613093723, -0.06680938512871376, -0.18316774875412495, 0.28031975398723086, 0.09849199508809028, 0.07653374205646946, 0.36043953310938226, -0.049107279313139574, -0.07670936210314826, -0.09302287967443794, -0.0704013954018469, -0.16402889167252535, 0.04958692973653107, 0.01210181104448014, -0.1503199615672271, 0.3802459339690465, 0.22450875841922993, -0.12524414961434735, -0.09372543157483415, 0.06083943569080715, 0.2607580768665547, 0.20803735921707384, 0.15804731615311185, 0.25585851918599023, 0.3870988961575091, 0.2128553818179996, 0.5804453340131899, -0.5575299820621988, 0.22176338555194783, -0.15038467256889826, 0.351462393193052, 0.26556474129734775, -0.2646068105061699, -0.38644014301451296, -0.09504771618650808, -0.16409158453650333, -0.006922494555842976, -0.0903486204122451},
    {0.3866337992406165, 0.1029051421630608, 0.2151449885803636, -0.1983169960022019, -0.07908359840297807, 0.07233618275977129, 0.1412577629838289, 0.31638166873677237, 0.435436318702575, 0.1954841152235094, 0.5657053752263993, 0.4846450675564676, -0.6887547208766691, -0.047015981075230064, 0.2967769914269683, 0.16654824318861425, 0.4673247272276248, -0.2205211969379279, 0.4005879322729844, 0.27993078289759454, 0.5955453935968531, 0.2269252713395558, 0.14514230427338973, 0.046518427827275374, -0.5684098985159644, 0.22203125585405803, 0.575055445900797, 0.5487694054797544, 0.34937297928518213, 0.12607278481715875, -0.07686746182597838, 0.21512609620120343, -0.3976852000322793, -0.07673142628017578, 0.041097906053999905, 0.025069987780086195, 0.7450720433534234, 0.1680174667523374, -0.11941655607549523, 0.2622274117341507, 0.1901500968169144, 0.27929056325585894, 0.43192753867605393, -0.2910222994591803, -0.12728762636792834, 0.014953401070004035, 0.0106019308506489, 0.26543544430799904, 0.08367076372190725, 0.3815415923386618, 0.19716663957458622, -0.3954661405698247, 0.054975081322788534, -0.05236978753838416, 0.26417474968216675, 0.0777774654463503, 0.24852500644825587, -0.026870307754088173, -0.3318966248975614, 0.6047998552189825, -0.27122112023193085, -0.10554610143062355, 0.2931601711691999, 0.20429998279652006},
    {-0.42095621598422217, -0.2770174835248334, 0.367624804203478, -0.7165652953529871, -0.2669212964583595, -0.21070017184067272, 0.2837005462776423, -0.23539651183728988, 0.19472058271629641, -0.07592058849677646, 0.36970239196712146, 0.07878117827442431, 0.11712836655283064, -0.32241674912969964, 0.20989913234493507, -0.23963574824974895, 0.3629014339261355, 0.06713921633970375, 0.17634243532847507, 0.04159736095090569, 0.048634435609800776, -0.6078108154358127, 0.3159569489993948, -0.47477444311887307, -0.39016922759620654, 0.12334494793904266, 0.13999444211577713, -0.3751115520309175, -0.002848807631735678, -0.10840018433292498, -0.2610493225192241, 0.24157924153225194, -0.08113352699654335, -0.3170617135564513, 0.30635615237326036, 0.1393335060376566, 0.39921426777192615, -0.1694642231630934, -0.11988917452483096, 0.26895228274649335, -0.22291491286951776, -0.5452103885160637, -0.28293865561850107, -0.3521351258796471, 9.121868640866247e-05, 0.4354521947765381, 0.37558086990904527, 0.30338676105970097, 0.03850500567813487, 0.07768282537297555, 0.14055297798769276, 0.006275311768195154, 0.07181882008391621, 0.12511692097316682, 0.22346374916445597, -0.2703097732958744, 0.19950394363355742, -0.051163904525433304, -0.7574837505173969, 0.23998735475614888, 0.35081416035996904, 0.05703558324285445, -0.41232166195554304, 0.03889471196008757},
    {-0.22972541792318102, -0.07444032410501497, -0.22830370190901927, 0.21989907851701132, -0.11237964806356715, 0.35461717702481704, 0.4568209789719227, 0.5571890951217452, 0.029158223538577194, 0.13411228705420594, 0.2613824161366982, -0.14932669075355054, -0.05341875561035184, 0.1341736882669643, 0.13941944012521312, 0.3773057951656354, 0.390050683662481, 0.38222561309521935, -0.1129665386064233, 0.04089547678850701, 0.07401439887016846, -0.032674390059447875, 0.4305120221589174, 0.016852386768703525, -0.016082664702448925, 0.4084105910251475, -0.006273048002340087, -0.01041536647216192, -0.3569209708071781, 0.06436060735194582, 0.2991945125003147, -0.037578505167371386, -0.11636763376808201, 0.06785310783650678, 0.22042609149865158, -0.06231591867213052, -0.33388709613802225, -0.01828202660487643, -0.2287365523039177, -0.02743743296716126, 0.008039413188311589, 0.2248395078453972, 0.016843626374224856, -0.13370111664265363, -0.23655717317730457, 0.41569821795741385, -0.1736252987596936, 0.04414039163379099, -0.2903417240273808, -1.0025961390046263, 0.42978001766210955, -0.1388616751795722, -0.2747268486358578, 0.2635938472060484, -0.24420362290396533, 0.06361652291798356, -0.025857689115470872, 0.018579326002423943, 0.30865667818035025, -0.3730000191731337, 0.009276991982277797, -0.06747740933711349, -0.029644419435884545, 0.07504342610196012},
    {-0.37990091429991096, -0.09533157787524989, -0.07817458317862253, 0.013973745862747208, 0.17144255068804165, 0.09383746918788777, 0.18501278920111136, -0.6381862195246578, -0.10774497126826278, -0.31121436863170315, -0.05833908181975947, 0.6072782838755032, -0.08342872504349125, -0.004346392560563091, 0.0033099013865186635, -0.7393215100094604, -0.15090200242443538, -0.09874927008860637, 0.35268399713073234, 0.5709906509010847, 0.0123194160050216, 0.583436340913882, -0.06136539232786205, 0.04890218362520992, -0.07742574731818001, 0.3035599456513058, 0.3300140025447359, -0.5549547204700674, 0.13031093588094786, 0.5078518487587436, -0.08828115409866849, 0.07675809892789184, 0.5811680672308425, 0.18457137405808155, 0.5624389391230531, 0.18643704742210576, 0.15647788494199671, -0.24196514232428895, 0.0378860548494241, -0.16755312858553384, 0.3726162557961191, 0.15421357118324408, 0.3844463471964569, -0.16936533382103294, -0.002538960048733056, 0.3207591930070302, 0.23260736784414035, -0.052526231639771194, 0.5504313469106675, 0.008238868018125194, 0.5365970079779832, -0.3590404016028193, -0.09123370054830034, -0.2952076743308416, 0.273358827459831, 0.1438267990875645, -0.2275864312309918, -0.2348900970706263, -0.17804630075735645, -0.2559630625809087, 0.124905047269211, 0.5348658372339139, 0.004376594664548407, -0.28129694382666914},
    {-0.4459033640387128, 0.209830919512573, 0.08552854084253711, -0.14875182102780596, -0.03160045125197356, 0.6882459552421919, 0.42535916653262623, -0.34238130216610907, 0.025192506826012536, -0.44207637249985526, -0.4057270144361597, 0.1857673446531255, -0.2436137733864904, 0.21638528048469427, 0.3767593766206421, 0.15847669172324444, -0.39751503501029706, -0.04387347411017104, 0.5992080782818915, 0.527451998529302, 0.31086505010494886, 0.07710670946218927, 0.3446478863054117, 0.22015109230538693, -0.13302450135990754, -0.025315915274925965, 0.2253659840457729, 0.11544714772579948, 0.5441375207689744, -0.2640526970777056, -0.06053790215337457, 0.032312321169636685, 0.06581534506122519, 0.09291648878330269, -0.311505114875216, -0.13315237332524546, 0.16051671347539198, -0.17597215214857784, -0.17579475663303762, 0.0029566967457796615, 0.06344514516139718, 0.2283729745597256, 0.1942923812918775, -0.3553765748898413, 0.269603350964443, -0.06456257430533806, 0.046743715114961566, 0.11828082191791847, 0.07911003509459097, 0.25394546915036204, -0.2678575644281873, 0.09539601743046378, -0.10531112962495952, -0.9542951775012164, -0.1038844011918674, 0.12007928839231617, 0.24073081124792073, -0.350228486255154, -0.5474935505602667, 0.2843719803128159, -0.08673247821104423, -0.043722821539084446, 0.17820764498010208, 0.30527358200220917},
    {-0.12586376119919837, 0.27338848973332563, 0.06123186898342365, -0.429187781488077, 0.42840068624670186, 0.05746493294711846, 0.13283999322247578, -0.5391161682632326, 0.49896424887390267, -0.19046863150329152, 0.06418529448124875, 0.4082211262335548, 0.07204886944599943, 0.15557706855722914, 0.4095453350481533, -0.043167717869293534, 0.6159007953699075, 0.10997486549476865, 0.6657030786927144, 0.18091539037452486, 0.47368201812650806, 0.4764652379616783, 0.32205635906410984, 0.2762187796370615, 0.02202276357055096, 0.12365379950324346, -0.24804819954536822, 0.12040519137652075, -0.14071155769673496, -0.029686525482990125, -0.10893748253525395, 0.27753905086833064, -0.0040916675356528305, -0.04499292225197358, 0.20447594028725355, 0.4624339105797926, -0.1212530127541096, -0.02012087515099214, -0.40456024987616956, -0.497304215491937, -0.33015262745536567, 0.4272773443282139, 0.5548228513594978, 0.1251435791664847, -0.3735558203004748, 0.5068043508558301, 0.18191405146293207, 0.28490679270488956, 0.5416313785392033, 0.5179338499165371, 0.2927866874109969, 0.24903311800486805, 0.10713541580818381, -0.25761396399898506, 0.4027864756213283, -0.25556776810720006, -0.25626670190848894, 0.28850963722331857, -0.030612682217446466, 0.24731735535940227, 0.2535031870160871, 0.2524281814166289, 0.1219631711562461, 0.0025112198813142528},
    {0.4216772269172213, 0.47010151790958665, 0.04754626023633001, 0.46100057030564956, 0.4250341864743649, 0.11497565500774781, 0.0704124651278913, -0.21641715464461603, 0.5547918401237589, 0.05548949392570164, 0.16664528054170488, -0.04772358338145665, 0.23370558314917564, 0.1549088317902069, 0.16626292300179996, 0.188807762122799, -0.2175249839773278, -0.1147080751790635, 0.13975618967252415, -0.34499829863615017, 0.16845519022160443, 0.14199562489776416, -0.15012961066545644, -0.3784913778577111, 0.2724792560362982, 0.12856524322142604, 0.3554586057878286, -0.5270944946803041, 0.262912410203322, 0.17179589409389778, 0.04987797170958967, -0.25258785903820485, 0.21446010008980868, 0.4783986267985279, -0.0456779524152381, -0.11498481246420665, -0.406901342886716, 0.15487359332675224, -0.46907062213444983, -0.35013592011540956, -0.28074880708321054, 0.5400569410596838, 0.2691714282329162, 0.41423095632858514, -0.2807128652102897, -0.248951348792472, 0.5227425169893515, -0.12716509219660588, 0.08528136932732094, 0.43965765150435715, -0.09307779497849049, 0.14528582045875948, -0.4210652217254785, -0.3752721265870246, -0.014421259410619811, -0.18663014550092924, -0.8237298029432965, 0.4268350268637397, -0.27356236672807016, 0.42105259551827623, 0.4426324886933312, 0.3340750739404914, -0.15311290647361508, 0.39848444033885805},
    {-0.03524396656609413, 0.5284430711309255, 0.3798356561376315, -0.08284451105913541, -0.020427106313167413, -0.1366393795521487, 0.11430198637398231, -0.050595207890792755, -0.13483241320253242, -0.1931224872620148, -0.1880281477647948, 0.835614759945559, 0.32447070651213156, -0.1341256783544899, 0.10002194128483415, 0.1220503873690652, 0.1756762457264437, 0.11043406879754675, -0.001126619061669614, 0.12331096997980584, 0.29686706909786414, 0.04712157986188768, -0.1573834057541798, -0.11600794042999642, 0.205792299346906, -0.21195411744169337, 0.005457011248097717, 0.17801025159555858, 0.0709760777124006, -0.6407750993168736, 0.05883039753903624, 0.15607717405526092, -0.043167289804086524, 0.12314513347431559, -0.32471845486854356, -0.1951622170623445, 0.3336659635615741, 0.01688075334554051, -0.19722056022925089, 0.46597942744201787, -0.5325091068442419, -0.40009112078915376, -0.05791828552463786, 0.5274883777458924, -0.04916757743569852, 0.1676295898780871, 0.021061391520690923, -0.26340971830398174, 0.022947956750076815, 0.19301524030969452, 0.43000188480331225, -0.0960455433783974, -0.35487379567036303, 0.19325739263999328, 0.20099586902573932, 0.09755836853653192, -0.2980112501906303, 0.032020159344973154, 0.25559257134742863, -0.10117878447690767, -0.21951259443157425, -0.15426050916362732, 0.18143491194765113, 0.04324236968651819},
    {-0.20625275184925723, -0.6120679735928248, 0.15622483828993092, -0.49929270409559934, -0.10830951639102983, 0.44464163386556094, 0.16922251582800493, 0.011718939184032308, 0.6446454633437059, -0.4324662141692257, -0.09575558543929746, -0.5479963570355761, -0.4915857342788015, 0.03933543777033308, 0.5551310575431769, 0.32549415254494785, 0.14416493699801256, -0.3485151867059627, -0.08689387676287759, 0.01714512892101528, -0.30316250258445776, 0.11216824701253415, 0.16913081635492153, 0.4771036059311774, -0.11763548572548503, -0.21635125525463536, -0.6083505373783753, -0.21014502677731794, 0.43579819390755276, 0.2699496404991899, 0.32050418353207294, 0.06550678736039359, 0.13420795886532202, -0.30804316275367727, -0.19556115436164437, 0.3616167659484054, 0.437942429735506, 0.35929762656000447, 0.1914284559341042, -0.24255093147352122, -0.38447175192175237, 0.13012979585579187, -0.1893754821427018, -0.22120672307766331, -0.3002719679098025, -0.17440933762606312, -0.28429416392383405, -0.13468511500268737, -0.09267947770030184, -0.08821943740130471, 0.045786475256091294, 0.23382625244232078, 0.3244008782438188, -0.3559855344475856, 0.24481390710579748, -0.10309707641129048, -0.15219342972175431, 0.007886692396012024, -0.509734695515356, 0.08701174965603058, -0.07628087702937819, -0.013557254319698711, -0.22682407769268567, -0.0991914784238733},
    {0.25134412035786635, -0.2593951084216865, 0.20692396107109373, -0.17746515286597087, -0.40839934519997284, -0.10530703457633207, -0.18251161834804958, 0.06498018944158297, 0.014729478296858797, -0.026572911558810114, -0.2685228545890473, 0.173117003222457, -0.06946198318656614, -0.6439870109005104, 0.32801119309912696, -0.10499334669525043, 0.3661747777584166, -0.018433494635844153, -0.5053107449914683, -0.006963683884617878, 0.13408199128415813, -0.04449987093089579, 0.2396862085297229, -0.2835125356640125, 0.5584917423767352, 0.13060512081073147, -0.34807801493544804, -0.10831572258216925, -0.2535774391927842, -0.12993670338859692, -0.12317861165346133, -0.022920452898428315, 0.38101378016739373, -0.05035620218660177, 0.06558088241087612, 0.04732840112288804, -0.31475818840663294, 0.3627929620680738, 0.17297279953935765, -0.18767775473305565, 0.039048137466894305, -0.08196715984125473, -0.04708049084163197, 0.3032498397777966, -0.36834524591525586, -0.3635327524409876, 0.13399749936277314, -0.12688965928951254, -0.27292068008664594, 0.13575106240663998, 0.1051922873105146, -0.19066128996549764, 0.21375948614201765, 0.040108502875193026, 0.1726989605085011, -0.2062329381261382, -0.16468140342258294, 0.3402846399537002, 0.2963419641933522, -0.09655676256369711, 0.288415720696589, 0.22706448666696402, 0.07083950253023229, -0.045743447897054056},
    {-0.08186703079288714, -0.12095678886506811, -0.1767588681452012, 0.08401176843140254, -0.06049815992589737, -0.15490384287279635, -0.27307382621362364, 0.13191912726566127, -0.1334702409714812, -0.08626180180852852, -0.28012333270093126, 0.2264393466600649, -0.31650566942713904, 0.08191651564430066, 0.04906692122141294, 0.06532094783503863, -0.11437869553408521, 0.34260076517863824, -0.33443847551496964, 0.01174872759676338, -0.11457222700419091, -0.2876731249080563, 0.3386964016489399, 0.2781703031469298, 0.5949184105139668, 0.06749104149776179, -0.038187308171322175, -0.28203020279854757, 0.010299336997800656, -0.31407063420977777, -0.05284184243117621, -0.602687248153516, -0.07583432090989033, -0.12894727612165707, 0.02526607429422648, -0.5367210847033927, -0.6529794656167042, -0.18302341166953973, -0.3906513747843086, -0.0664553924565, 0.597694726132673, 0.2803623905637436, 0.059609012093605994, -0.18141990201409086, 0.2208748864576461, -0.254617047027831, 0.1022768103334848, 0.35250958459702886, -0.34999021967510646, -0.09819595120650705, 0.17910962550130405, 0.1741298092236334, -0.034484667838998874, 0.19192039339201084, -0.17425424485143712, 0.3265699764107319, 0.3826256893312378, -0.19654142344317202, -0.1756144195796444, -0.20949550994920355, 0.35506391990234387, 0.34792120449910313, 0.05323042387562352, -0.06612287303809146},
    {-0.395443745595501, 0.22868063953804518, 0.11381814989870002, -0.14409191286042788, 0.10307381591192442, 0.24708142980013187, -0.3425097225214151, 0.3245000523622136, -0.17355401257945524, 0.5502654053121422, -0.023934262838483336, 0.4288211766937338, -0.4334624020760219, -0.24527230896442065, -0.6528315146138216, 0.019597588492719514, -0.27150335801747505, 0.20374899711348743, -0.1705645179121013, -0.4102280408614783, 0.2505995691460441, 0.02985696971482594, 0.10887511261995314, 0.24511716470112685, -0.4342262142589214, -0.08009648254492151, 0.1889132878551075, -0.15822566142203814, -0.2554303219752885, 0.11226421940586549, -0.15399215276770634, -0.37579227012247585, 0.33047222725610376, 0.3252084318474196, -0.35783810082448886, -0.21915513382690743, -0.36576885367620565, -0.21007827634433454, 0.2908373733092785, 0.07999854087618424, -0.2146692712174669, 0.2827200209225684, 0.34699702666859056, -0.3145352323871123, -0.18602908839614476, 0.14434048798984273, -0.48011571039931217, -0.022285560640675932, 0.24974578603283307, -0.04929935795817212, -0.35600246068986846, 0.1705434979241657, 0.27905148138952024, -0.04057283734800333, -0.23811000763169893, -0.11551183579785768, -0.1490323829856301, -0.09277812800007715, 0.34929875998063836, 0.09166118928270375, -0.2576312853676167, -0.2754864597611985, -0.24867622751427507, 0.1435429492377101},
    {-0.007606978037605117, 0.6329597122411967, 0.30913783908261383, 0.6487783795702367, -0.011743892886433457, -0.039138811524664995, -0.20927242629418996, 0.4531239940206697, 0.1320696833365589, 0.3787499562537361, 0.24948939513063942, -0.09939661780269644, -0.48211872886951274, -0.13993713756720993, -0.13615924039397656, -0.4369589332017042, 0.03471759817508556, 0.3062340272394562, -0.05735583858653439, -0.36555896474586413, 0.2556981794870614, 0.3082800599827279, 0.05266316689380219, 0.110071257921302, -0.07939769429298128, 0.244182577291546, 0.004103561035114301, 0.1529762998795278, 0.1808977197845868, 0.14057308150508277, 0.036964875535706244, -0.08022991201739481, 0.04952530355744094, -0.21927738364021598, 0.2430514073023882, 0.6044213860116215, 0.22458767034576352, -0.20568438883554188, 0.2043324559683148, -0.04620466007988549, 0.1949168772807007, 0.1071742201713334, 0.04536763472070387, -0.22773303172089124, -0.11904653723165874, 0.3004579597572757, -0.018974901697780742, 0.5643806105134143, 0.05109036461901971, 0.4119506526747846, -0.39044628346908544, -0.07374726747207215, 0.4130025693807012, -0.21805410274375664, -0.22557456703514017, -0.427996558645223, -0.1367438351099939, 0.000819137136694403, 0.1369558432307953, -0.13563791894776284, 0.05294316637437285, -0.28683920462757156, -0.2121323877821545, 0.36757536422777043},
    {0.28740307515932084, -0.2166571552550415, -0.09356803184006547, 0.4742550961325488, 0.36265231116601365, -0.3038085502799082, 0.2704834396883064, 0.2759091762890892, -0.2635960090619209, 0.503062086849587, 0.5461421294760815, -0.30859563799548384, 0.17745160128654686, 0.2479512804989131, 0.06362453172558419, -0.5322056417485054, -0.12327607199680274, 0.5002228019570737, 0.06613593554109662, 0.2868021970324481, 0.02035418378176037, -0.12541426298281969, -0.26537361529726683, -0.6755728006086623, 0.12460071186982316, 0.19806655921387617, -0.10836905200044358, 0.02104312665317251, 0.19634847122188998, 0.027782178556009937, -0.3737288969870077, -0.3846273638084672, 0.3469028195687719, -0.020976500378138748, 0.08264849482856011, -0.28336936051139383, 0.8165100741422057, 0.016027202894210266, 0.011956469146934054, 0.20881281471222704, 0.14734077741093307, 0.1510839261292675, 0.6164994947043779, -0.474849025683604, 0.13101850053393985, -0.25580309830192377, 0.27768795202086755, 0.30611457250989876, -0.17291803822582458, 0.3457846285655566, -0.11266216818469937, 0.03732408389495045, -0.41297356677447883, -0.37851261856146845, -0.004715794154978753, -0.4764626206767391, 0.27525782966499085, 0.002932347163110431, -0.23493561830399806, -0.39349460199013847, 0.06856981232741505, 0.19010632638915384, -0.1343817861139072, 0.1749283761748511},
    {0.3066977839651174, -0.15004320744700694, 0.06339282610368835, -0.06385315746676139, -0.24534331384391062, -0.3447701912636393, -0.023022178409052525, 0.2199011497165138, -0.5168532616420303, 0.2883662597398545, 0.030849233973090483, -0.36560408953736123, -0.010236323584375276, 0.04560277175045745, -0.09785005877834976, -0.3829236374448225, -0.6837504662370517, -0.25153981272330433, 0.17113350480105358, -0.45708510202253844, -0.13176014983424983, 0.38978637730897325, -0.43549144925763994, -0.09596205138122654, -0.3937727007665855, -0.06976437709160965, 0.012287900784529064, -0.018066725239200842, -0.13197704798145832, -0.43102553714361286, -0.712181996776519, -0.456513049005645, 0.3578326647933434, -0.1935904078062178, -0.11332731746536082, -0.5839513765324592, 0.05339738418581752, -0.11966278312878464, -0.43852618964846446, -0.20144844628870612, 0.3206780149563913, -0.19273524862437819, -0.3536944744060656, -0.5958852448232045, 0.3006405053841009, -0.3313748052524943, -0.2594631143123911, -0.18382465034926712, 0.24409355177990588, -0.24837870570418552, -0.12146863669758204, -0.1512502526902432, -0.42374367806875474, 0.3636834149523762, -0.07937707221876592, -0.48273336831209007, 0.04199386152781078, -0.10849238331683059, 0.1485416463449743, -0.14862663481099977, -0.1404211923213984, 0.20615574774055376, -0.3165330675611501, -0.22138694369004494},
    {-0.09651586160182776, -0.4823449469965624, -0.02059573950911133, -0.08874916733423785, -0.26176153308459543, -0.3857484260803066, -0.3551090351042715, -0.3336860423033859, -0.5225034248058671, -0.04742192764597342, 0.13757881972927394, -0.21959368546800767, 0.24746810864899513, 0.1208915071130945, -0.17176125482367496, -0.015278715822034314, 0.2390173574397064, -0.7043631923980254, 0.24398246607965826, -0.05957907479267471, 0.3622818069925322, 0.00970399232443838, 0.09870754078620456, -0.16349391355557147, -0.43232352092919224, -0.02470810191620947, 0.13091853638158174, 0.0171065007242751, 0.14709804354788877, 0.0677178342804899, -0.1515629620262397, 0.007463726584430488, -0.1545844703823427, -0.06523022308035872, -0.09968594377694849, -0.41989294496936086, -0.2981263045959857, -0.2930821129331024, -0.07885410399239545, -0.3828623493243505, 0.5029799557595316, 0.19587388880550574, -0.027173311682459282, -0.14030270881714396, 0.4829365907361347, 0.09459393205249353, -0.38698094140132067, 0.19786755972940032, 0.034399634171454564, -0.41703494961540055, -0.18532762543708325, -0.23815228312113398, -0.32617298367935743, 0.3570140397516738, -0.2805607716175473, -0.27950489354972846, -0.1186690764134814, -0.2954490516377132, -0.25450893884060743, 0.19545268591717244, -0.096444991664521, 0.052776513306803476, 0.24788058518480666, -0.41908362048101194},
    {-0.04767747038643318, -0.1348282275203349, -0.1980600892730924, -0.5476742402383767, -0.45179007073775634, -0.19219765958770527, 0.0356658210319092, -0.32806229360865713, 0.2565488142809467, -0.14822990572360484, 0.43924411210512504, -0.06461927656506096, 0.2209427688592318, -0.16983779184903358, -0.44955566838542144, 0.03229623574418701, -0.0715584506047057, -0.25445943093256024, -0.24954651306811662, -0.20045742965914146, -0.14840922515838662, -0.016090067074311896, 0.5795198071662921, 0.32881968295144026, -0.3053858445666973, -0.3176617757228226, -0.029871493653307213, 0.3777781265043763, -0.494896480305131, 0.42963286290585495, 0.022596887064076168, 0.3664437858920922, 0.020691914661457755, -0.059255542722931244, -0.5491076195609839, 0.06390210499984941, -0.31687604947104414, -0.30910219265533234, -0.49147067483055384, 0.07829883271917724, -0.12080291996689164, -0.03450812229829082, -0.3293147502542833, -0.28030746497173786, 0.043996667177712834, 0.11251026955339258, 0.09680653398936478, -0.09886569376224062, -0.3252271578882656, 0.04980474793220841, 0.23948813358993737, -0.2661083572701573, -0.15220141095996528, 0.3719140442514485, 0.04128733041234166, -0.1809462763378597, 0.05893953679660073, 0.0831864543506826, 0.1380463969560373, -0.11675381525461183, -0.1897557640117358, -0.5280840661781685, 0.4778476295406992, -0.3923936097972934},
    {-0.20691355085774132, -0.04782508283170384, -0.5566703000171013, -0.354268399625293, -0.12116359815250984, 0.018541590578822126, 0.1495685345896266, -0.1262744094350913, 0.05329640162729802, -0.03894007638767522, 0.7339748503612572, -0.24978959382580934, -0.2620253349734066, 0.11216153043887041, -0.33211704673404546, 0.029994778480974763, 0.23470062749242493, -0.14570777037778468, 0.19356792892835223, -0.2677237054650064, 0.16670082057253455, 0.09299123616439578, -0.1729424472178373, 0.4709896001272828, -0.19847961543387616, -0.12828524710014536, 0.016050533334963507, 0.34511931574405635, 0.02425280394024938, 0.15911946573186378, -0.1590009294381188, 0.13339488267056446, -0.5954638839276705, 0.3566259338619295, 0.3551805609828367, 0.17183943818099687, -0.33364752495069266, 0.21041742069356015, -0.17762317907944217, 0.022688189675870364, -0.09193392042751139, -0.39868286712747497, -0.3418840380392627, 0.1071205418388454, -0.08015871851383521, 0.3727606177950839, 0.13068038529443787, -0.20391653448920682, 0.11230375205120553, 0.3916911208954929, 0.20386108080124124, 0.027602346654758244, 0.20253539835669002, 0.39174692285097706, 0.08489906741134068, 0.4600005872649543, -0.0875289344431661, 0.13795355288859182, 0.1135408388353033, -0.12426798176374194, -0.49768001266394285, -0.6018502079837315, 0.2541171446947786, 0.306598933065205},
    {-0.2426554919282553, 0.42460615960433773, -0.4651849494838716, 0.38172207296053884, -0.2883692870892582, -0.08551745970460581, 0.04753790268273635, 0.12485941097401915, 0.05481677599432204, 0.032715986523245505, 0.21053261529859083, 0.025573758064067868, -0.14260030069295387, -0.03465053101543578, -0.06301934345304967, 0.233272358266752, 0.09315689879838991, 0.4631132976198084, -0.05400517833904342, -0.49400013646172053, -0.532028985509061, 0.006783441991485509, -0.08589767713109919, -0.40100479262650307, -0.3716082233332226, 0.01979935134395758, 0.2555118810609279, 0.3153492343313945, -0.06817836276385418, -0.17098289422956378, 0.21962954302688317, 0.26612188805048875, -0.4224915378282549, 0.13128842505119045, 0.2839457660968795, 0.45563742743770663, -0.14264802779189106, -0.430579083476103, 0.47292717005491164, 0.1846721733489151, -0.2198683082079222, 0.15961644276904197, 0.3118665003195081, -0.32076763002875086, -0.27783749802203106, 0.3841275545627489, 0.18532547119843976, -0.02309810499036894, 0.3566777377390465, -0.30579188260779994, 0.40832060311018875, 0.2831949277407879, 0.7666025623889253, 0.16211143823027202, -0.39289152253443604, 0.2550891289492784, 0.1887648422964302, 0.18552109953768822, -0.23550905966855046, -0.13254723114681546, -0.4827780915424905, -0.399443813757098, 0.2509035042977576, -0.15288735480781143},
    {-0.1330841654502099, 0.13727898658001114, 0.4405678974051647, 0.13362149548006264, 0.03761863559906432, 0.15143028417513352, 0.14423997309782033, -0.4285762692382073, 0.047508295399780534, -0.515116745963712, -0.1384344081009952, 0.4248098481193633, 0.24443841848404682, -0.368689994693865, -0.23158498481684756, 0.600134559908455, 0.19152593664879436, 0.04948902654991411, 0.10218218141741418, -0.11069822272487728, -0.7253904765393137, -0.3719135743720617, 0.07989598888279742, -0.36058387073747844, -0.05840832374051162, -0.23440615699599188, 0.0523837751367097, -0.08989276959725884, -0.08786846734201514, -0.13776140204710594, 0.08483940346533161, 0.24812803797395985, 0.23230754060609576, 0.6378775441078993, 0.16888579976141463, -0.11457614264358726, 0.04809688738322998, 0.17179268738886344, -0.23534804177295288, -0.318618563581483, 0.11384328021280285, 0.3110233165425762, 0.08219016524796771, 0.04095500407866261, -0.45044290104529866, 0.6379528706992597, 0.25156187083637566, 0.38932918545310713, 0.03895581995064496, -0.5647768750587188, 0.04141852208107858, 0.29953229128840875, 0.5278894687079061, 0.010355963333182162, -0.023433921670029945, 0.5377192351868968, 0.11851394372666381, -0.10130979482196231, -0.3994093771889501, 0.24947408673825291, -0.14601908904722183, 0.12541964854714457, -0.04450293099547708, 0.16747199660584045},
    {0.5055748585373726, -0.34863298601482196, -0.23161360705193715, 0.2286406209459904, 0.5759098979662899, -0.3180903461637978, 0.10603550410545667, 0.18608346712465437, 0.05385538682582054, 0.26033391816376095, -0.34817221096725953, 0.06058867595634928, 0.3074241101860389, 0.1561262796587988, -0.20990338610978518, 0.01727536412715869, -0.1238962190879826, -0.22909537244790681, 0.008841267170596431, -0.3233935279184451, 0.0897027973675954, -0.24346401230946674, 0.12892046121356157, -0.4507982822900359, 0.3474435227129454, 0.33760042020506564, 0.26332645681630723, -0.47855059125191063, -0.1511165155258565, -0.020585573087927304, 0.019160206756870274, 0.008626218900759921, -0.3773956244666069, 0.035287392135807366, -0.5459398626533787, -0.2748193268068271, -0.36390950167377484, 0.15349186050312247, -0.3002471195720411, -0.5416202805518501, -0.11928787877498641, 0.480525630097885, -0.10594956557127028, 0.24561229640901316, 0.01844478135219484, -0.24714743095583502, 0.26610586287056565, -0.08217089305346241, -0.36842890168484566, -0.33855391880694935, 0.121707190964654, 0.15469038392339615, 0.17449658929134734, -0.09956180421605475, 0.00212945533006344, -0.09935889017501214, -0.39063451238419644, 0.007503063231906439, -0.3672021845619246, 0.17638543818395527, 0.43294446531068415, 0.266176454364495, 0.4066512481590073, 0.2024827761635404},
    {0.06473743318205138, 0.39390753314322563, -0.013838955567399284, -0.3544678545175415, -0.3901571733589407, -0.0012032277695099586, 0.23642851627168227, 0.3971239908043789, 0.2561140585747269, -0.15610222339478128, 0.20626488171133678, -0.15939164090892055, 0.3351045791083995, 0.13841437833906758, -0.019676188559628455, -0.11288727329792123, 0.4237203680975677, -0.3295891819617373, -0.24289414634703868, 0.32243407945595826, 0.2122181166379711, -0.038470972272354007, -0.22088201874660535, -0.12216087455778468, 0.012507239983706859, 0.13870007362260028, -0.35276505824647664, -0.13399977710710503, -0.05080691494064881, 0.22420190197154985, 0.5049520457891556, 0.5327422231337763, 0.3707456880274429, 0.16848332225554613, -0.401717529277835, -0.2414215231382372, -0.24639916488354394, 0.35677263095226563, 0.16381041426784798, -0.07261696145204216, -0.2764246596496592, 0.16157766777669744, -0.21178120040765422, 0.30449991359031897, 0.28594761020439247, -0.15504838361224144, 0.21524626415254128, -0.22993078244420198, -0.09306600273763514, 0.10116371220633479, 0.1590297572750941, -0.6304956645675303, -0.1320263255308906, 0.16369417267259617, 0.6325210985230487, -0.37397524228150947, 0.0879878486116565, 0.4361101272736566, 0.31664225908499183, 0.14991669799233417, -0.4848186840375522, 0.23462825408772142, -0.051393464440999966, 0.26538996186730285},
    {-0.3047208271122021, -0.19579270060766318, 0.03008895595241205, -0.031232895192388994, 0.07265314017354507, 0.17851299080936392, -0.5228245889596661, 0.08913038046424338, 0.1559135448070879, 0.05019922116904191, -0.0961227511639152, -0.34223261846337427, -0.49708989720261454, -0.04347860266705727, -0.17640969098803155, 0.08374002896904764, -0.06558296974522367, -0.3497168099329539, 0.2616731505404946, 0.3551002822022274, 0.012629399248376324, 0.02860470073562332, -0.4508337636694968, 0.5620740598678877, -0.06564017684739026, -0.2770250651983959, -0.027965905128701257, 0.2906865770585003, -0.09548823556552107, 0.13546102346388042, 0.09129422307737968, 0.3608224599177175, 0.22094610016479171, -0.17110050561934714, 0.4695095508978591, -0.21952597689447373, 0.2891841829802607, 0.14668850419490387, 0.45946661560069074, -0.26702324706779534, -0.10914720740091298, -0.014118581912135946, 0.42616849381923294, 0.1892732843751971, 0.3916219122833047, 0.11287754600345833, -0.3108269771842519, 0.07776066688713319, 0.11168172061914737, 0.3834995124596679, 0.4334081912557224, -0.376678815846188, -0.44260517619167017, 0.05737076795658876, 0.5154835980067896, -0.18106932934798795, 0.012772168361136175, -0.4003190412111387, 0.1596178750726101, 0.5666767465605702, -0.29817843783112463, 0.19845388352691756, -0.2351264122072794, -0.40212231915889046},
    {0.11778720929109031, 0.21675835554515854, 0.39571345724017926, -0.41004108106868414, 0.05309207975091627, 0.1402065416702564, 0.0758683982128175, 0.3053715553131964, 0.33203584201429875, -0.1420896455965615, -0.049806844484259725, -0.3686076032974457, 0.03195156973836183, 0.18734643844420157, -0.1367787902091334, -0.09245335127014262, -0.20173380864082788, 0.03907090383505508, -0.05706515742960926, 0.23220632378995126, 0.06639068770114674, -0.39172030797489266, 0.36516258622350084, -0.36471086391535956, -0.39468401727297725, -0.1628359436543919, 0.5792778629505085, -0.303070631438782, -0.36964905544788773, 0.05027045550856001, -0.19600330811756642, -0.4709271499836325, -0.1438913526292047, -0.35534103040151477, 0.6255958448928792, -0.38416219758697556, 0.2771229820738026, 0.1581185953064935, -0.5404191429146691, 0.5714172142556306, 0.1823429910179777, 0.15969048410070125, 0.012640085010602846, 0.37331296134443326, -0.09156501714311537, 0.011406431476547225, -0.017270529358820307, 0.09823364027295307, -0.16266682961952372, 0.38473198654672575, 0.12271425308850085, -0.25081557421963563, -0.17978607671465482, 0.3280051592895097, -0.04475657039325134, 0.6084953691433171, 0.022791863894876262, 0.17799329050500134, -0.16480821723856612, 0.3284231433737633, 0.13980723843645085, 0.11509488900343799, 0.3637042886040196, -0.46866117751583136},
    {0.10586354828005577, 0.6242874611171875, -0.163928308960114, 0.09491943029699193, 0.3739201986908682, 0.23150886530647374, 0.32982082297689197, -0.03288993485899033, 0.029528393179326554, 0.043743036630776846, -0.07460048944660742, -0.11289973259823867, -0.28065497083223684, -0.09869388927834025, -0.18782541892212753, -0.028695545051627216, -0.07207537383100276, 0.10314338219934972, -0.252951578389345, 0.43542254020622045, -0.6370800260969659, -0.17660272963594087, 0.044697990262992295, 0.030100835376172676, 0.13750730542527384, 0.11929372044097851, -0.060957499658342074, -0.006302926858960367, -0.3127406058308776, 0.2701697633383784, 0.3474415614541596, -0.3924600514275027, 0.06388153582468199, -0.050022224253927716, 0.21377665398936505, -0.07667438573694854, 0.05585182206433501, 0.434188595315603, 0.07237157535947263, 0.004229326851394565, -0.09299451316024174, 0.0013413747380246902, -0.14893379330472858, -0.09922331714960156, -0.039820530724010796, -0.11055488386578202, 0.4624759817078604, 0.16468188178613546, -0.06763012443979902, 0.06582131881016917, -0.18143565215842225, -0.12285005632753387, -0.3003326327423099, -0.11357124237549307, -0.23856659742983916, -0.06299756383999093, -0.4685604466363816, 0.011627850374544729, -0.10538536739125512, -0.2504182257071965, 0.17199771604052033, 0.2525164101823835, -0.0517833653251331, -0.0937776385915928},
    {0.1994879613879527, 0.21046292040649367, -0.11222514139476372, -0.13318497523771633, -0.15554105790127898, -0.22013108932279216, -0.0012744700852350371, 0.13495730855189503, -0.3066841107485227, 0.22245682867666203, -0.2619138690579319, 0.045563223662865124, 0.14087703583908723, 0.09744586935517578, -0.010946716457602824, -0.4408296737288572, 0.3266914868629481, 0.21513465756656122, 0.07338430859937023, -0.00531515292079088, 0.027536918698315357, -0.028012767881034777, -0.07338310233495625, -0.18566135969131817, -0.045709049002026825, -0.23053390000948012, 0.06808421401219265, 0.22948425856508842, -0.0596341152966607, 0.43003416840976116, 0.18305322484644546, 0.3092475712718856, -0.19261114840619042, -0.1559032156343107, 0.38266068626664845, 0.2759305648378755, 0.19263321801992375, 0.3613323368857585, 0.12899105702890176, -0.0791026280810485, -0.24147573971346137, -0.12084467307092131, -0.01020188470756802, 0.10445392291559862, -0.35293388187590513, 0.2935283251181651, 0.3045391957700748, 0.07436978674305311, 0.3286226918313647, 0.35220244740880763, -0.00587881288271526, -0.134487075272745, -0.14561811197063454, 0.02411141126328493, -0.10784826368567989, 0.3590461311917757, 0.5845658813826504, 0.20868521113519414, -0.5298753885028625, -0.35129034089044475, -0.29531339711934, 0.046769247215178195, 0.30333514478215845, -0.11316005466290285},
    {0.2869324578243553, -0.35864972853049243, -0.031537901041770816, -0.07505793971593842, 0.0446845667506548, -0.16040388746194423, 0.23169031486759212, -0.5594445366347504, -0.18384169915155477, -0.36320339563514825, -0.22116438363537613, -0.1848350874655098, -0.031005204038515165, -0.29720281635968043, -0.24458755184443434, 0.13509617372546945, 0.4826564497549374, 0.274451327027433, -0.16183091091637122, -0.05376231618136593, 0.3275485729778018, 0.49837952011445547, 0.18448858258583034, 0.1241152774950933, -0.35684268536659186, 0.058401384007089004, 0.09577391769703991, -0.15974836211084892, -0.3638559359360713, -0.04705518695491156, -0.11926807887604077, -0.07751794108331377, 0.28129303315809223, 0.03552969691491423, -0.10297204347360671, 0.7040390074505656, -0.4844175356953408, -0.2579179707648944, 0.037140270111610516, -0.25065751741544556, 0.5911812426403754, 0.1368932633249254, 0.024230897284747678, -0.08546305211094495, -0.09645110092305652, -0.21456454917253034, 0.694415574972633, 0.26181712555909925, 0.2369156635212049, 0.24606375507081624, 0.11538125563275331, 0.23707750282320916, -0.4048654931631357, -0.031747903784232236, -0.07266282959012052, -0.15068812739642273, -0.09826387851676809, 0.1465052182753898, 0.13240691831954493, 0.7776706701518693, -0.21713559082219594, 0.037461551387888224, 0.46362819010541373, 0.002093802151768063},
    {-0.3355524139489253, 0.06911091140301065, 0.23411965291543574, -0.0563257143333209, 0.15196770514887678, -0.005333822893308407, 0.11443229481321408, -0.3285228370010516, 0.03373436654470951, 0.113552313684569, -0.14259716509648607, -0.07804213784907457, -0.07633822571641581, -0.12090344146749739, -0.022974393020780547, 0.26902800952957284, 0.19566501344263068, 0.04908915155572679, -0.49758614146749175, 0.2998679453293124, 0.0011809314999426364, -0.06455642842997446, -0.10061014788580314, -0.38113278911919524, 0.4637576949420432, -0.17351860366546834, 0.07072474312227564, 0.2647929368051358, -0.019607624747133897, -0.17850516753474716, 0.006718547517277244, 0.013863829820820146, 0.12947653346266064, -0.046767855226876535, -0.2957310226234805, 0.5054504917109881, -0.2803489323064679, -0.4598076403092569, 0.0017167926227034049, -0.09759916089013249, 0.11952977599153296, -0.34767279396627143, 0.024118148821005967, 0.06541414921709646, 0.28843765644380975, -0.1117913096907397, 0.3890602065775357, -0.15227189596847196, -0.10926385948767689, 0.0191275724484613, -0.3036546492574302, 0.18669851404923576, -0.11751024944614946, 0.5227217512788613, 0.2205419572509571, -0.13528536900118726, -0.18298396500738182, -0.07381275982743941, 0.20501078332457853, 0.08674825077549911, -0.057167864462281254, 0.20366694146053482, 0.2652021213949786, -0.05600569226998935},
    {-0.12456526278884981, -0.016630535768159378, 0.48859343797269716, -0.13752827762944136, 0.3397043449660309, -0.2864230451436587, -0.1501775628114257, -0.09845658468079888, -0.15604705628660828, -0.09976837755582225, 0.19229461356493807, 0.048999665888180936, 0.443141869426924, -0.12122818569453155, 0.44433349621236073, 0.03087895029025006, -0.0655421325675499, -0.28710697037744237, -0.2956571699740435, 0.23614976682386563, 0.32191083001923904, -0.246407666988721, 0.11877017956554889, -0.6149515926381883, 0.019535280188805154, -0.2657032000332207, 0.32124323688242745, -0.11164450396182488, 0.0024305951790022035, -0.4017242521068174, 0.32928570546078634, -0.16074021008901443, 0.3364985413232298, 0.1453326115875439, -0.292297188827199, 0.02726670825347889, 0.17074997087925917, -0.13282839991700685, -0.12710700881686343, -0.441028143187512, -0.11941264003374234, -0.3594055919442286, 0.11068501020696271, 0.023764631351908573, -0.45860062646080924, -0.060017221360503754, -0.16150864053703018, 0.15400621861123337, 0.03025047123175108, -0.37324523754097355, 0.12658994858795256, 0.014106605653503149, 0.4226937408936003, 0.008137017630336692, -0.12057712039306039, -0.2999081555651347, 0.2092681058151681, 0.14848806980697632, 0.2939662352629545, 0.2634477012516886, -0.4831369483940918, -0.36388444339486475, 0.3325059226609221, -0.09182214295561482},
    {-0.03693112374105958, 0.4130361446631779, 0.04855439692084075, 0.06296571864225355, -0.356005467816741, -0.08942186019480754, 0.02870811444879649, -0.2769826956689802, -0.202360402528999, 0.04110236166561216, -0.13599882771728927, 0.14983814060461478, 0.037023585335918534, -0.3717984329589212, -0.32838223377996806, -0.3354943850502367, -0.16352728068444974, 0.320386769971577, -0.27674174511052635, -0.40715134325439206, 0.4333738931899038, 0.18204556620493775, -0.043789609563663526, 0.044163827068028676, -0.2769516936161457, -0.012288817013022263, -0.024676656362820574, -0.06185024127748011, 0.466668120446841, -0.055995203417490036, 0.2616170496323313, 0.31091077960809554, -0.19035240196168252, 0.11374806683967645, -0.21342198076549246, 0.01844178029132161, 0.0468589787183075, 0.15050505851694, 0.1724102778883959, 0.07819921561400477, 0.007170700840816721, -0.3227780247636451, 0.34795107821640997, -0.14371244330851032, 0.06371115754910997, 0.30345650565286475, -0.3453274860752555, -0.3270391437590808, 0.16830481057821917, 0.09340380815239603, -0.552942138255851, -0.04800962394762453, 0.163088079079532, 0.4191321753815257, -0.12648434802594782, 0.22920717313591982, 0.0493395708182172, 0.05905168904861568, 0.184352885535499, 0.46380851396361156, 0.22977761602313448, -0.1306278147837984, 0.01811873361299926, -0.11060749356108723},
    {0.09924137057550446, 0.14311796888309578, 0.4931424343151444, 0.4245639372750691, 0.1379780599829515, 0.07718066938974574, 0.20912221707282397, -0.05799936267141431, -0.23023580416326928, -0.08719977756140977, 0.045880437949250695, 0.37460170437959955, -0.0724705553526723, 0.0749572340431792, 0.05109557846284547, 0.007454482511939764, -0.06505662299342171, -0.43365824346162485, -0.018225317327847636, -0.31305716508765624, -0.23648370046797929, -0.2541268232107497, 0.04991529918665816, -0.0015822126960852753, -0.20839291563875204, 0.4488922744362072, -0.4776271720822841, -0.06761515532193413, 0.14826863560850223, 0.18575697549535108, 0.09031432944675115, -0.14870152445435067, -0.26139194943920485, -0.052556222717539784, 0.28662228374054843, 0.10607646804192791, -0.42813329903087405, 0.07959100790627409, -0.4552628485570772, 0.4453972236400324, 0.3717543325225827, 0.11925253889679092, 0.6461120508650219, 0.07386616738449858, 0.2735212998578963, 0.008805031126366781, -0.40680009044948257, 0.16590541261903882, -0.2551815241430558, -0.06897089273885405, 0.14686546227987568, -0.42731021617481746, -0.1691354604907353, -0.17659674810444834, 0.0018265632229285279, 0.14378303187558644, -0.11909111664072855, -0.28676169026788145, -0.2330362395015755, -0.16815789894094685, 0.08233828532056867, -0.01246943044645857, -0.12540413594563127, 0.013183036837177302},
    {0.1256193994782482, -0.36867557372771975, -0.22671430355753583, 0.28070387702395083, 0.09195451925584751, 0.38988962405410654, 0.26258591604629156, 0.11143312007298689, -0.032860378955579694, 0.2134588533674423, 0.445947216060539, 0.4897523077135481, -0.2795426351895574, -0.21731924903552371, -0.09040658617155611, -0.2227341711373278, -0.0007802375987857673, -0.201152862012976, 0.20499120057857195, 0.46487868578680436, 0.03796465373151937, -0.06584373696022505, -0.017616272251400354, -0.08239827215744287, -0.18296175804503956, -0.17883865641375868, 0.3477166952089032, 0.3251462501425033, 0.5088277205781729, -0.018984913225987856, -0.2989376868564416, -0.3872394563300837, -0.31094117531044596, 0.22780254222012014, -0.051989270451217144, -0.2770230261873543, 0.20220569770043648, 0.061516218243082364, -0.5542677818696098, -0.10200966657823977, 0.10865535745348553, 0.10841519956321422, -0.06876452581453724, -0.07618880616798017, -0.008240099868973078, -0.025827099854751616, 0.17306755199049598, -0.02484634248488212, -0.23087015974740668, -0.13213866576799185, 0.057092914742482424, -0.10814369358005381, -0.17937382062954063, -0.6937562120704025, 0.029675258232318175, -0.46992650525294233, 0.305210589241536, -0.12146616005726674, -0.3180251586221126, -0.4477844389583888, -0.18321948189806989, 0.19583015467398962, -0.07036563847013931, 0.20658495309845434},
    {-0.1587703143801666, -0.17307031653849547, -0.3592919127802763, 0.0903789557724071, -0.021253946037456048, -0.30256603990393394, -0.21136151832116987, 0.12802965159076415, -0.22533117156213725, 0.5351582840160984, -0.006363015440396508, -0.2404758079779255, 0.3812545380561916, -0.3768568307964298, -0.004219879656828159, 0.15486021997773874, 0.19963524897786022, -0.08673729505929756, 0.6194551407405979, 0.1279080464234944, -0.3405418195468966, -0.5873433094732828, 0.3505428542430288, 0.16860255055974196, 0.2808295514218385, 0.33314905295869607, -0.40634556930979965, -0.17709178606978954, -0.043349943528651076, 0.09445577769215775, -0.39431604140935084, -0.06288593710273228, 0.17631220562575817, 0.15508451574565735, -0.1431272444864012, -0.36855270751733654, -0.02426643704885004, -0.11875154833642802, 0.41935794968614815, 0.13822226073788604, -0.10802655793299569, 0.311364137220439, -0.0049752556916372, 0.39565985934745906, -0.13714698120251057, 0.04647804304148021, -0.09217125321235785, 0.22267926569619975, 0.27029943934884565, 0.255672081345629, -0.19293920853683144, -0.18670597494299132, -0.007294991996226837, -0.23747934423705325, 0.40086745504638566, -0.0707113220375609, 0.42633142403199187, -0.2876788977204617, -0.2592207465091765, -0.29304199035001816, -0.22435747916986132, 0.08777087433334956, -0.2517718055255927, 0.05830741231146778},
    {-0.36500317332921095, -0.05074331781468202, -0.23390860035359215, -0.3040558937390226, 0.06664083792752533, -0.17930764965767929, 0.17718921374009522, 0.024517378317889575, -0.37854418204324114, 0.058364715434570176, 0.10289952854357687, -0.2500203981233279, 0.11018847849842328, -0.334654998637942, -0.5158349279859596, -0.24180003998693597, -0.2957716083239945, -0.26404190432119173, 0.07168004514622944, -0.07346837889415224, -0.280154623687958, 0.42682720195388607, -0.026130326552057312, 0.13110925581879496, 0.043823526888134026, -0.08992408531059719, -0.1293731596903978, 0.01596133622066073, 0.04238599925092183, 0.2535131895757651, -0.11455276113653687, -0.1325585382456361, 0.520537365965404, 0.1126806738339907, -0.3365473947531585, 0.028182513013849452, -0.4270823315872917, -0.5707459504377823, -0.14624577051855076, -0.5104547641173266, -0.16825612618014682, 0.30214989067963244, 0.31267011717508075, 0.31581666989542123, 0.43363063919519257, 0.00998624372905397, -0.3751900020698073, 0.0636275773308371, 0.2538473867793738, 0.09218733847208978, -0.275610896628948, 0.18924788938963605, -0.05631680726468913, -0.016094502107573006, 0.36354711658767586, 0.08548351106353895, 0.12127331136463165, -0.12550375899855157, -0.32126238992112244, 0.3820171115643933, 0.14926600656937575, 0.4859106482888355, -0.49634653850821653, -0.16095211346719707},
    {0.29871958859848324, -0.14913279164697987, -0.047705755800376386, -0.04948558268746335, 0.07493428082420807, 0.2480968983583656, 0.1456745805467334, -0.12482809569764304, 0.04505405832845531, 0.27844582546819696, -0.13827155184277726, 0.023932524536782743, 0.1779913115877488, 0.25743693682173163, 0.01823233294063839, -0.17353576485224287, 0.2291420533778842, 0.028354116732603515, -0.478072398010437, -0.07011593555981989, -0.047133019148848876, 0.0645043586079198, -0.01975715736801049, -0.530742632400314, -0.19936387932132232, -0.016712507107657655, 0.30515860216907936, 0.22075057440681656, 0.046449788000428004, 0.06405748372643053, -0.5906472490112623, -0.41435177321753297, 0.2245080250953983, -0.13853342520121312, -0.15590338966102454, 0.5181525146767859, 0.12040427816628406, -0.030940492523672553, -0.25189107269540256, 0.07622613601112586, 0.16478720773995506, -0.2673460362994749, -0.09778364743952511, -0.17967442947921544, -0.23672832228592142, -0.13563776435073177, 0.10754072262283577, 0.5068568692320093, -0.3070906829600568, 0.19101868137078337, -0.35844127384351393, -0.054493375729704856, 0.18137677827238238, -0.09168194085654742, 0.18426432395271802, 0.12277466597562224, -0.2024519918980004, -0.40533573270911266, 0.5153650344119279, -0.3598505156165297, 0.11254229763200355, 0.3861478484431229, -0.027727654274299445, -0.12991072899639167},
    {-0.3805380868934067, 0.43784329135446554, -0.16082279700577434, -0.2490364963371314, 0.11302413465521426, -0.07407596891457328, -0.06756616198346194, -0.2686419320022208, -0.2535216901419173, 0.343225492143915, 0.13644452446351624, 0.0039081118199335635, 0.027210377061813413, -0.04211689937480862, 0.14179782368438706, -0.21446167743054717, 0.08932312537259876, -0.5679626072141741, 0.17078972445996543, -0.09860519122793648, 0.14157296048628673, -0.3579917213552638, 0.04162726428813237, -0.057280420166819244, -0.04831754449546221, 0.24654001708006473, -0.40726773940296124, 0.15119198992348337, -0.6029522443207593, -0.43773450663365365, 0.2771915959896065, -0.43892452222238953, -0.01854603474209422, 0.05716516312946695, 0.0024463973025568918, 0.041462983891969576, 0.41715153165718466, -0.12117668815312835, 0.4378349249238807, 0.16806843155011156, -0.0979181036423098, 0.10264462177919888, 0.013852992777532176, -0.2974812326862485, -0.0015207788638385582, -0.04132700156057558, -0.11986654200208996, -0.17773822354541816, 0.12723988145019627, 0.08511180149597045, 0.10847725328786922, -0.2288181032765184, -0.17059219800038172, 0.1897572683618792, 0.13987273347225168, 0.1227779934127641, -0.16858065383283072, 0.08054214945765478, -0.2976051997100827, -0.32876405359616, -0.07928022536670275, -0.3073689173115492, -0.26962208332111426, 0.14547499364187322},
    {-0.08654683023870893, -0.03851541087920397, 0.022021951235222707, -0.1449592393068557, 0.04132543899997252, -0.15761137693198005, -0.17616617257676512, -0.2807536377797365, 0.08155868691353184, 0.33699534232249634, -0.018605192538517116, 0.08864308355037877, 0.05613387568340839, -0.3154607454178799, -0.0402065241802246, -0.059214734473591844, 0.15713738499794574, -0.07343819914827494, -0.11115295021990126, 0.2530329950327837, -0.016794490937859237, -0.23317410996288154, 0.135635293239371, -0.09316838871840324, 0.08239627117504891, -0.24298302648310063, 0.1046057439301829, -0.3083984338538223, 0.16466487065875696, -0.17694515983431766, -0.248292803670451, 0.07525622708893827, -0.07266848875167219, 0.13346346931318676, 0.3558130337103756, 0.1990008688567992, -0.263880568355715, -0.07889548980990375, 0.4400902097859494, -0.18141901029056437, 0.04826462590442263, -0.15600329299597623, -0.129856992497407, -0.1393779964690483, 0.27345607974337377, -0.2366908640035303, 0.06916587327580644, -0.41973221851973247, 0.4492763886528659, -0.43336157214010235, -0.2353382925315007, 0.4200743297302373, -0.4639086710107094, 0.1694611937546248, -0.18939377841353322, 0.20710705115947703, 0.11771331752630551, -0.328923396829848, -0.4069710340951426, 0.1909399333688139, 0.34161088198564826, -0.14378648724565574, 0.12304199028162215, 0.10020659168234226},
    {-0.7628727265862248, -0.1872446322372578, -0.7155425568476866, 0.14255270339819054, 0.03247935717071449, -0.25128616790676933, -0.5599270834410163, -0.6548558592767478, -0.35653263494169557, 0.43182150457747104, 0.5294933398802871, -0.2986048165375361, -0.7844418022039286, -0.6220116975632827, -0.09733869953411886, -0.7113683071130821, -0.5609282961046739, -0.5431804510144052, -0.4992297968738325, -0.1736666963850087, -0.6876519656774234, -0.22515927507524128, -0.46506641519151143, 0.33618828017278296, -0.4502752863328722, 0.4858365006940476, -0.4837577402670068, -0.6145050070127941, 0.6101732406484643, -0.15606881141118778, -0.5726777374460618, -0.6992617857511572, 0.23387555900871326, -0.5732246717172624, -0.35623996748918135, 0.06384917335477251, -0.06591373028441941, -0.5888708146503475, -0.02616568624616123, -0.48880825351969076, 0.5290868771959553, 0.5517295814330633, 0.35196127210830613, -0.59413454712525, -0.7212919607005419, -0.6953278147087529, 0.2513140878510475, -0.8562953004788265, 0.6871861391095815, 0.2235017402300154, -0.6599286818094171, 0.3068755601508727, 0.12527279255900206, -0.9168897042640335, -0.05524822702574613, -0.6181823388831562, -0.006538803251078019, -0.370484211519645, -0.22831057778465885, -0.6533486060465766, 0.5592508487976716, -0.23598351833755168, 0.13619768378839195, -0.07822197285922126},
    {-0.551019098273854, 0.24965922850130906, -0.46158280951495445, -0.51084085500795, 0.10291006240976663, -0.20262208474607213, 0.039455548915686436, -0.7709789475754314, -0.5187173553732447, 0.5959861401208868, 0.4781882696736074, 0.02495492989751753, -0.42943478943217267, -0.6386030247822868, 0.08743710810282644, -0.667449057096272, -0.04455461940121965, 0.20215224118041555, 0.003700673544064136, -0.03805923584400573, -0.8088530625716, 0.07514746896441361, -0.22513823927701299, 0.28505578797193626, -0.04154333888571031, 0.7320733696176636, 0.0465439466317452, -0.894893765487245, 0.4716461929483594, -0.2805745200785139, -0.48914519030898657, -0.23162970629035193, 0.42909971718930473, -0.9041423406924713, -0.20461410126449214, -0.2569467611689689, 0.05184449392555476, -0.5186625368007864, -0.22009576545639786, -0.5913751712342408, 0.38111956463957164, 0.3707412445263377, 0.7924072803973561, -0.5858335957917189, -0.5187894723098796, -0.7180518194410498, -0.2444072708758992, -0.6643523211877858, 0.5375105557231695, 0.3179281481995383, -0.3264828122704012, 0.42006031114455367, -0.30873179940735007, -0.562825749265062, 0.1285172465038302, -0.5536480809298049, -0.024065893379780483, -0.5652194904103309, -0.037801672347049044, -0.20512576965914564, 0.3816891445143173, -0.20463553261007172, 0.35969816073437716, -0.04015730612196401},
    {-0.4904527317783856, 0.11244638418807977, -0.6127362534342615, 0.4094834966654436, -0.32257181862661016, -0.09704683549610674, -0.44600645640078407, -0.41647262224158293, -0.3031067926492344, 0.2737568981772196, 0.6669482505917546, -0.34846259268446744, -0.17782414960568943, -0.288899180929836, -0.3175465567081893, -0.6198572919512734, -0.5723566149658365, -0.5584423469410894, 0.0542979574572252, 0.3623612481170305, -0.41562572091145, 0.13104456437212728, -0.4205214107320461, 0.46725010101767134, -0.22855984243412278, 0.2675450846872771, -0.3242483035809706, -0.7340509213661873, 0.5986185879582581, -0.3335120287476439, -0.12624475022622558, -0.2926854394722278, 0.033631955760596605, -0.5292202739226678, -0.495216857230202, -0.2717937342328124, 0.5613482726983264, -0.7034176300270876, 0.15999800833638939, -0.5194951011826304, 0.4215898873750206, 0.3692154483719282, 0.31119488458128214, -0.06955790371821909, -0.3545103490580455, -0.19086328622231868, 0.29547008297191263, -0.4267183916374647, -0.2038861640566137, 0.1080270968976815, -0.4704042842848987, 0.07755864797702475, 0.5181618276853752, -0.09580082081166144, -0.022263882488687374, -0.593705278593524, 0.0593694510894069, -0.43832771291030187, 0.25016507401483074, -0.5609460533051498, 0.19962288288530589, -0.31435100915336806, 0.32786198910068154, -0.42681644986488537},
    {-0.4730695825225485, -0.048411050247642994, -0.49504457626445586, 0.004174970145383624, -0.06389589641623207, -0.08500384662019181, -0.02717787720338434, -0.4479946760693644, -0.28804118085333696, 0.41356327922932473, 0.5418659473442494, -0.14348510108580048, 0.2147876414418746, 0.35346976648763867, -0.3084593336516112, 0.1997961060662639, -0.24145734977899527, -0.143316820116321, -0.371882657174617, -0.3327969154049064, -0.28289769388854263, 0.5900729906229353, -0.642654618381589, 0.17325461376465884, -0.3846285860795645, 0.24650905555269828, -0.4509148554684345, -0.2634444236112493, 0.14123707327268464, -0.1241454613515546, -0.4010517610264255, -0.32371695156033337, 0.13507784186289384, -0.14448405403088885, -0.5889311080066106, 0.0530081111045686, -0.2593027634179643, -0.3516992701173781, 0.25211459899366034, -0.6150393520212978, -0.14162926816989557, -0.2377782607943559, 0.6646243908391875, -0.41854144552474887, -0.7173216418540518, 0.23023369711124447, 0.5228209586202103, -0.6304511981860124, 0.4437789147184571, -0.004941099684344452, -0.2118785141927181, 0.2295807217482061, -0.08290521975505431, 0.0003816140944398223, 0.06446494704616687, -0.36994537882003187, 0.5975552660969728, -0.2634918135772312, 0.019696400456227576, -0.1208406421162843, 0.22133148531870087, -0.0057275903056710235, -0.43013925684039883, -0.027017616212403964},
    {-0.5549727902989907, 0.0752779457981053, -0.22038376439827218, 0.2882652568486016, -0.7296816610889129, -0.17676855420168971, -0.47996905444881166, -0.21491717228122556, -0.1712693774629801, 0.39171148117133736, 0.5379218957704767, -0.03236726919818903, 0.10398106447130806, -0.26460844739484246, -0.192085147904684, -0.0059517236675601486, -0.08278314223138016, -0.09103061383729634, -0.18519781621838866, -0.15358672942240087, -0.4463039268736428, -0.06433090590160605, 0.07876271675478479, 0.20985308264495303, 0.19518609254266928, 0.13245631021093093, -0.24233238592219128, -0.22866021589148303, 0.18581554927449212, -0.5333552735983758, -0.19371066055824543, 0.06645984304860308, 0.09841355430309273, -0.34140163699710074, -0.3745952970051498, 0.033970394400384914, 0.233771166812426, -0.4743277102785942, 0.05236197746785609, -0.3955046830867816, 0.38021248876584113, -0.7859065380649722, 0.28510076245763966, -0.38238091302911026, -0.6672231975924358, 0.1750372890940159, 0.45495312031910173, -0.28531871666667574, 0.19410874977319426, -0.1613857911099049, -0.3015286097188586, 0.5988348537281561, 0.27696499935462826, -0.4192445021812617, -0.09242583544282747, -0.6025676430325995, 0.44164956924095056, -0.4639313576956288, -0.401200582584439, 0.05431972539131103, 0.395738788387831, 0.03124797693047421, 0.07281291146324867, -0.06569485930657291},
    {-0.12490846578682817, -0.1256361463886182, -0.6656503929595583, 0.48622722259414236, -0.10393699262418335, -0.047623066016620225, 0.03649242910759556, -0.4156383273919049, -0.557962135295851, -0.253174476609307, 0.3624195226983802, 0.13006575377591637, 0.42458870128046794, -0.5165012216908061, 0.11146884292325979, -0.11437041875547115, -0.6134780520416481, -0.2791329650138615, -0.032591810533685324, -0.4963781010521193, -0.17255412585216579, 0.03209626694526559, -0.7024183265585892, 0.8458468523438516, -0.2998641418255267, 0.4803141190069247, -0.3829493067000081, -0.4646965111716002, 0.12940803306398888, -0.4062911518099251, -0.324269673450414, -0.212947932984203, 0.3151671929597221, -0.08801278750735311, -0.674685923408307, -0.031414183265320486, -0.26638177854754735, -0.493249599181784, -0.5488588239614235, -0.5534751512613825, 0.45322214888614804, 0.03516208858977104, -0.29219784308878527, -0.11244935751021837, -0.029434304905469715, -0.1820593710000671, 0.19499494695519667, -0.3565303795359249, 0.2630084755194395, 0.08239647698384102, -0.6435652281631771, 0.17242473009352433, -0.08006805867614733, -0.38675451750630396, 0.10650159924473095, -0.3282795620528662, 0.3440623475849379, -0.3317669489339224, 0.10208854719776919, -0.23060997941697503, 0.45679137903007433, 0.2434102614179609, -0.22174943099729166, -0.48681830523666225},
    {-0.1857547260282282, 0.3945945210484788, 0.3171709461290946, 0.07544535839084279, 0.2755516698192838, 0.4335130103763318, 0.5431613992683706, -0.4196079554588158, -0.13399547365895234, 0.4617929148383275, 0.1013431803693655, -0.1664821472782514, -0.2536874646972308, -0.4662590839623579, 0.08148955746491714, -0.4197533545444837, -0.6868663014078925, 0.19658390883370108, -0.41572825471358094, 0.3921285444410968, -0.16958712248221974, 0.17234457178469936, -0.2850748659207525, 0.31443730594797753, -0.2186728250604703, 0.4105960937554687, 0.1291648086107332, 0.08503575432183055, 0.24731439925210133, -0.1260620170017843, -0.22200518856343526, 0.15952589812826806, 0.011919221023240983, 0.20658273447533101, -0.21994743197370997, -0.4436843215620306, 0.14139979873264075, -0.29034589838492597, 0.33339108805567774, 0.3181674853987587, 0.252734882968874, 0.2872898543925829, 0.31364249976472053, -0.25436604558619763, -0.6814347674064772, 0.04835811710627727, 0.2763690947635491, -0.31075507336136504, 0.27534096264598085, 0.3813130556527861, -0.43774930025433173, 0.44566291130282315, -0.343383595365499, -0.18513828870515317, -0.4724536620095583, -0.23936953859174134, -0.28196658301570315, -0.29125423324755956, -0.08596233689918494, -0.24887822173452334, 0.14352368131344548, -0.2949343804155895, 0.11407110660224005, 0.18412428122845967},
    {-0.004559083602460859, 0.006576717455739945, -0.31214943806202483, -0.004158217631155451, -0.04884205785906226, 0.5724146847038208, -0.3859878848911648, -0.37186513156696044, 0.45454615781622615, 0.11391739466933865, 0.47822448963971287, -0.20349318538712483, -0.3866303142635267, 0.037173992569250906, -0.04932934824324119, -0.22893474461182722, -0.38498340930406955, 0.05837771137668514, 0.14005599799127189, 0.6851694178977079, -0.10225464264281008, -0.08502932352835618, 0.062417161275861485, 0.37402164946133765, -0.2611590579300771, -0.05376460584971131, -0.21393364770290876, -0.28739825749635145, 0.13817661428755348, -0.7143412206054194, -0.015873259578542877, -0.20995032462915095, 0.6423397610607908, 0.024879184753683014, 0.027060372395797415, 0.39961906950130177, -0.09997795877118876, -0.5917492626220946, -0.696383109152106, 0.006266092011561927, 0.24872130560557473, 0.5302348144490291, -0.08970226028512066, -0.43714808188006055, -0.5210799936641131, -0.18198063774734438, 0.23378092097705372, -0.4105179151294258, -0.3535631678286748, 0.8420126267949224, 0.019623254694842034, 0.37022449195114426, -0.006177429707070047, 0.023235106937594556, -0.09351001948094274, 0.3152806725326482, 0.13336857070603536, 0.042905142614367876, -0.6561867712291197, -0.2453881292089835, 0.3504084758322785, 0.00487150785873629, 0.6110100020799881, -0.611824837284342},
    {-0.3313723311353435, -0.34092645595803855, 0.21556302037462868, -0.46728638502260006, -0.09928681852600986, 0.305192440255561, 0.45600822398964935, -0.5802531154677218, -0.3268336829455698, -0.4459545066961873, 0.4498679668316968, -0.19963067998106804, -0.8629550561140098, -0.24089491619190218, 0.17443073262934689, -0.28653377684379844, -0.2539470573673599, 0.22412456004731118, -0.06762771815503078, -0.22133723520101162, -0.5064967899263879, 0.3394456862633902, 0.22123524572523348, 0.11892305702899995, 0.2628365392669664, 0.5122505481386079, -0.3331786444450702, -0.27004663802373674, -0.21164759443712375, -0.14917020814828683, -0.21543714072995626, 0.2386401664459166, 0.004547494698196088, 0.4181456560327192, -0.17021482228583815, 0.2627279189897853, -0.23449291282893722, -0.5125882165335167, -0.27555006684075456, -0.15517419557632614, 0.5012346326932999, 0.331571555851327, 0.4310920862099192, -0.30970564889508373, -0.36004247027681385, -0.3549165816546196, 0.10777311789423573, 0.0005117086691179813, 0.29766380978854257, 0.03604031163227254, -0.3903723071395324, 0.09189094295448158, -0.08430659513441631, -0.23116191849204928, 0.0692286304299674, -0.3282446683337998, -0.2585157156071424, -0.4770619299015662, -0.14662152932092806, 0.3557365995491733, 0.1428915752481706, -0.30038751335820657, 0.03603126117638799, -0.09464715469770052},
    {0.47769418870617697, -0.6973905284086362, 0.13838930225961402, 0.27442606069348874, -0.03237317012767553, 0.21576591060510283, 0.6160659465618598, -0.10012575087448976, -0.17352635078187886, 0.020740179176700898, 0.2326212227428884, -0.2582770036894219, 0.23632116376609155, -0.48872731475507164, 0.057823352718370746, 0.2118508793612421, -0.3550771581921789, 0.3863868139830917, -0.02956711108638062, -0.7387456068995395, -0.12506841509204772, -0.4246734055707555, -0.11351277554196691, 0.45429424759384207, -0.7193191553470711, -0.08902878747582332, -0.2868903172176536, -0.3291200475541189, 0.0970151933361995, -0.30502436010670586, -0.19222974527662257, -0.2574774126637404, 0.4556754165310453, -0.3241631391467457, 0.4061608195629321, 0.20718009947131497, -0.1756997866790652, -0.4522622058465469, 0.13201873667992012, -0.7510154822780534, -0.33158821772730684, 0.2952903670987528, 0.09811748913740463, 0.2311326377535739, -0.35979578700164033, -0.5552436055378508, 0.4249456303838198, 0.368533923180511, 0.0006755021849508413, -0.2816364962784242, 0.5851938751199324, -0.23080830663495294, 0.28855209340886656, -0.5297985287416551, 0.391592232651283, -0.17441202273631487, -0.05708137105976895, -0.30815257496357523, -0.09995788185961825, 0.1058073355376792, 0.07114650667277124, -0.08358149157788429, -0.2098375242096013, -0.25759511441443406},
    {-0.46442440889204756, -0.3443882829782134, -0.43337382117698275, -0.04334938935062795, -0.37078419440054866, -0.021520225672575406, -0.3573869893008173, 0.09603836486594328, -0.19423501105779864, -0.517820444045159, 0.6051919751506645, -0.20530686861711803, 0.2750689992310384, 0.10879041197519267, 0.13864658673904742, 0.33380092657043914, -0.3752452672447744, 0.15666027902719534, 0.4810379039393705, 0.019719988976206627, 0.019407513580133366, -0.0743992822035189, -0.18553136105513646, 0.04679733812710717, -0.24666989454528876, 0.057808202650282144, -0.7174313344333605, -0.26308798282846657, 0.5768938187159501, 0.16586245010841652, 0.19513973578437444, -0.09230389188973906, -0.08825588416955217, -0.28090602968177397, -0.7150214591417302, 0.4782295865383098, 0.07252457149110753, -0.5619389079641474, -0.026210236039017096, 0.034461428702946315, -0.04300139060000795, -0.17206655466496568, -0.025505830426093695, 0.5223099556263732, -0.2833768681754558, 0.0638845069083454, 0.4961630702290484, -0.5909932196291604, 0.32480363733544276, 0.09953563696331602, 0.0738068570338008, 0.3771521802577566, 0.40515319088987, -0.6129453315046351, -0.16409612619111572, 0.02670446928721251, 0.4962692037145968, 0.06023203770455183, 0.11271421625101868, -0.25028295541459095, 0.11709205667037544, 0.1470193744316424, 0.33768407151289387, 0.15342491320106574},
    {-0.14654150688235543, 0.1658652974132125, 0.14561176663407832, 0.3779959476006897, 0.058901201768342196, -0.05726973703514076, -0.005486478094963808, 0.10170420303196465, 0.2236212399611067, -0.2971425266822949, 0.337226010924036, 0.025282597038431883, -0.31966219822978786, 0.6499490323534041, -0.1522981000622243, 0.14070537218737503, -0.17808780729478657, -0.5961330783616674, 0.5656653772283737, -0.01412463425085023, -0.2661096267287979, 0.020728344963318598, -0.015304601010559082, 0.17959010857114885, 0.40277740365052095, 0.0014292181815734862, 0.39878861982630853, -0.3192921417585958, 0.33731209241385424, -0.48406643101205254, 0.14593644224522648, 0.16854889481147337, 0.29586055037162207, -0.5606264024605488, -0.419535780262373, 0.1415835428557308, 0.2045473608455102, 0.11613102461546398, -0.7181504183810261, -0.7640522767297537, -0.5046301117669211, 0.3272934734008291, -0.18145075167543662, 0.6312366810960053, -0.022826644277081563, 0.236013870530948, 0.4331663317023648, -0.2057653611925336, 0.03066864769468153, 0.03312999522463284, -0.25795307523551886, 0.4603568851250796, 0.33084128430302856, 0.045536023734054604, -0.10232844331115686, -0.15427110237335973, -0.1352683371674019, 0.261989208461233, -0.04567772409558435, 0.14689363187835794, -0.26115647540660314, 0.21022133367480575, 0.2771464077158394, 0.3227889464239328},
    {0.5070832675160719, -0.06980440370920735, -0.15039709615149494, 0.46749339257162326, -0.06408452348635969, 0.383019840245801, 0.2047821164515572, 0.03292667992666371, -0.007831949894429542, 0.04216763191695043, 0.23230790134001925, -0.38803878655275115, -0.04774121575816451, -0.18340963485799242, -0.288927790519203, -0.08868545933558138, -0.34359024427392354, 0.5022587139211049, 0.24731770255073685, 0.06497047903598338, -0.11577680404925424, 0.6535410188776178, 0.3630716657194266, 0.39453490371103717, 0.4111465888921779, 0.24408823817978098, -0.3860187635363941, -0.26601650581722214, 0.03986990306363895, -0.01188041333662004, -0.29846879137475524, 0.10913935752474753, 0.10858677169144633, -0.21711915151245553, 0.17813764261607684, -0.5558663724312279, -0.5521470331372101, -0.22980672555577408, -0.100547561653747, -0.41138934144707295, -0.2936608325600205, 0.23122864404712654, 0.27949647568166325, -0.052944369230292214, -0.23677587001923678, 0.2093709716007364, 0.43320334951097905, -0.24374458457353174, 0.3173656362603731, -0.43545199740432255, 0.2042701662295799, -0.36063564502334816, 0.08133023894981549, 0.15968129419827495, 0.09510533827372322, -0.31548874222876083, -0.240429109534853, -0.2037498666368573, 0.17827906278268715, 0.14117521367210348, 0.0006274653703821826, 0.07023883371748499, 0.058415427107708646, -0.23808538790180314},
    {-0.09866427745598981, -0.05264533459520777, 0.016422722191408792, -0.05295837604395935, -0.1552819421714026, -0.12372699959945464, 0.1953782770169159, 0.00028870528629958066, -0.41571500644281134, 0.46691715754496305, 0.04875449387396832, -0.07921560785006715, 0.006409520677615601, 0.00478348652297083, -0.2405278459982266, 0.094777514363225, 0.36471977124964405, 0.022347415412149216, -0.1344717923275929, -0.17885827097062706, -0.21392385282749385, -0.11859358208639194, -0.3567970142340181, -0.12944726970292506, -0.23039151712040415, 0.3552225812904986, 0.1599443332626999, -0.0539409538637688, 0.13527038533808097, 0.06208010477474476, 0.48438209653076364, 0.4743305726778626, 0.23150690103494204, -0.01505131624553993, 0.11676729013290259, 0.27981452680531294, -0.3248467105741726, 0.44176163153134473, -0.11848306802766703, 0.2514210069674015, -0.06525548528227584, 0.21066567225269592, 0.15513572563788783, -0.31359682250360454, -0.5722627065711752, 0.2867404602657961, -0.060883801906589, 0.09898115331291832, 0.4122218526139937, 0.5035531119601042, -0.17827114133974203, -0.3506329718250011, -0.0538075567164191, -0.37410531952421333, 0.009455751964716532, -0.3066450975926497, -0.12005406541441735, -0.3641074060076995, 0.661703443600915, -0.33262509074525753, -0.26928816274816114, 0.0027186224847813648, 0.4280997899427153, -0.14479270784858356},
    {0.19671312701020266, -0.3693691183828827, 0.047268052317559345, 0.4149226043120502, -0.2793834167755363, -0.2579908014071119, 0.13555270753876553, -0.11840933577264076, 0.10382123300557203, 0.3233549106997867, 0.21627576105543414, 0.0023073197613877453, 0.06902451771653523, -0.16011331126169587, 0.040795166360272195, -0.07376201800915817, -0.18975480530602015, 0.21551844093579897, -0.5833359340326143, 0.5732682662010316, 0.23858755724306477, 0.4303345497948576, 0.045118046026391426, -0.0628063934769138, -0.10395217820364706, 0.1027752059310655, -0.41081565671529885, -0.18119644772568938, 0.0872983358863348, -0.1312792958056518, 0.279117674255489, 0.05274016844671317, -0.314873187165383, 0.01103974178142014, 0.01600058042253154, -0.2508240788412768, 0.1590613167463915, -0.2211203236685454, -0.3244763527626169, 0.02500485327619137, -0.2631051556716056, 0.18457417648310645, 0.18955287445572946, 0.35133010324597025, -0.12663971614733202, 0.5343202170532863, 0.008300679482068073, 0.20152761678285083, 0.4308526409414873, 0.046982128828144135, 0.05821447022654815, -0.48780139271145995, -0.16944665363639713, -0.0008510407761356681, -0.11624422465011673, 0.3620700615995359, 0.12488274212694611, 0.014285664881474014, -0.2242895887030079, 0.3432592486367737, 0.07401356667104621, -0.003632443887323139, -0.011099247578562097, -0.16721316653328552},
    {-0.9583653965250738, -0.35364300379651104, 0.028461531471626916, -0.5752411631068988, 0.6155021448883568, 0.2628328494581416, 0.23955162696335433, -0.11919536933250088, 0.014953097511706473, 0.4289017775910547, 0.23397696244756164, -0.20648295097219155, 0.29227752487963826, -0.4426018735750907, 0.08589838954686328, -0.22899511785261353, 0.19620443559176554, -0.09353030734897518, 0.008810694672172279, -0.03179247254642194, -0.4763766620318826, 0.01435848524464398, -0.3621583594870825, 0.2291273807934661, -0.14783726165654826, 0.24365077394388218, -0.1413304203440921, -0.6157262601941944, -0.10819527852528198, -0.009835309142604248, -0.5994950037077494, 0.27672031198590386, 0.20688185630483755, 0.12237870546983465, 0.3359729381607866, -0.22374796259566465, -0.21036879223646218, -0.3158435783663815, -0.24522304820610355, 0.08880781646207131, 0.0410081576674675, 0.2025110642116715, 0.4971211129403592, -0.5870717632011335, -0.47302371640412916, -0.7265411285070701, -0.24703170005478764, 0.25750911076606814, 0.2874898156466504, 0.28203107568603913, 0.041136314279038216, -0.029131367024481696, 0.07630016895130197, -0.42295693578600363, 0.27077541753348083, -0.16906233841589186, -0.344058739916973, -0.4636417937254742, 0.2049051232135218, 0.30704936675237027, 0.30698311291762836, 0.38557638715361103, -0.14233456698652172, 0.023153242242859844},
    {-0.005236996698827941, 0.40892301233663086, -0.2851204184551215, 0.06926108208143154, 0.16489942201867, 0.3110217947381488, 0.0954586823120464, -0.5816316093187636, -0.22191350729897455, 0.11777903709211049, 0.22457686044151545, -0.24895554554778407, 0.5775404964985998, -0.5813326877822116, 0.15123135121742823, -0.07043678620452613, 0.20372522852984376, -0.02870947733175982, 0.14620095735376484, 0.027480617387749363, -0.19635424309923064, 0.20993147337154508, -0.7028529747203933, -0.1537587572234618, -0.2756200133002678, -0.0400633724359372, 0.2512228157321776, -0.20994262891142673, -0.008243430376415924, -0.1637581476042512, -0.644945752957955, 0.3744910582198055, 0.14130959570074803, 0.05466548532979434, -0.050256006159848696, 0.17232824266048663, -0.10732096311184172, -0.39495462607172616, -0.24179151968486906, -0.33777719412643165, 0.11064038923537489, 0.1490106887145043, 0.11896906659957297, -0.49337596996287963, 0.0006078057992864651, -0.7029356517807702, 0.009363200673734584, -0.18716499165764666, 0.360994498446992, -0.1855273882356349, 0.0008135892227312191, -0.11158538434239765, 0.14536602867646947, 0.12960428710257343, -0.0871918477305386, -0.4414597452637048, 0.6348169302030225, -0.03923298829978359, 0.18704756828362684, 0.2551138831928311, -0.2135624688288827, 0.0061453375551869405, -0.30202475178835775, -0.45524496518686175},
    {-0.21877822573384553, 0.21778623429317545, -0.10190173374573186, 0.04937802372268995, -0.12376941101929007, 0.5989982531366342, -0.2776238390008023, 0.22070748440249022, -0.07746700532512636, 0.29446798401756075, -0.003076599842697615, 0.043708610457052245, -0.23673285260166305, -0.32506426487809276, -0.32824930499735444, 0.24087046345053353, -0.23733787178452753, -0.6541556711084332, 0.3022686694432392, -0.7192163795438626, -0.00025461400230517657, -0.04526500128981371, 0.24700818434718236, 0.4409597726954172, -0.40370299136111043, 0.0878590737198849, 0.04782342169351682, 0.2991830869879669, -0.2094936889664126, 0.36801516902205844, -0.23334847743028422, 0.5043343194433954, 0.4855239523012128, -0.17637528441004124, 0.24598632223417263, -0.006483138910998293, 0.0059206378585446645, -0.19510731825886313, -0.3178384361262396, -0.3069885104142333, -0.7244997131677642, 0.05819813852361106, 0.2385194518737642, -0.32348789238986225, -0.11544579963800197, -0.1969295674866557, -0.42505709483250187, -0.16483546748142452, -0.11935785007205083, -0.14500761504088563, 0.10768494782122028, 0.05160558311949623, 0.1690146331240375, 0.09487803052993506, 0.23528140457665112, -0.3591235978109886, -0.07386625437955835, 0.2041437673403274, -0.048676197171302664, 0.18642799161520163, -0.16712907428667803, 0.45538464031910064, 0.12534943139459917, 0.44386468641878457},
    {-0.4013108009800133, -0.04558545255042141, -0.3150959789213759, -0.2448244736037876, 0.5189483847077326, 0.1034693315237349, -0.015807499138486867, 0.052652406860138196, -0.1279848419700135, 0.36641949282798186, 0.03315344869005979, 0.034047360193913176, 0.4500384452213432, 0.19185916037352518, -0.19349107308007776, 0.008575188645560476, -0.8477517929909145, 0.04570082857954608, 0.013010630133278252, 0.15220754334575337, -0.3619594649057808, -0.06806041242343608, 0.07759898090469906, 0.1059637482797948, -0.40024936475094347, 0.5087196776626224, -0.20066595784069144, -0.12835068750931666, -0.05065775280389564, -0.007184917530708552, 0.2312419616817223, 0.20043992563978663, -0.1814186744534631, -0.28534350040351375, -0.2522478854151544, -0.03919962537245205, 0.13266580482577947, -0.31281554038946413, -0.4858127823882969, -0.18883733850756834, -0.11267280333489206, -0.2573601817807235, 0.3194149978916229, -0.12343941701225597, -0.021716662278756613, 0.09822252179005214, 0.08949541501692047, -0.13432991733027802, 0.2887686521955339, 0.06077734047660095, -0.047107304304004734, -0.688762876965885, 0.549626507318512, -0.4598268733955767, -0.2233544139308134, -0.1675127219372272, 0.33479728041357587, -0.30582263137104804, 0.058064641259351485, 0.024060015753862456, 0.5086642777892721, -0.13468326893455235, 0.18906179846306598, -0.3784017530099763},
    {-0.31773698500582803, -0.5859808149628752, -0.4232294993624899, -0.2297494433673881, -0.4511185273074855, -0.3525370465853406, -0.006905179967359696, 0.10800157188139739, 0.2631453006002959, 0.10167433498934193, 0.12239430262814144, -0.4923209468732671, 0.21292532634570854, 0.027468146460651554, 0.23759398008767388, 0.6187801676229929, 0.39643446467817206, -0.020007130258606627, -0.18036720562814323, -0.0025079785140944394, 0.0014558480654811334, -0.14195875596944033, -0.3551192051846176, 0.26173588843836965, -0.1174242290454203, 0.2032897212159581, -0.5350655438718082, 0.2495093129701064, 0.2609238192686771, -0.28253614464743004, -0.39125460641133464, -0.051018070669451514, -0.14895459694920601, -0.22592469215177852, -0.3925395811377809, -0.4915773530007722, -0.599818071049288, -0.22827590246819868, -0.29939097769853606, -0.4329624084415404, -0.7091396291818056, -0.15735885050229223, 0.2767110363753505, -0.08316825696321511, -0.042666709895694016, -0.12061249823330761, -0.6579310102670132, -0.6204309992671637, 0.07656987355910949, 0.07162842461867983, -0.041754566797709024, -0.30056231426583657, -0.1988826713034429, -0.46889473934419434, -0.4705523201812318, 0.17281019244675758, 0.19268130270018902, -0.43237408016604306, 0.25164265375349654, 0.1092054866026825, 0.389911010989177, -0.344411067603584, 0.010094640306195918, 0.43696344611906107},
    {-0.06015622677563676, 0.4596135780689096, -0.3297657786654164, -0.5668275271833115, 0.02297192564263586, 0.06385338980529756, 0.3381117876753858, -0.07375124691030782, 0.536786187808549, -0.6283105912183528, -0.07203535554090981, -0.47314219946767766, 0.149379183627751, 0.6773074690637028, 0.04157541215530261, 0.1535840823017978, -0.6097945563165486, 0.03311287224887851, 0.3260518025726422, 0.03204686826869734, 0.031933514368056484, -0.38900468566815627, -0.10606041381823557, -0.004599021099895162, -0.44433621223381, -0.1657934301167963, -0.5107612292171311, 0.0483769180919496, -0.2519073185908309, 0.3068776575677151, -0.011693555464012274, 0.6002979817217071, -0.2360486154035109, -0.21306433352581788, 0.006326770401710487, -0.1597261790651326, -0.07703150541218906, -0.16304822010480102, -0.506524466374602, -0.6315387946117873, -0.3838599509433908, -0.12349085943216147, 0.5619407158145785, -0.44401933539371674, -0.3486506821278959, 0.42622743957387843, 0.34082637731974424, -0.1070507199701565, -0.06104219522203062, -0.37829781025392945, -0.19692992818913752, -0.08893875407034284, 0.04282790498177771, 0.015379813794677245, -0.2141421004236694, 0.3303252144755244, 0.2788358568412722, -0.2296075627687375, -0.05097560488185121, 0.5113221989478106, 0.03200934224540813, -0.7718315835313119, -0.34595845996731833, 0.11441407976310844},
    {0.11721260116888066, 0.24274662481530732, -0.3656457475311455, 0.337119040782001, 0.11993825289533487, -0.2702621199557547, -0.026439352242313526, -0.028060499342694188, -0.41828898257905306, -0.33136998662438666, 0.5918069734881432, 0.11813930443886149, 0.39660165440249606, 0.4348254612860731, -0.2695543706055742, 0.05812126815051217, 0.09937460468959726, -0.015075410285713908, -0.13087647602261396, 0.1441562159922115, 0.3262144953414397, 0.6311329279221172, 0.10411104220760808, 0.22083990939642037, -0.06564738220041276, -0.10770295200787951, 0.12391558726801516, 0.2892216983752175, -0.25499088355603633, -0.1260330977401626, 0.2353908063624491, 0.7057678852313557, 0.23909994751294925, 0.2167801315410252, 0.057774761342869345, -0.173451325111382, -0.39868540836958427, -0.25017062673100904, -0.06338220289674794, -0.4954742769462044, 0.012602280713490989, 0.0037173771641271125, 0.37222914495271797, 0.6300941340657981, -0.18340455056207872, 0.14324723633574774, 0.40771669048867465, 0.09671572399887372, 0.5474309775038888, 0.10137383303392465, -0.3086810044143791, 0.6607347035340803, 0.24536012461589798, -0.0821013300214769, -0.28034538748213567, -0.05684280195841829, -0.13946844634935446, 0.607398745205858, 0.023725005828767992, 0.5701816034619317, -0.1417106432901511, -0.29810728397757813, -0.09657939883636449, 0.15968199440046138},
    {0.1568041440210171, -0.1051865809410682, -0.31829345449704266, 0.4127244324795238, 0.27067091105229046, 0.5790113830808586, -0.5022007645029332, 0.22506605232946056, 0.2803821732858862, 0.6912523339881911, -0.20724163131860612, 0.07847685456480535, -0.5110525597312577, -0.7131432574427616, 0.07105500953064663, 0.2541919810816222, 0.28083356039380636, -0.041113234279715034, 0.006049098786050844, -0.051365552911564166, 0.20342487880599938, 0.11693257204239238, -0.1744547601272579, 0.45286167672665434, -0.1737968700837353, 0.3555954154696472, -0.06050692876264309, -0.2707163277933428, -0.24499813364155743, 0.0030400115774981027, 0.20477538028310246, 0.05154246340406118, -0.12791167024907818, -0.30299375583732396, 0.02867331203923899, -0.4254562079096588, -0.11541054922149926, -0.04590271365166742, 0.21496424981908044, 0.040529709008690365, -0.05524367551703036, 0.06208450679307814, -0.09250530574254041, -0.09731078900674166, 0.09608446589619937, -0.23828682710190296, 0.12122839747401465, 0.002199622572538996, 0.48704961555448706, -0.29358993167990954, 0.2551254946738806, 0.2057443960776646, 0.6247024721516266, -0.4273929677459024, 0.13119738553609359, 0.12076813685644783, 0.3493657490798579, 0.4163183658421555, -0.12210639500724603, -0.010591981106560972, -0.4073909448720523, -0.48571354377000275, 0.36357964103733165, -0.2624554369870674},
    {0.010717512543397973, 0.14284060239683585, -0.17556354810444882, -0.37273722840753104, 0.09322688557985562, 0.0023264203761419787, -0.3023305671131891, -0.05150041692465745, 0.5359286657994444, 0.004226076847874623, 0.13556646302344968, 0.11439085629435032, -0.5177291919900793, -0.15791442092691288, -0.11558548620841141, -0.18567052507545323, 0.12086856386911109, -0.36468406613394583, 0.49460499115561307, -0.09865313532911321, 0.27733828882176687, 0.07439718843102659, 0.007981285821373875, 0.20930541521449375, -0.10579391810824906, -0.39016090832412853, 0.6273838574274777, 0.22093458263727667, 0.15938355445573696, -0.16291276336686158, -0.2639859821675462, -0.027241543691146796, -0.23006026106932043, 0.010005528633507838, -0.05638934830934486, -0.04044165119931909, 0.7086792708609244, 0.13971842652476205, -0.47282807192515786, -0.14121797737103509, -0.04203790971706571, -0.17605544398232484, -0.10613165532529505, -0.36721239352130614, -0.042575478514753864, -0.1356105776580545, -0.11926620176607264, 0.22413163579801446, 0.27337570194792027, 0.020281794333120513, 0.5366149622870537, -0.19369215733553038, 0.17926630164424628, 0.4868095232523725, -0.12883708254945633, 0.10638356908766307, 0.20903627915009024, 0.255117315053407, -0.6038354771202016, 0.717754378583031, -0.5343505619205905, -0.2261714581045578, 0.23707851629200682, 0.5089427736823633},
    {0.0718770073966922, -0.2191353620309597, -0.043660217569772466, -0.5787646865233753, 0.02324150187267652, -0.3623186258721442, 0.29656687249676666, -0.1438797201798139, -0.19906897464852263, 0.12274357927650884, 0.12319621426776618, 0.17982522509766552, -0.1277532813349298, -0.25265747824093077, 0.18839588736776225, -0.13527731393481862, 0.10599339624853223, 0.22981556772566453, -0.2881815836516907, 0.436606158275905, -0.07649814785762035, -0.33495601669269914, 0.22247232126411004, -0.5782802331173592, -0.7016718320450603, -0.18139964204523773, -0.25873582216023006, -0.4089145347813726, -0.3261409771504341, -0.07290951278966831, -0.6858349138495132, 0.45741292037159087, -0.05752434796716047, -0.08170629858301175, 0.5020948630178691, 0.4587651498040048, 0.32020226849788325, -0.3376278871534835, -0.35679371272406324, -0.11448755249197645, -0.20238867991742893, -0.22305437008739154, -0.06583100793109763, -0.17308912214566327, 0.028509290406459994, 0.206835497235554, -0.1890878917344526, -0.15127049821884786, 0.2160784360464403, -0.32582012237678903, 0.04978507898521704, -0.09826209947321551, 0.03315305241553301, 0.19758117404586228, -0.3821956399129975, -0.17161373656102577, -0.25540504312319534, -0.1684027768115661, -0.547975542977001, 0.1585286098238762, 0.34973881789990213, 0.13475250750774212, -0.09547921531310308, 0.3000472570132572},
    {-0.5919681858706235, -0.2688417175011921, -0.11092526626662153, 0.47893224974874227, -0.3418018314237875, 0.5790801179939093, 0.22223641818674775, 0.04758524469389758, 0.2796283053471682, 0.32308726894353756, -0.050394063139993305, -0.0651291356456581, 0.1353992084288802, 0.31486453182395435, 0.4042790232174261, 0.47389799344000993, -0.16196416703666208, 0.1467456176314535, 0.4162120204491507, 0.3818914516751603, -0.25078213831062507, 0.285748078458858, 0.1526205607560029, -0.1037156224419466, 0.014028067669244967, 0.3324096755901354, -0.08845344615860018, -0.06270884112694877, -0.16712509210728066, 0.26065310904973843, 0.2937050648009781, -0.2073298032877254, 0.016551714569303436, 0.06626915024900738, 0.23364227681734046, 0.028994290130390225, 0.36663161536352257, -0.00948539734415295, -0.6470916192566796, -0.17250094477799954, 0.111497666978536, 0.641665154872155, 0.2961461850568902, -0.04006193471463036, -0.242648439940104, 0.3164638364971762, -0.015174003960262668, -0.11854056236298258, 0.15119968281905666, -0.18892842945361385, 0.7641824735171988, -0.1486039469084958, -0.0025460695689550118, 0.2768153041882292, -0.3030973602255837, -0.011789456721726169, 0.4328445888300872, -0.06902565668218404, 0.18471453055080805, -0.3768289005736478, 0.1198540127753473, -0.27462877885745174, -0.2590296197939015, 0.020270864942487494},
    {-0.310239845476246, 0.09406797671904162, -0.3216378032985127, 0.4579343095150173, -0.1723038858167256, 0.13760404481120256, -0.03318971691353124, -0.6131118443136543, -0.49937130917134137, -0.2579132150725686, -0.18510313844168308, 0.5548582729131737, -0.3758894328361062, 0.08052795656982786, 0.20187799842350201, -0.5909003478700787, -0.7968970768298845, -0.023687914273276555, 0.18739325774549553, 0.2355463258689783, -0.15332890245257236, 0.4687623644827119, -0.006837804285471396, 0.15639277967628634, -0.0835720516382142, -0.3353286645992167, 0.3589088993981915, -0.3376564055009252, 0.36592978312514124, -0.1392135720913074, -0.28693415213548096, 0.2064375490868207, 0.7202652517682347, 0.09207051595628737, 0.5756477609677486, -0.20872653717626571, 0.09100434101715327, -0.19486795629741285, 0.05784622527571215, -0.4439357371883044, -0.2275946178403973, -0.051430888352002074, 0.09248793753916121, -0.28606336636292645, 0.19320746161182228, 0.2455905287514773, 0.5300638357596632, 0.058753201470044945, 0.2800892205457564, -0.03203640823076553, 0.15348708153340884, -0.19312523536900142, -0.34258446494666844, -0.19746723915618875, 0.28684956399145595, 0.23802262469903518, -0.27468982972610734, 0.12932992270274563, 0.09564576908274514, -0.4270637566833649, 0.3738656147695067, 0.044185737151809096, 0.23105088657705622, -0.44681005129768553},
    {-0.6240370760194611, 0.08384035528316905, 0.07647687507365165, -0.15831227160599726, -0.18303162295181763, 0.5966626248923279, 0.18318268084148057, -0.3783756584797373, -0.2095952984145541, -0.3300502127846704, -0.2504030480189217, 0.42912353998816083, -0.2983471829628445, 0.28889988017649765, 0.2971781065126229, 0.24775277649713454, -0.24357894516761452, -0.019703143315943597, 0.18846054806741755, 0.15255553035297023, 0.47575166389633516, 0.006546939037586497, 0.2450257593714174, 0.6671119484677238, -0.5094731652960944, 0.01800169191619013, 0.5356692178951552, 0.02767034260982757, 0.13162738862345294, -0.15044223556284694, 0.3927180171490157, -0.3848810538575581, -0.22376983596285382, -0.1497848727873277, -0.3204423353369244, 0.09476783615542538, 0.6355743037286681, -0.06927816481055549, -0.31845232033548787, -0.24834319850006611, -0.539377788213652, -0.16913138394993465, 0.07438396023022308, -0.369967344126057, -0.18592593980466485, -0.018000872326188768, -0.13248933496137916, 0.2920519623034024, 0.2767971413107503, -0.539205270961663, -0.25501640223140615, 0.23822055617508833, 0.06476655283186766, -0.2802151270215177, -0.030279258607593243, 0.23326228369247354, 0.34282190696498466, 0.030446788311709622, -0.5118197632964295, 0.13517016526890574, -0.34364721456478203, -0.05879102926705874, -0.39623222134381403, 0.2199991599547216},
    {-0.1562010663929148, 0.29822413613610216, 0.019921873518676195, 0.08644530401501517, 0.4933688830198284, -0.04360494094546109, -0.06566166673473882, -0.2288478962817677, 0.019831046447170843, 0.14423008874293133, -0.03815516987565203, 0.41662008953374563, -0.5395104438103648, -0.22400560301011951, -0.028880499566970187, -0.2351867812525399, 0.15403158655390034, 0.07629682553172329, 0.3311545573316789, -0.3470270694695344, 0.8010443846563942, 0.20879352291380285, 0.4038377867602458, 0.36424209818911496, -0.022110216526818924, 0.3999425490407005, -0.19703548522156972, 0.09043202672266189, 0.27643730324946963, 0.05091783383262851, -0.04881792350922473, 0.23213384240238613, 0.08019874060144801, -0.020065046741946063, -0.10090166790196178, 0.25612740530146116, -0.1551381752145138, -0.22644184517848373, -0.1641909767069241, -0.4729389881346246, -0.5395782668479943, 0.6214581292951294, 0.44005592539694305, -0.14656456564422127, 0.021285044777727084, 0.33130586659915656, 0.019964576537443487, 0.18764016117682608, 0.44045241599946766, 0.514745376271599, 0.43176909300636757, -0.12054651000276692, 0.41165043487480873, 0.21447907721718903, 0.6293035181290614, -0.6172549822459931, -0.011629034907333618, -0.07837853362999828, -0.0835352856381918, 0.10319694942502745, 0.2442268456371705, -0.07315863579272174, 0.3044930045966637, 0.03668480212641713},
    {0.14267247343037148, 0.6005895954107401, -0.003951233265895687, 0.5662872713535912, 0.38419161913312644, 0.5891028230431344, -0.1177292225679599, 0.02679554492592273, 0.2858428302226227, 0.054792537956377924, -0.01814033870526725, -0.2639183363199674, -0.13621679196266973, 0.27233317830247145, 0.0691139825948717, -0.1395473320663514, -0.2130154627041902, -0.309453531449812, -0.12204482285054363, -0.16761978150217116, -0.03711241918766663, 0.047777585367951084, 0.033852940398421155, -0.40016684512823386, -0.06377067189835035, 0.14872357106857484, 0.2333833248447149, -0.27388624000308864, 0.1808423187308406, -0.027989054218058196, 0.0067679935667801635, -0.4567306087537601, 0.0756942096779385, 0.3215017789517256, 0.28737452549792075, 0.14401863460089098, -0.5462947967043723, 0.1265312361524586, -0.39770740259245063, -0.3985216519144263, -0.2635245005800879, 0.19091339813142072, -0.0033718370473844366, 0.30857348991359573, -0.1401486400148931, -0.43867538780338317, 0.38035667818212426, -0.2629038970375439, 0.21261414745733503, 0.09898037970029103, -0.22712710635797945, -0.15152845145331736, 0.10005554601316764, 0.16697445639535297, -0.18968627601702145, -0.19399429601965185, -0.26790352952116664, 0.19440750902047713, -0.29755676172288104, 0.1214186257613629, 0.37681972793520074, 0.397572192932239, -0.2696129108126656, 0.07919223585414688}
};

static const float b1[64] = {0.8491068147542106, 0.8555458453786705, 0.8287443093281822, 0.7693895036606461, 0.737995793696357, 0.7735273915748747, 0.8147222396339984, 0.7690395751583458, 0.6927804120358813, 0.7778193033052166, 0.750179154877516, 0.818842197004508, 0.868326043005442, 0.827158036700667, 0.7418004746984052, 0.774297545352285, 0.8544070883592901, 0.7520352928440704, 0.7918434056843099, 0.8288372843797679, 0.8218430316003082, 0.8641869914950867, 0.8170351379258015, 0.7753421107283547, 0.7491641478440622, 0.8250440565522851, 0.8177702071132247, 0.8195214372356702, 0.8446554883154431, 0.680760241802508, 0.7194016159475686, 0.824209045004259, 0.7860131326055676, 0.8527949720463823, 0.7959597636518857, 0.8626169091048849, 0.7862311412944463, 0.7533387125750041, 0.8283713974803434, 0.8177244001215207, 0.7813066473691114, 0.8236662647121219, 0.817381454621529, 0.7657898659110742, 0.7406837868269663, 0.8860481111574581, 0.8308755777007835, 0.8200895295366006, 0.7948415952298228, 0.760554390741949, 0.7598051728136614, 0.7913517959497853, 0.799231380136677, 0.7847415978204406, 0.8286777122663305, 0.7922570476741817, 0.8278696264690313, 0.7646163676753869, 0.875101077211407, 0.8070534777346567, 0.7404450654666783, 0.8066884210824362, 0.8083949387181559, 0.5915903574644062};

static const float w2[64][32] = {
    {0.5662849258612417, 0.4899777865334795, 0.48990691125052926, 0.5589366064315089, 0.6987988116075908, 1.067704643327729, 0.9829544082616356, 0.5938977276712424, 0.4888341575822726, 0.6269878252479744, 0.5207389563162066, 0.6876249233070552, 0.6573706775841166, 0.6827144929594353, 0.36724139391530325, 0.7594596535368244, 1.1241840673159014, 0.13328253532463602, 0.7598950365000076, 0.3883599999040196, 0.8515960293410013, 0.5557874336712083, 0.7057820866068456, -0.32211333087632943, 0.6881221336461116, 0.8943911286450316, 0.7491110191307729, 0.043085369850272434, 0.4650975017173066, 0.8900271463133921, 0.8650507428413547, 0.85166836281327},
    {0.7352528582607553, 0.3182974961307162, 0.7086423472323852, 1.0001603237725307, 0.7916545799871672, 0.6711479231693686, 1.087824305269889, 0.9511712391653234, 0.7689760820465045, 0.9433128452118485, 0.6392386415854934, 0.967722242769426, 0.4859083333015625, 0.5367934672857514, 0.3797768588099633, 0.6768635200824633, 0.8086845540957099, 0.6758069303468182, 0.7874600600096853, 0.7167853749630568, 0.7556939664852924, 0.7413653400759467, 0.6508144320810054, -0.15503210749301893, 0.6779261400808478, 0.8692208143877772, 0.8078352613998954, -0.09727585547833041, 0.6389703691239036, 0.5722004359950029, 0.6784788658982989, 0.8307560606296434},
    {0.7525919096070421, 0.5475093228259036, 0.46651891176130095, 0.6400615671817395, 0.6688677574980638, 0.7131059670230326, 0.9901597913849718, 0.6958459560467576, 0.5604160768711288, 0.735520753074655, 0.45809480400990416, 0.9827339799723127, 0.5730517544043883, 0.8860742266808274, 0.9524693461152077, 0.6657310558390963, 0.9239583749016825, 0.10291450097533254, 0.8360651866269776, 0.71992885866341, 0.8831482908397025, 0.8863622678872719, 0.6494559559362961, -0.37392274217701177, 0.5269414307423491, 0.7770747540138745, 0.5601534697321643, -0.3979410928221548, 0.7834954055574432, 0.5726936473398689, 0.5311725890388816, 0.6906949495472658},
    {0.9906629542167096, 0.5967406814236118, 0.7113311218804451, 0.42733945880358526, 0.531602181818878, 0.8678813423022027, 0.49327533027712156, 0.837873747920798, 0.7500771015328617, 0.9783207700699272, 0.9449904828179531, 0.7110977050077767, 0.7560353276162701, 0.8968764547866326, 0.648042880488835, 0.6201041964371891, 0.7316916451479786, 0.37988485703060154, 0.6413269619490486, 0.6233567178512915, 1.0728162086432136, 0.6799831615962387, 0.7593995531019694, 0.1470524987030618, 0.7029970799227003, 0.5725049297727024, 1.0395251098477154, -0.22764017255109453, 0.805288719067649, 0.7915065603236839, 0.753012585260065, 0.9660108550176214},
    {1.1167340934739058, 0.4267537100312434, 1.0678114243046037, 0.6636880533294977, 0.48101654144568073, 0.9629622021137083, 0.786399619433074, 0.9541597527024066, 0.7959416573903619, 0.8056786030058847, 0.8470747550814665, 0.6435800955755242, 0.6228411211155095, 0.6508035280707016, 0.5946990488470197, 0.816272346700483, 0.6630638935310185, 0.4113010708043061, 0.8366070371171075, 0.8285755216915802, 0.7390869549992151, 0.6476845008958365, 0.5448697639975327, 0.32230340042857236, 0.6251532870378858, 0.8321511401267038, 0.6470195410889484, 0.08432693204820237, 0.693281362716272, 0.30683077382023566, 0.5165445099461303, 0.6540243222336056},
    {0.6165309565308758, 0.49791148792265366, 0.9008485955436372, 0.5014210068916919, 0.7056255127987221, 0.7602533883340964, 0.8096327326787401, 0.8482723390727841, 0.9652571215664122, 0.5994008305951432, 0.6452362926751775, 0.7418440284045157, 0.5642886904285754, 0.8341054534398514, 0.5886850239912998, 0.6830653498541635, 0.5241991710965025, 0.2131055268149578, 0.9275491729988622, 0.47981075447436505, 0.5591845881726499, 0.8920828103236933, 0.8099337205018432, -0.3368708307163088, 0.5979199731544147, 0.5763450763936371, 0.8236806158440829, 0.13535948145500154, 0.5241035387128683, 0.5302632335544123, 0.7058800534065347, 0.9039572014810839},
    {0.476541292229874, 0.4877271762464978, 0.6591798916765178, 0.9129659977247557, 0.7285152246513154, 0.7979114323044811, 0.5699808899400087, 0.839482261330921, 0.40400379642772744, 0.8890501653138775, 0.6478307883363612, 0.7847948466072086, 0.854325597101591, 0.6792101369438096, 0.28469398418473607, 0.47387540892687124, 0.6621104334081385, 0.2348739035595064, 0.8178458789525592, 0.09593458054295281, 0.9255918412881703, 0.8892477984794687, 0.8580959012602118, 0.24847499808191856, 0.6954893404201762, 0.8587000562962086, 0.5112457599282679, -0.10806407760979132, 0.3337739170612073, 0.4106156914041991, 0.34903162554492145, 0.6187916580306739},
    {0.585524974672538, 0.674196734422737, 0.6529140762604878, 0.9740007225311401, 0.609521037632821, 0.8617079190041323, 0.7004593273877495, 0.8667490310763294, 0.47323401929772446, 0.8552172753359535, 0.7705984360565625, 0.8900437890229264, 0.888608720850991, 0.6499814938252207, 0.6452979737332657, 0.8528466347174285, 0.6515314323926964, 0.5713120623914889, 0.7777739876537509, 0.5904606573652488, 0.6480759091824085, 0.7875646449869045, 0.5889795747883639, 0.25191212008340214, 0.9069537789277573, 0.47097106237577663, 0.6558548013321337, -0.2078410931552041, 0.9204992557299784, 0.8407572549759145, 0.6818222044046469, 0.5972590313571068},
    {0.5778276590008522, 0.689097089356177, 0.9035226135097654, 0.6119231910674015, 0.37533466400267085, 0.8000151644317824, 0.07907500709043154, 0.8447727223195697, 0.6423008049874558, 0.8038154476862884, 0.8072868357973552, 0.7810932083567891, 0.688404274813143, 0.6495776929979674, 0.5822601446328908, 0.7167178401730606, 0.9400994143498642, 0.6757817583629481, 0.7655759673033076, 0.7422985326278685, 0.8033181199176511, 0.6468601615997449, 0.5144639829780296, -0.20557133118676532, 0.7312572112844388, 0.6094027171109491, 0.9176537985601819, -0.18624714663060513, 0.5289689033443031, 0.7599637062822712, 0.26806507639009813, 0.8743623725041928},
    {0.4792338198057087, 0.5005366037249506, 1.0752138072542892, 0.47844626652725064, 0.3779402696271934, 0.698230378660869, 0.51551589413416, 0.693383056208111, 0.6946190329852142, 0.8087702557653824, 0.9105108490700439, 0.7202709400132443, 0.5397150458764595, 0.8142758712216757, 0.6444491685534827, 0.6978009671558673, 0.826948279117629, 0.10162427429752485, 0.975393351868996, 0.4959337634510666, 0.5095703566849475, 0.8808318477091042, 0.8852341008679377, -0.325672144714803, 0.8145675551881376, 0.7443719095071686, 0.7351298900731421, -0.023958325643678093, 0.5972840684593314, 0.42942321196270095, 0.5206421203091961, 0.5723348375352043},
    {0.8125127703948763, 0.5325268588218952, 0.388520921212565, 0.47190365494248426, 0.5999574038306003, 0.6133381741677661, 0.4857261878055696, 0.5537222515765876, 0.49861490971886663, 0.6458085823730284, 0.5903341154513378, 1.0244246022476946, 0.7705574666580293, 0.832388732884116, 0.7450565811652741, 0.7454997919011722, 0.6957391736366731, 0.3648324867893347, 0.5160509256092011, 0.4550636965541953, 1.0334168693773649, 0.4106112148506037, 0.6531316942300563, -0.03217277879517454, 0.7225476811345503, 0.7672430306650944, 0.9328516334783291, -0.009592553209744172, 0.6940740753136359, 0.7976042300472642, 0.36458699379483017, 0.6069101373103702},
    {0.7705019892778654, 0.6945454485628069, 0.7251956525457806, 0.7866934973269277, 0.5439410968053673, 0.5948389827107425, 0.8972063113080605, 0.6244866900380357, 0.6077839967387686, 0.4631949394034402, 0.8442360814180979, 0.7587011163977248, 0.7978704123165246, 0.6322198939976038, 0.3806961051000071, 0.9040410850740395, 0.7158601725466363, 0.3470647835275693, 0.3146523606037406, 0.6977009215837325, 0.6072596809753574, 0.6418332689233562, 0.46588580397069074, 0.1429487401066309, 0.5653769648717774, 1.0360613755063979, 0.8251262825150112, -0.0648066085921015, 0.9109058043929574, 0.4429481825301832, 0.3273162284198432, 0.5005035884729333},
    {0.665442290042802, 0.7414934743729407, 0.7176961333962945, 0.8582940317751138, 0.5460968073068191, 0.9760152596664019, 0.5328750817916372, 0.5654663152362339, 0.27581893503825794, 0.7227317590487211, 0.6513648356719706, 1.0241124649300741, 0.9922979231445802, 0.7589995316134179, 0.5971253896829027, 0.9416498387931294, 1.0935863169802413, 0.04011746200147145, 0.6156339677033511, 0.9597853032790427, 0.7802077880473871, 1.188955018703385, 1.0586912000830195, -0.033214223575763646, 0.6680532703961516, 0.6649648863744473, 0.7640991179169633, -0.16680908695015492, 1.0030142531116022, 0.7910270333141847, 0.6477977323455637, 1.134387517734723},
    {0.836944951854563, 0.780493813364735, 0.741712702020708, 0.689602025127995, 0.7744577862636045, 0.7881071215780414, 0.5281381965765839, 0.7174912642166125, 0.6899551742767153, 0.7915082909736101, 0.6515368353100051, 0.8295000797169815, 0.6842299144004009, 0.7123984042338444, 0.6476308448998893, 0.7756846733289935, 1.1097176326769385, 0.25686949583411645, 0.746834025056933, 0.5583345497618947, 0.6999637815070756, 0.6434621796007848, 0.362482516176202, -0.2722486506054709, 0.6570971032899714, 0.7882794223403955, 0.7220190036100872, 0.06220161469257235, 0.6715468609232128, 0.5663217128534297, 0.65969639361964, 0.5390193566553615},
    {0.8722117133295407, 0.5095406019772677, 0.9689806347195998, 1.0306608779892912, 0.4020032467753478, 0.48895402837416096, 0.7358756739889286, 0.6849173994301812, 0.6679539308063027, 0.9002767133361818, 0.8866478291521611, 0.7469739825380275, 0.7233181307865322, 0.48727182987378603, 0.5469026995780586, 0.7537847701520514, 0.29258776316168394, 0.5096120305654658, 0.7644855435208004, 0.6305174506632255, 1.0002686534698617, 0.7360664944312815, 0.8034295812171155, -0.21746412750118252, 0.672950801055919, 0.7034872383999263, 0.5894990490357345, 0.18106734918769202, 0.6983738093397032, 0.9824275545372777, 0.7788902838882263, 0.9275423803649516},
    {0.7762712577548454, 0.7518761160820813, 0.861421946537594, 0.8664503226025098, 1.0524937068864664, 0.5600034412449285, 0.47455926508314517, 1.071428971232463, 0.6841371447482663, 0.7083768961793373, 0.5228449526882935, 0.9338117563912578, 0.6903614314162159, 0.7197437615349359, 0.7105029297903698, 1.0853132908360084, 0.3170305029255275, 0.37754915438509257, 0.8978685817311869, 0.5867453315927632, 0.9357764985904998, 0.6080987389110003, 0.7708490318081959, -0.09871970336795306, 0.9256747608483192, 0.582873305444295, 0.8388918963089792, -0.26982067983710234, 0.7792405967988156, 0.7387925181431452, 0.7159480407831378, 0.7544905057022832},
    {0.7116391817553006, 0.556495282236402, 0.5662577542079245, 0.5255598925426492, 0.6203855587209292, 0.5930332626485976, 0.9241455964982935, 0.8650456170795003, 0.42914253611619924, 0.7750097113570662, 0.572127858345486, 1.0630068854329568, 1.0936409275981145, 0.8048397130524562, 0.5064657811239359, 0.5890555541707456, 0.8019033183741797, 0.1795985968674745, 0.530475589083612, 0.7144250554758964, 0.9039094949776815, 0.7797445094595409, 0.53113727418262, -0.012295607290887205, 0.6137496262380531, 0.3294172318530899, 0.7157123141343638, -0.1483054233854998, 0.6624389403068603, 0.6392072750905826, 0.6572087187532706, 0.6525644092760574},
    {0.6128825544056, 0.3697285541767731, 0.6252742924884453, 1.0285196763334736, 0.6711801620852105, 0.534242411841911, 0.8204917758842661, 0.6102730015187907, 1.110200107798805, 0.823675965838621, 0.9124846177686912, 0.8346426509475129, 0.43669394067543055, 0.7764759065627291, 0.7892022403094348, 0.9677750207362529, 0.7640074663940639, 0.5093457749107391, 0.8089774193945306, 0.5420574540528327, 0.9030479389507714, 0.6950232957639512, 0.4100047897590953, -0.04604299241087345, 0.678348654025402, 0.9239877056137693, 1.0099559172439057, 0.25357612958788095, 0.6655753671965733, 0.6603631313998245, 0.8163763815368736, 0.8255478167014542},
    {0.3765529362087426, 0.5180233089996256, 0.5064000029788172, 0.677527935023466, 0.808667164862098, 0.5525519598416321, 0.5552873657856933, 0.5450193020074451, 0.9535856011137985, 0.8135603058214426, 0.7215203748541138, 0.6721415206247846, 0.87312082215657, 0.6588488289569109, 0.630071758021849, 0.5996690299633809, 0.32334986699435736, 0.35833445922343776, 0.7209974547160192, 0.418002921006143, 0.820474802443977, 0.9397758856258148, 0.5962265294535526, -0.10012775221285555, 0.6066318517079057, 1.0194894220031523, 0.9222225003498642, 0.044803031220815165, 0.37510284812955386, 0.6021074394480116, 0.8007497507830993, 0.8162055438110042},
    {0.8752063090357854, 0.3945928514139484, 0.44398427297006515, 0.7628884944816435, 0.4806387066734581, 0.7872198576801301, 0.6214099724544431, 0.888255093884983, 0.9881363554226994, 1.0520554412977465, 0.3149406195406439, 0.6847790379103664, 0.41778822609731076, 0.7638379004524615, 0.7202939449099702, 0.5269652019073651, 0.8572609545440658, 0.29660298374586724, 0.502546480918146, 0.6918934612314466, 0.6970822367423887, 0.969799371506985, 0.4881969069091254, 0.09774543829839473, 0.7834666699197037, 0.9128673180289357, 0.5076407375855974, -0.015244254866852778, 0.6780765661125062, 0.5835767972073003, 0.7243081925298037, 0.9330428848638476},
    {0.9441836051409661, 0.48006821324913784, 0.781606171887, 0.7237145831957306, 0.45755710379637726, 0.7898795455846656, 0.4785419682488588, 1.1094954034040987, 0.7448634383959896, 0.555715901087967, 0.7906740060096753, 0.37634436565127466, 0.7302300634668555, 0.781003961120111, 0.13339953563352086, 0.7827512976877548, 0.6173382014694236, 0.33350092670477083, 0.4446318491460335, 0.4019669894825812, 0.5060473878709031, 0.6337710794407576, 0.5824540360872852, -0.019641227292770253, 0.8317809879467561, 0.850422844498397, 0.9144206978479074, -0.19165796111466604, 0.9204373859912636, 0.9603029632460652, 0.8091405443446301, 0.830218845494523},
    {0.6223139408973726, 0.8309532771479987, 0.8250442300190214, 0.15348565690370125, 0.5465861603809047, 0.8311726685950077, 0.7179259379624692, 0.9573395679348563, 0.545234690054158, 1.333406282433255, 0.5631238095814664, 0.9675256369976563, 0.9155347385751083, 0.7499145213800338, 0.6399778303013666, 0.8039754316994321, 0.9941024312485451, 0.21391202434429107, 0.6103337117027599, 0.4272105395962305, 0.9238879426567598, 0.7601679864203934, 0.9277094846657269, -0.13600497942755638, 0.3399213832613844, 0.815865112417605, 0.3678869695148519, -0.1449056026328065, 0.8001714442191294, 0.7179483327308326, 0.42189427558993237, 0.6930582948389222},
    {0.5388213645784127, 0.6351341309297223, 0.9188049718907135, 0.6242551423454505, 0.5668526340726331, 0.7506641637436757, 0.745535214358837, 0.9220630905380724, 0.8366640988681235, 0.8329981241333098, 0.6456338955616266, 0.9456490115210114, 0.5824936386890017, 0.9736130360355605, 0.3597059565348859, 0.8319592137754287, 0.6774830380966806, 0.40164846910524526, 0.8664964956957139, 0.5572353607149647, 0.8164350990301706, 0.8207584793385817, 0.8629693214974565, -0.06748314325016296, 0.559959760826055, 0.6568662426614341, 0.6627498139095371, -0.05658445791373875, 0.9810813008747097, 0.6707770311350295, 0.6779927136639297, 0.9026552122787176},
    {0.7882704399404742, 0.5857001729119643, 0.9021090501626639, 1.0024620606687433, 0.3533566413700127, 0.8104323934198785, 0.8352954664609346, 0.6334184139903499, 0.5338969243528752, 0.5499666340652772, 0.5864678199103388, 0.6644088258371439, 0.7322002559645837, 0.3814901422343414, 0.7753073827624513, 0.7287196009356635, 0.564144482041257, 0.290497317676486, 0.7552333783310214, 0.9480387857847689, 0.9852751903882909, 0.9661298987825425, 0.7480637789292045, 0.14682388159943055, 0.7387391826753317, 0.7649923709931448, 1.0622975968817696, 0.005059477327462613, 0.4327429665228341, 0.6073642210923997, 1.0851675240530188, 0.9781243441578594},
    {0.7527516301579235, 0.4533563362538283, 0.6102816314428138, 0.6700060356161979, 0.5340875480287782, 0.673984849052537, 0.6639523987790055, 0.9448071923398946, 0.6964300264879649, 0.9521512182756549, 0.2280422817967238, 0.4928606807653602, 0.5689155458063365, 0.5613618390967475, 0.4090051044600695, 1.1385843669612021, 0.805537887725279, 0.19312193241992215, 0.6461210339937868, 0.5341072202208385, 0.9122144226849798, 0.5666122497293282, 0.6856338258287451, 0.14233877535144965, 0.46234872946687755, 0.7818697585269933, 0.6542547119546299, 0.012350805744409712, 0.6416575534085563, 0.8244275016412573, 0.7736963708002432, 0.8982255564553382},
    {0.8781212400582221, 0.7287236112250172, 0.5381239428102729, 0.7665487014271448, 0.544360896416672, 0.5729246034635664, 0.9504773718292425, 0.882255537478501, 1.1531549734843354, 0.6312197284358474, 0.9440936911246609, 0.8671757003848289, 0.8037921133809949, 0.3768631313185332, 0.5589156542241732, 0.6328982345695813, 0.8981633058560664, -0.009019341733011148, 0.33732684708351424, 0.5338310182510335, 0.9092917630350922, 0.7549963672180801, 0.3493833512832676, -0.07253293014643508, 0.6051241088223197, 0.6809708721175789, 0.4350643648797964, -0.15854889770926636, 0.8172328423881167, 0.7429548769422107, 0.5412290230766129, 0.6527155543605935},
    {0.8873624840608321, 0.8092990543853946, 1.1079282684784928, 0.5705297067187721, 0.7190732280527952, 0.6718815668429085, 0.5939179800976162, 0.828889881136533, 0.8409525672669048, 0.8151914548997711, 0.6785254959853385, 0.561205594048946, 0.6755663964327062, 0.7985024768713751, 0.7020814825943352, 0.5669508978794898, 0.8157699328784382, 0.21047065389540298, 0.46927447711388454, 0.5893200213024676, 0.9715628767356691, 0.6726991337441025, 0.5885962995690764, -0.3171171955413399, 0.4629393819569277, 0.926476875282103, 0.8276049104049614, 0.07884890237263233, 0.7033791482256666, 0.564439492479914, 0.3635128518638788, 0.7200803309600389},
    {0.847723599350248, 0.7253499453532383, 0.6611905871807434, 1.1300866422361984, 0.47529502683517993, 0.9702982230903029, 0.7983916211874116, 0.7675690064783345, 0.6547519806123303, 0.9191920009729896, 0.5006608987088927, 0.5706421348120411, 0.6546739371062223, 0.5082406283731846, 0.5726840270218116, 0.3952814880844367, 0.5138540921292079, 0.5896116055903886, 0.9015433855914669, 0.7341698557329733, 0.636308472824046, 1.080656448238981, 0.4217587955051257, -0.23424562211461497, 1.1003599486451074, 0.4567710221246474, 0.6161209125411509, 0.04198799138642018, 0.9440146267506662, 0.7469258239602625, 0.45073338750187747, 0.5672348403227081},
    {0.6989574908622183, 0.6044066457838861, 0.5046834350667824, 0.554372141673357, 0.5584273841429239, 0.5761956181232409, 0.9582343768279792, 0.6334070953086565, 0.9517112284996024, 0.6362365637069595, 0.4880879178448856, 1.320059647183394, 0.8587649882273525, 0.814271638221954, 0.5428228792844817, 0.8999409928445716, 0.9639192339525828, 0.38513492374399316, 0.5352167890693766, 0.5305581461627848, 0.644366582092352, 0.708507231310624, 0.9364639266139183, 0.10118768675082278, 0.33964304760840053, 0.9057764598634388, 0.24460211436600726, 0.013349310466825063, 0.8207387091149567, 0.6521206124803393, 1.0681570172597235, 0.2827086312172674},
    {0.5661023416587361, 0.611685576670178, 0.5816018190463044, 0.5132026162676333, 0.6211843242502761, 0.7764975136289889, 1.0324087363753358, 0.6003761978306904, 0.45239690337425914, 0.8218510496283988, 0.6347503191803814, 0.7117281694249056, 0.7596310833289402, 0.7084752092327518, 0.447430876864627, 0.8296649724893655, 0.5359032133772859, 0.20356003135544024, 1.0935169342906246, 0.474267171943595, 0.5686209140379067, 0.5074767589891832, 0.3615589177106958, 0.45784526054599706, 0.46129964656873146, 0.8004133982933234, 0.8113390834673384, 0.02147065621206222, 0.647609807539467, 0.6169789629563058, 0.42345812541233463, 0.6659462065799133},
    {0.8483628818264941, 0.8187285309016685, 0.7494398620171698, 0.99079095009563, 0.6223150905186247, 0.9725416745537855, 0.6157083008005786, 1.0599899961947692, 0.5002202037542719, 1.0332565203338466, 0.8914654901192958, 0.39040113554938266, 0.5762812181338398, 0.8059110252782095, 0.8521433231380805, 0.8520001701418808, 0.8382784356131598, 0.5451877560270778, 0.6198872005884694, 0.6356572815990785, 0.8578031528112198, 0.3540476670894985, 0.626484189886779, 0.09407726649245586, 0.9012751021970956, 0.8666067623949882, 0.9253374407419118, -0.0134297880284975, 0.8641757027991097, 0.4293099925599452, 0.9794066402931472, 0.6297290154139413},
    {0.9253002596283874, 0.6344852820042173, 0.7979004185635261, 0.6646032362129437, 0.6730164641757036, 0.6153085646600712, 0.5649398782205889, 0.6035340853878948, 0.7369397114229925, 0.9613667999441746, 0.9792556412439818, 0.985964282582084, 0.6543424509500171, 0.7936143074686232, 0.6631367203697662, 0.27112441147729205, 0.8078298955927115, 0.5816160423607635, 0.48347049657102104, 0.5829190789976815, 1.0595238742942537, 0.9572332465894076, 0.698301170002075, -0.08525987910460238, 0.6836143315775373, 0.7985946048617447, 0.8874303075865924, -0.01342686404747929, 1.0120342906978061, 0.6412565581467783, 0.5787430712200368, 0.4069623417764569},
    {1.1276570169006936, 0.6617222661750605, 0.6370100819811365, 0.7098629917180713, 0.9644915791941951, 1.1123584921173355, 0.9250818843633206, 1.0452524347629493, 0.9449175657311188, 0.612607717538945, 0.706790092011504, 0.9899096640428763, 0.8781346539880099, 0.7176985907782192, 0.6877313620095027, 0.9296710857292915, 0.7554736720105932, 0.42403196626936224, 0.7558121812896944, 0.4119968216216281, 0.7007265047585924, 0.8607043875789657, 0.6825951825187453, 0.1549408878269296, 0.514457870607586, 0.721242950353215, 0.7465442674561672, -0.0971620917068975, 0.5432350350348063, 0.5299531988925263, 0.5720478108771493, 0.5613639581093429},
    {0.6023220600591094, 0.6113670324058041, 0.7268155199898888, 0.6050072201245513, 0.631121632394109, 1.0565099048227635, 0.8475514681655679, 0.8102658820651835, 0.654879410570464, 0.7954334739188762, 0.6974963324538489, 0.6975433496971729, 0.8457299404422712, 0.5555952794772137, 0.6446170938726693, 0.6103306283326069, 0.9161831064106943, 0.651553311373026, 0.6361397340058136, 0.719826874264548, 0.7976995159538376, 0.9455201895307074, 0.7830222877393087, -0.13438454394301722, 0.7615482318328909, 0.7930271693903654, 0.5003986469725227, 0.05212353721092279, 0.6686274076195308, 0.6900882835953983, 0.39223815453726535, 0.9125543552745299},
    {0.8579589471138073, 0.2123071351507632, 0.5137236765037853, 0.5931785095978395, 0.7550371250790329, 0.6886080633508942, 1.212782758773108, 0.9026994009904065, 0.6031760614733843, 0.6374880675844372, 0.44589416519924857, 0.6912851319740101, 0.8924664254241976, 0.4844353063926705, 0.6671085031633907, 0.6090975469891228, 0.6629111813968147, 0.2267408212719611, 0.5423653017241564, 0.6472118483222128, 0.5343026314630035, 0.6867050402090344, 0.6233982720458684, 0.041256083336654786, 0.854279787581052, 0.8174018571651228, 0.6463045428536346, -0.019718793344756503, 0.557543556672616, 0.5227341128500169, 0.6986314322309631, 0.43302129413894996},
    {0.8417743915411598, 0.6970452543531512, 0.826155666994304, 1.0952098772427477, 0.9370194887104636, 1.1144862385801602, 0.8046800233108962, 0.9604896723880892, 0.6167569426954067, 0.7276010674211802, 0.8021476848028103, 0.8634076911525813, 0.8578515792089899, 0.5254109754648983, 0.3398177056547405, 0.5911388118899136, 0.7333525684999944, 0.20179743009702572, 0.6128432792342153, 0.7302709974437676, 0.7771284783601143, 0.6538853152491366, 0.2511779305992332, -0.28373279415078534, 0.6912767707939061, 0.7818588013202052, 0.868544751626662, -0.2929073495623589, 0.44879649084344564, 0.7027027868645273, 0.47422831038437646, 0.6797447861222788},
    {0.7817349553209184, 0.5765372950443683, 0.8914940423061958, 0.6634413492176564, 0.6396229878063099, 0.8379753093919734, 0.6085695291065006, 0.7506595172249161, 0.5289908253019732, 0.8684830405257052, 0.48783534345870494, 0.9657427553427879, 0.7152232112029898, 0.7453818113089515, 0.663857146711857, 1.031969755097252, 1.0080148426078954, 0.32529857430209674, 0.8912406700585824, 0.8173698648948947, 0.9163392470301331, 0.916537982271231, 0.7484029902308462, 0.42799404248793416, 0.6232942922456229, 0.8778446013246969, 0.7906191405300065, 0.056647588211782736, 1.113380599442404, 0.6182042648659175, 0.5364489561121567, 0.7081806690973663},
    {0.606693859687909, 0.6347530116580005, 0.7755283844841706, 1.0792020690416184, 0.6461090380254242, 0.7640499072368485, 0.8364283109012863, 1.0963092583667877, 0.8335951853914063, 0.6067789112995928, 0.7362007816235577, 0.5488608193010931, 0.8343929899516863, 0.8562509173568319, 0.43309058848961235, 0.5001645919639877, 0.9635702173284014, 0.7142097491408559, 0.8274621048811824, 1.1128393881176872, 0.6990387732724538, 0.6454436037845939, 0.5543093637597606, -0.18374907422716324, 0.8084516478696825, 0.631962248145166, 0.9184699049438529, -0.1821933552995868, 0.6440447153049448, 0.5881184297714427, 0.698923036738686, 0.38561700777892083},
    {0.5314019159610451, 0.804848436845187, 0.5875003170618014, 0.7390996489324841, 0.803857571364616, 0.7896907693836442, 0.7886560110970536, 0.972774911786187, 0.6207125718223406, 1.0303192096323464, 0.49266792529669745, 0.6188165767632985, 0.896667045996909, 0.6334236497105347, 0.7724840935411232, 0.7136674652232834, 0.8265124410205784, 0.46200919845774335, 0.8492693867008152, 0.6870260812254413, 0.8150896046146723, 1.0513129129118255, 0.8484836157873163, 0.0440772063399568, 0.7296191593036092, 0.5150108871158426, 0.656432739588592, -0.1542471291016407, 0.7573643066281425, 0.3914763138086201, 0.46007010487957045, 0.8159392794772986},
    {0.9176168491741958, 0.5901735142862377, 0.7488647113479113, 0.6927834714832796, 0.11990738279451106, 0.818090150782955, 1.005325581476119, 0.8192149191357084, 0.5504759763177707, 0.7878253849826656, 0.68139694332401, 1.034050196823052, 0.48441551669220834, 0.8132116266322478, 0.4423169704371305, 0.42060803132347163, 0.7568488557406513, 0.41469281522654816, 0.5777552202758762, 1.0223119836683079, 0.6636493197537815, 0.6923381664896942, 0.8962266704836415, -0.2274395163131865, 0.6260139977951787, 0.6280971453859358, 0.8827733933174902, -0.00015169082082566713, 0.5955434806806946, 0.6743103315923176, 0.6916593657181478, 0.908967323229615},
    {0.8169947212336978, 0.7497891092483076, 1.1809074696447703, 0.7923031794361689, 0.8794874389956978, 0.8361423635123324, 0.61855896024089, 0.7074295501161739, 0.9730869080825656, 0.682708001875708, 0.8212183540198197, 0.7638179550497998, 0.9328645885298212, 0.618806693706397, 0.5440570430299387, 0.9110343014960876, 0.9322778983066503, 0.339990064319013, 0.6506581240429423, 0.24517715233931892, 0.9439723994332281, 0.707350496846606, 0.6898015153128759, 0.2700477236941857, 0.6685921726561455, 0.7866524248279146, 0.5743968916576918, -0.25853469702845394, 0.589618052643423, 0.553932146443561, 0.4862334982486971, 0.7846738205214652},
    {1.1547420161408417, 0.5327911737361296, 0.8896391270183758, 0.3408889440266712, 0.6982719607992527, 0.9376428841239811, 1.060317286705033, 0.8976854102409362, 0.9658756760631519, 0.6889188857041172, 0.8667405444555423, 0.4872472399445545, 0.6727739012611434, 0.6782726087533604, 0.6943741832081116, 0.5538257901053479, 0.727781136016115, 0.531167492157314, 0.5272350247141653, 0.17578758511814274, 1.2315819236649523, 0.9533410643509381, 0.7341457078655357, -0.1867048543884436, 0.5087407179287841, 0.6249842565531166, 0.6353631106846818, -0.08218345420221505, 0.9364070189463386, 0.7309203984520145, 0.4070039221143733, 0.8290353360152559},
    {0.5245785139767131, 0.5284619649268507, 0.8444395673881331, 0.7363625694661651, 0.43816226886260873, 1.131147764625559, 0.6151627624863698, 0.6824311384148448, 0.6896645750066165, 0.6915154200939756, 0.4706265334501456, 0.831227331583412, 0.5640592978694245, 0.3442293152065833, 0.8467275561407357, 0.6131811123121992, 0.6198677381309158, 0.006498349101805493, 0.6892586668429271, 0.46014933867894275, 0.789039108311262, 0.6809375677739505, 1.0738999140507361, -0.5108823980691457, 0.6171864792532498, 0.9134025004741303, 0.8426551312880369, 0.001431748074613397, 0.7075346655541017, 0.39566712227655154, 0.7539408609646403, 0.5994198390221227},
    {0.6563862172383194, 0.8811117231748576, 0.9820833409517165, 0.9908820296042328, 0.9765248871854101, 0.860008518407351, 0.7853231070475043, 0.9618948266792454, 0.9145788869042482, 0.5984299270320752, 0.7116361032772722, 0.8448886376215704, 0.7010430488042658, 0.7575030999248, 0.4824594816054925, 0.6984730853457036, 0.8763399256220108, 0.2098196102546163, 1.0686883207822935, 0.5375946489450588, 0.7038172267328866, 0.8015413056739763, 0.7914476142663508, 0.17106655582555283, 0.5550716952929627, 0.9593133530754875, 0.5443095709441271, 0.1175031802029292, 0.7787004582679561, 0.49631700448492144, 1.17967348150562, 0.47579038444242294},
    {0.5452525953430584, 1.0609234760358712, 0.5741867620311862, 0.9051591471431748, 0.33365586556558774, 0.6947258786823447, 0.7162200261956202, 0.66105853852106, 0.6193425300426775, 0.8802874383854785, 0.596846156364263, 0.5894487495229597, 1.0367685011352088, 0.6636878234523357, 0.49242882085691336, 0.6117492069754414, 1.0850455759236022, 0.1509357560317964, 0.7016976035918666, 0.5907471961945032, 0.6601267440660474, 0.729394990837093, 0.788119285340311, -0.3024189738479562, 0.9424516532402819, 0.8055473228434856, 0.4959319833021839, 0.19395666933024003, 0.6398811935697724, 0.561844272165772, 0.27639220740099196, 0.5280692846721087},
    {0.6474878585951016, 0.4757052645772198, 0.7291066595266827, 0.9464932865458267, 0.19253309869742208, 0.8558773761676587, 0.6932142176116299, 1.1360680022893734, 0.6626068808292184, 0.7298814409352242, 0.5531082051352175, 0.4342389813355223, 0.7898692138804858, 0.7405746413091266, 0.42994539042835334, 0.6035578873117576, 0.9404059191229455, -0.013052849221417936, 0.802611397906145, 0.6731949403362958, 1.0281758075513336, 0.5949507148236505, 0.7211162790797276, -0.10272964089201667, 0.8606357469309285, 1.003914650946567, 0.8649145925676472, -0.14545305619597057, 1.0053073192605138, 0.5824498932895305, 0.6289473337637326, 0.7811728877582833},
    {0.5144544533207003, 0.6486964431331154, 0.7897740453666818, 0.530479290621278, 0.680263272869668, 0.8471582533779756, 0.6846132142920177, 0.7565579950321438, 0.5880565508314815, 0.625918544853428, 0.739859143548557, 0.9216627702650301, 0.7761281131021979, 0.5375138424222388, 0.5421267184783651, 0.6575667530082554, 1.0063336750007537, 0.3586631645529099, 0.7057514190354901, 0.5663023857709097, 0.805231839793617, 0.8810408463385042, 0.8858111113889312, -0.042018206331656344, 1.0335176814710114, 0.7293409118251407, 0.809415468676186, -0.145840934411954, 1.0191744497390682, 0.5074163548423707, 0.6989114301383231, 0.7360511387020403},
    {0.8338220785519034, 0.6549965433139662, 0.7184702107934713, 0.8149579767847897, 0.5981359936102709, 0.7406406717853765, 0.9074937683239117, 0.6893959794165654, 0.6362075362263557, 0.787716439456052, 0.7429631031031396, 0.8930442059744176, 0.3582103409411146, 0.6097627148912733, 0.3567932630573084, 0.8874761703021753, 0.9412651546904098, 0.16519696557062047, 0.07892295930428277, 0.6873206106448355, 0.9423222645462921, 0.58411174585799, 0.4835088848354147, -0.16792184486783185, 0.5232255939799311, 0.848681572778542, 0.8054988086380187, 0.12438436806426892, 0.7398933634530684, 0.9686114303100569, 0.7708001803249013, 0.6906808813202139},
    {0.8508381291470695, 0.38114032805171943, 0.435455982367422, 0.6854334201016283, 0.5841327198558869, 0.8121261109937673, 0.7773254467103091, 0.6953176357389991, 1.0157891573428697, 0.6502281383571631, 0.5796432177480002, 0.808198559153539, 0.4644530579734587, 0.5383138706407767, 0.5094058726211372, 0.6951242733871567, 1.0664880029127717, 0.1121944852676786, 0.4111979562522419, 0.7544042189404542, 0.8100298908735722, 0.9453743517301284, 0.5113140423207585, -0.2411654854829005, 0.7419416338889361, 0.42109033623591385, 0.5417184486541433, 0.17308193645194087, 0.9759647381566879, 0.7253039108808595, 0.68281889606711, 0.9746185968230566},
    {0.7219834785015842, 0.6741507127925326, 0.467992677114602, 0.8312444519593184, 0.8147259608735296, 0.8723363381232364, 0.8088912551750946, 0.7930098950596652, 0.835340647740357, 0.5923948593888352, 0.2035578422111656, 0.6301801915800596, 0.716295280276717, 0.808504392877567, 0.7661445737885513, 0.8923509900674439, 0.8388638069994528, 0.32000373647433766, 0.8578914897287693, 0.6995236974444935, 0.609767449326784, 0.5707565476571828, 0.7609804805540625, -0.2995508103052601, 0.9258888864825656, 0.9087603532227404, 0.929518019752701, 0.1772387810449359, 0.5679580385675026, 0.6119390041866883, 0.7276265728747268, 0.9347158227380319},
    {0.33507012831951744, 0.6745060015601565, 0.8225564250078903, 0.8233452868216607, 0.473262985822959, 0.6491462008225595, 0.6898423719902391, 0.6752183429665852, 0.5181413608697802, 0.7222743966113095, 0.6458995976765148, 0.7217922672820258, 0.5982556308644899, 0.8812761438259649, 0.5000287088819751, 0.815216428153625, 0.6417204815949384, 0.24302923570960133, 0.834713964532905, 0.538360371892798, 0.679261110741673, 1.034371313560662, 0.7547501190110292, 0.1921423016702604, 0.6169380518677243, 0.6650264066363399, 0.6354667476993937, 0.1437070159466095, 0.5288121085935875, 0.6485342767867336, 0.5555397024681983, 0.6930545371951593},
    {0.8525364220777288, 0.5987354909317485, 0.9358826013755589, 0.9004100600750375, 0.6804927833808324, 0.8271634686717273, 0.7037824804149607, 0.6725183173030189, 0.6517275210248357, 0.8254812367272802, 0.6161631021602312, 0.6687991012599199, 0.7164217487650577, 0.6091468207512339, 0.6357478141615373, 0.6560963570640684, 0.7570117404823382, 0.18830332866474436, 0.565154816179052, 0.42101842269193285, 0.7202367353813034, 0.7551473089309892, 0.6950248202140477, 0.0300371597437015, 0.39989014733037265, 0.8767792646450594, 0.497980764544452, 0.16482762230404469, 0.9803585155450137, 0.616730941660182, 0.6289506287417642, 0.7087560706920939},
    {0.8702730774954979, 0.481409289242726, 0.87056590262408, 0.7394422350752051, 0.5370724820396332, 0.9483005153657627, 0.766675617866686, 1.3324213440177557, 0.74038413501299, 0.7859385612957831, 0.2912434123305985, 0.9572383798344389, 0.8227757868428339, 0.6668624236949574, 0.9311054878408035, 0.9564804675934437, 0.8546832799262168, 0.42153222287918046, 0.8016017189020667, 0.49150414383883606, 0.7073174431636089, 0.8240203535871428, 1.0537614292162798, -0.325453970551498, 0.760102636629671, 0.9951661530520767, 0.7654587971809419, 0.4933192817914064, 0.639634324288442, 0.9273594382240863, 0.4232028792460449, 0.11277113881968637},
    {0.5745232194124562, 0.759077298419886, 0.8962452030108369, 0.7601148295473072, 0.7609206539759954, 0.9217148373460293, 0.7205056082911897, 1.1416567270255993, 0.9531990913284217, 0.7025631496913748, 0.470819936135054, 0.8369621007591783, 0.7658673104191912, 0.6799750078201368, 0.6716315678345409, 0.39849432416847136, 0.9711446827150133, 0.466210122995771, 0.8049479507761617, 0.6113115521607688, 0.7499658435474182, 0.7999084910994754, 0.8629684986236361, 0.0921011901063083, 0.8535185797186624, 1.1048309952569406, 0.5894047462936229, 0.24327177606855455, 0.6708853527486611, 0.6064073858180022, 0.4740329646416521, 0.9144774236329333},
    {0.5510336244206184, 0.5161345878266912, 0.702978928990917, 0.4765061028693034, 0.6098771804162625, 0.6961465544466698, 1.0670290693314612, 0.8034499065522317, 0.33081200362906527, 0.8599305365177664, 0.6888501093924234, 0.8279669614202703, 0.6020047691666899, 0.7344299117452088, 0.6603025956526147, 0.7574340159455377, 0.36086821517589635, 0.26893924656761004, 0.8489490539056566, 0.4826710130631945, 0.612912650041576, 0.9502916108029921, 0.7438000688766724, -0.3666520075334925, 0.8947462660814135, 0.7153164816929449, 0.8783469143237607, -0.3238767276561688, 0.4895453026676809, 0.31342375257444227, 0.6456682232112121, 0.6489691726692117},
    {0.9123464954830102, 0.8854623504967213, 0.38036611128846265, 0.36219638171939844, 0.6511731330879149, 0.7326268376124826, 0.98397711360922, 0.8371841616297181, 0.8306595941005926, 0.7308019253405009, 0.7235882952592896, 0.9787325322178412, 0.7009779206225826, 0.6390226257457228, 0.8233826101385552, 1.000918924544155, 0.7268757955941411, 0.44834924987943814, 0.8795185339234176, 0.49932825954727633, 0.7520044292777683, 0.6821044800818771, 0.7108445417701043, 0.0920914051714812, 0.9878937565481434, 0.6637689581062591, 0.8127637794148125, -0.19822606596103753, 1.085803604037223, 0.7957530916474126, 0.6526304034165682, 0.7997652049324597},
    {0.8353391183738217, 0.8792410173259028, 0.6021666252626958, 0.6618477684321341, 0.7210478300002335, 0.45082583574683793, 0.612476365723037, 0.6504615105668761, 0.7443573311035531, 0.6905487696618068, 0.4139788567737167, 0.7966691841318132, 1.0585489074209047, 0.6156351792639242, 0.36357561207349537, 0.6429032180905905, 0.8065456616748038, 0.4811018152006653, 0.9740561718527766, 0.7745794400768108, 0.6703514007709597, 0.5127298630891844, 0.5680541901140977, -0.5368793791420537, 0.5756732825924398, 0.9787401448244266, 0.6881665527565949, -0.08338594669265727, 1.0320498055473148, 0.593356595461759, 0.6170991536162047, 0.8545807458435002},
    {0.7512929600174797, 0.7878828655035611, 0.7618140643528449, 1.1130543530445776, 0.5716640127756585, 0.7488590250562653, 0.2964168234996939, 0.6807529618595544, 0.965206501640093, 0.5299727367149693, 0.8422047343313441, 0.8700847174376509, 0.7230309380855923, 0.5512572126327979, 0.8950402427236197, 0.5859872900584722, 0.7917894225632807, 0.32953432380434244, 0.9430560453818401, 0.5554920027558574, 0.6506763154429536, 1.136291316613855, 0.6522222319648497, 0.05965235352045757, 0.8956524578002667, 0.5596899155900366, 0.9733704084832839, 0.07292128826757448, 1.0674790358642743, 0.6203139355062602, 1.260267299864707, 0.23325559720374459},
    {0.8602395512665911, 0.5441307142225014, 0.6830920789016636, 0.6972861931652157, 0.8072952024866209, 0.5952265651581807, 0.8451980893549615, 0.7003595764102274, 0.7573468209637185, 1.0928049993680498, 0.8998487447958502, 0.840885631835598, 0.5613506389688602, 0.40991402092181656, 0.7267974544371195, 0.9836104096175647, 0.6408554674485973, 0.5272924509782848, 0.8720464319323883, 0.6289565650048429, 0.7504799682646207, 0.99509630577612, 0.563649808406952, -0.025726533186881426, 0.47705310528933376, 0.5549654563820839, 0.6913605452262601, -0.28581396405709864, 0.6086557990556136, 0.6359192406536072, 0.4630681645802027, 0.5319278000545751},
    {0.6474295322381466, 0.4439572887708233, 0.7847227274037049, 0.7106911317029888, 0.4093366462519629, 0.3585247009249456, 0.7923045779341885, 0.6815795407447244, 0.6596107526782381, 0.648112889974143, 0.9069332032455405, 0.9239494061675245, 0.7209496119494146, 0.7130241364907713, 0.20772229161292943, 0.9773635088790711, 0.8365869356035447, 0.21542531308073365, 1.0024698634285003, 0.7485321009128237, 1.06514937721734, 0.6739980686241815, 0.9637360296910261, 0.42655707823697353, 0.23530569519403516, 1.0314744225228507, 0.5306122743904196, -0.2631670099659133, 0.5529006657794182, 0.5334742745630486, 0.6097138635131918, 0.6941215929673699},
    {0.5337326600567138, 0.43391046507731595, 0.9700647157765707, 0.877562499599754, 0.5841070727672864, 0.16909605981703438, 0.9770934429463745, 0.6112620986288674, 0.812653413295687, 0.40833035615424956, 0.7876242491570752, 0.7262844078953128, 0.49358988274301707, 0.8434142575058805, 0.8696441778228318, 0.6516462176434757, 0.5761623393004375, 0.34556941985968653, 0.6665016602085354, 0.7502362962983984, 0.7796236578985107, 0.7984049907475265, 0.7314057170090311, 0.09580992608239425, 0.8105130096612039, 0.89961981978387, 0.7178411354207809, -0.003015186463905479, 0.8364924982751141, 0.6594156035879354, 0.5759060679678819, 0.5164532072387218},
    {0.6718515606949719, 0.4482468866435244, 0.9863387130502695, 0.692961360503457, 0.9730349859286803, 0.6334883283492336, 0.6654948830356833, 0.6518664154962939, 0.5335810176217052, 0.3203669971385176, 0.7061886259149297, 0.8389436699383174, 0.6000822414534509, 0.5862437638141065, 0.3948576044640464, 0.7067783544554187, 0.8906205006000095, 0.20595170471353919, 0.8257458593906929, 0.6021577057764944, 0.4303220264483331, 1.046674605641706, 0.7763841475241784, 0.120522688621606, 0.7068430193031269, 1.154514698204442, 0.46801512659924915, 0.22253721077992908, 0.8191530020034441, 0.9719663615652463, 0.8684559078099501, 1.038527914704484},
    {0.8102618886230541, 0.4946676258415752, 0.9579566733018025, 0.3711788532365345, 0.7260567790182147, 0.5786921527953287, 0.6259701435002881, 0.6516158927708242, 0.8715764311401526, 0.8947322511717578, 0.563503332166272, 0.8809763051933822, 0.7811790383354842, 0.7148138301905405, 0.8593700921077312, 1.0237062195447906, 0.5012322243811542, 0.17706407655059941, 0.9146541621121101, 0.5437124178366366, 0.49779515073084585, 0.9006044575653452, 0.624172238559938, -0.05801050368349565, 0.7363747541272314, 0.8642561749092221, 0.7266384706045216, -0.23404398254753386, 0.5924549424639671, 0.7018259889699908, 0.723474472906841, 0.9030044722784155},
    {0.6999312105953482, 0.8213991881246251, 0.4833792398732347, 0.5878478613752395, 0.7099905549748919, 0.5460428765768501, 0.6820501817717884, 0.550640815546866, 0.75196979311236, 0.8731071692627858, 0.5837786504829634, 0.5181724329137268, 0.49667947578971555, 0.9789725136963137, 0.961173203199607, 0.9261217758418163, 0.7701699379952692, 0.024656818495410956, 0.7106432797178867, 0.7002736650252924, 0.7687655423769552, 0.4690262077165321, 0.7258141185026276, -0.14736979554236482, 0.6652618130787985, 0.9286010567945036, 0.8416763537428459, 0.05305759208145356, 0.3884806184219963, 0.7063538887126126, 0.40525063266848166, 0.4068487347193952}
};

static const float b2[32] = {0.698226785990607, 0.6042699700452707, 0.6393379915862616, 0.6934071207775919, 0.5965588917310104, 0.7192659233404266, 0.7046676814981887, 0.7478382137909179, 0.6908593367789302, 0.6955715468696821, 0.6480586027671136, 0.7033183568686077, 0.6385276768550187, 0.645139447916074, 0.5273120669427868, 0.6927038680113535, 0.7212186810799914, 0.27858272539363943, 0.6044110164919799, 0.5702530995850682, 0.707663193220451, 0.6827495664864103, 0.5988656837979264, -0.07519076010082779, 0.6390786663737782, 0.7127155072382853, 0.6435138552083208, -0.0711976813051216, 0.7010691152034896, 0.6263797139972269, 0.6773788987847434, 0.6779375375576039};

static const float w3[32][16] = {
    {0.8463531044249275, 0.9494332363008359, 0.12222345020198414, 0.7580497528848044, 0.591678136379817, -0.09644731833432062, -0.44228916597891643, 0.6999584319500148, 0.7172099630486487, 0.12707923867984322, 0.6684441407898202, 1.409596473891757, -0.2296724177086414, 0.09518708198265888, 1.0732084080202564, 0.13645392156173525},
    {1.2908997816916106, 0.71212335793591, -0.031893379501852163, 0.6248122314237344, 0.7658463576245299, 0.2659829167548405, -0.22067639822692878, 1.1068238279655531, 0.1843045484677392, -0.1518725393955322, 0.2803597160920299, 1.2598337313590533, 0.0019897510531737264, -0.2797012137768036, 0.804844880583355, 0.06967395515177559},
    {1.1837206216488303, 1.074572036840933, 0.3196409008053657, 0.5763197941901895, 0.7144704037337295, -0.18381655810796996, -0.14494561444975734, 0.6350403407562734, 0.924710173408718, 0.21045650362058504, 0.7910531531186223, 0.4205117043190216, -0.010508269118464553, -0.03731619093085349, 1.0671620707320144, -0.5807076364251624},
    {0.8309378759323247, 0.3474158901323708, -0.3042113726572915, 0.9967010471653055, 0.8297077013831042, 0.14991066285960658, 0.21787757667900923, 0.8684018176981216, 0.9999402907322954, -0.6240531270158876, 0.9804781875818205, 0.6143058773637137, 0.21818436019889237, -0.0403560392493385, 0.7574778228153843, -0.02697372507037226},
    {0.5883587548307649, 0.9081810529028866, -0.10271858492394241, 1.04801383068183, 0.3334704666153092, 0.3256941313113241, 0.025858360692474623, 0.36228832208669043, 0.7368167171454354, 0.19961639576035675, 0.5670636397563018, 1.2464141983145958, -0.5922329378248867, -0.16131016085313227, 0.6489974485039168, 0.21369171790085606},
    {0.93241856013824, 0.7451643212293837, -0.5998417808045413, 0.9208629546255648, 1.359821516133326, -0.10657152373193551, -0.37837488851020606, 0.9254947000775519, 1.015343191687137, -0.2391985386499533, 0.7843209235887642, 0.5706935681195504, 0.19880897027423533, 0.13748635322791486, 0.6680974905639406, -0.11539937068691081},
    {0.7638701753734467, 0.7743223342701766, 0.08125399676898616, 0.9415452199551531, 0.7763178291431424, -0.08363816074536132, 0.09147253086097294, 0.7546934288475056, 0.7629604840849287, -0.11119110289208409, 0.9639724375766704, 1.179140701612103, -0.11016943971493423, 0.07457365443189833, 1.2457577759841032, -0.0892760645257327},
    {0.4569512813295962, 0.5653279073206798, -0.38720575538081015, 0.962546295460238, 0.7617969476561041, -0.13269793627599413, -0.39053168269407, 0.8292053006483482, 1.1315453583857138, -0.18411228010894054, 1.043315842421092, 1.0374680641455916, -0.2617436140125005, 0.09632924057616697, 0.988079819169587, -0.14929848234144544},
    {1.3032948911972533, 1.0791419151346453, 0.0765021816775824, 0.3587407776870924, 0.5714782720599949, -0.298671592486108, 0.2987060915191595, 1.0436005065603848, 0.606984398903854, -0.09990308818179575, 0.9349086329328242, 0.7833359187448679, -0.40017920792253536, 0.13138602730527194, 1.070340821430267, -0.2190870670236886},
    {0.41345167198395094, 0.728969128622547, 0.4521478901268881, 0.9503445920491045, 0.7491160330455432, -0.13645864075995728, -0.39098954701612093, 0.5559119698705861, 0.5789095153219469, 0.09511880568209176, 1.0629954429277402, 1.1159635353933173, 0.0919627801477532, 0.11918710003281399, 1.2061772937271122, -0.46722533137396943},
    {0.5804127146225289, 0.9456641350646013, 0.38802107426498766, 0.9002941521856063, 1.002092399635546, -0.12928667830792287, -0.13259357590947363, 0.5627628842282106, 0.6966995784989266, 0.08140124119911744, 1.084626151751094, 0.8444308989401289, 0.39147714697413344, 0.32644321763391404, 0.5673860407594604, 0.21912284818514977},
    {1.101078063951925, 0.7667165276199661, -0.3533069763226635, 0.7760426178545443, 0.7560526937321174, 0.10709075020945338, -0.2852055667326364, 0.7713293583759188, 1.1022688340854463, -0.07051595382030282, 1.108002483371634, 1.0876127438503338, -0.380151600950736, 0.012710688936793009, 1.1302117257408675, 0.20987498544459585},
    {0.9117733492915621, 0.7214439947448257, 0.27529144465438543, 0.5811032668159811, 0.8795873963280769, 0.07456384344071029, -0.14545291113799766, 0.5585571187153829, 0.8230012678647123, -0.1124296625705583, 1.1080924871553086, 0.739050808429017, -0.17394746552432813, 0.3169527834976064, 0.9817924095239406, 0.21847624693944406},
    {1.1932521516654055, 0.9595945162842415, -0.05100362548836965, 0.9001281159993278, 0.7056043627557083, 0.22185354422680814, -0.247518925803342, 1.0428449757422575, 1.1940697210873785, 0.40139394381131266, 0.6397664226446214, 0.8592820952697433, -0.11034220584081877, -0.0659608780117469, 0.6185142770760372, 0.13177447616414353},
    {0.7798245605310916, 0.6738722109402481, -0.13785294938633755, 0.5912478546751274, 0.5071988837093334, 0.04170620169517171, 0.7513515520701559, 0.536263463570625, 0.9333676721750156, -0.15803069506237646, 0.8997276931299883, 0.29806048911605143, -0.18712735961981797, -0.13293997552882977, 0.9202898596810548, 0.042439831975888534},
    {1.0471846394019044, 1.3079985718585814, -0.08707975501176714, 0.2244043305414792, 0.7583674909207098, -0.4115699907462172, -0.12593313374761025, 0.7682149197368592, 0.847630770071279, -0.2275883155534116, 0.7528987006774442, 0.8114331474714394, -0.11254418741223317, 0.33150370738316354, 0.8635552886068781, 0.005554856343452457},
    {0.48503854640360433, 0.9606619670242199, 0.10812828811070072, 0.8219594863622994, 0.6565947267512605, -0.27846965468557483, -0.08120857406909712, 0.8080897603000656, 0.5342531797178003, -0.014169220484562598, 1.030822230662131, 0.8554511728377358, 0.16465345507021298, -0.5848098215735663, 0.6740106694022441, 0.03415282663933512},
    {0.5500973837784547, 0.5618174310677849, -0.4826494279007875, 0.299068109168206, 0.16034559888046798, -0.15728243084761911, -0.05071947311548621, 0.4630569766171111, 1.1430057053985283, -0.010747662026109188, 0.2691281047268483, 0.39027446497949486, -0.41243260835882, 0.2983061115711079, 0.37652999468682763, -0.14582425902038637},
    {1.0858447216569804, 0.906366629532664, 0.3254108047743367, 1.066224459826479, 0.7652362138053719, 0.07589509772856559, 0.005113891890379951, 0.7526087277513107, 1.1995483395486763, 0.5307580392896424, 0.7887516947523329, 0.8954145870307824, -0.3450633693515543, -0.07561268692021772, 0.7831279028448275, -0.16490190601586396},
    {0.8788990725504058, 0.7487302755914941, -0.07436572347632055, 0.7060530737832055, 0.8256302049476959, 0.019698169465398246, 0.19596883133222898, 0.6998429774212458, 0.7686222775155613, -0.1626659345211818, 0.7828318933795754, 0.24234463875752296, 0.6758761831570191, 0.31663354303976643, 1.0225184639533795, -0.25470704059337274},
    {0.8156361335263861, 0.7068930307841909, 0.06290281714035548, 0.7613821459565948, 0.6411936866002377, -0.12310972551718079, -0.29695988976744603, 0.9415842850866877, 1.1290919223253066, -0.05800123073996588, 0.8274148058138202, 0.8391981972992321, 0.3439216253688648, -0.10552581832935981, 1.126987111517654, -0.12572971550623463},
    {0.6056565661723808, 0.7619358583788788, -0.37009405773682597, 1.3750962257204316, 0.8434250459022766, -0.04350042395582491, -0.14967821838989104, 1.4369071292461313, 0.645469591805458, -0.036643580900642014, 1.1528275120496259, 0.892246318917448, -0.07022225617737904, -0.5186850056228015, 0.8976436322220627, -0.33608441857049154},
    {0.8693821335849798, 1.0499831444440106, -0.26189132875432336, 0.9692913551034847, 0.9434052087369375, 0.13707178945686016, -0.3164494037765121, 0.5163612661095061, 1.1275993653517062, 0.6076733475237227, 0.6339796316682124, 1.0098674832720158, -0.18260340769040226, 0.06589607968789327, 0.7279141879868127, -0.06967140054235386},
    {-0.1268160999587351, -0.15674686151016076, -0.07869132490303957, 0.2326669125919776, 0.5578665559718656, -0.03397506602598812, 0.34830145650449745, 0.13592892116794897, -0.10651458559182266, 0.11851508360275712, -0.4753452001415956, 0.18720209227702167, -0.27077105209965385, 0.2386536942462929, -0.12716830098523277, 0.21418610025077153},
    {0.9610955704893083, 0.8935842793976081, -0.13263173552369503, 0.8070354786509266, 0.9879342226988823, 0.2654394074368046, -0.4354030787450295, 0.7578873023138971, 0.6832454708607761, 0.11521113395005947, 0.5952185035449108, 1.1346147854589002, -0.11079872247232789, 0.09569595542290107, 0.5733813056699453, 0.078833778213176},
    {1.1912939135155047, 1.188033305159927, 0.21674147069297864, 1.0597852923390005, 0.7565422867353434, -0.0038068624412787256, 0.26165737197960715, 0.747761616803837, 0.6251137473549705, -0.21003332331147773, 0.7208889916081337, 0.7759120789945932, -0.12716396866355759, -0.06318625916573213, 1.2799797421151697, -0.26487767766893205},
    {1.1126340567903883, 0.815622822187512, -0.00013458823984746306, 0.846751705802916, 0.5174135954757144, 0.2689939542519472, 0.2774237614275959, 0.8421379107284486, 0.7316042832945179, 0.1505089080068564, 1.1742432630179802, 1.0886073576908155, -0.11770778144464746, -0.18972592440299543, 1.1071558223839313, -0.3851201828628901},
    {-0.10872357969537307, 0.08322467431852186, 0.06169090690583251, -0.10428443099131682, 0.14805890723213908, 0.5867791623671184, -0.38650817305178253, 0.22896549356874588, -0.09867214909037299, -0.2621254307715712, 0.6034278124615692, -0.24948169900510933, 0.04952051352146853, 0.4878844112101128, -0.17481995804055542, -0.2646564795319816},
    {1.2020994472907178, 0.9239389917171869, 0.15737359393763548, 0.9338866771565951, 0.6611531370213989, -0.08060809488756983, -0.01668524073361188, 1.0985490737787273, 0.8598756626244275, -0.07906037886679963, 0.7797804212586756, 1.047139145665985, 0.06624750700072446, -0.04253654355849268, 1.2283885387490006, 0.23201778290111413},
    {0.7659416318125685, 0.5080372488820677, -0.48197587259421987, 1.4090968516383078, 0.3295728957416393, -0.0006529284437723486, -0.30648638883531204, 0.49295302728980334, 0.8397055791127886, -0.10167294611004751, 0.5119969618568222, 0.5927823242597969, -0.18627452724735327, -0.5101277964683902, 0.9326266498152487, -0.29203806868563903},
    {1.1562993034333062, 1.3207641422029368, 0.11553056415635783, 0.4955573405818048, 0.4245987957696409, 0.018675543499895655, 0.15536419054025968, 0.9795255533603494, 0.7433745265431543, 0.29310776890188656, 0.7401678316242176, 0.3333218613359282, 0.09320255340662319, -0.43008397984738833, 1.1398579516288583, -0.15408360548545824},
    {0.8497456392767998, 1.126511730010522, -0.11172806391345495, 0.796416281707157, 0.4152547485351341, 0.0013452150828451286, -0.15965083983307668, 0.49957657135318445, 0.8022798206287561, -0.5159464163230882, 0.685430042303272, 0.49183758244555914, -0.1663061394151387, 0.3251479402751185, 1.0281690778196517, 0.03277856267148833}
};

static const float b3[16] = {0.5846389915297249, 0.5497066605840087, -0.0064661698424097105, 0.5430212721072005, 0.46047909076684174, -0.0424521036857103, -0.04140421438652061, 0.49955667795055736, 0.6043436884152791, -0.05101522731408995, 0.5211396610292961, 0.5233150053397803, -0.017270848389186966, -0.04064840318984031, 0.5693883822419122, 0.005047426047732352};

static const float w4[16][12] = {
    {-0.038500785300403746, -1.0349376509574464, -0.5985307029236844, -0.9020793143662884, -0.9733409777463807, -0.47014250469906566, -0.8915522894794841, -0.6020923953575048, -0.8511791064186994, -0.533615366400363, -0.8548403626864617, -0.7438369172801346},
    {-0.5207582992624575, -0.43102884860356233, -1.2247349982866111, -0.45083098585836745, -0.8684114394635679, -0.5059476438700093, -0.5921858937794682, -0.7877694641798919, -0.6920858370462596, -0.7794701326433097, -0.8309187716661273, -1.1433801244890072},
    {-0.5433525398086028, 0.6669049767532678, -0.05649092798868308, 0.17510738508589338, -0.4252913185589251, -0.44262217899497786, -0.326592437955029, -0.8083729488402849, 0.04774310436151503, 0.2209198366161755, -0.08651447224911744, 0.35025376552206644},
    {-0.8770842660003142, -0.7799885620588569, -0.20753618366002022, -0.9058233281384064, -0.38962425260710887, -0.9436712434232843, -0.7236842247461894, -1.0527046274422416, -1.3465869217498156, -0.8346310056284819, -1.2638644430627393, -0.9299481388992236},
    {-0.8842374495764028, -0.7429812208126358, -1.4583575852158819, -0.5199454425840103, -0.9037013610568064, -0.9662919910631261, -0.6686333505378157, -0.2952055005387416, -0.5648283314349546, -0.20752575347127603, -0.93325571021818, -0.9308666371337024},
    {-0.22252430349752425, 0.02399470111205901, -0.1949908939673728, 0.5181705964826855, -0.2722485603876368, -0.22609476169275883, 0.3893582996561089, 0.04316325010055711, 0.01341923543150674, 0.5202088109239794, 0.1189440690944167, 0.17042377262648192},
    {0.1679642856995225, -0.20550494629356655, 0.26481161189787544, 0.5735708963991221, -0.527424401640337, 0.11484061814883367, 0.5430390611761673, -0.15272414771248505, 0.010961437289698416, 0.20720830552875805, 0.6754178285015409, 0.05968352047680149},
    {-0.6247506029952743, -1.2897216860427692, -0.6361629771339226, -0.9171718038874547, -0.7225611643807854, -0.567598223264512, -0.6607023308698393, -0.7717670845829078, -0.43742761231331195, -1.0581954065083308, -0.002243643556523574, -0.4378132639202967},
    {-1.0987840704722998, -0.52850531171197, -1.0988283727013761, -0.8405795900584976, -0.40881849673417875, -0.9794298789973138, -0.6522095266393203, -0.8611917927138864, -0.9378978996184197, -0.8194520979088055, -0.5849276388998769, -0.3155314785743097},
    {-0.049406536031782786, 0.20847757089808364, 0.4205026900556474, -0.1549595438058788, 0.2622977284922065, 0.03742565574343454, 0.32277429136401053, -0.6200729996024823, 0.12145448640019484, 0.48198530254920674, 0.0333741093443011, 0.47471979311318024},
    {-0.868356123934249, -0.5094046178497216, -0.8324001213220897, -0.9505514212358097, -1.0010440206665254, -0.5991511639784711, -0.13594572831402807, -0.847971264747948, -0.2650392883095362, -0.9371176646977019, -0.8607948668010436, -0.9804866204623192},
    {-0.7071994956910235, -0.7288246755949104, -0.5254373260985112, 0.08279258016053898, -0.7901418888090849, -1.0039640334742708, -1.4463277416533167, -0.6084835611309809, -0.6282521238600937, -0.6752375901884884, -0.8942497032819494, -0.6163712368080647},
    {0.0395041838554053, -0.8221214926537964, -0.08269695544273806, -0.13781336249032972, -0.20301523013418166, -0.007357462359066463, -0.13521433144153966, 0.059544860690905844, 0.10198403672787848, 0.7388366674522763, 0.10075368777280243, 0.16571139899794113},
    {-0.27240097095444743, 0.36998840711659614, 0.07238042778296574, 0.7429759083957368, -0.32396040312930224, -0.06464127162963854, -0.2450214483750138, 0.24297287941126638, 0.2636402412102597, 0.33886254075902866, -0.26922234452215077, -0.2522270369465742},
    {-1.0830230684012383, -0.6253530515154377, -0.19558172706650628, -1.1449055813823128, -0.6433284154585069, -0.6978588887278715, -0.845105393602743, -0.7888678242884438, -0.8814150421954776, -0.7800382105092246, -0.452290727514912, -0.5792665601353951},
    {0.10535611603668485, 0.31028452502245696, -0.31984153571100654, -0.5514228904953252, -0.17984628488636073, -0.3710833176537403, -0.5019261707521319, 0.07186876034673118, -0.004902094178096619, 0.3693755385803407, -0.2707386779610689, 0.3554492741817945}
};

static const float b4[12] = {-0.35225391802125966, -0.24235482821082313, -0.18081540229802515, -0.3178716849545005, -0.29305254765709143, -0.20831720927070863, -0.2853017967863773, -0.3047863477935034, -0.30836985305107373, -0.32646940020707765, -0.23314091325431707, -0.2184394304141178};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
