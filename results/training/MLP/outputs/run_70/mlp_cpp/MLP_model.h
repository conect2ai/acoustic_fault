#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.5097206039099176, 0.6994406953417844, 0.7025613122990793, -0.33894823601139606, -0.35620599732293917, 1.6304477966406419, 1.7354691438108893, -1.7367958836055246, 1.0160119147049502, 0.963262743584413, 1.1116410166216435, 0.7911658405551146, -2.1844059674139467, 2.15770125156977, -1.6325909863153736, 1.615817963757243},
    {-0.22906625460319438, -0.3415506931652314, 0.3178826596033074, -0.9576869113536913, -0.44728046009186917, -0.1432541111017978, -0.20765673678058283, 0.44659075977866813, -1.7574422454207064, -0.9885604892948272, -1.3618254010225257, 0.23004330827420935, 0.7832367135369867, -2.361225966638204, 2.6928340492944267, -0.5833709282159588},
    {-1.8726240962432896, -1.024917703708088, -1.2054056398863895, -0.14252377877044928, 0.7662102419315066, -2.692792269437354, 0.6847066040035418, -1.7339525104289324, -2.1474690525115228, -0.7552237427085507, -0.603291374905953, -1.1227837713055326, -0.04093603166806279, -1.9241747267316984, 0.3248804443266408, -0.9094763982915272},
    {-1.432233393665095, -1.3210787543018625, -1.9598257471256442, -0.4503665439937152, -0.5880598467742103, -1.2836712438211113, 0.522042882325189, -0.8725259970203987, -0.3830980549145456, 0.010571503326859764, -0.9957012285978871, -0.9170703825067699, -1.0892146049240157, 0.632708277455758, 0.13922970396838055, 0.618220461025069},
    {-1.4975639671449812, -1.3476476126341397, -0.9143677564025069, -0.16814778730898808, 0.9371669847003453, -2.0614552472487278, -0.6237968880906313, 0.7390053062600989, -0.34512674417879197, -0.4910365973798781, -0.30807601851871846, -1.5003643919109053, 0.9902635955210621, 0.9496608557473052, -0.005687701887756436, -1.0682424333110194},
    {0.3352865989710824, 0.8359185018356382, -0.36660315037128666, 1.7979456912494063, 1.9084108331083351, -0.4341076792693928, -0.5655065568129086, 0.14569061575240252, 0.3171054460648547, 0.6182640241536455, 1.060193549415835, 0.5625630786754705, 1.3195829113197117, 0.9836786890078648, 1.7324601802352, -1.1163297658787654},
    {-0.10284913646544981, 0.6677430824586856, -1.205631330746786, 2.183999143705912, 1.6110418532654887, -0.7356714105635093, -0.31620210379617003, 0.6158192284762181, -0.9517288766585915, 0.5519199684130109, 1.071403580659166, 0.3223093319955455, -0.2193441550889587, 0.7980247361370328, 1.3830159290812318, -0.4379840257533958},
    {-0.18931638264975761, -0.6345271449545323, -0.35115506350710823, -0.617419388908715, 1.347776544812056, -0.7987018333314618, -0.2490513683803274, 1.09242520364147, -0.37153855813153036, 0.004329572753618902, -0.6886076691359443, -0.3289457482464577, 0.5173557943562596, 0.6494628252208448, 1.142392539603171, 0.6391039160795464},
    {-0.8448601939611272, -0.8028489155860741, -0.8053655940046353, -0.5541099826857895, 0.9256330348196867, -0.3278458302004592, -0.04068438444417479, 0.644818435285865, -2.0940303175404056, 0.5806851660994365, -0.6056521321165182, -0.6103768495635102, -0.3355274994261041, -0.06563355032852998, 1.3508729117268716, 0.7677442149498226},
    {1.55361631169488, 1.6460153996515532, 0.9821975179246332, 0.6869197544374258, -0.25873687738659695, 1.24027947170727, 0.15295038605525235, 1.9608122565739465, 0.13800326742836658, 0.15252153278856379, -0.5325912252538016, 1.7478989063313757, -0.13209983048645693, -0.5816782284929085, 1.7655407181987486, -0.5576256934540887},
    {1.1601125802452528, 1.1682713511785519, 0.5702270206541933, 0.8406774441471391, 0.06971451140381053, 0.07730734431195112, -0.38922327053280875, 1.429556116221541, 0.9727679907669332, 0.17439382511856819, 0.727694345976577, 0.8835930719412391, 0.28224323150703606, 0.6106688088976153, 0.09289611857803377, -0.19485807074705175},
    {-1.8653898259497548, -0.7759616337778502, -1.222080505912445, -0.20476768795945027, -0.4359632425219661, -0.7465813633401782, -0.04493848195996564, -0.9664078941611691, -1.102303999700774, -0.7279152274391628, -0.8954598745128612, -1.068703906993712, -1.0168951069251444, -1.187195447275248, 1.0339927496724446, -0.7435425664959278},
    {1.6086348809017659, 0.7183635948505916, 1.7675090543819363, 1.6943821832009367, 0.7251753289861034, 1.3262348107137039, -0.13054861283907146, 0.7243574792840309, -0.8247539417283389, 0.3176457632081464, 1.3699711722559755, 0.7442386311258958, 0.03738752571551068, -1.3316546624758876, 0.422813731959562, 0.44179201905983606},
    {0.2741498784258975, 0.3321063919229275, -1.0984458567964221, 0.7644033925504091, -0.5245978065744629, 0.26161573323896514, -0.8084428082267809, -0.35255561375560274, 0.941064418504526, 0.666232275557747, 0.16540366121574665, 0.8045301976546784, 0.5041436853092247, 0.6953993615406315, 1.2381261475564669, -0.2995325496152379},
    {-0.5603864492845444, 0.01603600271850155, -0.8331386287887076, 1.9884783910770536, 1.20096560445995, 0.9871528299197856, -0.7966229304950693, -1.305828272813203, 1.241086639984743, 1.1607825446883686, 0.987295081682441, 0.13161799976184324, -0.20856402821362488, 1.1008899206408151, -0.43660025991080126, 1.1531264337137217},
    {1.084226653277835, 1.3768196656975835, 0.561254074358209, 1.3736941981535755, 1.0874336107946418, 2.21534452267223, -0.8837939892486801, -0.2980335221683422, 0.08366088404351299, 1.286116324844258, 1.8154450539129934, 1.8369920347612771, 1.0848938504508074, -0.9176378863512356, 0.4047415808490018, 1.341230426002225},
    {0.8865630628810549, 1.3324061941411862, -0.3893163766190961, 1.1538477138269707, 0.7539822080937825, 0.8859484738928544, 0.5007477161467944, 0.3093879686275155, 1.260685677319255, 1.7988901883232207, 0.7384347187582202, 1.547649143581971, 0.6569976038025417, 1.4008198741090816, 1.3137082877372288, 0.9000068582009842},
    {0.11844345938852006, 0.3565288588970968, -1.370009147174337, 0.5997926396453308, -0.15318994972723732, -0.059742668243630274, -0.3995942958708028, 0.07068326389312746, 0.385307587983329, 0.34088089922137554, 0.15846231441978195, 1.0398117219131031, -0.2603725357496366, 0.1161327109091966, 0.7557477963660293, -0.9875425443955792},
    {-1.2546454776810638, -0.23860222071547033, -0.7072358344775347, -0.7065897880231835, -0.26981534928884, -0.4838342053683712, -0.3034662256681228, -0.7819245359724272, -0.6878051575583984, 0.7805814373100279, -0.7976513255428991, -1.0688581469459604, 0.1910056956492031, -0.3098333276702962, -0.16204990275184844, 0.729563368426659},
    {-0.3464716250531614, 1.2345318773045855, -0.6491181540655362, -0.47238260033630625, -0.25807214039430204, -0.19902534010710707, 0.2605472383432971, 0.13210224596475983, 0.8470536793141414, -0.39322485815712377, -0.22569798356360926, -0.39557527565050066, -0.40242312868551017, 0.6260637574533915, 0.05223158183076969, 0.23541302134913572},
    {-0.9787375234898207, -0.3443856576063304, -1.9221499813426746, -0.6856328050734201, -0.2820743621869443, -0.4794771722706875, -0.6003741516563397, -0.8576641903374587, 0.2910614246875219, -0.3366998973450464, -0.8480607886151581, -1.1585522256348575, 0.1396933365088584, 0.6241852074427414, -0.7473282890407544, 0.4013539739310008},
    {0.23176286336331262, -0.2576882952293011, -1.2911534042583501, 0.5466068299517443, -0.6466525126851672, -0.1667209801901892, -1.7742212224847305, 0.917125002324847, 1.3004395939699056, -0.32061926380720396, 0.04699861710239448, 0.10811513879402554, 0.46174109065266994, 1.255552011446838, -0.3061336876099825, 0.6049338071270861},
    {-0.4107060958516366, -0.5248450041546711, -0.49589715663981565, 0.3341000902570327, -0.6910045365005552, -0.8117144255144356, 0.068375682809614, -1.5737106136434165, 0.565953439734977, -0.4133240342631329, -0.2679816264863643, -0.26687663894502683, 0.4942920783752496, -0.6215851364999138, -1.345743534152986, 0.5579735000791269},
    {-0.28185634282906713, 0.1296793300305251, 0.3450540398139738, -1.0666294708009816, -0.9359956148064774, -1.2101549155371738, -0.7982589450846869, 0.31943831433582726, 1.4881899359942607, -0.4428360345884789, -2.0198583509522883, -0.9459642845628401, 0.48968214176124936, -0.45760206267782355, -0.533281864387762, -0.3023235837709984},
    {-0.48804447785496347, 0.934116649360753, -0.9069057441786673, -0.5023147250670659, -0.6604564608002744, -1.4276273983894918, 1.1999890979276155, -0.2175222799679292, 1.296460854203133, -0.14974861970240305, -0.8718591784829011, -0.2692029985124553, -0.13609163817963213, 1.0513704810770803, -0.3816590468439772, 0.2747938816968091},
    {-1.2952582455387476, 0.006087255815826936, -0.8662246348494521, -1.5157282955072695, -1.4918704657778266, -1.5988360574878644, 0.7123903124300995, -1.258702513460206, 0.30968109077667155, -0.6588302847930146, -2.001177259201039, -1.5572705900845119, -0.9380161714432904, 0.2577417884778732, -1.4097672326085968, -0.04667574397466542},
    {-0.8072264409446113, -0.11519782092635203, -1.2606933542070269, -0.4505633405754101, -1.60721254047737, -0.741159662959698, -1.0748853268364698, 0.45120796044232026, 1.2383867288111192, -1.1023662472759894, -1.1811034961095288, -1.0678949998212255, -0.6371940215866103, -0.8144586474969034, -1.4697421048019423, -0.26539286290803255},
    {-0.9415369567574596, 0.6072593652512253, 0.4325483929591996, -0.28339131771191395, -0.6766917208723414, -1.5577040178394914, -0.10315559792859708, -0.16925505882013453, 0.20201083790130892, 0.09748925128987329, -0.30532384739177737, -1.1572404656037627, -0.30705370850838, -0.989165793330966, -1.0544299600406146, -0.1512715700667118},
    {-0.6456638167498248, -0.14193611624921104, -1.5066061025830373, -0.20475829681447835, -1.608257214695271, -1.5197688634386752, -0.8391711169390588, -0.5402741901503663, 1.1403725431764449, -1.1972565451188455, -1.2138615664455719, -0.5729036795602763, -0.19000411042207804, 0.0015854641486858737, -0.3864844205221208, -1.3101849136901864},
    {-1.2602846588914092, -0.43820050996297333, -1.1255628641588598, -0.044321337794486174, -0.5236081447065108, -1.3274355175031396, -1.5322638422478754, -0.753409144689162, 0.45847395565639687, -0.19047888974943958, -0.17705940369000353, -0.9924992256623323, 0.3702123662194858, 0.005017951731104291, -0.5886262333075095, -0.9234360425842758},
    {1.5580289067424908, 1.8220148605549356, 1.668707455568076, -0.2881525921686195, -0.8206923778525111, 1.2688091392031953, 1.5448107294321802, -0.09010881700118305, 1.4135411243226603, 1.7987909219982219, 1.7719365285267787, 1.4082699033592323, -1.2944518510509935, 1.9836919418802315, -0.9728832155125712, 1.190105670003057},
    {1.4505439201823915, 1.7823885721341999, 1.3787195004041655, -0.46991417100942307, -0.7032123514200065, 0.6288295563402743, 2.3415211274371557, 0.07726417116950428, 1.7764458426814322, 1.8543599143311642, 1.3004361267245255, 1.343255251092645, -1.4514918579977323, 1.4820256531164389, -0.557003507992948, 1.7607694021955265},
    {1.9070991243417275, 1.5538146844451308, 2.017031401209861, 0.612591845548499, 0.19071992606798419, 0.9535461653420403, 2.2342620886883644, 0.3820144984007536, 1.318795361525922, 1.5014004711152864, 1.2974319802072845, 1.472579491330161, -0.19199838913412792, 1.2313939016555926, 0.28000681047756126, 1.0256471970175343},
    {1.127434567155698, 1.319301548691456, 1.6268020945507138, -0.14175195207799032, -0.13195074675258597, 0.5823988279315793, 1.4864628166087461, -0.399234986000458, 0.5601154196930548, 1.3634275781785041, 1.0978255633846383, 1.3132657597144561, -0.6565856587321415, 0.6443911376618212, -0.3484932371688768, 0.6308014440082654},
    {1.02967438984228, 1.3616881191714518, 1.523964619641432, -0.21085046805687152, -0.18083707482016323, 0.10665109275429605, 1.6692423385890387, -0.4011424132049711, 1.3042523119271685, 1.0635203740798909, 0.9824438548346562, 0.8913117595379123, -0.45475165070458584, 0.6144185386714284, -0.7244405163761414, 0.648118820180499},
    {1.0984639900677158, 1.1489925905188627, 1.1977589910743318, -0.0708467625531402, 0.08021166208392995, -0.2514608023558209, 1.2304420113876247, 0.2771416882553094, 0.9365231351015999, 0.8561271004871923, 0.983973989215524, 1.4936684596925285, -0.1934190760593343, 0.711917133245357, -0.146309515930631, 0.35842702919227937},
    {0.6039107676595153, 1.2565575263521784, 1.040209031397193, 0.0834212451133346, -0.631994071360537, 0.12587185811465595, 1.1823195815059346, -0.4586216699270806, 0.5757024358815185, 0.9494876442195384, 0.9144432891130158, 0.7514342203572939, -0.6370809033690615, -0.0658598079283097, -0.43390685138334967, 0.15594462614616594},
    {-0.3271902421257183, -0.3201923463510894, 0.43159831472272253, 0.39312648876500794, -0.4686988127323913, -0.24221259703902973, 0.014120048498363789, -0.5074205306463199, 0.28834411907391166, 0.30051155380089395, 0.874536895029002, -0.08954623946076443, -0.2960485148873199, 0.2203151007336133, -0.8142963992096712, -0.16341148731939423},
    {0.6427405056272522, -0.02687103447630018, 0.7586198770616465, 0.03816008984841608, -0.5620845958578673, -0.27535535828459995, 0.46482044664466454, -0.3373882443241272, 0.40553607945795006, 0.484244128104731, 0.704534810357469, 0.61487364978113, -0.7787136688059981, 0.7087104939860874, -1.1142670147968687, 0.5347579548591623},
    {0.2603832897394575, -0.07863937685808643, 0.2027733478155963, 0.05598663222766629, 0.10167645744197597, -0.06297186123161926, 0.007543447159287369, -0.8047604914339886, -0.018150640324819094, 0.11449080030693015, -0.5768412308527173, -0.17380438601397047, -0.605938660325407, -0.10319081266307781, -0.2585754689577965, -0.14137826230734138},
    {0.052777120387853836, -0.4565183124714935, -0.2447452367084678, -0.15434923145246254, 0.03655895294535071, 0.28047552443712254, 0.7420773333585828, 0.15060719894120686, 0.009454938547090853, -0.19166062010538074, 0.13599247402519143, 0.47273075218527066, -0.3156584497094164, -0.36184227203938235, 0.408617587963928, 0.13482623076424652},
    {-0.5312669142689382, 0.43601815668935595, -0.009262337772540317, 0.0905806764258945, -0.3366845488474171, 0.3155539049417108, 0.5109977327036292, -0.08869092121163137, 0.06509796406803452, 0.2971393486225307, 0.06476031330500702, -0.369854592740414, 0.3959774572664586, -0.022614497809242937, -0.1955490662204515, 0.2825530990851956},
    {-0.6955887022410999, -0.7772459276431636, -0.9824661763441015, -0.475564652240088, 0.29750956119665023, -0.20185371066384303, -0.5672649700274466, 0.10031950937575569, -0.16643398475322418, -0.4935894876559289, -0.4789272961848453, -0.3750735940593216, 0.22536869769865323, -0.2517525497567195, 0.4309985990510136, -0.35346070090396076},
    {-0.2966698457151918, -0.9703535313296573, -0.5770170916006794, -0.8437510219871998, -0.23761931942830167, -0.4013393161253354, -0.9122797401021319, -0.42985452606636365, -0.3490434078454125, -0.3540672157149542, 0.03651529430357118, -0.2446508789919043, -0.09964589778182384, -0.3857736204899695, -0.35261547276790484, -0.2509418135969187},
    {-0.5969172751472822, -0.48973243356530066, -0.2747484102029616, -0.2797504597615149, 0.051745028231140903, -0.6461605461527268, 0.18123431209497998, -0.10462860853142661, -0.6281564948825386, 0.06864093033286883, -0.5315535973259031, -0.2946702329252863, -0.12139889508100041, 0.14163485258202146, -0.3369517588118725, -0.16155534500515806},
    {0.24701805978937447, 0.0583326899848583, 0.22448296387602923, 0.3843464054984915, 0.38170257338751556, -0.11672319590230965, 0.9296356839923487, 0.17364426197579874, 0.04228681046967879, 0.28245902863234434, -0.35809631850164814, 0.5774719233107235, -0.31824292763314654, 0.07967476396373514, 0.2985767044140827, 0.3640163499777436},
    {-0.09794821358542802, -0.6728804938741244, -0.38378294020031445, -0.32326264145066674, 0.28657688771767253, -0.22828192573123945, 0.4340935878414628, -0.10643583904500781, -0.061284463439716504, -0.18467437223432775, 0.32495685188284423, 0.18227587222878242, 0.5899508930727121, 0.044784003947184764, 0.041488949147142795, 0.15870366670133337},
    {-0.20495997051582793, -0.5803781339756767, -0.3448387655460107, -0.6281230047277789, -0.2531243139516164, -0.5456205673507598, 0.5321549549454984, -0.4069524178372421, -0.44440573280616186, -0.7641595196264646, -0.5331151893868545, -0.43464769210284077, 0.33157243526120583, -0.5236886894603718, -0.28826608699565603, -0.43668186637286766},
    {0.11401184273340843, 0.17215836953807315, 0.418864791470414, 0.1125063733052493, 0.5357317681443775, 0.12234558485440573, 0.9270619266340163, 0.35543822286229215, 0.03694274147371716, 0.3029633071691058, 0.5139156008632766, 0.3935259423747345, 0.1713471804583412, -0.20529104208019053, 0.7585114479655135, 0.07915619566436712},
    {-1.190722563895662, -0.4817653401350526, -0.15437042143168148, 0.36282632759199873, -0.14369847512732595, -0.789131449633558, 0.36871845912753637, -0.4363842680685745, -0.6360590711891485, -0.34812195594693857, -0.8683176746802371, -0.4860147143862678, 0.18075189879659692, -0.26966408141379633, -0.06756326010388916, -0.4421788404457956},
    {-0.3239881060416321, -0.2936259885913846, -0.32531967301546355, 0.6411139847948922, 0.15588763780325215, -0.6844283737170068, 0.35948102146840827, 0.15170857597938842, -0.4226663699811426, -0.34652903073271096, -0.42556272490925734, -0.14787794816657127, 0.4274855456956503, -0.37817697067300604, 0.519177576640338, -0.2822853504993079},
    {0.004022218520006692, -0.22990797260063636, -0.01911896948699998, 0.3866339252433371, 0.07393107018199026, -0.4302384252886155, 0.36423595519918495, -0.4438170594111004, -0.4035067436638495, 0.2022466707097889, -0.4950880898004475, 0.3966741938222224, 0.4670378289381392, -0.48183622454331004, -0.0544076042468359, -0.1281528354293122},
    {-0.07479234660240168, 0.0917943562325668, -0.46709366616640857, -0.4882071557619089, 0.10425303164888423, -0.0715104662851436, 0.41722619216527035, 0.2641649867619513, -0.18514312854856527, 0.009686785006988165, 0.7267223327820346, 0.3832847669623949, 0.39866362329880417, 0.03425555708754882, -0.09216898072223097, -0.35340917188576976},
    {0.475966106999682, 0.5987370115198078, 0.0779018095897756, 0.03639100524524324, 0.23659112188282294, 0.21024457595539162, 0.5608984457173688, -0.063150932139695, 0.3633937667468141, 0.6691023079457754, 0.4963140126079064, 1.0594084886665653, 0.1402757931105303, -0.2814217377218844, 0.2512316470464646, 0.1442058700525526},
    {-0.7539558447962678, -0.6055200028061325, -0.8027316984344884, -0.3978185855923741, 0.25548980104958563, -0.8918732333883799, -0.5786510521307424, -0.23492423030829013, -0.38865877241455654, -0.16366505808276732, -0.4989576987198601, -0.1011850595132099, 0.22947562653242476, -0.40431829419539594, -0.345826687348013, -0.3379885550239547},
    {-0.48985588965176813, -0.0012476061280044723, -0.43481524345116956, -0.20392626285772467, -0.2282793530028722, -0.7416981947497282, -0.36711044608974064, 0.4493684448750958, -0.3296970228520071, 0.17684996337232103, -0.5784577081243419, -0.21863646210482213, 0.517989042039442, -0.11092092722994316, 0.046827905929507724, 0.027104395104405724},
    {-0.08303436313372316, -0.04280268506976806, -0.05187765365159395, 0.46531246528278586, 0.3145328106461248, -0.017661601474901107, -0.010008578502405073, -0.09074101312475434, -0.26294972922785387, -0.019931885511338607, -0.3108728172521273, 0.013999340483327703, -0.4326827871781966, -0.14591003978988526, -0.02490464961316651, -0.4070296141950908},
    {-0.7652797472650145, -0.4140553967980095, -1.2460051421423015, -0.02488478101080095, -0.46229024783172906, -0.89657401303592, -1.0825660785713411, -0.7052846047032598, -0.5723141065291448, -0.6880669451352398, -0.5550717078930976, -0.5936760475077874, -0.06967923773285503, -0.46391813219872546, -0.2567943342067421, -0.4190374204355301},
    {0.6194552051583601, 0.9289714281257803, 0.3087175354201669, -0.032052427497637336, 0.3192581955705018, -0.06076947141455737, 1.0110771905129603, 0.15720323150898877, 0.7395143689645433, 0.7421030443423113, 0.8593179351446681, 0.781862057781713, 0.34715494371883254, 0.24055131985499442, 0.4601061078772252, 0.3073129506420251},
    {-0.7559398327171625, -0.37286990548580645, -0.5752012677785134, 0.13066258529974434, 0.24989994087481981, -0.6333796912201363, -0.19100653067265053, -0.2288804792347308, 0.16572419350867132, 0.3101281189421441, -0.29602478024950146, -0.10170901752986387, -0.1642260693459889, 0.03224931915024274, 0.38824588427457063, 0.04394501545332799},
    {-0.9934499297308874, -0.8724066666641792, -0.9805116729618842, -0.3436773966009658, -0.41663186119759665, -1.1261056513530945, -1.5278273915645786, -0.4577991343334468, -1.1731338988178293, -1.0818335956025953, -1.292182323348184, -0.9037470902844777, -0.44314271639842073, -0.879569173959669, -0.027568936950196823, -0.8469376719073245},
    {0.15470306868913114, 0.3526017626444795, 0.7885631905694875, -0.1766440241664329, -0.639859457545385, 0.5359066635538869, 0.36372845186170344, -0.18333014626504496, 0.338901224408363, 0.6360720414761932, 0.8657487780057037, 0.3046083430446759, -0.2692127480048101, 0.4715827214029473, -0.1641258138510558, 0.22070658266716553},
    {0.9656509762055897, 1.1806980963614466, 0.6458160389751738, 0.6911979890346407, 0.152249857076344, 0.7077012041003508, 0.7749879492078475, 0.40582630176785905, 0.5188631251327309, 0.6186779647755105, 0.956843520064679, 0.5524922025790335, 0.2635689613905219, 0.7769980968436441, 0.605580671982275, 0.7652760757671171},
    {0.8003030598835829, 0.5081885214293035, 0.5508109977340306, -0.16311247076343888, -0.4512224147548791, 0.6508300502761326, 0.5239005897707795, -0.37830401803912156, 0.5972327937303556, 0.5155259494718092, 1.1191112371354244, 0.3727307149652631, -0.08459047037323596, 0.473822080790387, -0.10245110584979154, 0.4409616330324084},
    {0.2972664455467227, -0.3141133760077626, 0.3275188862912976, -0.020809682877300117, -0.10867344542097887, 0.07352842381827622, -0.20696027314729423, -0.21396087730269955, 0.10849747613971242, 0.1728046313373143, 0.7281274252154951, -0.14701009477977434, 0.07247203398541921, 0.0590364765973926, 0.23829165691996124, 0.25518606957803497},
    {-0.17895170148683562, -0.5068519797084979, -0.5061848946077249, -0.6970044971030696, -0.255292475172408, -0.2295643392894487, -0.1591533721602425, 0.07690170235114938, -0.13268726407014456, -0.04494505628235619, 0.4372484735066284, 0.10407180233737799, 0.3205679086621671, -0.017543011161176816, -0.4592839987956348, -0.011730377235800825},
    {0.736761844658557, 0.7603635379239218, 0.8235268101416243, 0.36383306222648915, 0.20201535244413726, 1.0478709564210973, 0.7574167677725225, 0.1244193516118392, 0.23629841480424074, 0.6414893340213064, 0.9330880183812298, 0.3113216566109886, 0.4067470394649356, 0.18556010170106493, 0.35550258446067234, 0.37314127814462056},
    {-0.11392092056866429, 0.044342873257310456, 0.2658250571222938, 0.04366308148964587, 0.08674669259715898, 0.27981685538076034, 0.31112685227361747, -0.347687568857911, 0.1455295136195404, 0.1559836800520844, -0.14718774135914714, -0.038850982216620436, 0.033661393342023255, 0.20744853438877245, -0.25093035299770905, 0.07425002187437679},
    {-0.42146809510847494, 0.23532153932917427, -0.05930448919821972, 0.07651086196881479, 0.4967834260999852, -0.15848847424770343, -0.11467970815187314, 0.14045566732476103, 0.1055889091409379, 0.09455679151343657, -0.4152862207637642, 0.1447132209206214, 0.173469812656015, -0.15206833909836884, -0.07589160535747526, -0.05074541194680016},
    {0.49268452368045385, 0.07891426319094597, 0.11587066640556624, -0.14601217953619644, 0.309172373189152, 0.43382721968023524, -0.1490811847097479, 0.33092047498554067, 0.23412785652374832, 0.05596153224281272, 0.6886774220291564, 0.22921021402830719, 0.0421539571505237, 0.568248943350774, -0.3518876135102617, 0.36561773555265464},
    {0.5501527565898545, -0.04164811323528239, 0.29451522237180894, -0.08097811076998299, -0.22297347856969602, 0.1678724399437115, 0.2831263638408241, -0.36747281438957147, 0.13071171964125752, 0.3307809980836598, 0.05201664794847144, 0.17374801513185378, -0.2545456021866244, 0.055170373396446516, 0.0714079037454561, 0.15950489599847084},
    {1.2687369562607038, 0.42676188950147304, 0.7902898966223398, -0.13118602484766095, -0.24494615307643594, 0.40558245527331455, 1.2691700326751496, -0.130090669358098, 0.9433814457364221, 0.6942601039467827, 1.1887561485957452, 0.7473344639386346, 0.06445226360284523, 0.42476607152553914, -0.23535952524878148, 0.6271472498896277},
    {0.14062494501973874, 0.7669476048156245, 0.5366009536457045, -0.5138354203004174, -0.24822457719430394, 0.4306148602608012, 0.243991810849087, 0.1338384602625387, 0.45666739608290857, 0.4996215050017794, 1.0931261942103396, 0.4890040124904436, 0.31101159465152095, 0.791830385372829, -0.05771664983706507, 0.6919228845230209},
    {-0.12226377926458636, 0.025744733337970036, -0.4427549002796846, 0.02975664997804374, 0.020414284444891937, -0.06320129675481438, -0.34517793956968124, -0.09319625676034395, -0.1417163071798186, -0.46010075488999236, 0.15520055978136071, -0.5066641599687312, -0.1816613199705032, -0.23768413613481973, -0.34384638074446033, -0.7531904367510494},
    {-0.8597428235570249, -0.5369874105762676, -0.8169734017823974, 0.4736561530701021, -0.012882889547688393, -0.07559162295393945, -0.19959477938155484, 0.2560518019972305, -0.3079507153689725, -0.2672134812994718, -0.887452155148944, -0.5925039405021802, -0.2589411952929451, -0.12757877009465818, -0.09663905540794025, 0.08641240288472733},
    {-0.144624899200962, 0.5781603949981212, -0.2362697764416028, 0.2203289370691318, 0.28390789808800987, 0.6207576609984871, 0.43108047307521763, 0.259096780008296, -0.07904295598028949, 0.12312796389544742, 0.025915703221145572, 0.16625811970793708, 0.21035141969421892, 0.20614954727261345, 0.24667426459727101, 0.3027179553925537},
    {0.6289147655522636, 1.0296569740846881, 0.4353756952579584, 0.10927167305614342, -0.3074181191559556, 0.3335508246992863, 0.4628977791566074, -0.2114485277414926, 0.3934262720594486, 0.1450339956413566, 0.7781100730418923, -0.1154029096387929, 0.11848189757642323, 0.4161119728838112, 0.05148989707499404, 0.1456718224583837},
    {-0.044747083192025285, 0.5896026885892688, 0.4562019967514052, -0.044200106614506435, -0.6248204949933851, 0.20894294280375422, 0.512748584315784, -0.07875187735529281, 0.5163467205756782, 0.6559585030326603, -0.16545802424567355, 0.313784098255669, -0.38953555894869235, 0.5199184339309553, -0.287837044075216, 0.16126377842300327},
    {-0.7280123300108704, -0.4128263757650642, -0.4527934206271199, -0.5660779091048126, -0.2852283292694064, -0.5207221142490035, 0.018930849336986272, -0.2525752711996223, -0.3415934454530802, -0.22183563622401042, -0.7575304867387604, -0.328010757110067, -0.3202064295988, -0.44822065001701256, -0.38653208772959885, -0.7042592712306907},
    {1.0821707436776182, 0.6737459019889136, 0.7115683614464291, 0.6316765326972147, 0.5992993024256121, 0.5899058904237139, 0.8170170795055831, 0.19214493845827335, 0.5169327677136965, 0.7679308178230133, 0.5866707709080207, 0.6598078040837762, 0.399629719224482, 0.6649591553230007, 0.31405938566723385, 0.8467620637596548},
    {1.2366345090771658, 0.29781101954299843, 1.2322347028116436, 0.9629007118114832, 0.6397470098370033, 0.6902100936950432, 0.6140804915627738, 0.41712627035298055, 0.703400409714769, 0.6697804801707411, 0.6658711659477181, 0.9859348548332583, 0.31306672142663794, 0.2714233407348816, 0.6430622521880939, 0.9325273604392984},
    {-0.07846750308090823, -0.927225792308238, -0.16913781480941947, 0.14410137099730305, 0.4962848689621231, -0.6632035349509366, -0.6553892518432708, -0.05159392108832465, -0.17066717173105103, -0.6453295754778813, -0.6247105862501069, 0.03748866014838468, -0.47946247596724656, -0.16604792210088434, -0.025151750893816976, -0.3662541214219166},
    {-0.06935937210338407, 0.10768163671985878, 0.1116054832629461, -0.25939430726139123, -0.6245327579131981, -0.8471056206182165, -0.14697017145323582, -0.3773060555015627, -0.2459568386103231, 0.09056237365501228, -0.4503597174847494, 0.209207098222785, -0.4376223243297082, -0.3920294899120864, -0.5061254259841537, 0.021235706818583302},
    {0.5490894152913899, 0.33261354924400555, 0.5661867698380594, -0.043019775504766114, -0.004698130469808096, -0.039816581319850074, 0.9030472422123648, 0.12694858170275386, 0.5781702431703065, 0.6355981167425085, 0.409919689708648, 0.9299198306350316, 0.5290434321364541, 0.05870164345223388, -0.16822615125421783, 0.2126903946714005},
    {0.14440629975023, 0.7459165686335837, 0.526430828525238, 0.11069990791483504, 0.03566281216251844, -0.030568034440073884, 0.5025875363291975, 0.1554120647805477, 0.4790642782475045, 0.8381508093552125, 0.6990611525229913, 0.38713640725838533, 0.20947856873400944, 0.0344207174264781, -0.21641986573737187, 0.04440062220775762},
    {-0.9738363691702993, -0.7376754914955163, -0.317631552201677, 0.01667119929808875, 0.17806853137422832, -0.7835301237576611, -0.41015160633058595, -0.32389576635017486, -0.4519071736480732, -0.4559572013299623, -0.686998493845402, -0.26069049915352094, -0.4400656306388865, -0.2800512235679367, -0.9433968395763191, -0.40115922995728626},
    {-0.431573831852821, -0.24257390078749758, -0.4638806396400622, -0.753770758011376, -0.2249475238706783, -0.29622731517384293, -0.6298190462882125, 0.3081776491781154, -0.309653583773773, -0.16643714876151375, 0.2352706115224389, 0.17535536889377834, -0.00689362109901478, -0.5355512868727127, -0.46745504727841586, -0.19817890632710783},
    {0.22309422847966506, 0.8818760515050795, 0.5954095870221428, -0.17882191392775562, 0.22724382693411996, 0.4032038070228354, 0.18243103775555353, 0.2806792297223349, 0.31821571296856144, 0.2508372080410227, 0.8879508312513429, 0.3790512930051697, 0.4981068454678892, 0.5605363735896882, 0.3110426537269221, 0.5848112932836153},
    {0.9444220397220875, 0.20701504551054087, 0.5421633626835343, -0.06854251071188515, 0.2623036834802494, 0.4088391407173602, 0.6109185524913534, 0.41826380506243505, 0.33631488604381193, 0.370015481415936, 0.75085415340754, 0.575308079965739, 0.07371606895053254, 0.3139200505008375, -0.0743186664328126, 0.2142566986850163},
    {-0.3064662617823663, -0.4216044496309639, -0.24314872833056658, 0.1586597453610122, -0.36768603099691405, -0.12365247384993835, -0.30165952564358356, -0.3570361829309962, -0.01994650020475479, -0.7533802583645214, -0.49155471599973327, -0.4510751203185191, -0.3089973969790993, -0.196068138705268, -0.39729687247564494, -0.17164739830499973},
    {1.6178046819983662, 2.2351152870899003, 1.607564208828458, -0.5198972578066069, -0.3691680367928279, 1.1062050350128043, 1.4854904966218763, 0.5817951911065328, 2.0545351990453806, 1.6327830388444124, 1.5662036585648815, 1.6225893086886374, -2.068026365331737, 1.5826196614829624, 0.06911620594414998, 1.6552260552834972},
    {1.1267007134805584, 2.2081984529513337, 0.9782477925419187, -0.9556632611537436, -0.591561984026076, 0.31285461883998644, 1.5035265522805334, 0.23680186786120455, 1.6829458594197992, 1.9282605990283594, 1.0049684299345103, 1.4583917396679773, -1.754112458469809, 0.44246199814490644, -0.10283332472157451, 1.9789045247855748},
    {1.8158451175825114, 1.448855341846671, 2.0157464342484483, 0.45526095866252875, 0.030744813955778025, 0.9062485487703491, 1.4885043649718166, 0.15139711623399532, 1.1784507746734765, 1.4906882066504357, 0.9660740476221324, 1.1056578904539975, -0.3501161497594162, 0.7764903547180829, -0.03990842532850319, 1.0495344018086834},
    {1.0968993962067632, 1.3859973542353328, 1.374503514783079, -0.11788476954845117, -0.353094275966056, 0.29999980639024704, 1.5667505162253406, 0.07750901559686817, 0.9456722692900622, 1.4622368889463155, 0.7138369572677741, 1.0877393764329866, -0.09476814907536679, 0.6101965875097902, -0.5037116019998706, 0.9030419543989128},
    {1.0353512647857073, 1.8301185234946222, 1.44434331596475, -0.15720462510818306, -0.4060345111804202, 0.8107737780163223, 1.363558401815771, -0.05178118089554499, 1.0484183281474397, 1.4265790939749183, 1.01763635325714, 1.3513333919640451, 0.05308277416781928, 0.5238856273796882, -0.1454791013167817, 1.1131791056244178},
    {0.9420439870329749, 1.0440540859619118, 1.172391244949185, 0.26943486350068674, 0.6653302127302981, 0.08177545633663712, 1.0182426456973712, 0.5092079488712337, 0.9247953125488242, 1.083859719120121, 0.842361040194889, 1.5894060859502697, -0.17769640812517914, 0.16027989315155794, 0.16284200586071945, 0.5963189065510882},
    {0.3917356537591959, 0.4859957426658274, 0.6083238573748266, -0.7529171377163146, -0.3680662000057808, -0.1351105026884382, 0.30308916817435827, -0.5828490972946174, 0.25857170919123895, 0.7794040275374753, 0.8541172903538644, 0.6834740239991034, -0.5202204073149377, -0.2756573351861315, -0.20369808086770064, -0.027472082095334784},
    {-0.16418057681654452, 0.010021235439357387, 0.08871614036136057, 0.009062866040128958, 0.21361015337616596, 0.16177449734139462, 0.055144379303146, 0.09042247191660445, 0.16487460475345037, 0.2907096913546549, 0.35532387228156925, 0.632426173519426, 0.032800242151522316, 0.1266516275901055, 0.09746109101566595, 0.24484340886717437},
    {0.6731166815065829, 0.7196205120292694, 0.7730476475349356, -0.29781375669273946, 0.21934955154490257, -0.18568397092085492, 0.1323364193194636, -0.4063628758469924, 0.4106418462356721, 0.8534842204585603, 0.6183314205225956, 0.8512637476982178, -0.6856582105269301, 0.1845054317660194, 0.050676603144788314, 0.8145408690350272},
    {0.8897127468904786, 0.5602831878043368, 0.6941982096688155, 0.1481436760667213, 0.46912340215610726, 0.31532510950253906, 0.2282530658344393, 0.029322949830733205, 0.4763808111155985, 0.5750198735471609, -0.20710755918978116, 0.7993698654968568, -0.23875080582211958, 0.08646544694492601, 0.3485204896956958, 0.3898714440034934},
    {-0.5456423279816618, -0.25356447380854696, -0.681607782398463, -0.49610603435341355, 0.023977012971804296, -0.1005240530308299, 0.052891106943692714, 0.051594670697079605, -0.001828088726132512, -0.4672585318659889, -0.4507334214293745, -0.22241556039857266, -0.40973465873893883, -0.10641891554181575, -0.6911151133701198, -0.4294777847541676},
    {-0.08998285683235226, 0.3379807685533125, 0.0710344994342821, -0.07828085304761345, -0.6453368633759444, 0.6753839825442997, 0.6997979062027382, 0.01214551220543516, 0.6037585311484599, 0.6594644556421381, 0.45988742927155485, 0.027360656459309744, -0.14326378471371118, 0.24454497213161225, -0.4876870594968436, 0.1305671008334445},
    {0.6505506555596379, 0.14173704786901523, -0.022480640005175346, 0.17820549979130212, 0.7402365723511342, 0.24398356698491774, 0.3141904023521054, 0.4870613292489356, 0.613858378672725, -0.00044084222813588284, 0.5051988687271288, 0.5498378110831011, 0.4050241753912193, 0.1949530174625115, 0.6187144279041127, 0.25870673154796847},
    {-0.878166428957594, -0.7605436920577139, -1.1331180861924854, -0.8321741568864444, -0.9333827289782767, -0.9943634420530852, -0.8111749854370152, -0.8039786764726355, -0.24568123906821063, -0.5345276966495042, -0.943556133886192, -0.5662648354679161, -0.2865256840106538, -0.3429759659207454, -0.6971402896028683, -0.6207819992644736},
    {-0.28785936520988104, -0.051528817618134284, -0.5967981034822714, -0.43140361847344577, -0.06794094584500263, -0.17102000057324163, -0.2149670978503052, -0.24906082585539024, -0.22671611373741168, -0.6163324869861032, -0.06044891779897898, -0.47379536060551664, 0.04387548537782449, -0.242375299180471, 0.17457789896585657, -0.23601075454130507},
    {0.08599803326391485, -0.3326975728730776, -0.3269020902838731, 0.28831535707372263, 0.5432134966815543, -0.6488626129165237, -0.36286759056247675, 0.346954603213119, 0.33292754870331703, -0.08824633478924537, -0.7708435625982295, 0.2761737904760834, -0.058938678628718204, -0.2760758237345107, 0.22759855499991485, 0.1750164202667416},
    {-0.3807766762602923, -0.0043932829961531765, -0.1754204272137199, 0.11374990314329675, 0.14564206421211828, -0.17700747643790066, -0.23057560323442233, 0.31906146092295434, 0.1831308966223643, 0.12669402812926983, 0.28828125437329066, 0.48933403762875843, -0.5322735733826955, -0.26654702496167676, -0.33919890384853413, -0.019992096288988542},
    {-0.4536205621532502, -0.23356896433762142, -0.37585252807231523, -0.2809322458608507, -0.6426051278518964, 0.027891495504802282, 0.19967763030891983, -0.2770288702012952, -0.07829668193976135, -0.1917725572480377, -0.42419610692935983, -0.448945670330083, -0.5505514439212477, -0.3845300497516657, -0.4123802096997366, -0.3039602499263221},
    {0.5852860121186094, 1.140416475977272, 1.1586549467065168, 0.3427876954871959, 0.4339621502827804, 0.59442289279955, 1.180038110975364, 0.6674538294472784, 0.7834959774635452, 1.2004307042909441, 0.7176335249624088, 0.9892935088302424, -0.11695253570154564, 0.5349651362624733, 0.3629243717217228, 0.6785253273966537},
    {-0.7483296760068181, -0.37735003758794, -0.185773251696065, -0.22559564162526302, -0.045966560955905435, -0.6755838582027214, -0.18513422911846988, -0.3504193862617158, 0.011624658487607265, -0.232107290664352, -0.8612085135513755, -0.2859675863289066, -0.2901521586082044, -0.347015733510269, -0.2175791594317721, -0.3939457984963511},
    {0.26356284046753053, 0.08364398809883863, 0.44666578070750035, 0.2917968866943431, 0.1852196364364457, -0.02299087342646982, 0.10223685650295374, 0.3767046109899558, 0.016842488279437542, -0.1035527779140739, -0.12195854602875679, 0.10493232294025578, -0.40031567959132536, -0.055418101598941574, -0.023816082914131283, 0.10533555481998497},
    {0.14177440306719882, 0.06547244445735008, 0.4835950138055574, 0.4265352371303153, 0.07632922121222874, -0.012950749694011318, 0.645897213357104, 0.23138963320093925, 0.2683810488459846, 0.6241191993527214, -0.021049810694459735, 0.24892520437077714, -0.5757723504850522, 0.30842290911946474, 0.07687172580106684, 0.0844550756992252},
    {0.2076890598427321, 0.4308869830162825, -0.23017442605268104, 0.03655171292101763, 0.05910671231599688, 0.350527958930062, 0.5280144010411849, 0.24464079232167235, 0.4570067410261789, 0.19992265517745572, 1.005914589871916, 0.7385331471937657, 0.46643221205056973, -0.1646519364998178, 0.09174999953278624, 0.58951415751005},
    {0.6469099637246475, 0.5781963471365796, 0.19224362819431634, -0.14913123311453372, 0.36009878730915323, 0.11472278057163504, 0.7332407395633407, 0.42674110247665753, 0.3465960198617292, 0.7004255304920891, 0.5709315042637666, 0.4558780634603931, -0.1434743975313325, 0.1530493216474547, 0.01655153840353795, 0.26187790291988183},
    {-0.2119888599682563, -0.14565863095834133, -0.6039755956899872, -0.024014893246572758, -0.45892526023041114, -0.26322295367522425, 0.24359126933709524, 0.33841106596236215, -0.06403887860626706, 0.28605558101046213, -0.17515974361944983, 0.28864240603059116, -0.028502298754245023, -0.10783049165810245, -0.17097517774561594, -0.22015431285483805},
    {-0.722260700869564, 0.26139185329253145, -0.6792630916046842, -0.10801281011635318, -0.3815560351763851, -0.5380088705370946, -0.4083795288496668, 0.07392549276583864, -0.24027059660713693, -0.4565595483598579, -0.2742202395701986, 0.011267819148841283, 0.12786872920971568, -0.37620438395567013, -0.2450857421354082, -0.1570095230001241},
    {0.3274900333783521, 0.5659145664679021, 0.5685979204595024, -0.24299767744947223, 0.2246336730114632, 0.2334966658313916, 0.2261937117647151, 0.12287960218861173, 0.5299421922277476, 0.18305043030474819, 0.29352168577944143, 0.6548868625563408, -0.32277229908102784, 0.2729148120143002, -0.26539710000223515, 0.19733375425831923},
    {-0.8092228308889473, -0.40132568073940933, -0.6332962977211782, -0.15568927317269193, -0.9440067940544206, -0.9653435258948152, -0.8714409150528432, -0.8178307537735885, -0.5687778532126986, -1.2484839048834107, -0.6394161078104873, -1.2094791900215127, -0.3515261937631882, -0.2069356136776762, -0.5607423990251109, -0.5466772220274708},
    {0.3216765420892666, 0.194856045365323, -0.04895815979584592, -0.5618868489508742, -0.09900764745244783, 0.009667021140069915, 0.41553912866889303, 0.26295697278335695, 0.6562148345712202, 0.15240911093812315, 1.0285768889992641, 0.9486609930972724, 0.03579314643675802, 0.0676085928978232, -0.21457055490735785, 0.06611202262187672},
    {0.02320682528178667, 0.21533896719217752, -0.3316205167273078, -0.30324067531798926, -0.19773377121943553, -0.3988098595574962, 0.2464127601202549, -0.14619335355380159, 0.01858952804813338, 0.5522986050367006, -0.019899108682280512, 0.18895069923797306, 0.061352328999743654, -0.5116100345923122, 0.018904141884609024, 0.03278697718157765}
};

static const float b1[16] = {2.1667882613817917, 2.8811112393346927, 2.710757875477399, 1.8208711793195693, 2.2032802383956236, 2.6288356611402284, 3.0249121282699662, 2.5363645984630834, 2.9219235691898366, 2.682315565839136, 2.6477463944882174, 2.977008923816521, 2.083503522349871, 3.0001804693016916, 2.602381297669141, 2.863309083388773};

static const float w2[16][12] = {
    {-1.1399526435247642, -1.8429517555456192, -2.1169144395325086, -1.3190617469734134, -1.6852783264003297, -2.023864994779801, -1.4224039658056895, -1.9372691148706416, -1.5806910057060894, -2.003139491469452, -1.4520290450890845, -1.8640814957786938},
    {-1.2893444561220768, -1.4422810971476763, -2.0338119799507446, -1.7704350584776627, -1.3623743115351972, -1.3654412200494166, -2.1994742904106577, -2.035486299435324, -1.5560181151469359, -1.6093335704469725, -1.197565324543565, -1.2978404697268957},
    {-2.2336659338362472, -1.594986820615379, -1.503708168764726, -0.34837895402610297, -0.8095966633097686, -1.874317717368916, -1.8108590059495553, -0.9681246658433574, -2.0041470023160284, -1.5613906963607658, -1.0023938779470059, -1.476936984859996},
    {-0.8339133080175013, -1.2244540587387025, -1.101941961200813, -2.0622288664508055, -1.2944965651401896, -1.516730395725009, -1.5009927540005266, -1.6221071810921661, -1.1824321114103513, -0.10323352773053887, -1.7886624979172865, -1.9110193706167629},
    {-1.9200872570405856, -1.3681297404907475, -1.938936446497202, -1.8279387202323019, -0.7967354624491473, -0.9478524795824095, -0.5580966218403103, -1.0780061587381382, -1.38134317366303, -1.0174608906607876, -1.2706573105164256, -1.628501161906958},
    {-1.1531989648168393, -1.289898049294812, -1.5410833278354825, -1.724545761816883, -1.898838227813796, -0.9412650183276964, -1.5894915562469922, -0.29751302435944343, -1.9309011243023382, -1.518497782550538, -1.9259669573433966, -1.5193368954793034},
    {-1.9284154351622633, -2.153848839197801, -1.7221194660050527, -1.8732362743738242, -1.6313538159425613, -1.7436107505407397, -1.0177883131900933, -1.8564377049524305, -1.3164773420207077, -1.4398241895982786, -1.1169093451322103, -0.38207845993838596},
    {-0.8553292453992516, -0.8278652806143002, -1.8205958570867722, -0.1875619882135663, -1.67199430216711, -1.496411810559804, -1.2597173407690865, -1.3514583569122918, -1.2443433989752855, -1.696981757670638, 0.15367732339331172, -1.69131681932587},
    {-2.0206904442914646, -0.8379318539063698, -0.5697311976959015, -1.7246992068855247, -1.0267514101677682, -1.8513191705711303, -2.0957137056729294, -1.4936259867126764, -0.5516656902998607, -1.3221082642255033, -0.7556691286220777, -1.7277796612818073},
    {-1.5061924730040397, -1.5653789918005936, -1.0405969282111036, -0.892379909623555, -1.4056174799169239, -0.8352415312939406, -1.0113995747068627, -1.6813560155626874, -1.6835738567864926, -1.854604750223598, -2.267232027208659, -2.2054011974362173},
    {-1.6347481895261031, -1.7792727098891428, -1.5573791268618595, -2.1952396897456845, -1.5461764128986977, -1.5796150447900936, -1.4291046885747796, -1.8203332998838468, -1.8442475822593627, -0.4516765651260945, -1.8304145368467897, -1.9429386723062716},
    {-0.6501737650638075, -1.1118586047700518, -1.516064087384198, -2.0278327635221496, -1.6309560525307578, -1.3155016951940515, -2.2204802796393075, -1.3059919482165507, -1.6169003892954699, -1.854733660357078, -1.6290731036091621, -1.1615702686556655},
    {-0.6973800615203486, -1.133687492807915, -0.7170251291057975, -0.7131911067280177, -0.2982238742705179, -1.7815857101919466, -0.8462816357306729, -1.33163166154268, -1.75003612193523, -1.1594099836801544, -1.6575539956868899, -1.2166492630346146},
    {-2.253312509453647, -0.8667110294258541, -0.5706410256485241, -1.9973183075438108, -2.3803985968898855, -1.7180691636613528, -0.4796231675086999, -2.2585660881889966, -1.9229857465351863, -1.4058125307174856, -1.2630526219510203, -1.4457948338470616},
    {-1.1397710791363092, -1.050811233345975, -2.0823783842674835, -1.1872903662547896, -1.1930095793716724, -0.44693990708570486, -1.689409276266309, -1.6655198525262496, -1.3090657679364754, -2.1775655820048634, -2.2129806905722758, -0.2828052709110889},
    {-1.6669184084035364, -1.545757770016777, -2.1666468098406586, -1.2385591696115248, -1.3353838880093878, -0.8676393943341155, -0.8081718789835719, -0.7717958358664908, -0.33302348432415857, -1.3128631533489923, -2.386543387335641, -1.506957804912894}
};

static const float b2[12] = {-1.188822635116523, -1.389611196837364, -0.9815634269529034, -0.9619031535497196, -1.0997053695708339, -0.7074654022687444, -0.6857494295135007, -0.7327656447305013, -0.9042379908199105, -0.6779946390699663, -0.35116504767817797, -0.43388583773476286};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
