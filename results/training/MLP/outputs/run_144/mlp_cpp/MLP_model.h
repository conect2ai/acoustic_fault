#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-3.8432067225528432, -3.8660429774885956, -3.4660154797363747, -4.3694644090068335, -0.6419400432536083, 1.820599832563233, -4.769346056386166, 1.7975217246908048, -4.840214837647255, 0.23384415184478746, -4.701728879868838, -3.880783670512648, -4.293328714336991, -3.8559475970037136, -4.302932218418881, -4.149614930547693, 0.9287567773926853, -3.4423244654805987, 2.2594840885753777, -4.471521848417075, -4.3555682410569885, -4.9599633824612965, -4.588848035305444, 2.4870361501110803, -4.886106073325163, 2.583404535607319, -3.8424552101226985, -4.345298945086207, -2.561132128500671, 3.4676148989183706, -4.094404821292274, -4.426966042163363},
    {-1.8225782330011069, -0.7964735404612384, -1.502883924983755, -1.0084653276890976, 2.858486946036095, -4.2858694382800975, -0.8580637504810525, -3.609803503618112, -0.4618091830734898, -3.9633915622166542, -0.25460353760852017, 0.3699420682961359, -2.1551097567729416, 0.7682711225217235, -0.5402758677585133, -2.064819966604026, -2.3696754012762145, 1.5361879318903018, -2.7706135096073217, -1.363833226168154, -1.3921122172660834, -0.7838976868664872, -1.6846948644045612, -4.039600192624763, -0.378227950784119, -4.163234058123004, -1.4689547989261023, -1.1876606291079295, 0.002728862628158888, -3.209599897049637, -0.6674124415602395, -0.8758920186185112},
    {1.9880037183334323, 1.881641083473499, 3.7671535489013843, 3.388278823872327, -3.386672736794651, 2.57534362949746, 2.80396195075538, 3.7734443354146676, 1.8511699563785473, -0.07350472579133677, 2.55699797486923, 3.613377693897114, 2.0603859403220506, 2.43274306022069, 2.218193223836058, 2.9703607656600135, 4.098776109680925, 3.6773618916392983, 2.821650055421077, 2.5442688905594957, 3.1716198321988247, 2.569800902254895, 3.769559744030088, 1.7834947010575377, 2.7386949809292305, 2.6936177313729917, 3.1670703440890255, 2.7386763835046004, 1.2403711489716127, 0.6890460483633634, 3.5343344035229873, 1.7989780545808083},
    {3.3141806427172726, 1.114067179829302, 3.548662086113171, 3.2489164015836147, -4.240059995896727, 4.00909992203255, 3.0511134895971073, 3.7647768427466266, 2.021680574543126, 2.8596025366766433, 2.6223962639742457, 2.83335545887101, 3.47729078943773, 1.2239080062409298, 1.6419963472630044, 3.7766999073897174, 3.131635894998151, 0.9412836541993116, 3.1898132048632215, 3.482287127544589, 3.3920695526508644, 2.1381547396301857, 4.055706580033884, 3.703139141781434, 1.9545468938639177, 4.006817641001647, 3.5980792732837736, 2.5680936986123464, -0.7801724609721363, -0.6374078695367125, 3.088228262237212, 2.049526559178965},
    {3.832482330386473, 2.5890273404271937, 3.773911761132222, 3.207761746045502, -3.860407184984385, 3.123323950336104, 3.67334104167286, 4.040665788569063, 3.624921724759885, 2.124953641462457, 3.8662389900388967, 3.252631814575788, 3.7041493811237083, 3.44342161115057, 3.289810339060428, 3.945797139152543, 3.437275087236928, 2.8242443729244147, 1.3403209159971772, 3.992006394069207, 3.9158557242520984, 4.207456626327456, 4.894263293677452, 1.5955335383623352, 4.1423580458772085, 2.8436080015559546, 3.719709321152921, 3.702860214510706, 0.7350383369808886, -0.5296523098482887, 3.4082907134417297, 3.168333144073839},
    {5.590350486463265, 5.547170415502309, 5.127838978977216, 5.667836869746659, -2.1063331531653517, 3.833827395004493, 5.56563124835619, 4.737966486573442, 5.567837740070393, 4.8830524218895075, 5.354098328767395, 5.19861448401272, 5.529349296641208, 5.018447611350939, 5.547816158899029, 5.932837650627051, 3.8341706814960332, 4.352867836418799, 2.213905958006118, 5.5203086173191345, 5.60313344978078, 5.750957638500833, 5.843779350735198, 3.052024614358135, 5.62061420536951, 3.4900577843551206, 5.181941551860687, 5.203007811936684, 4.147367521308793, -0.903711301955825, 5.4029541739258455, 5.5419049806216805},
    {5.538221949625758, 5.285741029442048, 4.969699400971975, 5.577109793726672, -2.083755101860083, 4.213464504062795, 5.327797298097046, 3.9589268426632573, 5.384558203941235, 4.7599699326143075, 5.07994562588301, 4.8096765463083555, 5.243816528960571, 4.888203905485908, 5.305092870612583, 5.7238802673673, 3.2209388370450154, 3.8204170933766637, 2.256392505621526, 5.532726827241846, 5.257557753323789, 5.445820699365151, 5.420054385315097, 3.5455096845324747, 5.264301619965805, 3.559609709208823, 4.818855145033267, 5.18100594002495, 4.014378096772561, -1.0797775434563204, 5.369464364205158, 5.544517852700115},
    {0.7487666551884659, -0.30791780131499674, -0.6886301010000357, 0.18754172207457961, -2.028345155837353, -1.3386401745562837, 0.007588151189179327, -0.3682001917800569, 0.25067250403451924, -2.9350151595487284, 0.7176946380615906, -0.35732307364419624, -0.3066004213283633, 0.9054081041887461, -0.07702472768339698, 0.45707138932780955, 0.34724942059051844, 1.5755830879635204, -0.9877434036486957, 0.19724281022255544, 0.4119401699050257, -0.3412898217617439, 1.2174642047738415, -1.930755636371152, 0.2473809412073139, -1.663743618867867, -0.27483083091536603, -0.14917772587308384, -0.46543776125399566, -2.6976828674916997, 1.0465165936198306, -0.21299530269591413},
    {0.19603854403527873, -0.33457079715489835, -0.6777181757434595, 1.218962812987209, -2.066807120106061, -2.7775178628630446, -0.27211193261036115, -1.9018049862210098, 0.3629521752573036, -2.641714784626597, 0.8562422651889976, 1.147847354332611, -1.1423863767083207, 0.5816038927083478, -0.022052436064734907, 0.3137138165445142, 0.06859815715399128, 1.1362915014979553, -1.6767737196106802, 0.866153361466272, 0.6097067010810383, -1.1288527188132595, 0.5255965408179187, -1.5599835519602057, -0.6772847267953261, -1.71144075011409, 0.957022830525968, 0.9542608000212619, -0.8907009150667996, -2.7488263144485336, 1.4383817101837242, 0.9117183054742625},
    {-1.750332291107789, -0.8055231007684013, -2.180409342861725, -1.7682970427177636, 4.525590956282543, -3.936601113354605, -1.1499472740764973, -3.476622975581494, -1.3254010060601615, -2.2042682363283315, -1.4642644679938084, -1.2070755805944888, -2.0702090925611616, -0.3197052735421063, -1.5201052467054175, -2.7248673868206534, -4.161450342775797, 1.6345894191470831, -1.6893128597283589, -2.373832751694269, -2.0998400444559873, -1.4111971223208406, -2.366147899427821, -2.598827960385914, -0.5726957418821951, -2.884784720249634, -2.1450931889444917, -1.4560213705485507, -0.8990844775516118, -1.5259510573945159, -2.0989187680116883, -0.9988497640094176},
    {0.19098306149287483, 1.460943106475601, -0.1356417065527092, 0.025756739329391046, 1.1715191066131694, -0.4762430338108537, 0.8035811722204231, -2.3006028833410554, 1.489359097437524, 1.4489623119968524, 0.06801221497319168, 0.13261860871272038, 0.5377773523637713, 0.4766907791591755, 1.1313174013967453, -0.24477705382696094, -3.285839424895116, 1.6313738420941908, -0.6012947738833357, 0.4452212710994523, -0.09843880469114244, 1.483199797089342, -0.1865999491852455, -0.1710399253222287, 1.014184178948024, -0.6973253912623387, -0.18699229185402877, 0.30067542834094574, 0.6267298554199594, -2.5273868793075702, -0.19927963121169623, 1.5591581898283313},
    {-1.417442237910864, -0.9044623153537784, 0.5189231288421137, 0.006394801784546818, 2.285290901517483, -1.0433651364016714, -1.1647464049185405, -1.1589319251067918, -2.4896518405910224, -2.5257379827911404, -1.5162545910698422, 0.9374070691501849, -2.2856775306363626, -1.7287022177947844, -1.4811568920295397, -1.6120409331603778, 0.7718270647009865, -0.023943601738304544, 0.9172327781045224, -1.797681337360771, -1.0996772255312648, -2.301525786789986, -1.3653414747979808, 0.20952990752271244, -1.3692979790895186, 0.3077303752343276, 0.037520302881200424, 0.06136421363515013, -0.7913529866724424, 0.9638484008436909, -0.5748482883846704, -1.2530949410346328},
    {-0.25985622181398094, 2.1545008864385697, 0.2875927764274503, 0.05325775221193457, 1.6565688688143103, -3.059377302717071, 0.275785916927956, -2.646069121970358, 0.9398381287240467, -1.4770093102556177, 1.2744619241163715, 0.2084986985133003, -0.3643536693446071, 1.9158628654564043, 1.5356404565951778, -0.2782969477975541, -1.7572563020746437, 0.8055201554519551, -3.849889703204371, -0.45175272001060524, -0.5908065684778306, 0.48006422127004317, -1.6149923924105063, -3.833136299944883, 1.1840552459094946, -3.9899878819193453, -1.2872213576549127, 0.08989538696664985, 3.364554707536601, -1.9927506806490975, 0.1414820313745773, 0.7803941232066308},
    {4.254320887449936, 3.6464616605992677, 2.207194931994971, 4.294887740352003, -0.38864849451764194, 0.22678748541309435, 3.2123025967739376, -1.6330632497150344, 3.944126251436632, 3.170667856411933, 3.366650102902658, 3.946583652466074, 3.6407974722966165, 0.4682400648118445, 4.133805067724588, 3.7067538909206332, 0.24691385810797056, -0.7728035093724409, -1.1062945403463538, 3.9484208549697724, 3.2165774200501787, 2.7354432048958386, 1.3669940390714197, 1.293835804746893, 2.24537642709254, 0.4515994138027332, 3.619761885940219, 4.040318034352585, 2.4017744883736825, -3.6493409882606973, 3.797555781055043, 4.551485733713806},
    {4.25668083527261, 4.3311542965051295, 2.546670346381707, 4.102379770332021, -3.92990615770438, 2.2945392813831753, 3.0136224337208533, -0.26711915270722436, 3.355437033398372, 4.148048279954764, 3.5643035168969197, 2.8806048227065615, 3.7485533643779796, 0.4431007381886551, 4.3258883636154115, 4.175217556173097, 2.5952583307835693, -3.181336966600619, -1.9084008101165553, 4.3958525005605855, 3.263702760090781, 2.9801379542639608, 1.501851078722634, 1.5866810139227705, 1.830455030910406, 0.5843191962821357, 3.8302342197283683, 3.0536536732978066, 3.209427239818054, -2.7617620811811516, 3.675234160355379, 4.817681497551087},
    {1.8799677491248454, 4.126283025354827, 0.6911433797257779, 2.4498746403765335, -0.4751200361331235, -2.4881168294410205, 1.1047058446307247, -3.3478201114632764, 3.0773314927141397, 1.0628080812774987, 2.574185632463968, 2.646488160380956, 1.2655580008824407, 1.3960334577346987, 3.838912732289402, 1.989035430653736, 0.7418444937980139, -1.8039497933494855, -4.110959876727132, 2.4752338335568025, 1.6754822660623079, 2.079364236326656, -1.4602492996317413, -2.9213587018747855, 1.2923104276020894, -4.1202411864561155, 1.2475423136775097, 1.950672237667907, 3.9539177369474316, -1.878285491467444, 1.9940320439452743, 3.7491571696388686},
    {4.90305810785752, 4.489343639524875, 2.81756131935771, 4.953447232692052, -0.5344579993283914, 2.326145686432624, 4.856268186071915, -0.7077561608748785, 4.098154563173584, 4.52864688309152, 4.22762818819815, 4.249782686345301, 4.756445103485024, 2.621381199452583, 4.547760083563446, 4.645854949206782, 0.21128485123522087, 0.0009932240705560883, -0.48188454013207754, 4.728160706335435, 4.420691011325254, 3.926753981694229, 2.922854442066063, 2.726006356708505, 3.7281791529153807, 0.7334781749814254, 4.197653301776848, 3.9582317372175755, 3.791478170747486, -4.39203327904085, 4.579086755837925, 4.788802732153223},
    {3.770887986868024, 4.116518953233647, 3.5512358627569487, 3.4655727735199027, 0.7194829890671879, 1.6689527895298684, 3.7729316842381984, 0.10706915894995768, 3.491706853346577, 3.9261489059011154, 3.079873397742317, 3.8536639315240464, 3.7568450741129356, 1.581623848950809, 3.846760545364938, 3.900352158546767, 0.5804590784262466, 0.5772571364388774, -1.188164086729745, 3.9185200200425183, 3.2246775694429175, 3.4268911137812053, 2.1022553872355783, 2.0696879686165697, 3.529382284012484, 0.7192674140863164, 3.2899672778899425, 3.8620665874143416, 3.7412720340431487, -2.107807909852753, 3.520879906481867, 3.9734062530158774},
    {2.069465254459603, 1.9173304836814633, 2.4689480891782756, 2.4406708090843945, -2.6429985755606373, 1.4305463419869606, 2.366416884077497, -0.29724274779505055, 1.4970109669040224, 1.6347853156846208, 1.7282898413507473, 2.134171253098446, 2.000768546573729, 0.3077570170419545, 1.6995025776055537, 2.4760453452962143, 1.8735556123763957, -1.7306737112485222, -0.3928250245406251, 1.8711090405881907, 2.037618810721293, 1.2941224305740298, 1.3847862992773268, 0.7297111290421203, 1.6624932309571028, -0.09322481793190028, 1.8067292488700957, 1.6113217929612482, 2.26127150709017, -0.7475422744400019, 1.4897429151262118, 1.4210294297723314},
    {0.5029649746725536, 0.0559716357831691, -1.2357013583169343, -0.2639956736944604, 0.1762193989700078, 2.425877718483307, 0.48016392741194425, -0.6767797759289645, -0.6877175700148149, 1.8450036333724638, -0.9802305776453389, -1.6656161896192034, 0.477678430570432, -0.8405321271350009, -0.6156905104250691, -0.7050950681164319, -2.49924611966074, -1.4451652487284972, 1.5609893689437289, -1.0520529151010583, 0.19923729311408736, -0.9339164291449783, -0.8132938062251632, 2.453825911838621, -0.11861169217770605, 1.8101994137412964, -0.19626645762603706, -1.2567071027139314, -0.8335768179760432, -0.9039345089873986, -0.9500335441036827, -0.2112986952087691},
    {1.770498813624542, 0.44951982613655267, 0.9823925373462478, 1.3361168978965576, -1.602224511220649, 2.814776221425266, 1.7867739770870519, -0.3129552657993267, 0.5591060704000299, 2.6167406641971347, 0.27624636058725327, -0.9216697635363742, 2.2905835048333647, -1.0182414874356813, 0.6230345884308686, 2.030656663831464, 0.00690248526996662, -3.012349026964018, 0.4411622936371413, 1.4038335066100647, 1.7697044579069465, 0.5990906320332895, 0.1656514088263404, 2.4564750866702876, -0.052092241829575114, 1.0483739152370064, 1.9609579722541834, 0.33055510439849134, 0.2252926738413545, -1.031518247419609, 0.34830611895207036, 0.7489693048575442},
    {2.162181519297668, 0.6533647714223965, -1.6264425065328896, 0.5535088006058251, -0.5668071368080946, 0.8667615554875632, 0.9663345360764806, -2.420218855482998, 1.0399944525243794, 3.3690204772837484, 0.01363651172724531, -0.9781653501997518, 2.146214793500545, -2.011261019142119, 0.7990045846169376, 0.7050165195411805, -3.487545205152786, -3.8629447428726436, -0.8521785459158403, 1.3667017405802178, 1.1376594768201267, 0.277855803759891, -0.8852947314394001, 1.501230380589903, -0.24751965914943944, -0.41410400253031815, 0.12041542790123123, 0.5841451559870836, -1.6762948018045885, -3.2248521316962706, -0.3980569684193439, 1.0963661407112995},
    {1.8961144308402906, 1.5569103324603473, 0.8411417622189528, 1.2947619663729708, -0.1275293329610935, 1.5529709044643967, 1.8709728917098105, -1.5801473401363497, 1.7692649252209283, 1.7213857448101886, 1.7151764052138054, 1.344310731492406, 2.7512825232938267, -0.41933543609874846, 1.7750362196919836, 2.200528816502514, -0.2671650097241935, -3.1918483743546546, 0.48824014754492767, 1.6108157022884542, 1.612225560644682, 0.912484246080365, 0.2391821399475542, 1.0553747417914483, 1.0481195005647463, -0.2724015697737545, 2.1975787551019565, 1.5543344234652474, 0.7449894194435164, -1.364172541944261, 0.26934626699350733, 0.9394311434004498},
    {-1.1462003148547009, -2.8089926818164015, -2.21664220420055, -2.191928843682757, 2.2817089759691025, -0.07478115505401839, -1.3547697897596476, -1.7649277116026867, -1.4259727022024429, -0.3279620263445837, -2.5100956720920626, -3.0595080823613774, -0.5662859777932737, -2.302526794022243, -2.4771060805125584, -1.5926292660723669, -3.811850140580397, -3.215216745062407, 0.6836990511364115, -1.9096653939127886, -1.3669454413793236, -1.9138125114497093, -1.5673703296690888, 0.9567892774956319, -1.3525510916018892, -0.8633361125358019, -1.677832225591551, -1.417436511089323, -3.5177717573100593, -1.8933319081914812, -2.8851305779006107, -2.9208365188112175},
    {1.0069628307278466, -1.5846151208800534, 0.2874277964198059, 1.0752825029910273, 2.364025629969473, 4.530505638651771, 1.0648620053304674, 2.465130775956389, -0.41356619898853986, 3.295740430863551, -0.9114409113326603, -0.09993830309175414, 1.9528797372597249, -1.7581359650434665, -1.3155664318953488, 1.060850266855332, -1.112409075836466, -0.6790755195738537, 4.751419999679557, 0.39883430797743197, 1.151792840680293, 0.47935852989295913, 1.1529352551933574, 5.107924815697176, 0.46065908139164313, 4.857787961738634, 1.1815157778085361, 0.9057131843410009, -2.818986574596936, 1.2879925258201408, 0.11418198818168647, -0.961875303116427},
    {-2.8300333814260528, -4.057893488046662, -2.520069031425357, -3.083023014303069, 2.795302190017084, 2.720461952715937, -2.1035673140796622, 1.1901890844598288, -3.8850904060692275, -0.2846562878103263, -3.947440202757075, -3.3228276812645707, -1.9527473967173827, -2.658106421183394, -4.304456922193679, -2.324956293130677, -2.765363670131458, -1.6275066971981997, 3.831180073585828, -3.255155520053636, -2.956569991300749, -3.3893159251115006, -1.496562086231932, 3.9303043918469105, -2.6364687720394673, 3.804773757974405, -1.3490303676072815, -2.727244280951105, -4.363707932649796, 2.1745650908656065, -3.6086403955768818, -4.154952803344744},
    {-2.4759657360731397, -3.3704826166505826, -3.5032165374172495, -3.596005396388286, 2.5949938574655014, 1.1490950847282677, -2.5471795199883656, -2.2643287520868194, -3.113457515124535, 0.34407569868293325, -3.857193895920908, -4.013369050773298, -1.6049470506258017, -3.6962167696087382, -3.500692351065382, -3.2162657429482997, -4.353012310328047, -4.1989650252700255, 0.9368174113078699, -3.2586708866755685, -2.84309624895431, -2.9905718547313755, -3.4388950640109512, 3.0780027054836, -3.0703519849601415, 1.3340148864856423, -1.9276247658513022, -2.311495227289578, -4.00093532069876, 0.5882216652261443, -3.8562551503970655, -3.5329984825034733},
    {-0.7586418414500499, -1.269882229233427, -0.5133050616578727, -0.13989376258172775, -0.38180390882109, 3.53033743967852, 0.28362351416627907, 1.9969714943201067, -0.10978424882652789, 1.659308055325123, -0.6970171016811305, -1.4427107520653533, 0.9041111953712776, 0.37515931299863936, -1.8417378809272302, 0.3666502712650488, 0.15990318999541686, -1.4645024155103172, 3.1502832553270084, -1.0448372906421988, -0.30796907402773366, -0.32370463637124036, 0.9664161696905545, 2.8987444819650294, 0.430831338320731, 3.225988089941383, 0.24880014289177357, 0.3266181615474903, -1.7845339521636114, 0.7437375987534505, -1.4178703727880022, -1.557594574449364},
    {1.034939304409497, -0.9486824380760732, 0.3056499115125501, 1.1317680271417836, 0.5727291097720386, 3.608326261837019, 1.4489273980056296, 0.8363024446788988, -0.5456665005266025, 2.9926162552078583, -0.9402431655231653, -0.8062879127943273, 1.8144805533341584, -2.1367224928163986, -0.7612291344023518, 1.4685728020956001, -2.0264991034414517, -2.2061548901530847, 3.1477822337355414, 0.25973928077027275, 0.5794473448431764, 0.2403202098257267, 0.6921433827765469, 4.685563304489707, 0.563346918907374, 3.9321904863029116, 2.052526294245024, 1.395479866174721, -2.9340292489439235, -1.584811462108821, -0.17402077167011873, 0.012140661421551317},
    {1.5463784009076056, 0.3117777498156812, 0.7706298363491411, 2.3142048318000468, -1.4363634530478, 2.1736758308286497, 1.862626592962379, 0.5341387342887567, 1.686269230857388, 1.832487853818655, 0.8975114134542818, 1.0084605847941985, 1.8756865590729148, -0.6605870698645253, 1.0952314482751668, 2.4936224757793974, -0.42863737808826735, -2.2739051630380374, 0.8615011535749578, 1.6594563865268979, 1.6442799009803486, 1.670513311534315, 1.8236021986690145, 2.6011809715834744, 1.567901806134611, 2.3263837444928708, 2.149537743290308, 2.5253459324244907, -0.5957929759934179, -2.108279013399342, 0.869269180823068, 1.3498507986113892},
    {-4.1280971580850006, -4.311790645507, -5.1169692216514955, -4.897867190761398, 0.3488680467027292, 2.02335968877075, -4.535994600864688, 1.2449712670243807, -4.966428056397622, 2.060117737848831, -5.07945854158005, -5.047975020146758, -4.305497560923842, -2.9864475323789406, -5.089455614911585, -4.514527109346346, -0.8136067090463778, -0.48573498686103816, 2.380365519249257, -5.184055090997044, -4.95760515761083, -4.809255512462665, -4.663872545575956, 2.482683596091006, -5.112670582857024, 2.4177639682463625, -4.6821320744347386, -5.247274848933147, -2.832242561029762, 1.8227673731778156, -3.924587474334098, -3.7909275316622812},
    {-3.7272934315310406, -3.8849380659346417, -4.0818458928840045, -4.40473800254169, 0.50998041045238, 2.499156346251366, -4.5415997393588405, 0.8602487959107535, -4.702110060590469, 0.7744046074794262, -4.890010966241111, -4.2662783498071635, -4.591833098113417, -3.79202317192139, -4.597489289422023, -4.4653954801348235, -0.6341470313814347, -0.2134378880353055, 3.4670725306962225, -4.836923575192452, -4.6226338915252425, -4.585209516841166, -4.045499164224923, 3.4746037478965475, -5.047049957137565, 3.3473002494716484, -4.0186093616114755, -4.372706476973716, -4.055687073093624, 2.559152693114441, -2.9534848653585444, -4.041408816961166},
    {-3.222125531814981, -2.399498617675995, -2.371858359169342, -2.780179325049454, 1.5622641457439066, 2.2449727979517613, -3.8737309565939353, 2.1690706643642406, -3.439737521258346, 1.3195574006449873, -3.721594706076656, -2.386011449102545, -3.2606086345603678, -1.336355760777188, -3.1416431924360393, -2.957299091423598, 0.532418113829696, 1.5247405431180034, 2.748559122684672, -3.806297081728247, -3.381113385483921, -3.0765348212760064, -3.4752660409513325, 2.416022200009456, -3.7722328235806737, 2.840699527083114, -3.2982457154249207, -3.6232808605480256, -0.7452841019711713, 3.384748179514902, -1.6215368682545166, -2.2633551492185395},
    {-3.2639585674457807, -2.6919144177154624, -2.149848495780097, -2.240646700361656, 1.8465540829440021, 1.8983346653188624, -3.4577006855867576, 2.2718547457195566, -3.3458364677027332, 0.6062927197128207, -3.0584903744122265, -2.468297487753296, -3.5829495146364216, -1.3466118919223267, -3.2529987404142795, -2.2937067738367953, 1.2535431864499225, 1.459373298222266, 2.5912112359899604, -3.054348780274896, -3.874236047976229, -2.511698421187217, -2.4811277933408196, 2.292985486396168, -3.3108715638388473, 2.2083224230334304, -2.7344384036500013, -2.7424420671126843, -0.8399786010343268, 3.5342177272676687, -1.904393496103226, -2.2401341383709026},
    {-2.440872473305348, -2.2695353540576546, -0.5584468248028431, -2.344141790632813, 1.8954624518763543, 2.4583395651789357, -2.523354232391199, 1.9960811931276239, -3.010779146572926, 1.3821895340156367, -2.2049614936513615, -2.2620006466817744, -2.8797972472424562, -0.5582039027629132, -2.625177338844252, -1.396237238809086, 0.4167101075930949, 2.0367853849541837, 3.692294818877579, -2.987968385626501, -2.6623731693146016, -1.4841801281844773, -1.7895530773154142, 2.7533451988782627, -2.061473899464256, 3.4441784533697755, -2.129747800489388, -3.2273457330939364, -0.6106914528674943, 3.3662319861256047, -1.0409154071267284, -1.372824721530469},
    {-2.384772763488269, -2.2888210847626036, -0.15086466198338624, -1.4100467232343727, 2.9051017471589815, 1.8193270610524945, -1.8810597956738515, 3.0636593678152293, -2.7451154321905085, 1.792465109749334, -2.5778743241886333, -1.7662259921386108, -2.6587361018485205, -2.060514594379136, -2.1185718822086304, -1.8190505277849383, -0.22481059544391915, 2.785173738121365, 3.8247800416901696, -2.5395889061960166, -2.465336346942705, -1.334746422690982, -1.186078897901941, 3.1296714627346667, -1.8570805081276394, 2.847766778213276, -1.8728956914800285, -2.231010650219833, -2.205999294139077, 3.6019201213174057, -0.3343310298388592, -1.181599376413554},
    {-1.7703365232620294, -1.2050299878235409, 0.4419064999501982, 0.30113815650319686, -0.07652533176587843, 2.0469710451152197, -0.4693190323549078, 1.547054454017806, -1.1146464804078997, 0.7608922744195443, -1.5195063102503608, -0.7046159794446776, -1.4471230916906208, -0.6936279195839882, -1.3087711144401395, -0.15948206053842953, 1.2147940417598182, 0.26955889522144194, 2.2659800783242114, -1.2299209412103758, -1.9662927669620818, -1.2186578553090754, 0.31529086819620494, 1.3588724413324114, -1.78006032142304, 2.2961882309892125, -0.17979857867504875, -0.07930702307696832, 0.007268982370835933, 3.402992723097412, 0.0754374723748854, -0.3552030594080702},
    {0.6457784768038751, 0.743254686801878, 0.11826519037938557, 0.11868148189521001, -1.6969911584159485, 2.110882526101704, -1.2381578004655747, 2.653025685028053, -0.617674336212588, 1.50432392324921, -0.20520066793111263, 0.28037363545520655, -0.4303786055943643, -1.8456167775342687, -0.24425458681638276, 1.107273070967376, 0.9126034526478098, -1.400588203465527, 2.396063428278403, -0.06463850879944157, -0.942596133284219, 0.5235997943746104, -0.48467348711105296, 1.9095408652831567, -0.2478244750639488, 1.4272878774131472, -1.0440817781753822, 0.583821285487233, 0.17411856874671233, 1.6507597932480864, -0.5394208770933281, -0.42246020540832646},
    {-1.0884589110443892, -2.2074017955258625, -1.7688619478118237, -0.2892458738044335, -0.7709521133718829, 1.9338399977256802, -1.6618418332774585, 1.8078499636785896, -1.6806382160701727, 1.8475934593524033, -1.233071439449896, -0.2467404207875467, -1.3645210697285148, -2.612248491185256, -1.6370730778760219, -0.29303012190175687, 0.21766939546498987, -0.594548478489909, 2.9073048651616875, -0.36126903257359955, -1.0030253751365452, -1.5778831615020739, -1.0631130250335334, 1.9632290434217305, -2.2083824899692432, 1.3959928021277987, -1.3003989559654632, -1.2216930199339733, -1.720642502540711, 1.742836896431628, 0.06990715433015113, -0.3691944338985534},
    {-0.41172490352486, -1.130982645280743, -1.4750742799451624, 0.015036659646795614, 0.8386566954480078, 0.28894879798972756, -0.5483624938484782, 0.5032501796253596, -1.6537770271960046, -1.0178337358236187, -1.8543395762158752, -0.2470170212271378, -1.124245933632003, -1.370208768985221, -1.12501833156103, -1.1144563202150661, -0.018306191004037246, -0.9802109788194437, 0.6059526059713282, -0.6972430123637419, -0.6887964539797916, -0.9932680044230151, -0.4137833135681424, 1.5362829165853722, -1.217199653015757, 0.35975417009224914, -1.2445230856387202, -1.2052660424236559, -1.168795500542349, 1.1949219512585647, -1.1456447123858609, -1.0824590916569277},
    {-1.4374136321737077, -0.46452157051709636, 0.6143696723849672, -0.7289164520273568, 2.6413119695075764, 1.044399512178281, -1.6985071834824972, 1.9217132320333703, -1.9698029408459656, -0.7922956734135373, -1.8637730292740529, -0.7200320618572349, -1.8333514079582216, -1.9617337859849133, -1.1678459502003267, -1.3712574933280777, 0.7339018431832899, -0.11079072286881823, 0.6276234004618876, -1.4109146170533358, -0.6441476499486136, -1.465808887794209, -1.5056882647098424, 1.1168964604592928, -1.808560254636766, 1.851308855523701, -1.6288122231062652, -2.038681457755633, -0.6911739765355204, 2.7039657823156156, 0.057509399550168164, -1.4339924790837977},
    {-1.074680094793845, -0.23856062585660506, -0.663306570500029, -1.2294655828630758, 1.4989697304075251, 0.8283973083855861, -0.8938651811517436, -1.266239692462066, -0.3437689296618223, -0.8739564392099308, -0.8358592693058915, 0.15785813193019385, -0.6831504689290785, -1.098555902590274, -0.6735131321904415, -0.7434110316829359, -0.23704623993751472, 0.4307678208330568, -0.019126776326001824, -0.3712860018665458, -0.54876281529677, 0.4032525012634707, -0.6097963260271008, 0.8461346638031781, -0.2860174285310019, -1.2412664443694343, -1.160378536312858, -0.726336241414873, -0.6359513603211379, 0.2633343979195023, -1.5569788917770973, -0.4262619665618023},
    {1.050955186115638, -0.12527138503111127, 0.7144902149437278, 1.3107514253870602, -0.10595905060289477, 0.44078187694806725, -0.7043380348122193, 0.8129955367204326, -0.24264795943802692, 0.21355306389973946, -0.22033989827078035, 1.1292083419146863, -0.5293683634601498, -2.2493374784760034, 0.20814144010809596, 0.39843636479723826, 1.0747216819588785, -0.8227642864092863, 0.4464439831893514, 0.4529934188800497, 0.913617273309505, -0.21107714270722325, 0.05712135701638687, 2.10456871703039, -0.7772023938121246, 1.4629210341865733, 0.3173691403701715, 1.3457600957290632, -1.6543539267181149, 0.6030687752256608, 0.5960686858339428, -0.14398779376866527},
    {-0.8005222736449292, -1.0122404504983633, -0.7733495697400969, -0.6252120964211225, -1.1157775803449765, 0.26196083159146494, -0.9197368805282952, -0.9184356202472707, 0.11067378976449822, 0.17115274520121518, -1.3369614652213941, -0.2827793450589494, -1.0019561282046339, -0.6808295035089296, -1.0376128354509448, -0.5498108333032841, -0.603642240754061, -1.3574101675230688, -0.22538973329467643, -0.6888403905395176, -0.8662589441798223, -1.005180753198996, -1.5350168669843074, 0.34419246575176543, -1.2942484019220033, -0.4312273882992966, -0.35814548164188187, -0.21169924333325651, 0.18236581861292625, 0.8985238865312158, -0.8741432456142634, -0.5216531048026776},
    {0.6722669228064146, -0.08536553282840584, -0.6865643150487939, 0.815090465837924, 1.3658492914317517, -0.041390220162117214, 0.05221871585300362, 0.759709071649518, 0.4452050592665926, -1.643723758275315, -0.18302608870362755, 0.4374422432124477, 0.04215295185936952, -0.8422669238706175, -0.04436928861539843, -0.5176510248847899, -0.3588543316306377, 1.2987460196869842, 0.5878732450452897, -0.13782757758456463, 0.10404026135499332, 0.08748929261271172, 0.23736470786084787, 0.5808981823896822, -0.2713976950616809, 0.8675305329262453, 0.36361092776727955, 0.49235490449858543, 0.5358869722440145, 1.2795245996000875, 0.5641608890050114, 0.17109244583490424},
    {-0.2972463807113388, -1.8522202830502348, -1.8362904695503721, -0.3545208699114269, 1.2632711848184899, -0.24309304586782807, -0.16345491085320146, -0.9310962245652101, -1.1756027033344338, -0.7359628924741237, -1.3922698126726754, -0.5600615720693444, -0.05504887464681818, -1.3459669945075643, -0.9689829950299074, -0.7483139775123361, -0.950859520967047, -0.5925008729765405, 2.2370363852098993, -0.5919269447928422, 0.5873588129714166, -1.8534549672974896, -0.3829466814522492, 1.2862103684983468, -0.4251079991833221, 0.6665739855140889, -0.27587317127225375, 0.6032341080165216, -0.47576922237257174, -0.24195488067315787, -1.5440068587817697, -1.6209090154009773},
    {-0.04030505991958618, -0.9696360496136224, -0.9296342138808986, -0.25834159357255965, 0.47628561403171715, 0.22569019320741127, -0.8571163061424234, 0.029068829636102484, -0.8598458394082332, -1.7489773095042302, -0.9150103215921653, -0.2502216775669238, -0.0592448397782851, 1.0774306333977997, -0.6054789371931839, -0.21122558073366637, 0.3744148335067441, 2.4292728130872376, 1.8033335724170065, -0.26935278247121486, -0.6568445223048623, 0.14915143519190688, -0.9750154857925468, 0.2559699985723417, -1.2199770590543648, 0.9052871127493456, -0.8391977296922396, -0.050855286795105994, 0.5542528312675408, 0.893560848408502, -0.9482678823386084, -0.34506047948156177},
    {0.18962842076994987, -0.8543201925539277, -0.09300687123545785, 0.6378387707494967, 0.657893879647198, 0.804675516343776, 0.16755856774888991, 0.9624435691912572, 0.22095053797641523, -1.2022985089560192, -0.2791789694897365, 0.09664782191983566, 0.15256896068547066, -1.1742950279659843, -0.15060673278091077, -0.021282592128023463, 1.5139900384626652, 2.2495429614437263, 1.594099042619923, 0.1208712990270681, 0.5150547526595322, 0.18676713347041923, -0.13919847613623154, -0.5183887655153534, 0.19378019038640407, 0.8103915026828463, -0.43196945055707175, 0.12041350410691624, -0.014462871675905544, 2.71557979541335, -0.6013213260650728, -0.8560800241812171},
    {0.14079869340267182, -0.3894577698375508, -0.5919292048839693, 0.3169507544723809, 0.8048947170510988, -0.8451242902316106, -0.8791278447439735, 1.697679603323701, -0.5474766922361468, -2.1335218628680823, -0.8823776957023934, 0.7228418502916466, -0.5188456530030519, 0.590559224689529, 0.19539912634513143, 0.007306853586749555, 1.5167369213077158, 2.745666940990583, 1.9652441250744002, -0.20347010058164025, -0.4877865751145489, -0.04431091655575468, -0.16814124229691343, -0.4959646305055018, -0.5999039243646014, 0.34540008362131647, -1.5712650106165587, -1.07582804903864, 0.42750259422369696, 1.7849685405591469, 0.2507202219942003, 0.5466430519405355},
    {-0.527022309329417, 0.31461301137264486, 0.46708139891572503, 0.4078785365002673, 0.9573821545901895, -0.20665011991270055, 0.14792708977916713, 0.21560188469437708, -0.9947262554318256, -2.8068896515613275, -0.699164134855023, 1.2130140762862147, -0.8415644974069386, -1.6051996578613223, 0.2898961128321141, 0.5208210476652622, 1.4626293136366841, 1.179927696467184, 1.0264815536389749, -0.23696205555580438, 0.18242918381376746, 0.7700146276310997, 0.6833397738401629, -0.37926969286657225, 0.556610317680542, 0.555557044952409, -0.10954035031943828, -0.47637960846138905, 0.652123489934268, 1.7306633963060596, 0.38323210582561673, -0.41639314690900814},
    {0.5902125638182261, 0.15543422339371074, 1.9135759458102777, 0.8647949272825692, 1.0152405464251761, 1.2681861145333675, 0.6845657640544155, 0.6174481664157097, -0.19144143473199843, -1.089767800181578, 1.2144198894818212, 1.5213163347773375, -0.1965583321274001, 0.7302434394633747, 1.2500444637950392, 0.03776485593147831, 2.530561110700427, 2.921359285048969, 1.6626217958333764, -0.44855398408758607, 0.4340202067993173, 1.1488446071920082, 0.6454203703911412, 0.5956412302924693, 0.7269408825352499, 1.8286168343118032, 0.28413767218574654, 0.2789765955202903, 0.07768526139182025, 1.9387367816173546, 1.6062182314656472, 0.5468752098549556},
    {0.8451160647585133, -0.013403146229909216, 1.2893624341089327, 1.3812595560757692, 1.137330476480227, 0.9157075988669328, 0.6622988035632694, 1.3035259524292289, -0.11782761704924434, -0.6916849763780881, 0.6446643239706101, 0.8139659478270427, 0.4763076275498494, -0.33595740288349635, 0.7286230294036418, 1.181488038230453, 1.0913576863051744, 2.126743148583067, 1.3369484376565595, -0.18839819113223352, -0.26727710126390664, 0.8496506127860639, 1.2252567562691508, 0.17031407628605932, 1.0519575436815962, 0.7392027272853204, 0.6719250415114303, -0.3440648480713488, -1.2285408327484229, 0.45645436249382587, 1.6468308618591243, 0.7748861944945974},
    {0.3942453923314975, 0.559725143354886, 0.23494922295358295, 0.6056007352197139, 0.9383141608295414, 0.44905331758281075, -0.17316993053547505, 0.36449956141347506, 0.3807276464880701, 0.07969087608635876, 0.21074324527873792, 0.8253883991212602, 0.05933315650227823, 0.31874286328426, 0.4481935623559763, 0.09573427621231605, 1.3559582352634312, 3.1803446023885895, 0.7334426202761102, 0.4242933728511713, -1.086365712010404, 0.2719143271981783, 0.5973266077806602, 1.7621228144369985, -0.7964943524101885, 0.9221929620351014, 0.11544549854249724, 0.7483138814523259, 0.741900750031714, 1.724966102304869, 0.44603386191006006, 0.330088260003026},
    {-0.3006910726381915, 0.14634694855072494, -0.351226943315244, 0.536681776503842, 1.9456437104543096, -0.8176589380186021, 0.5628974160886131, -1.0412044437682462, -0.1531675220956943, 0.31827059132825786, -0.06631032950169222, 1.5803843870773688, -0.3432358779865357, 0.535742590048729, 0.38416495970957254, 1.120519029272325, -0.16181826846962938, 1.627389105091166, 0.8496968004391493, -0.13961214733554517, 0.025582165605424822, -0.6789215993662692, -0.8435101847570259, -0.4579545374547898, -0.8081918880994989, 0.644259766662665, 0.7170705800818451, 1.4454375715383505, -0.8062276621445624, 0.2129273827751777, 1.3908672720406356, 0.42345136090047986},
    {0.9795039633835461, 0.45378784831460267, -0.0959146285369753, 0.7841822641580594, -0.41225408225335897, 0.0994057269682387, 1.571207208990223, -1.156845671529248, 0.3372427362068282, 0.04217817693669202, 0.914398625974703, 1.5561038992437577, 0.08801855635130569, 0.2566623539715155, 0.7041270417923544, 0.5542709208773435, 1.3988961307194914, 0.7784686744922338, -0.4153461684126414, 0.7351970086398798, 0.40393051179946815, 0.22459621246164366, 0.9291052357037786, -0.17772281513292887, 0.03465131524455611, 1.5945147980206518, 1.391431685162142, 1.0458000646804582, -0.8709181836218869, -0.7628463727830761, 1.430785426918146, 1.0246180630709036},
    {0.897306997046954, 0.213998360402182, -0.7286913251160542, -0.16978776839114282, 0.6025065162147841, -0.4733668284420175, 0.27528150464815, -0.3240650641601949, 0.6590239472395277, 0.7660607860153666, 0.2120090596600927, 0.5876733353384866, 1.023573253499122, -0.0824015876456986, -0.0826758559147215, 0.9902415648721582, 0.06784730428863821, 0.5814082993564984, 1.577601510800145, -0.10890064096550363, -0.608213158802731, 0.6935183312538301, 1.3319783463646024, 0.8353092301454716, 0.735516377470467, -0.8463329458687884, -0.3510091130573864, 1.511025403047812, -1.6372329106735777, -0.12796244194555428, 0.27668333734639716, -0.4042884663301571},
    {-0.45722260459629216, -0.9723016120442781, -0.04374700446704907, 0.8458587448777322, 1.051776165676179, -0.2328982895261865, -0.8317408287051327, 0.4393792886307321, -0.7802826482940808, -1.0084686278389394, -1.0216875999043786, -0.44372019762002635, 0.4906691256106178, -1.0787110758362808, -0.15671917626186377, -0.327083321581019, -0.13600867185886326, -0.8888333501162119, 1.6225211009995746, -0.5796117757431779, -0.31563096418754055, -0.8667160974317432, -0.9335065809564376, 1.4590180272007116, 0.09002296253267868, 1.046010426146367, 0.9091039089237075, 0.6724726022280101, -0.9329264205653137, 0.3467613567492492, 0.2725449856346279, 0.5251535944306973},
    {0.3911340773316344, 0.07736489199265123, 0.4616692525283016, 1.3707925142374675, 0.8709102551450921, 0.8520477865682163, 0.1040702194157687, -0.9102802875702887, -0.6149987938421764, 1.0657008207340606, -0.3199102776236793, 0.29620721631869457, 0.7242728307221331, -0.9097886775798186, 0.6375180379212109, 0.4084533642390248, -0.7653308153815258, -0.7005492908187185, 0.49502368060466895, 0.7076034718913048, 0.7006532405936259, 0.3627946964240557, 0.9272069171353267, 0.949867662594903, -0.2406890553696454, 1.1428149958330927, 1.3583090521533174, -0.055514441278724694, -0.5722780250161301, 1.0338005216932573, -0.3395148009962188, 1.4257135289428922},
    {0.41407819817391195, -1.19722520807513, 0.28097402067522764, 1.136679380357703, 0.5404875280342026, 0.4995107960382725, 0.05600447310908151, 0.92765767558613, -0.6240062734410884, 0.3186325665950513, -0.5771479390162799, 0.9422237559749245, 0.40885427617727627, -1.064472804576151, -0.2092696496163365, 0.13561422600584236, 0.029982859774089456, 1.484385174217638, 0.8340494888935288, 0.007414139638150847, 0.4598931392415157, -1.0894742398874906, -0.7540712030783289, 2.317349571351378, -1.0865432290329293, 0.7821122222934441, 0.5547604376026032, 1.3357764679722322, -0.9182617790968456, 0.45930280916642474, 0.7077737844425207, 0.4785494837916053},
    {1.067650679963173, 0.5209563910332761, 0.1297839884334018, 0.6376771717429972, -1.2929184954696193, 0.024306481889494018, 1.0991114834350646, 0.1229858186575845, 1.253457837658873, 1.0054716423300278, 1.1814129374539177, 1.2096479000912876, 0.3470920624302544, 1.3984069649900035, 0.6788110215194055, 0.8597154828882735, 0.387552041602927, 0.12795969784135156, 1.9914738694710086, 0.8833643115918278, 0.21672505332105552, 0.6569880699213407, 1.3616756758779536, 0.4662883018856943, 0.5829298601671317, 0.09470930128570913, 1.60894320208297, 1.7969153204737078, -0.515879074563134, 0.2826786914766924, 1.1607202577270974, 1.2406682246891136},
    {0.3863591812323673, 1.1583599001516731, 1.1791740735969574, 0.6513338919467548, -0.08997756302215253, -0.36205976476205737, 0.48369059439085177, -1.3004016788623345, 0.5224207165799465, -0.6955697401668751, 1.0329846664557492, 0.16097603796451432, 0.40183737007700293, -0.004968984609517173, 0.668291924274685, 0.932103771464177, -0.9295346707513562, -0.6193624458343711, -1.460093363608826, 0.955330120192556, 1.1728746586900591, 0.5460946597034227, 0.6262485427760434, -0.7873957710671573, 0.20869226355976245, -0.8091520985040015, 0.14928009068509845, 0.03621668139011057, 0.5869099661802356, -1.4422347493791599, -0.16435569338368228, 0.22591551903367973},
    {-0.09672752214091797, -0.5088349580869519, 0.24470838328796277, -0.6718329858828811, 0.5468492972374555, 1.1719281361126637, 0.4776840457842602, 1.5345554329814464, -0.0008616136577113016, 1.0292152894017566, 0.4066354548081161, -0.6108891195687988, -0.5960112914051997, 1.491502143954037, -0.17088978593602686, -0.3050957254379449, 0.6016244999089351, 0.06335075602851441, 1.164070421360462, 0.06179790091479831, -0.794774305061147, 0.8973396772400858, 0.6501355493712625, 0.4118907837113604, -0.3106129835846527, 0.9145539198061838, 0.6767357239031522, 0.07363835592541931, -0.19467006264106465, 0.35583102607642614, 0.1656252497118709, 0.1464312606484054},
    {0.21997761710929017, 0.1439077880739536, -0.8896582292084683, -0.02093744746794475, -0.09100640759111757, -0.44999545224562787, 0.004329873900761112, 0.8189754091207746, -0.670811017267155, -0.536273006880153, -0.1590476911078745, 0.2826465099623712, -0.2747990504648781, 1.0745548393744764, 0.12767652775580185, -1.0631566344858012, 0.025060316782476656, -0.41399031365721706, 0.7543423863633091, 0.02427066077746435, -1.2619256238431846, -0.6107734708478604, -0.11418376270945779, 0.38143716711439707, -0.15401661202766787, -0.4134700107275138, -0.44039164081985177, -0.43746285191084167, -1.177813644320117, 0.11226577761578853, -0.2010034689432107, -0.20914475750472847},
    {0.7676961788899614, 0.3728131438287634, -0.3971305545956156, 0.6462222298757296, -1.4642711171333544, 0.5042919550427476, 0.33568124646010955, 0.4984727124894457, -0.12993074836964763, 0.6506577854035199, -0.1253681785978371, 0.2347972603773976, 0.7863167022330627, -0.6637145771121, 0.09830826013024983, -0.5195111749889175, 0.11603825567936084, -1.1869856906570393, 0.806991206986624, 0.6471556307052084, -0.32259178586892995, -1.1619644642989904, 0.25357450983509894, 0.1549016788284646, 0.3508188585713245, 0.5764661988474825, -0.6376522514882942, 0.39066301858249064, -0.522832478840275, 0.938270877783883, -0.22337665000789927, -0.1475118600907302},
    {-0.5141727422905507, -0.6902026156067157, -1.3238234988172946, 0.37648803628474564, -1.5774439183573692, -1.2680355515234791, 0.07347789105197038, -1.4054274181761721, 0.17948226721818977, -0.29767412594251524, 0.48462960286906154, 0.19384526236937016, 0.8197320884354758, -1.5642928313225444, -0.04457013962261427, -0.09431398254234849, -0.47142283689349634, 0.435463904139774, -0.7066275042044002, 0.11939819642596868, 0.26102778050436276, -0.00100073006986673, 0.07875724790060655, -1.3201191570353086, -0.488641810540551, -0.9313209901879748, -0.8281846020095719, 0.5967234675305925, 0.12027350424606635, 0.29942544524919507, -0.7126029812525924, -0.32803176168204895},
    {0.3419444973152442, 0.14124930017630333, -0.4254499704303955, -0.10818293838999614, -0.28088509021580427, -0.500679659157961, 0.2510404830914332, -1.044836048841028, 0.3505737001771574, -0.6255391517364862, 0.8959484030764122, 0.6846931711520329, 0.17369454478362137, -1.2119549416205997, 0.043227346129150676, 1.0337911504750525, 0.6977543880869803, 0.9270117860325049, -0.1973086403849339, -0.31546453557256415, 0.9704446386573135, 1.3309862325263067, -0.16103896693532008, 0.09832846690754748, -0.31214140061647166, -0.19049609000500783, -0.4514346946842588, 0.19816016214029183, 0.45399785293013895, -0.2000624511048836, 1.011682714502367, 0.2613861475081356},
    {-0.0951652711936267, -0.30993437547285685, -0.5848090846270259, -0.4121386326011645, 0.8046648419296754, -0.11736057909108284, -0.7350316936605666, -0.25424850865071175, 0.071794961890402, 0.3681991158788155, -0.024603594324268657, -0.15220990675986074, -0.8233205662486819, -0.150335188674501, -0.03777450212503474, 0.6220757354801654, 0.6039030862856292, 1.0022490134653734, 0.3706877640653449, -0.8893997053398094, 0.8765642337429613, -0.028486707682075983, -0.9069159557676968, -0.10643545723424415, -0.10548611190151487, 0.614949931922063, 0.13877261094324805, -0.0015760871534766239, 1.2474133249047172, 0.17249024828906565, 0.7257206463520245, -0.3688122758047862},
    {-1.0336143632819101, -1.3299034889568293, -0.717099342898761, -0.29062056402896497, -0.3371168954888331, -0.7718265822231565, -1.3981083389802036, 0.39241689341417685, -0.857734221793051, 0.031042722784917744, -1.117325262692018, -0.3845058057309877, -0.5880695705725455, -1.067131379811342, -0.4120683363857634, -0.6984914910721058, -1.4198171946640081, -0.4641475382039263, -0.41219577586870254, -1.0837004774874668, -0.25567951927553956, -1.7239973076741928, -1.0588115594335852, -0.0669450477532866, -0.8101558980740449, 0.10597737600013546, -0.4353038591170368, -1.1600846089581989, 0.08518419023563116, -0.9244562832202108, -0.22901404732021813, -1.010949268592699},
    {-0.2324676552500935, -0.4844822994950341, 0.8684379231860517, 1.1144467274764658, -0.48141445982024456, 0.4261199212571707, -0.07892422331342536, 0.9128982361663277, 0.05986430141819716, 1.1045372620538276, -0.27727692864286385, 0.019407918554146888, 0.7249692032953953, -0.6909110662248718, 0.3735680393333081, 0.5289615328936177, -0.4650862739576834, 0.5954647815387962, -0.34404013748438994, -0.309688608106396, 0.15936198629520068, -0.33315427761412275, -0.4458044643157211, 1.042275602949133, 0.2571387015863588, -0.5657513814067123, 0.8179865437986423, 0.3009039452447781, 0.8581743026122893, 0.4089890116784291, 0.3761150352764136, 0.6792677489050837},
    {-0.06066148364342408, -0.43624484890782406, 0.032324560337738506, -0.31613414523622374, -0.6297841205061014, -0.4722098233877519, -0.11940971384557615, -0.19711326083725492, -0.08842558835949015, 0.4275385695567478, -0.45269291018352104, -0.4877791138467931, -0.031816026018382786, 0.3353395549770803, 0.23751078757849697, 0.2794075710382827, 0.2525982424967894, -0.11944285427527401, -0.22321407215004882, -0.7347138576561848, -1.418769074733953, -0.1825455571923541, -0.47331375938574916, 0.5239341407416306, -0.7254278922456798, -1.6048364944484907, 0.18295534846299727, 0.19346939129850613, -1.1402104421761792, -0.007745423170989592, -0.24912321813285995, 0.11484215146717419},
    {-0.15691792404980257, -0.3355804258784871, -0.023700924697570427, -0.5740883912769197, 1.0728807067797597, -0.7545980224360391, -0.2905417130570816, 0.8386947359699322, -0.7379689325794534, 0.40542596573265954, -0.9048821684168586, -0.9094904017321132, -0.1385251896618992, 0.15257730211874104, -0.03067105497537146, 0.33181995887842597, -0.07466493534094598, -0.8808602194497998, 1.0627131612507603, 0.006169019136401946, -0.5436904480605121, -0.018814134303217066, -0.16804094711917958, 0.028891091841692387, -1.1285924469578765, 0.6269390291101451, -0.5132829726524749, -0.14199419778569597, -1.8153484178831074, 0.5436324245321742, -0.0016114386742168225, -0.32343514217635333},
    {-0.24252724495634043, 0.25338645991593484, 0.4052378870858619, -0.8195290461640613, 1.3341730755659515, 0.9511880231399945, -0.35489249423789987, 0.045617054854387704, -0.45524855742782555, -0.3086649955983667, -0.4952781830859019, -0.18292887203258051, 0.18491727300222058, 1.3177600728606411, -0.34476906324704715, -0.18988912751291506, 0.17462264749815215, 1.0888669185532924, 1.5808339095744621, 0.4856495186927611, 0.5104131780881114, -0.5576994909465827, -0.8643788111937589, -0.7369264724652431, -0.26424579299744616, 1.5457821374654044, -0.1656161555370569, 0.37078972679972294, -0.17233521096824347, 1.207299738954329, -0.4679572901389112, -0.793475268938932},
    {-0.6575243321879053, 0.6556553528457977, 0.9112314473409142, 0.21397402516449998, 0.10934185564439002, 1.1214834270334346, -0.04890810756199911, -0.9363741280730117, 0.18097712482125425, -0.17601449080815482, 0.2591863866435376, 0.30966981025299556, -0.09131639160864995, -0.5113406735577313, 0.2343717473436994, 0.10013928876230255, 0.3032472607289031, 1.1174728133925493, -0.10416559250733082, 0.7871653816177229, 0.3669156137545929, 0.10228875378408475, -0.13143536538056236, -0.2725136712318288, 0.8250293448642081, -0.14696015122032507, -0.2330711661657317, 0.5925437950597029, 1.4382385038940466, 0.6420920432977681, 0.34430175882511843, 0.3144420791579461},
    {-0.24388906555883627, -0.5426806455837693, -0.30333097321245533, -0.377371241077049, -0.8466347205007317, -0.050110628948069814, -0.7776883966419036, -0.15535256104604975, -0.34283637848293586, -0.5245952309523527, -0.6331357671232423, 0.09589080012318829, -0.2583171466035692, -0.08800432094045198, -0.06716875237925388, -0.2975981687023568, -0.43876526584767445, 0.4344647794965246, -0.19564152177488292, -0.38139283305907234, -1.0648600471780032, -0.1057200031656216, 0.3030628085482265, 0.048876646199354855, 0.5923450186075081, -1.5225205673316864, -0.7672255764022768, -0.032879014507039575, 1.036926622888869, -0.03220441945563463, -0.7771369720986769, 0.09530482811728362},
    {0.9554275901791605, -0.478035493177262, -0.062481113312414356, 0.5325497438293995, -1.4652708736884033, -0.5032268998665763, -0.21069497437677046, 0.027293527102136124, -0.22303129498926064, -1.3001550943311622, 0.42730450633334555, 0.6386934327469, -0.002399755133309722, 0.4402717504769335, 0.1014001589163829, 0.26377993108216796, 0.7019884873737894, -0.060883224885396416, -1.1166511609678378, -0.32580332112661103, 0.39677953511140657, -0.04342266486691791, 0.645077794843164, 0.11994200480338153, 0.06548547483665121, -0.5539608272866854, -0.1841314554977588, -0.1542613013379578, 0.08993667809412441, -0.1672807378675315, -0.22134800575183652, 0.797111197087671},
    {-0.05277806341090751, -0.13919623741030335, 0.8118343482742505, 0.7072540418579549, 0.23738757043950773, -0.40444273698023225, 0.30790483262783724, -0.03413668531667693, 0.6017775970714676, -0.8333347599267468, 0.20562841501963572, -0.21214289877754697, -0.1307110657371973, -0.5873533441689803, -0.1199988059320743, 0.12349767805534786, 0.7329963827402599, -0.5132404866854933, -1.1295691018949996, -0.04996518397179411, 0.7116065918758541, 0.6445088247606909, -0.4145112823594933, 0.5503822600885626, 0.07577005344630725, 1.0580136272865386, 0.403174555292281, 0.3702064769500005, 0.9043734913315459, 0.5176969634411099, 0.891144060460552, 0.6029538886550194},
    {0.3163917200582438, 0.7221582741884762, 0.825479699072945, 0.10164095311317502, -0.42535760129595535, -0.8991418536073964, 0.9423146129406198, -0.8398092039538169, 1.1381875496963307, -0.7607785697111916, 0.5830645657640142, -0.38090562855413684, 0.9655005972414135, -1.0908116376628332, 0.21152544982444313, 0.34344729567615545, -1.1596530402134855, -1.068663556575538, -0.7577867649534885, 0.45413312009374807, 0.8129349626394825, -0.007450722698531769, -0.6510004643548094, -0.5478149903124491, 0.5228257671461751, 0.10694401781739168, 0.2304558082400719, 0.13147263052297065, -0.2364573299506864, -0.19681565824682223, -0.2775504646063087, -0.4010299409429286},
    {0.15108893620123096, -0.5573339754731867, -0.2379475624492327, -0.27930871909875454, -0.21495498109199604, 0.24908529781338914, 0.27588527998321977, -0.01706403998417572, 0.030648525954623366, -0.026745257277240295, 0.3568784034387058, 0.3619228257544043, 0.5723906916750041, -0.7348212060442812, -0.39374198514698805, 0.27444420220669874, 0.2945710313031689, 0.5477871115329261, -0.4291729678986266, 0.3445351776683254, -0.7155566898103776, -0.23857416142691465, -0.3535921387157944, -0.009203845300711054, 0.17105105682725544, -0.3355271090499555, -0.2867394657634407, -0.02474471574138914, -0.5704419029365911, 0.8242308546480442, 0.11518509325217705, -0.42355282399393074},
    {-0.02400394377426196, 0.14265351044548058, 0.20096379947597504, 0.046355773604759856, 0.30360636901539784, -0.09631101657581212, 0.05262753590734497, -0.30397756370462026, 0.3456053676332754, 0.5943563692756533, 0.6520211639273847, 0.36844025353368975, 0.12620735074895295, 0.26673930767078274, 0.7403594210190547, 0.5887094796926485, 0.2347447797724835, -0.4261246533428216, 0.29096267491009015, 0.04246603694331443, 0.38645773014974316, 0.012668913750079974, 0.363110324109074, 0.0834191538929215, 0.7536975644473244, -0.19418676410107819, 0.6334070380531275, -0.01635420651347307, 0.9497611436155654, 0.39415932592846503, 1.0287457675530973, 0.3681896249502578},
    {0.15745674019663009, 0.0834653643084102, 0.14396351844269797, -0.4124689355334419, 0.06089634354410129, -0.1174514118419162, -0.18164623109422645, -1.1669355105330665, -0.1268083033518042, -0.08417087412977238, 0.4450140370989049, 0.2090144195673732, 0.08396717817155154, 0.1550822475946498, 0.47759060005540976, -0.34420533280636706, -0.06435900110318366, -0.9715390762467407, -0.1782611429691301, 0.03329867811066939, 0.5041761900198463, -0.765157978352244, 0.015162193387965981, 0.30700526224152613, -0.1104990335021972, -0.8201865007072106, -0.7813579980412007, -0.46429559007235727, 0.3368723736554465, 0.3263401539575874, -0.49796210458093915, -0.4254276111723724},
    {-0.40144162341283923, -0.6387852248717171, -1.4012090709354366, -1.1814603994259971, 0.02156885209571253, -1.162043956686319, -0.2694812963624883, -0.39920186142745484, -0.11664153590700214, -0.06983592754908181, -0.41021554100416424, -0.7330081069059352, -1.2335094189678086, -0.21623359687223764, -0.9321754008968908, -0.6406682011576731, -0.11812006248731173, -0.49497485668402746, 0.3321008716806811, -0.3773183676215138, -0.22921089574443848, -0.3085670500332867, -0.3701798536370864, -0.7697403517556866, -1.4201263381162823, -1.2603735178648254, -1.045886538391489, -1.005508964595778, -0.977696230301511, 0.7009699798938143, -0.2742090451435695, -0.842189842624061},
    {0.5876935935735211, -0.11908976060682053, -0.24668989591711496, -0.02206559315887061, -0.37558295653385215, -0.7956691380385852, -0.149489915858038, -0.7154135570841322, -0.3049410686417211, -0.6649513628759677, -0.43136983020048303, -0.3271167385221035, -0.5810140919443096, 0.6252196085838653, 0.09951893702311963, -0.05774251006019179, 0.213152613576383, -0.0022128010303558445, -0.23170177104508036, -0.36737387633695606, -0.32535752360740594, 0.025553916073707644, 0.026223282627125994, 0.6014107284997052, -0.7286304436417386, -0.019927074724471694, -0.25163202178753924, -0.800599599944273, -0.44323731737202254, -0.01069622968255354, -0.3705938179718987, 0.1758690132910917},
    {0.03163608329881842, -0.14162554240622618, -0.4483990892874645, -0.5056925251653441, 0.6884280250033964, 0.014287256842908358, -0.19351902258372156, -1.0225674310714317, -0.6216040946464225, 0.87458052591805, -0.6587279595736121, -0.10129253686605477, 0.204456931699191, 0.910154548810507, -0.1396227007008376, -0.849649931574722, -0.12160156196604913, 0.1668037249394289, -0.16793051506775228, -0.17079911497267924, 0.28404452201321745, -0.1468249997884818, -0.2355536559036393, 0.22357050979989504, 0.5451270901788604, 0.2066103285758202, -0.6048977021502223, 0.2362330043712787, -0.7146282224357602, -0.5514487937704443, -0.3462527454931194, -0.33213429673338707},
    {-0.86507053952395, -0.005568302459384358, -0.5150202833926151, -0.07495424965710493, 0.07218983465174139, -0.20993774892588546, -0.021838251553175227, -0.28045995056693457, 0.02539093548798886, -0.3277564575728034, -0.8634245078480648, 0.4888640541933003, 0.5353945399302613, -1.157782870442, -0.10043716117453358, -0.3640921501940535, -0.47914603630620906, 0.4472656717165458, -1.3541880894626002, -0.09657037144703293, -0.018473460260346228, 0.32672109313058817, -0.6717563830976948, -0.6473120725192177, 0.6643381999046616, -1.1757438496067993, -0.5254351166136537, 0.4696524651491126, 0.30797700766551456, -0.8769559950108449, 0.15075225571746023, -0.523345482675507},
    {-0.6744121653540547, -0.614534017085975, -0.129519618293624, -0.08459858881619303, 0.5120841498956982, -0.24068609087934073, -0.1846835035974399, 0.8047040188963596, -1.0981374305698004, -0.19046717817404657, -0.7662869761869321, -0.742224939065518, -0.3033876749977619, -1.1268910035837556, -0.2139921309283014, 0.014732845934989773, -0.585063099650261, 1.3496258571327198, -0.5403697078503122, -0.17395376367232485, -0.9306539886804601, 0.32343467627167743, 0.22586671145902193, 0.08483325511894706, -0.9365987795986735, 0.5764696907089285, -0.41614254771365816, -0.8756451005770288, -1.0363240087972099, -0.9365607613992023, 0.31451130941065486, 0.11021665814483154},
    {-0.5765337442703335, -0.19390163118051315, 0.055197335353783364, -0.05072575927798998, 1.2331276619996852, 0.6102219188988518, -0.08720066160425965, 0.4754545900254055, 0.06065739065617532, -0.3002201449988694, 0.1700559709364947, -0.23687876506490718, -0.8186967435956317, -0.8519464130139198, -0.17176723005270786, 0.2530815856487635, 0.7161106214780205, 0.34572775900420105, -0.33283148675584634, -0.5542935746668771, -0.7455580923939722, 0.9745733254532466, 0.2235183118977024, 1.0663055766484641, 0.36511986853303396, 0.5510293904044143, -0.009510576872647815, -0.22588649184896342, -1.2057111586454863, 0.3116504966893241, 0.21312672877947733, -0.06128888431695699},
    {-0.14056010806831185, -0.8543831768916804, -0.00882961956128605, -0.9279288736788092, -0.49017020242736764, 0.8045381864975221, -0.7534709829735428, 1.1939154632563613, -0.7063153525488594, -0.14485220565265422, -0.9643878090178393, -0.8772058452571868, -0.6469025210153586, -1.4065178232841493, -1.161353408634852, -0.8174283157038121, 0.3763047051483422, 0.7419916231106926, 0.7472972575685458, -1.4584703879540142, -1.0053196426871014, -1.5100922842649658, -0.38900114315965534, 0.3009565675745419, -0.8835152741845136, 0.3923139584828023, -1.1970736431214204, -1.2721612120567087, -1.4291117054783853, 0.867349043711062, -0.7640214760054952, -0.6060732724550211},
    {0.39271472685043957, 0.4076723678753057, -0.026475796041378726, -0.06382007082896889, 0.2028302831671535, -1.1531522516434474, 0.0299023558237319, -0.697669946895212, -0.06165708794740983, 1.3349805500318122, -0.03974434309447029, -0.3014838429797939, 0.005645476497169472, 1.2274860794213422, 0.5092935472527022, 0.16738950153225482, -0.20413769679587676, 0.7732602609377566, -0.18243337862133494, -0.060273563780614284, 0.732757985817255, -0.2641333463912886, -0.5792720357132911, 0.5577372122071487, 0.4619058535421017, -0.7213760002378442, 0.7366919687617265, -0.7777133402113665, 0.5450840464858603, -0.5131861251808081, 0.8995272602861362, 0.7959099108849221},
    {-1.1272786566751332, 0.13756596419794379, -0.6374838653189133, -0.9143248939666374, 1.054883023196871, -1.2326700027350974, -0.8285425325404663, -0.985279478341666, -0.6075398358885332, -0.4814932465480807, -0.9421268953142966, -0.03301865183652076, -0.7338254877802234, 1.0549347846172326, 0.2643998898835727, -0.46262833167421247, -0.8563503279746136, -0.12001177605554485, 0.32569274150888994, -0.7702147340824766, -0.23465239693371273, -0.31217644603022054, -1.4205351377076225, 0.44069098696120995, 0.08143556798121035, -0.09867335723157307, -0.25647014863270373, -0.3235312230779262, 0.06257348655410276, -0.3781829633493796, 0.3177935263724797, -0.3237121901524272},
    {-0.247829270211409, 0.586906836587083, -0.2712639543641066, 0.6144197388370279, -0.03860291701152605, 0.5267514094225323, 0.4096152795611635, 0.9005207679655064, -0.04299424392620376, 0.44203940112041207, -0.2481141203742742, -0.19064146053678752, 0.08066561019259864, -0.4379577541774593, -0.38861047490592115, 0.2526309489124396, -0.4601281261625162, -1.0304946345059358, 0.9215042085727215, 0.4140122875596934, 0.44665684395684996, -0.763693383108438, 0.6216318125255322, 0.7225121793863111, -0.05533503392993931, -0.10038174433167911, -0.018517551509078013, 0.45788548043094834, 0.7055605464345783, 0.0532823225151169, -0.3238372617694659, -0.5771733807411269},
    {-3.9541335304234346, -3.624340436550291, -4.593049078788679, -4.254663099837201, 1.2947827167247086, 1.7804404038302077, -4.099153703740567, 0.5174674247547879, -4.830338306581247, 1.7535879766877471, -4.626640535108856, -4.854741167026618, -3.7754390365065724, -2.7588461004677485, -4.527273277629278, -4.520444123647643, -2.2899165121761835, 0.19930797069550799, 2.3779227228654425, -4.5594941696569915, -4.756161877544424, -4.290727785694135, -4.012682625006657, 2.6286078349497557, -4.529476503603437, 2.0727503061502985, -4.3714256113525565, -4.500887396260232, -3.3787856027960483, 1.12461224301963, -3.718356713983927, -3.5114360574553296},
    {-3.5989637048431216, -3.842340589232127, -4.359863616261591, -4.272365296876718, 0.6883330125553299, 1.3186983514324633, -4.112620990034007, -1.3110730529318475, -4.835152105843154, -0.16501687207872218, -4.791657930776098, -4.383654644213138, -3.984432800019317, -3.7646631369611088, -4.3018671731386595, -4.226670632850229, -3.57956778720295, -0.9050621224148885, 3.1287335874578774, -4.4436610911727605, -4.336667017110405, -4.650254552985382, -4.292164961166739, 2.9664327695472683, -4.884575855904011, 1.9376332073200473, -3.8303835427035495, -4.469208157401861, -4.672413542718164, 1.1921152308480745, -3.751098159363038, -4.024306813192433},
    {-3.0367910875742354, -2.5810901278467124, -2.7278675340789227, -2.7433925657671714, 1.6056098259554712, 1.683398673479723, -3.6690652009834586, 1.2361084115507015, -3.0810212411615185, 1.0264769987839155, -3.3513196582287974, -2.5224034416827306, -2.7147017628358463, -1.8227392603922261, -3.2406543348552397, -2.97853043557399, -0.16624732465656675, 0.994954950966541, 2.5469261800982093, -3.274135982831553, -3.091252727556622, -3.3072201301639086, -3.5385328176532838, 1.3388382787123427, -3.6936664176442005, 1.9768262748147702, -2.912718924885118, -3.3739452735091815, -1.435880415632792, 2.8196281900109272, -1.7039485944946806, -2.0959064386882633},
    {-2.2865511221263346, -2.4219586511839575, -2.1494451516133535, -2.1855605020355027, 1.5278391244558849, 1.4317777996942003, -2.2820460097695996, 1.6745183141775215, -2.348878556210076, 0.9902214220683682, -2.512537564434802, -2.6421240061869207, -2.7793132140108043, -0.8602483811385492, -2.5172508374389992, -2.241985097865204, 0.28123821324354, 1.5312090220759444, 2.1795524764751937, -2.3175002758344827, -2.8417023323250605, -2.059954520557931, -2.1619723293409194, 1.3515148118882205, -2.686619023355052, 1.8252329730481376, -2.2321253639480583, -1.9218624577621384, -0.964988750838901, 2.9927499760908973, -1.9131888280862228, -2.048094097584402},
    {-1.7433014120954224, -2.019149226918753, -0.6629970337103597, -1.9281928370545376, 1.3429319461442446, 1.5623268450395373, -2.1761994869156474, 0.9082271414830846, -2.5199049936959246, 0.8216137848395474, -2.0002037894038565, -2.335994151781819, -2.5967322062077023, -1.276667027410132, -2.422086837566769, -1.4272273178952082, 0.5591094341454843, 0.8533510695254918, 2.7817198704838355, -2.7123219939283443, -2.1593991930798273, -1.0319020536306238, -1.9148999833030027, 1.3007427536812817, -1.6661215104874212, 2.2674796698163306, -2.204041015934675, -2.8155402215127716, -0.8006748889982087, 2.758366463827182, -1.0047819322509548, -0.8952644860720377},
    {-2.530523352493702, -1.948146032366839, -0.967469977174242, -1.5240213065569284, 2.001760959226506, 1.022297644875904, -1.895280250543655, 1.8120339058903745, -2.489823653820567, 0.704985490518098, -2.580447037578414, -2.08172521699729, -2.5995677653109315, -2.870515551663109, -1.7652180855786164, -2.025546652131369, -1.368102562693696, 2.432348379034488, 2.4647895659597845, -2.756950172188956, -2.3941534534843947, -1.6503374379510287, -2.3986709957327985, 2.351747068608427, -2.3234078512332266, 1.176110289943214, -2.523714085944293, -2.0323968430960018, -1.8638731633731127, 2.707920825658772, -1.1720046599138019, -0.8749569372436883},
    {-1.2171965015311104, -0.7262335334588212, 0.6708018262881151, 0.6804550993682589, -0.7095874010366617, 1.6063170664850437, 0.1481717471627164, 0.38095557762247584, -0.21109141787953878, 0.4903813530622828, -0.6191313174739254, -0.29251661077666574, -1.056946093435286, -1.2465086809903283, -0.5462609523878046, 0.14236025213310813, 0.8001253298444453, 0.015594780491311116, 1.3623866991337565, -0.5101699474357551, -1.299109897587966, -0.8038149028281251, 0.15122431676995052, 1.036378043046651, -1.099782939259948, 1.3116740379098208, 0.23410285305845419, 0.5067859782943397, 0.2578666939031048, 2.6852663422089753, -0.24913782866307987, 0.18507400890569328},
    {0.27807076408462306, 0.40330546595651245, -0.6722847889469845, 0.19727081469416088, -0.5723157985460103, 1.4575549111643635, -1.4291127510089399, 1.6747357920681956, -1.0730826757190013, 0.8498834614669151, -1.0660885490239864, -0.16081830872520386, -0.5457689043767335, -2.2204344778169056, -0.725643754808275, 0.6847368975151044, 0.30005033007438375, -1.2525956267149148, 2.1310571254250696, 0.01832159478465815, -1.2714205459488679, 0.17232852845874383, -1.0067008809693128, 1.820825042004195, -0.8717450702728293, 1.0343940653130466, -1.6093831686509745, 0.4376857803452747, 0.01080871930553123, 0.6875798666931531, -1.1338522150530734, -0.9391668748720085},
    {-0.17864838033057878, -1.9331242151111354, -1.8860851717645368, 0.32009280358332903, -0.6102195507267987, 2.1289862450399557, -1.4041293756342221, 1.1349669725199518, -0.9781057872449139, 1.9128086625556144, -1.4326195371187385, -0.2548655896467064, -0.8862000805273493, -2.987545683543693, -0.995034716791552, -0.2510023824814552, -0.8597635969170753, -0.9175852539672257, 2.620922166585611, 0.015248727439575322, -0.3674619449291541, -1.512149359819195, -1.3420800548872804, 1.5498897193666512, -2.1262216017199083, 0.7977308805747114, -1.2764319485877076, -0.9827936250666741, -2.233390912093489, 1.3025741871058534, 0.1880069606662076, 0.048182633573907195},
    {-0.3465097900299611, -0.8344786655200264, -1.9250968600161624, -0.20159159242769506, 1.126885352843911, -0.6985759827948104, -0.8515022362208758, -0.3417604819013381, -1.3142721523797918, -1.062310298716287, -1.6795985850577806, -0.0014511156155688867, -1.0812349722388104, -1.4077169078428204, -0.5092642717590301, -0.8934166592397, -0.1881564363747898, -0.9044092784188522, 0.46685270189809824, -0.971325040363749, -0.06116764067183318, -1.1739105869751956, -0.5513600913950106, 0.5500900015136256, -0.7576549678024561, -0.7826348774158395, -1.391116083128551, -1.2130397595010316, -0.7391220968313396, 0.220300708428063, -0.7741828074620155, -0.6955498251317034},
    {-1.1734122636234772, -0.6518801813651669, 0.1737034328454061, -0.5388386884359431, 2.3915005212954408, 1.1912372011855217, -1.4068211705834743, 1.9700363628679707, -2.006408924096256, -0.624886953456384, -1.7041805267196242, -0.8092897013327442, -0.9465109964757338, -1.6848924371450904, -0.8239148894286102, -1.5525201268810611, -0.5221207802115504, 0.07647648770558571, 1.4843813350840143, -1.0122875910860258, -0.45899193822186346, -1.6370355008124187, -1.1651564271383013, 1.1757230382539143, -1.3672804002086734, 1.2809391474377856, -1.948978499325091, -1.9136959785349983, -1.094252102077981, 2.142064588942755, 0.17702690602525661, -0.9975151904979314},
    {-0.938561456790038, -0.17789172900432795, -0.14307774144090687, -0.957579711964194, 1.1474970268350704, 0.989875607070411, -0.041122081093770975, -0.8781347733822422, 0.4194996405482852, 0.33029773861586936, -0.31466706195086647, 0.14019344626181884, 0.09707466304844573, -0.18937110306333543, -0.5624753066455562, 0.13069910995008047, -0.18961342801216274, 0.4283062115992915, -0.11179012633540943, -0.011274512144080052, -0.1429468547267808, 0.7538394227753883, -0.13737574436862363, 0.8661452241690037, 0.4143477095476391, -0.8975376264340903, -0.7899623410741355, -0.5248611099549855, -0.81568342392386, 0.68940512520305, -1.2467305755282696, -0.4039188096914472},
    {0.6867063152934488, -0.4501634794950134, -0.6017068112190612, 0.13633354755761534, 0.11541498765031366, 0.2441926000703923, -1.1594183168703711, 0.4566416875284395, -0.4031638402333907, -0.1789510259740875, -1.2178758589497176, 0.9211151306528583, -1.098689610027394, -1.8034977034905888, -0.24816511315534234, -0.09801203126952937, 0.5533122858168605, -0.419449561113631, 0.4754208492643612, -0.1000230527233612, -0.09298534685408669, -0.8065195199505751, -0.7529059766897334, 2.0002922358787942, -1.240162901798812, 1.3963877131398394, -0.5042070362119345, 0.7491806175918135, -1.7839598466010305, 0.6386988473717303, 0.579712494967736, -0.749790655803982},
    {-1.103305657441332, -1.5610067338377553, -1.2849405867265828, -0.7805269152143689, -0.6645587888819229, 0.648268536731061, -1.3730024874971272, -0.7066095973356044, -0.2630392267864905, -0.054567741863833764, -1.1989254632804933, -0.7018927385555623, -1.0078812804421928, -0.7501270037746137, -1.2031023809558514, -1.1414955768286907, -0.8492815699363593, -1.4686052052439738, 0.11243683124354939, -0.8118450503539655, -1.2529642250972655, -0.9427788949976863, -1.7952978273963225, 0.3107945303037929, -1.3158637137231, 0.2866279484109355, -0.9444625256682768, -0.6421765473379327, -0.20043321525706667, 0.9275375759361928, -0.8012795101536173, -0.8193156018805096},
    {0.48262629413038327, -0.5680945129298137, -1.4672348271340887, 0.3872258132348857, 1.4912142470905339, -0.8956402546435785, 0.06858061082272897, 0.23431338556448844, 0.3325441980750682, -1.8100728314308399, -0.6897286023875636, -0.27125626303706674, 0.005198132675614302, -1.8127450221487402, -0.2301364386664401, -1.0882151011140424, -1.78252675043813, 0.9150656582629625, -0.2290308718376351, -0.9887182644321165, 0.21605049994062647, 0.16700783426057753, 0.023377047261218142, 0.28350901886531593, -1.0064885587162538, 0.22149605797254582, 0.05855768757234727, -0.09777091733098667, 0.3445930166899189, 0.2640779206298651, 0.01014153142392962, -0.2506121916208241},
    {-0.4316281894054671, -1.5522013263122898, -1.795542957577816, 0.011378028088520911, 0.7017841239544644, -0.5771463906487251, -0.5549176560827542, -1.7937233448796341, -0.1957208950650303, 0.0339819070316801, -1.08333489246958, -0.8004297019349276, 0.02468321437172744, -1.0468787041840324, -0.6776284664693188, -0.4120719994856194, -2.0211852717432306, -0.9533100044481727, 1.528811630893569, 0.07513901278749353, 0.42197154928203673, -1.2933050458030517, -0.9780874113906407, 1.3270520769708096, -0.33238275424143937, 0.2402985803716305, -0.4666838989898467, 0.47518239336556023, 0.02090961583276895, -1.0115554547991426, -1.3874311187416017, -0.7680454347779423},
    {-0.960513437241251, -1.6516476280548325, -2.333942058718592, -1.7284814198847256, 1.629234960748754, 0.07069318108025208, -1.7150289306696, -0.5832104468200671, -1.4855007221152676, -1.5737402158286427, -1.7151167268974274, -1.6185525719163532, -1.223225408135483, 0.3844019475383672, -1.5558276291596747, -1.5266655716425435, -1.670683719842029, 1.9248879408827537, 1.8607157506208867, -1.6992484206842007, -1.878476044744597, -1.2736666877842335, -1.5551834223814467, 0.07242008898609545, -2.1671071807504996, 1.0561788922848627, -2.0507834353775443, -0.8848369458819744, -0.6189904412093281, 0.6944607735597088, -2.095444023800536, -1.4025074513382974},
    {-0.19932416336394604, -1.8783932278065927, -1.3761922630485275, -0.4915661273795331, 0.9314326328935005, -0.15814303455923517, -0.30666235254636914, -0.3090653062745453, -0.6092335937089416, -1.1534312504159012, -0.7374454688664206, -1.145230381092974, 0.010260857482701205, -1.8473490452357157, -0.9455167297264204, -0.9915682077664155, 0.45744459536188486, 0.8016320332900926, 1.164646654134055, -0.9451897829399324, -0.20945171134866172, -0.9750315510275303, -1.4158702725069126, -0.3308612283678773, -0.5711157118599154, 0.37228772641621616, -1.2803201647098899, -0.6078976743406068, -0.9482336656895041, 1.6885170577170818, -1.4422941417316872, -1.7914293877291116},
    {-0.5238207419619404, -0.827626491323275, -1.5011077773695312, -0.5458323876724216, 1.0099719623995675, -0.6527413035654507, -1.7656197734896049, 1.2830495434121292, -0.9965631341337815, -1.6980127457240464, -1.4825853844227903, -0.36336228133617166, -0.7615957517627128, -0.29214633442302834, -0.568594370734786, -0.500062723744118, 0.6089222319714915, 1.663562480910787, 1.913672343477501, -1.001566638471285, -1.142145447314478, -0.07005964410231112, -1.2758805246056146, 0.3418186496378138, -1.4398229977074404, 0.4834873143793744, -1.875108657749214, -1.7159024438005965, -0.651366809407229, 1.1783026231766376, -0.9005356208527912, -0.11389728512539206},
    {-1.7685477873193167, -1.1297956364725628, -1.2315380339557764, -1.1527362065913616, 1.6095885394300185, -0.42915907617342813, -1.3387521308879595, 0.06058137316028798, -2.079270621266657, -2.7824722387662693, -1.7541679287305842, -0.31056568573511717, -1.4136324476419182, -2.3958698928497633, -0.9856298291092651, -0.6334445818799628, 0.12866989902753118, 1.0305536530228177, 1.3798832892471737, -1.1987950839495531, -1.6343741249344999, -0.738882879633052, -0.46255057158473123, 0.35826229130626586, -0.6516862860771836, 0.33289761805985596, -0.8379181328155291, -1.060590866327209, -0.8278817338818848, 1.1843341075962714, -0.47188449721841963, -1.6290591682399527},
    {-1.2672865555519683, -1.5031184406582758, 0.5149301304007412, 0.03750864428501522, 1.6635795056805436, 0.5873614697538987, -0.49831839533702554, -0.44377554229548016, -1.6368426063793713, -1.0470374372727318, -0.058577866968167844, -0.4330231037274118, -0.8507267450177767, -0.17595233932547769, -0.3538122065957504, -1.1655860097929747, 1.0626188238858172, 2.007497028161291, 1.184591081346411, -1.7471121553267186, -0.9797160397439642, -0.6242423461482955, -0.2575143074909054, 0.5482002900053703, -0.26509913672135804, 0.7900702563733768, -0.844035776439483, -1.3374047668250588, -1.4319549493017276, 2.073312305770713, -0.07038862700098496, -0.6922658415926242},
    {0.01051852336721976, -0.5406577716069478, -0.026720078091437567, 0.3656336905424624, 1.4319293403326228, 1.425154015985035, 0.21475721283159263, 1.598129610030589, -0.8706983529238517, -0.06615982181548434, -0.33493286067818356, 0.24231265731944443, 0.07944648948748205, -0.16865261742140286, -0.2798307641866688, 0.32241943669578665, 0.4222408694246292, 1.700928556271111, 1.5110928558672234, -0.40909107644730974, -0.32315355873934654, 0.41712918267826615, 0.7194160840360945, 1.1419211806892653, 0.5487144356124627, 0.9297722791719205, -0.36754943588224914, -1.1034739874862, -1.7979555542012793, 0.9591721819009046, 0.6756976688529309, -0.15942852355088855},
    {-0.15103017048060174, -0.17412005527945798, -0.6487878326815129, -0.05723171694822664, 1.0063785628083723, -0.1165634826273674, -0.9904604985142245, -0.3717086771873453, 0.30751709539329647, -0.25162292299702066, 0.14712635924504994, 0.1240166647470333, 0.009808203113077278, 0.2966934505633413, -0.5082783669900617, -0.47766978244169833, 0.29967886851035375, 2.216702417133418, 0.625681771013417, -0.24933685908014636, -1.2236083702951432, 0.036731893869757, 0.15301011993471922, 1.1579960272243717, -1.0187648737698816, 0.4156833703907406, -0.37475460430640517, 0.08729341977282197, 0.2383970786630302, 1.5118874060191583, -0.14829924076158152, -0.2942889266653578},
    {-0.7745811730033917, -0.8992928025489495, -0.8322530222643935, -0.5144052968881383, 1.4494860874930535, -0.691209646074232, 0.20701160080926112, -0.833530370158534, -0.7244628329271018, 0.2627242916390026, -0.08859691796696871, 0.6930796673289149, -0.6495222222506998, -0.6024104980007148, -0.49690121174210233, 0.632963079663388, -0.054435550981559916, 0.9221402314323476, 0.7355273441320294, -0.8925981083475965, -0.31562036745378297, -1.3538481418392365, -1.427671819992085, -0.9976603144935787, -1.1120277100601006, 0.43959995494137943, -0.3718399877369697, 0.7298433686430571, -1.5785484772268945, 0.06250821601528798, 0.7001430639608934, -0.2160574205434372},
    {-0.5086842158185892, -0.5042743195025264, -0.8997054724021941, -0.1769670254179789, 0.4274921428264237, -0.3253434576493451, 0.44641074113839346, -1.2768255905195716, -1.0513170890374446, 0.04152619454433217, -0.9708799600903869, -0.2399830527883818, -0.6234149672301439, -0.29740318875544797, -0.4482474084177199, -0.2526113614937637, 0.06341231089117225, -0.2222600317383414, -0.9269000262572124, -0.728372457828435, -1.3430934907117293, -1.3655283981152266, -0.10062109625248394, 0.08789826737716173, -0.7325791575802736, 1.2015278793881878, 0.6416288734401415, 0.00649431682741929, -1.8715999905001366, -0.40755491287758155, -0.1910266376307999, -0.2947141437437176},
    {0.30289574751807863, -0.28510607163685403, -1.5140934749636032, -0.617074831562656, 1.4165551096715776, -0.6218849835213173, -0.20671102232993052, -0.8060486909201727, -0.7029954992962376, 0.6056439666329575, -0.5672835259363295, -0.1364226261766787, 0.35458801318367444, -0.22168884278774093, -0.43166615415294823, -0.017706255802739115, -1.144086149499026, -0.14114820546637008, 1.2092635779029035, -0.6877025388271298, -1.4642259139689007, -0.8039611262166436, 0.5509008100082409, 0.7393612928642519, -0.04717632814825702, -0.5825434182134064, -0.5298199838747054, 0.6158170814012257, -1.5071754585988513, -0.37187334383648435, -1.015343450500933, -0.9275310160786507},
    {-1.3947268355245235, -1.4946271069907229, -0.8179270213130249, -0.3329081119260866, 1.4750324612737487, -0.5695771558159454, -1.5496590224255933, 0.23019491625454636, -1.6934946491482799, -1.1879264119176587, -1.7661991317080827, -1.4766509959031713, -0.6325288243702, -1.3599003681350619, -1.078273255614579, -1.2024329202478774, -1.0230229623781688, -1.107094015393533, 1.4646842990992297, -1.623880648878138, -1.113564476139323, -2.0563304907646627, -2.180360884176686, 0.9927760679456189, -1.056014855712516, 0.9363545317900072, -0.07009692289350669, -0.3101961560904834, -1.6549342425985527, 0.5439126683042749, -0.8095123635843812, -0.4374249881926361},
    {-0.5018482755855364, -1.3721613929701413, -0.25701992688837016, 0.24795381778475045, 1.1577652103505067, -0.12662438965944411, -0.2601338139434299, -0.9138413373418037, -1.3792679068691334, 0.2922977989208488, -0.7380705324945094, -1.3822955979629143, 0.33319254809393306, -1.5731265466140245, -0.79827292259241, -0.22388924472985697, -1.250735119892104, -0.7486867508038844, 0.3640182076190457, -0.4277898172075841, -0.4234668660439608, -0.2755371375952149, -0.0669256677441581, 0.16315744477713337, -0.9285743406428033, 0.9925343092898026, 0.21709852446588257, -1.42922651709003, -1.5340209873358357, 0.8620661394281108, -1.5042197063557954, -0.08913159733555184},
    {-0.19895843655789, -0.8765491436497145, 0.4606232906813651, 0.6105288238860288, 0.5077956911044151, 0.4070070006376087, -0.4430033008467929, 1.0296452001441052, -0.4383166838404104, -0.0700688158065724, -1.0643113614050443, 0.734985493396613, -0.347167588039044, -0.8892469160516798, 0.144510836940946, -0.2521638790315326, 0.06545731022687182, 1.4798813838836633, 0.0015738272946457393, -0.3053633492351749, -0.011876020714848104, -0.6220198493274782, -1.360484208745662, 1.4086885390621586, -0.9550057854216809, -0.2354737235316547, 0.04607218592417311, 1.001218668744608, -0.4964911182022576, -0.017232280711703577, 0.9081714201228523, 0.18136200762923171},
    {0.16739452054801343, -0.2330613599403773, -0.6309101036796132, -0.1432677698198638, -1.126482837830546, -0.8233418902323285, 0.3615887021364441, -0.4778006836669656, 0.8504338217402959, 0.265427073473589, 0.13758098958685397, 0.9000275494700496, -0.6146796445701702, 1.0232161436845173, 0.1223222355227714, -0.41018704684412444, 0.14353639084327144, 0.16753099831497542, 1.086385108014593, -0.16802186189900417, -0.8518639559104337, -0.36581303599014403, -0.021697510240915478, -0.0806579806536351, -0.06113211191302224, -0.8013297792542153, 0.6373130877632285, 1.1740455806833652, -0.7427894534792019, 0.2394747033239969, 0.2290903043916561, 0.24478719810943828}
};

static const float b1[32] = {6.426839449107817, 6.415338327617818, 6.481669358843879, 6.594986735812231, 6.739271975071462, 6.532472301184716, 6.4030726827145745, 6.697839193038767, 6.513887043759243, 6.563764801442411, 6.4464713640665465, 6.5954534651363845, 6.452169456656924, 6.5942744054043905, 6.2281076370627115, 6.500724136801268, 6.353723223192863, 6.738179428128001, 6.7602559678846355, 6.524306769645456, 6.543349217047137, 6.498800280783973, 6.665220942158461, 6.8215203074844695, 6.598895047213308, 6.782243093950619, 6.565753969538048, 6.5397185397724265, 6.419872090196086, 6.65601437700651, 6.482260967513292, 6.370811218410462};

static const float w2[32][16] = {
    {5.486845909709059, 4.824397288302611, 5.744049075788084, 6.3469197239370825, 6.1944140611570155, 5.66071943952448, 6.1952419451973615, 6.021176899430244, 5.590381081870113, 5.971504897385656, 6.107536549452399, 5.910567482860443, 6.307144509134314, 5.9344300263939145, 6.160077300141069, 5.760762259508734},
    {5.289130882444789, 4.807841809698897, 5.98271752435909, 5.8350892293904595, 6.0201533946069095, 5.238970366179817, 5.976504165102923, 6.015061452941183, 5.019364203836743, 6.024258912490888, 5.7341784113079255, 5.460866648695391, 6.123770554442924, 6.059174132566816, 5.8617214631506736, 5.538561662246192},
    {5.280797206787564, 4.885940373509661, 5.536837728039612, 6.2483163432484226, 6.029656695009549, 5.682943109958275, 5.986590988561619, 6.131832312290771, 5.586941200745851, 5.6114138666964, 6.085964834292528, 6.0166268552791085, 5.53597415052825, 5.53961029378945, 6.0577697237954995, 5.562868844525024},
    {5.54642611906807, 4.571812125641982, 5.946637957849318, 6.090870428188966, 6.165048132746003, 5.361824310992918, 6.1488772966058205, 5.864111197808736, 5.244238101839908, 5.7614068482332765, 6.210537159009362, 5.618645248351954, 5.874386512544701, 5.767081591857983, 5.840620089832622, 5.765642908005395},
    {6.2814426993994354, 4.963684979977273, 6.023476733772922, 6.1912708013618705, 6.147614767702883, 5.970494118046114, 6.396573850659685, 6.1355109281007305, 5.617541139226564, 6.493933593164202, 6.523861387290941, 6.517596656071033, 5.9848791069370515, 6.22075864152503, 5.997429272744081, 5.987618124688224},
    {6.080938952227633, 4.53517217793308, 5.6686641536701226, 5.854498448341837, 6.02820987302678, 5.888451316071889, 6.074243120379522, 6.37259199106313, 5.515910372644567, 6.212119188433749, 6.203205091070484, 5.804483432451722, 6.4726059196144705, 6.3414943057923505, 6.3736548377113325, 6.129558454920482},
    {5.814928379424618, 5.008043881194039, 5.580012609163211, 6.071280910838298, 5.897592701891988, 5.743285942342725, 5.850758842143313, 6.279393946594136, 5.015870973124537, 5.798671505150268, 6.176774691383543, 6.157944311172034, 5.871350725658461, 6.248586896546911, 5.885865774252476, 6.159770261249633},
    {5.91757297822293, 4.595178177811058, 6.165274036322462, 6.027967131256668, 5.7410414832812835, 5.305630772420944, 5.82601913430834, 5.837013933341788, 5.6698845173546, 5.6603675461491605, 5.886316505121134, 6.186810550680652, 6.134964269743477, 5.741627179966239, 5.597949862215654, 6.110268706157472},
    {5.56370008799126, 4.7507753725238455, 5.784788535405944, 5.665081237478453, 5.6242745595124966, 5.035322554732739, 5.801125805148456, 5.937371559303185, 5.1827586222615905, 5.805981440566032, 6.070810578471905, 6.010449796546659, 5.976648730051788, 5.6967272953801515, 5.782286900587288, 5.655648509799225},
    {5.680319727656116, 4.613072381862778, 5.6963984745113825, 6.119411050312317, 5.683174146809693, 5.581048442453361, 6.222336824957381, 6.087773545641856, 5.337250173947268, 5.872010799057986, 5.834998197453252, 6.137869256675772, 6.309875520528955, 6.014481795272851, 6.175594611378332, 5.833226904981265},
    {5.23131423806913, 4.440085326908068, 5.8264681365483515, 6.037712286054706, 5.991245967073622, 5.474504372614969, 5.997135926848261, 5.677282937599979, 5.416643482861759, 5.628208269715838, 6.023732450380064, 5.831339346072441, 5.535253030263704, 5.806823519260253, 5.585512131381791, 5.964213824208947},
    {5.533559255198073, 4.749760111376722, 5.605339049302498, 6.301490548476601, 5.638805761984466, 5.126985782263338, 5.8726397330068325, 5.97637299964305, 5.009830922894633, 5.986749629372721, 6.0100476005888686, 6.088663112964765, 5.678557229854225, 5.990619117679101, 5.594213316410542, 5.5935139240055305},
    {5.91551314407812, 4.888291899354879, 5.980355657278304, 5.789878871326099, 5.682852511883537, 5.8254693318308295, 5.97729907745811, 6.339408424850721, 5.6348008000896845, 5.917030202255808, 6.261790921318419, 6.014045188904567, 5.9914667839400355, 6.115505556867723, 6.097289744807008, 5.905193731466691},
    {5.582639661457701, 4.803985929635527, 5.954233334124995, 6.090295442978835, 5.917762457423195, 5.460245047362854, 6.2574862224431085, 5.8619300274758315, 5.639988622260026, 5.585227544439564, 6.173063309606884, 5.845076804082442, 5.58980664914307, 5.745631832979339, 5.747745757896023, 5.952114350414066},
    {5.762125576139235, 4.98978389557706, 5.480023861555778, 5.625413792115335, 5.534445725213523, 5.262585415580177, 5.817078662814608, 5.74454616415586, 5.441220074056583, 5.473998017107453, 5.6948474911817195, 5.569112310630911, 5.871142868821939, 5.7264859215150565, 5.54455287147102, 6.153519971666},
    {5.263838207734073, 4.616726940295474, 6.0010628912122, 5.7186958794695375, 5.51779380465467, 4.999887863262954, 6.171232069595381, 6.257497438465466, 5.2394648376371045, 5.559901526146252, 6.158203768521041, 5.966677253826204, 5.811796698767594, 6.072256728587318, 5.940252565130449, 5.744581666284998},
    {5.54491750136379, 5.107907687431054, 5.57849426515598, 5.7032257299831635, 5.540630998171512, 5.704169171167374, 5.498883366682686, 6.027867462947192, 5.732263006870904, 5.568593681535343, 5.665197669216533, 6.0363591271410595, 5.815755566795563, 5.7583236029781215, 5.680687970667997, 6.154612232437761},
    {5.426686957130856, 4.615781482189512, 5.890104441929009, 6.250326045077105, 6.0894985371748405, 5.696361675668718, 6.2895392449000305, 5.9366620559167425, 5.318954799797923, 6.003600622717191, 6.3216158864561205, 5.873471540990073, 5.83527684066073, 5.905370391263301, 5.868307801764464, 6.154042916520786},
    {6.106482363197365, 4.677846001345756, 5.963492646973238, 6.332511465307907, 6.295093685951048, 5.71051333521022, 5.87382010160385, 6.1488278566392935, 5.488113759746088, 5.8921556285501175, 6.413865256026035, 5.950381915085693, 6.308767604569159, 6.2416023173514095, 6.151107760692247, 5.901645766989413},
    {5.485808731387016, 4.768700656863234, 5.699794044750016, 5.62073670389353, 5.805850717899204, 5.5032076453187235, 6.214978626358332, 5.9738924457212645, 5.544574435037518, 5.691466865543759, 5.680620039008027, 5.757716328277832, 5.806259838878746, 6.1241167097649925, 5.450126119405159, 5.883910888933861},
    {5.601787569185291, 4.629256815495574, 6.068324341750272, 6.280281015253342, 5.57174155548892, 5.431430596215061, 6.144142736826949, 5.915762964560956, 5.207064176955173, 5.888336397773958, 6.075839540858803, 5.924555682402355, 5.9497922441567495, 5.851533210561836, 5.872030267621044, 5.557826646475734},
    {5.223546461959303, 4.474616607526637, 5.763274639192353, 5.902802734269151, 5.727440039115022, 5.282844100297326, 5.946168029254899, 5.767233578259395, 5.534817040821944, 5.411621765128417, 5.917873044048475, 5.871730824485881, 6.013773693057763, 5.9293614246323205, 5.916418347173103, 5.753445872950696},
    {5.269193286490627, 4.54667519571642, 5.998477872084985, 5.817847652241999, 5.796413677481308, 5.320626003064168, 5.930986971883581, 5.716790622617842, 5.238490097479197, 5.734706216959811, 6.182485710706888, 5.801496428407324, 5.878864152093723, 5.556941377933378, 6.078652237105319, 6.132079333697844},
    {5.813410628150713, 4.656646297365475, 6.039762775225692, 6.041442831070164, 5.891283279240499, 6.223320664867614, 5.898088452329048, 6.538380063213704, 5.266134030295908, 6.394233737685163, 5.967632517330717, 5.973511877751641, 6.275912117778656, 6.322859367508714, 6.133991804103938, 5.827779911681576},
    {5.8583857599655635, 4.974767790050313, 5.986489065414315, 6.02466433146821, 5.675486511744116, 5.364832331293467, 5.8692447550780775, 5.483590832907497, 5.439753613411415, 5.608889091886047, 5.896210236740921, 6.018550820728898, 5.894330174470431, 5.687606856243186, 5.500490589790995, 5.561048409104666},
    {5.973900544105504, 5.225675758458272, 6.259454074800513, 6.091559630534518, 6.073540018009027, 5.645610768120666, 5.980375820572487, 6.485441615303453, 5.111839815046197, 5.760445696313329, 6.059360986062922, 6.194447349820863, 5.913641769250416, 6.315304167623221, 6.410704702433124, 6.119524078061185},
    {5.55299425959667, 4.845446202565349, 5.853192612154982, 6.33561109999239, 5.626525131754794, 5.333619308284479, 5.769825429640322, 6.126846814144891, 5.7185481319549245, 6.297737587876552, 5.983173290744029, 6.062358780165081, 6.283277374959254, 5.9331209031546965, 6.021789139979286, 5.660074038484498},
    {5.823453751977857, 4.568310515543728, 6.054686922087409, 5.730493094453088, 6.082767022328676, 5.7122838263276074, 6.071605766443874, 6.088609954349334, 5.363542926889373, 5.858471220413156, 5.9567290670473785, 5.968538944256157, 6.030964630819008, 5.877116214417279, 6.139621564511727, 5.7923658783483525},
    {5.596641532717597, 4.89229917513727, 6.027164763253294, 6.078788380571885, 5.660416447423759, 5.403320099398575, 5.718158504598418, 6.068442750466895, 5.375022682968332, 5.623971685341818, 5.436080070978573, 5.694021835660139, 5.994905780312145, 5.586373853851781, 5.9128505036249965, 5.891886319530576},
    {6.164524702272297, 4.732084780739273, 5.646714273338597, 5.877730801509531, 5.865420441962111, 5.73016331093238, 6.192109233116734, 5.8406347260637, 5.762409857108382, 6.295060502879131, 6.11704614777437, 6.042631433715281, 5.8901396190861, 5.717929194151948, 6.255396101650262, 5.923225628943752},
    {5.881461272827037, 4.561567697347, 6.1490828185882505, 6.056500265224997, 5.920994175353767, 5.6646842853261195, 6.12962392037187, 6.185845782622941, 4.893967082081769, 6.11384355664738, 6.1717896400136665, 5.6000590054977195, 5.9015786035841575, 5.91131191157597, 5.993954456750348, 6.230411086661755},
    {5.459460961578869, 4.768182117274252, 5.49695292707744, 5.826913481224051, 6.0798533007675575, 5.481562624790044, 6.264877047063773, 6.156161628183672, 5.113791308458328, 5.910898966312604, 5.636775212907228, 5.999400017429878, 5.949362136951632, 6.12807003265207, 5.5500002984448695, 5.977988061250446}
};

static const float b2[16] = {5.579510172417222, 5.54813188603843, 5.202500963631555, 5.44888861962055, 5.419527248878623, 5.624742508579156, 5.348134742589624, 5.427195205025231, 5.506647037313084, 5.422287325381698, 5.444974210284288, 5.351549754462618, 5.430079289223624, 5.475109378710335, 5.436229581893564, 5.372338302956028};

static const float w3[16][12] = {
    {-4.175265585388771, -3.8062062790278923, -3.9068516581979007, -4.101472615894662, -3.6473622128280114, -3.9577797405468043, -4.250314106553949, -4.005292515550581, -4.114109067539473, -3.8552521948154856, -4.080437663726931, -3.7760198674876624},
    {-3.038296217282642, -3.0938151458774654, -3.0401976398440858, -2.965704127459082, -4.118610211292497, -3.7529956558431197, -3.6092267720047873, -2.563056705826685, -3.1113127479889364, -3.1184482534596984, -4.02309720990045, -3.3117777041237884},
    {-4.5161730418809505, -4.633905853599303, -4.487980457641291, -3.7481933206027653, -4.171372675702351, -4.115365520823313, -3.683996932387063, -4.340811840201573, -4.484664380202833, -4.158449796001743, -4.613608981659831, -4.582082592225298},
    {-4.593861619452457, -4.175147828772099, -4.177867585096991, -4.414134322425639, -4.355020413696617, -3.758277169342658, -4.404438505078589, -4.1217657120816185, -4.1159179754480935, -4.458476770451803, -4.379332780644259, -3.658920923528829},
    {-4.116153664793354, -3.8782445119907845, -4.027244889158889, -4.057131545437867, -3.9578518554112594, -3.850722413875035, -4.439909496210367, -4.442509304590192, -4.6549777144719515, -3.773534424802575, -4.4610987410571585, -4.063233067335639},
    {-4.101882296968036, -3.676052598685702, -4.21807549448409, -3.93703447680714, -4.260942139476693, -3.72171453170717, -3.5658615030350775, -3.4732899845817924, -3.672477751108878, -4.103558893689932, -3.383829701917829, -3.7885961858440362},
    {-4.409767859958487, -3.901064397852724, -4.397713805319632, -3.804043644988849, -4.402004955377162, -3.901504691811057, -4.3797542097376665, -4.16958875311715, -4.467238856991548, -4.148616694761984, -3.95830992622785, -4.202884660525977},
    {-3.751230641962292, -3.8646346014555966, -4.058869118728089, -4.564083160441184, -3.980876376751708, -4.416865311744545, -4.220053391961629, -3.9080076101076564, -3.9004115756479947, -4.570891397899773, -4.335629910720233, -4.055582592429672},
    {-4.109555736036335, -4.109897360973293, -3.9535781924603337, -3.5384858733768554, -3.4930190038324205, -3.9498875991747866, -3.6476396045520714, -3.1036779942657713, -3.9294932729611816, -3.9398402045112255, -3.3120861586871286, -3.757150922972289},
    {-4.10469385741397, -4.5923873053397415, -3.8278024641646327, -3.8761560707503775, -4.578431047436592, -4.27755003057974, -4.256905020967356, -4.357438192233375, -4.072402312388485, -4.004089505658404, -4.021630237831398, -4.491220606044541},
    {-4.115345286502679, -4.6031191922714765, -4.4207061813233315, -3.8392790386346825, -3.9307524912332434, -4.247471756046698, -4.30655729084459, -4.675053422165915, -3.8257396376236312, -4.052790170451365, -3.714709447882938, -3.85970628443099},
    {-3.620101598687307, -3.738904147415763, -4.390996858287946, -3.839448675591349, -4.265998142621453, -4.564494935361128, -3.6451739670031817, -3.867971885336701, -4.347454002302909, -4.100700597128936, -4.34737897864335, -4.100021734902364},
    {-4.077046917414173, -3.7576738289322535, -3.7518107911237175, -4.5849532037744645, -3.98503423252568, -4.210311150183218, -4.331890360805477, -4.550593903487265, -4.056418828587354, -4.5966581457377, -4.207804583812017, -4.055299753949463},
    {-4.089290071256318, -4.218042305633517, -4.194474678346861, -4.741727103374102, -4.022235851093906, -3.9083759310673045, -4.02415726338092, -4.7659930877997665, -3.879533673925829, -3.844855128817186, -3.918089548641224, -4.550058852931842},
    {-4.326010875422201, -4.421251135779618, -3.806556899087501, -4.079887438971354, -3.981680847696319, -4.159035202085877, -4.333256698001821, -4.390631749848777, -3.8888875783524015, -3.8664112593967968, -4.009682356011288, -4.168200772264549},
    {-3.715350426902101, -4.359436248072538, -4.20210282441156, -4.696333703029761, -3.880670456708965, -4.266521992056663, -3.8372340605140467, -3.9055153947360592, -4.333653192328288, -4.079414822960545, -4.259063140558974, -4.453266887982801}
};

static const float b3[12] = {-2.4136705771019833, -2.025137616739834, -3.1112344161905763, -1.9390825181362896, -2.2963141067196013, -2.2329293550862834, -2.6636402282754568, -1.3810663762272826, -1.1776924935504731, -2.8033653558978324, -2.859246202301914, -2.1625009159658473};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
