#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.1744230629930077, -0.28798476585342314, -0.2810040536269992, -1.321803084631066, 1.8808368790874515, -1.604803937204829, -0.5900602284817865, -1.1856890317620132, 2.242489541774015, 2.9967636769157426, -0.5152962889950077, -0.1110777874853448, 3.3700530894456957, -0.7023458804944458, 4.232448841202863, -0.9489887384033212, -1.285346816989278, 0.24980749840076855, 4.074544002547756, -1.6463585546708295, -1.6498024302329337, 0.09660925644563274, 0.15796559883239977, -1.268520819514301, 1.9534691281624321, -0.8645899844277101, -0.6836438711707453, 4.073230331783571, -0.13200790455230124, -0.796050939603951, -0.0657547331760179, 1.4245092336762843},
    {-2.3209280617368897, -0.489807011424694, -1.1693384673962886, -1.8001325145362288, 0.827424974902156, -2.1946205915871464, -2.0331844319660077, -1.7112874159832097, 2.905236000923523, 3.4463348622488814, -2.0048112071212887, -1.3993242819712528, 2.6516117449157957, -1.7288943469808513, 3.4056926604941666, -1.2994906563285291, -2.1963025319125222, -0.1426673205960441, 3.926764191544043, -1.94011720614863, -2.353357818374826, -1.1972598870889002, -0.41192877474480794, -2.8652287840915616, 1.9569791383939954, -2.404265333232218, -1.577072493787451, 3.9839883652683, -1.47915324043868, -2.460888392451532, -1.0453457631963674, 1.767114233923646},
    {-2.068264758049467, -1.0911234108981456, -1.7454493402405156, -2.3118432629507364, 1.3810755446910843, -2.0968146322677574, -2.0828486543531257, -1.647792512187894, 2.8907000215009595, 3.289635600466128, -1.7639001479035463, -1.6065514740828222, 3.2876878404121537, -2.062920445624503, 4.687383163287219, -1.3306522721053786, -2.3774139316627925, -0.6545496646578626, 4.408852586287583, -2.357468791012867, -2.656851357477877, -1.2672241398863102, -0.627910055757635, -2.630677299106801, 1.3468687880225476, -1.7984798855965192, -1.995302151713821, 4.791585224343948, -0.9719418175118688, -1.9114226521530095, -1.7434299908376847, 1.1570739335377995},
    {-3.1855261263008057, -2.7975279417045176, -2.979462962750795, -3.670557791830743, 0.12388553738914695, -3.1952709704724716, -3.0344664296561734, -2.9285000428188575, 1.608513627179633, 2.5622032069096368, -2.6069907677121895, -2.2692705023137494, 1.6992706700455147, -3.0778995572489607, 4.097024998748039, -2.3287810330720466, -3.5939798026524206, -1.7183037957819283, 3.980393464661229, -3.1831121065526418, -3.883805501934266, -2.43625962645869, -2.188631132604845, -3.266762573342183, -0.0022466932583602227, -2.727581186952551, -3.007966198978298, 4.316979753029527, -2.1376796581873667, -3.0455673100737233, -3.105220503407646, -1.1465837060207116},
    {-3.4362045333179716, -3.662272866434528, -3.9587569479617075, -4.029605852839291, -0.35370995697123925, -3.81693592568348, -3.293432917432501, -3.4903457510910787, 0.59989064486501, 1.3423443018193912, -3.2843625798171514, -2.927166423565458, 1.1470329558253558, -3.2331287330535425, 3.368977998047673, -2.664251976529626, -3.9035260594525596, -2.979420005334529, 2.6946577131397564, -3.741073718724434, -4.029763802932461, -3.0219416683870755, -2.6860001786845125, -3.6501190970042527, -1.3134274294118762, -3.0540301828068834, -3.5818179143585334, 3.2289216159058367, -2.6089625901357287, -3.2981564475122265, -4.051965044834209, -1.7571837958611924},
    {-3.4457438234043014, -3.604108152936956, -4.086128354738823, -4.180369661924764, -0.7710011269648126, -3.910145594149593, -3.4436992035557146, -3.394359784422093, -0.18469137729313578, 0.9088622552361173, -3.494320965809254, -3.33973635006459, 0.5517095386397554, -3.59812736262896, 2.170443500003036, -2.8785721937746183, -4.170553688700832, -3.1032576435054526, 2.1055238400818976, -3.8006989079276687, -3.8666671914464956, -3.3482571972748554, -3.036646586921046, -3.4720133631810053, -1.6317109538386056, -3.456505054980124, -3.638388067389557, 1.8366447263244097, -3.071874885345295, -3.2665633715801317, -4.142940717751065, -1.9450930372170394},
    {-3.7708040772504683, -3.546261939644989, -3.8569298686990963, -3.598925620397861, -1.49561107371566, -3.60578589690159, -3.7258592147835157, -3.479728532985478, -0.18068528930148828, 0.5993078859732132, -3.5340348400015373, -3.4329467320319864, 0.9297388053174969, -3.3607111513662056, 1.5531935525917646, -3.118920269577421, -3.884505188117409, -2.8432570851241943, 1.4799396345873594, -3.854856668256689, -3.993242875031502, -3.2805881351726884, -3.2605548361724566, -3.863021837534873, -2.10222440406033, -3.505561654761948, -3.8728741856866065, 1.4535046962235258, -2.9513168905583087, -3.4869463674240495, -3.879184090443734, -2.0880020255154093},
    {-3.8656613045336496, -3.6846793800164477, -3.8790629501691165, -4.038169049196355, -1.140373299614251, -4.025826947068573, -3.95153302887627, -3.6181350491859128, -0.4666745948239961, 0.7941783011142236, -3.615074899550207, -3.499521297458311, 0.8421659579467642, -3.5761551005977132, 1.7604495008403218, -3.284270291300435, -4.248963487423081, -3.0048525795820993, 1.545965273409964, -3.9152519297477566, -4.270267016319729, -3.422292918530717, -3.088648901436414, -4.1035022812496225, -2.1155761414117547, -3.600523330806534, -4.001878848139811, 1.6362156296839308, -3.3522190522005624, -3.645883132316715, -4.044197204186701, -2.3967319695016758},
    {-3.428913813280918, -3.8957162957173157, -4.087881848552958, -4.168489424782728, -0.46373815166411075, -3.8615690235189684, -3.6039773281179914, -3.4943906695291953, -0.19428790042046115, 0.7436023001572973, -3.4267740595651652, -3.2907633448205846, 0.5319789633400412, -3.828284193790672, 2.17556415618933, -2.9005717025425777, -4.2434627834577165, -2.632828678625681, 1.8891956158962102, -3.566346620764574, -4.20038733283397, -3.633371312006925, -3.118005049610967, -3.8086744442200833, -1.6912583171960576, -3.529219131455135, -3.5484983552105254, 2.1161832729701358, -3.2013791570643897, -3.7383190296140882, -4.055805626780825, -2.8271926953853534},
    {-3.584314465819963, -3.363759008065183, -3.565958337246084, -3.7014390416169722, -0.38402148518527884, -3.808208686773598, -3.7485999454089765, -3.3825321451381716, 0.5951171965081853, 1.5304158582674605, -3.631526695213132, -3.120013235470047, 1.1378214740095924, -3.4715176842466153, 2.4983693905195326, -3.031109984975583, -3.7892571343489436, -2.2912693787683995, 3.2329926617584976, -3.764324166412389, -4.225460997705607, -3.2047136663549476, -2.5234724113781377, -4.090193816353889, -0.7786806068710761, -3.5024504825833627, -3.6866386273147462, 3.1479504796533835, -2.93433340646457, -3.8355035754182896, -3.6861760961000503, -1.861962252158457},
    {-3.602072030427046, -3.102011669707975, -3.5066224364763894, -3.6194278684252894, -0.7246268151993124, -3.682733171040839, -3.2870949409249794, -3.1952308746434985, 0.7091957872059295, 1.5216758902949334, -3.4121668316546483, -3.086771903546986, 0.7910006881256497, -3.7429486351027523, 1.794375598926749, -2.920135410982606, -3.647677134167598, -2.457271989831283, 3.0066165664456808, -3.3824101774573054, -3.9551602098247423, -3.3334624255905316, -2.4113341049710724, -4.025184547386301, -0.7328060039924956, -3.7661254575062717, -3.3651957419175154, 3.06211198676694, -3.135148184002927, -3.8602362380846054, -3.194023108969881, -1.6084935892118457},
    {-3.549100084308411, -3.1815209746683983, -3.35356564968488, -3.338866930207165, -1.2497519167624043, -3.416166835190997, -3.744666517252663, -3.1667405942394042, 0.014219667628688521, 1.0172469438882439, -3.3806531403760567, -3.0867976280720213, 0.8448802939961494, -3.9112220025446263, 1.2086035610996257, -3.0587536255625847, -3.7743299860280772, -2.452022556553327, 2.389600259490893, -3.6013838838228924, -3.7891856021343586, -3.662045472875674, -2.817955278372299, -3.7811624120496523, -1.1635812405532107, -3.430900505285952, -3.628154395369373, 2.6722951827339263, -3.1812462606379865, -3.478661641879516, -3.441590318417219, -2.2528284983805364},
    {-3.509928852542922, -3.1350789588646366, -3.461642823845123, -3.3070192987283926, -0.9429825258847464, -3.2936993114543784, -3.6863367758350933, -3.2074861541061503, 0.7248933980762023, 1.5094254811575785, -3.5174180794661103, -3.25040624048788, 1.4234725675683624, -3.5733667829710583, 2.0488825788001215, -3.028311866168293, -3.7170960818670737, -2.4769226558743602, 2.701536738230036, -3.2560464361361374, -3.732321302668631, -3.72498001241165, -2.8750626923864187, -3.9814827071001817, -0.6565844670001347, -3.3609137161930103, -3.4427102685234123, 2.9162976980233877, -3.1692690195322526, -3.728371730103357, -3.399941120506518, -1.6363907526481416},
    {-3.7071258178412374, -3.0252174832512178, -3.2573242297129625, -3.6370488379944934, -0.9104652493016356, -3.4372950233455946, -3.7117688495264134, -3.0904512025578446, 0.8411806508678525, 1.4875319590129004, -3.49079720319429, -3.1110828184668105, 1.166703205674922, -3.6070882692601307, 1.9611492445839103, -2.86638694240495, -3.5877169820910564, -2.3311622756363066, 2.447393678121304, -3.3264720173817057, -3.708390479730154, -3.3180476532791956, -2.680434534768916, -4.014126934625625, -0.60506182405956, -3.4293064734094085, -3.4484374416692507, 3.134273522092955, -2.994449232878315, -3.377550918850285, -3.3457204027502887, -1.6208654688980793},
    {-3.6087722391496717, -2.8426991842547866, -3.3864026033929977, -3.326994927941795, -0.5699461070546824, -3.611144843416809, -3.597975054941612, -2.9903265222448563, 0.8621608997045832, 2.1101906823657033, -3.3562720950268154, -3.0347705590642584, 2.044633121984185, -3.524163976389487, 2.7185017499468187, -2.481301347689037, -3.714650530141988, -2.2056314331897355, 3.110790269813693, -3.364448583254371, -3.7369123077620183, -3.0384440584387034, -2.5670871722053086, -3.758147048622407, -0.5658978618160444, -3.4221765132326514, -3.3449021912663564, 3.571123167743759, -2.905785460451162, -3.248150371367516, -3.3592466463504866, -1.4190162873114514},
    {-3.548707523987578, -3.122097629949328, -3.485591811181778, -3.8400503461713402, -0.26779594088081904, -3.669794867829373, -3.771795613111382, -3.293436046097385, 0.8444105155483356, 1.6218151240649856, -3.071785783549289, -2.736018032479437, 1.2930098971008874, -3.6305793362832173, 2.86090405273688, -2.6990520425477693, -3.9231936377043817, -2.4672675579978733, 3.2621504742144545, -3.3827641703900984, -3.92083577491223, -3.2539540228409747, -2.4837947307642416, -3.9559442639247173, -0.8263571678038292, -3.256963840062943, -3.269140095748667, 3.434016461678856, -2.7591776430487487, -3.438458274905, -3.617919052144254, -1.4647411507987709},
    {-3.22931924902924, -2.9367741619993635, -3.2370403381882604, -3.690766091719688, 0.11935478886220757, -3.246735505670028, -2.911923752680354, -2.838174273308084, 1.6045570699259806, 2.092480762274052, -2.6732691275942724, -2.301953358366786, 1.7721526381621897, -3.118487899837272, 3.7922897067942913, -2.2643593053627886, -3.4615160846931334, -1.9084335592235502, 4.001588986458382, -3.239586914347169, -3.613318183574261, -2.874105580010803, -1.7419457924157298, -3.2992969161912353, 0.06204473701146917, -2.8716375689458187, -2.7874684409728046, 4.337310460567598, -2.110736983735094, -2.878061772302111, -3.111420293931025, -1.2915663961008423},
    {-2.263332058119669, -2.0023127554182647, -2.094767916158123, -2.5255348181440884, 0.9833697957805575, -2.2820135140934528, -2.425264381408351, -1.947320775594421, 2.452038989038577, 3.045922276663202, -2.048997221683756, -1.647445256855648, 3.0856541763133216, -2.3783969882939813, 4.5976801400606035, -1.392397681119258, -2.9324101577174524, -0.9498728971991739, 4.543801100511263, -2.210608609814113, -2.8288258691672485, -2.033475675874827, -1.2776266836601184, -2.6960053010264833, 1.0592131039197954, -2.0704678037793145, -2.3296018422515337, 4.835815450018832, -1.3693231408662736, -1.9872023268423447, -2.3106362236997358, -0.25738315266878675},
    {-2.3193416406226453, -2.3730700102778712, -2.6725946406000336, -2.6210521364663277, 0.5426040454120867, -2.5017534823849568, -2.5071102617543333, -2.129027059559105, 1.7846016779181566, 2.5556695303859267, -2.1569212192722746, -2.036152419353242, 2.943334100988587, -2.367839433552792, 4.372366736911928, -2.014793526378275, -2.978958554393152, -1.3926855393156856, 4.232397932115829, -2.530067151080486, -2.90858456804013, -2.406288305357031, -1.4825203833527798, -2.788428322599312, 0.24565568090269488, -2.3236374721530018, -2.519384610349521, 4.363873081208054, -1.7931891976858816, -2.0600600971373755, -2.6036232265591877, -0.34378183142495916},
    {-3.035519124693679, -2.764290965889428, -3.1921706631976097, -3.1677358629482115, 0.2728570673757755, -3.043884387694704, -3.279940669770646, -2.8045275920815276, 1.4357852643700468, 2.1399408702624285, -2.6052268904287295, -2.4546052817310517, 2.3069385211504985, -2.9972601763513746, 3.7999468876950147, -2.2864973278909067, -3.3767079331010503, -1.7557581906088284, 3.992025527845969, -3.0359136839517644, -3.3526500732500146, -2.7680003820356993, -1.971545931866199, -3.2598613052498795, -0.06280897726200163, -2.935261081748034, -3.2317458027261536, 4.209411066461612, -2.100623001091613, -2.792891649263628, -3.148028587954319, -0.8437737416798978},
    {-3.2598431424294443, -2.3885550693803457, -2.954026578361226, -3.3570075696101576, 0.11605263496770886, -3.2813345128692912, -3.1400690480821347, -2.825174770634071, 1.7201720004129901, 2.5281198459798206, -2.8203235198392718, -2.254928357052068, 2.05044517066754, -3.189908125967644, 3.6695098923280494, -2.2584272397831273, -3.4736198950560366, -1.6736448214044677, 4.113423936728125, -3.189288299279907, -3.564607262740532, -2.8859271708307914, -1.7744996519772465, -3.301164901811633, 0.3966984954451882, -3.0692957570982267, -2.877055515029473, 4.42137864831744, -2.4631012755981034, -2.9914085587708907, -3.1688571066746047, -0.6841655563434121},
    {-2.371411483146871, -1.7175063018432775, -1.8868107349039585, -2.399693155485377, 1.1807045102405305, -2.615034826982285, -2.4511837195484736, -1.9405740897242938, 2.5830379474875107, 3.2472058506773944, -1.802524432596272, -1.4277077610901663, 3.3359449136854065, -2.192165534611481, 4.4898408416102065, -1.6092751711881697, -2.7545128308839315, -0.44087473436118396, 4.845272332557283, -2.2201687621588952, -3.02229490817539, -2.062454399473904, -1.046215724585637, -2.505059509636996, 1.0882449026208227, -2.231620037198594, -2.253330866111276, 5.104388175484994, -1.3317459429046645, -2.1985814565656683, -1.9517343591675824, 0.3383757213776655},
    {-1.712242625726953, -0.8814834847121702, -1.2152247212415708, -1.6993425820784147, 1.685962089208054, -1.8253704351166846, -1.64771372753503, -1.2250584392873818, 3.103634164092842, 3.6525374548163123, -1.2585584130454606, -0.9275968088104528, 3.7325900807744206, -1.5926194998900056, 4.843286655936518, -1.1201897987094804, -1.9887048050190783, -0.04726737368497814, 4.867111403188894, -1.618411003986323, -2.0042274377639346, -1.1097766751563853, -0.22729297644042523, -1.9515273462796867, 1.939614955456023, -1.3027981583059, -1.2921604724994988, 5.150547153930045, -0.6381189773091153, -1.6665799065678444, -1.4369760898399597, 1.1340724336271837},
    {-2.1848913152918144, -1.5291387717729956, -2.0660461861114054, -2.3810352237217534, 1.2378253664805954, -2.1969468277613813, -2.3339173605371357, -1.9808914385260565, 2.79272089693921, 3.2620043713319755, -2.0023586375168083, -1.7640958286244626, 3.0580990248706925, -2.506575747984703, 4.518220981196317, -1.4840548426114986, -2.5575634585345446, -0.7296658406736218, 4.454911437367153, -2.3115640770617665, -2.8697639744226384, -2.0494646534223184, -1.0009719376869453, -2.7698171636483186, 1.4840567880763893, -2.16249357772453, -2.0593584175710116, 4.734017620800262, -1.428967335556057, -2.5237075291163253, -2.136704385338423, 0.3873347250015743},
    {-2.6639221111277007, -1.9220233734285392, -2.441955680204816, -2.8177723664322354, 0.6590751972812504, -2.8088130189517337, -2.928701656247294, -2.2117476148849917, 2.2400802818290537, 2.721023384388646, -2.326457422720878, -2.247423807237714, 2.028312586146081, -2.7582282253192534, 3.804439916614395, -1.9123048338517306, -2.9393976831786564, -0.8373491077906339, 4.173180619750912, -2.6332391267989306, -3.289006080379033, -2.5651579938954443, -1.5895597433831077, -3.306208322927307, 1.0369283402091338, -2.8715402995236925, -2.601335922361114, 4.429345835837863, -2.0351503186694933, -2.897993249450322, -2.6762023895951965, -0.15074431083021206},
    {-2.5284581991228063, -1.7637383837513365, -2.258484045450996, -2.6058718177003826, 0.32747250258287747, -2.4183532352247354, -2.634170547110615, -2.2960530557310546, 2.05890332933717, 2.710846388868135, -2.1979407637727695, -1.7720715198812953, 2.491646676089138, -2.879837176693568, 4.0499544974986765, -1.7131837325167194, -2.9639782670012567, -1.1757960560663017, 3.9102891815924092, -2.2704183059870062, -3.141130949208982, -2.298407053278359, -1.3950407494356611, -2.687220370269991, 0.7864951244242437, -2.683579213431433, -2.5689015634911674, 4.385130242413425, -1.7259937061900286, -2.460173849039238, -2.6737101313362728, -0.42818724326972507},
    {-2.376742099311862, -1.9141503407885254, -2.2942018563764415, -2.575723560053171, 0.7993474436441744, -2.4789857416550127, -2.3466159761722074, -2.298544549124067, 2.6043855552275983, 3.2710413854230778, -2.3135524361417095, -1.8376391633301536, 3.0565022839981406, -2.793331449576515, 4.250899398085076, -1.5583348230553449, -2.750397130882919, -0.8945402615947757, 4.574765975310982, -2.3396317662293438, -2.8413835614446117, -2.2245931202359, -1.3713989945933258, -2.5813715935851103, 1.1567660187486768, -2.5938156407036734, -2.1633764873672305, 4.56476194707686, -1.4720168062386096, -2.5744462090258415, -2.567058658836208, 0.16323047125718385},
    {-2.7863116142894695, -1.950107354760919, -2.5942976465725653, -2.791787099970517, 0.6731890634724034, -2.7457932819798967, -2.582478452472957, -2.17366172065304, 2.4744168938632605, 3.252161005153403, -2.517048916119774, -1.938080800591751, 2.959361867020539, -2.5535351887216295, 4.585342850189248, -1.721785564838498, -3.1277478287841367, -0.860429531338855, 4.455656785251865, -2.5494515713724324, -3.1419859508154637, -2.0917485240911917, -1.4311104225079856, -3.051587392453783, 1.3475239191545316, -2.490960436275812, -2.477860343577379, 4.58130647501084, -1.6831754541054802, -2.832633800685463, -2.434100013266464, 0.2464032951917728},
    {-2.5134339896186817, -1.5656278306333329, -2.126482626919182, -2.4631112916149256, 0.7262973039719091, -2.5336678487921214, -2.4715035916776116, -1.996158917249522, 2.600806493394616, 3.1197530275962357, -2.1874567649596295, -1.7984348425902195, 2.7209789045290904, -2.8135916199585274, 4.210691393562514, -1.6631312442157182, -2.9957258665474775, -0.6702960384724191, 4.447581729924062, -2.372823004006192, -2.8926057720244387, -2.303303327876845, -1.2801234461992932, -3.1126241717050602, 1.3238979689879316, -2.7444949420921887, -2.448697551554359, 4.658176386368905, -1.8443128491510379, -2.5117968176893073, -2.648857520507551, 0.16895201509596097},
    {-2.453164034133445, -1.7397647674779886, -2.2211600170942454, -2.716240540163062, 0.7040078894917364, -2.632848765074596, -2.353386084267326, -2.086135711921121, 2.3902811990952832, 2.8309702597230006, -1.905026913026095, -1.4100841939418074, 2.1738137444447636, -2.580270118403783, 3.901786908077597, -1.688694882734133, -2.9068814463674606, -0.7306270501955544, 4.368858805023605, -2.371426238688497, -3.009377297383844, -2.347174065572468, -0.9658375298474626, -2.7684681382062473, 1.0306754281264614, -2.5768090079073973, -1.8540004285012457, 4.255832436154057, -1.6085911507205428, -2.671699002927601, -2.190173271553586, -0.02615694487299761},
    {-1.5743567997122967, -0.8245480159521389, -1.4136254904056962, 0.3295462305159475, -1.7774735671054862, -0.3955449035891141, -1.8654079951073288, -1.384650873026884, -1.1195930277284336, -0.8591570480921927, -1.0009553026625877, -1.7869044574463244, 0.5651097728269263, -1.8671854452208516, -1.3270993252478749, -1.4538706440121483, -0.14733313234197867, -1.9863942313770244, -1.369343379565698, -0.5215061005546173, -0.2357727196524225, -1.5438768135686243, -1.8722745030336005, -0.6658694927619083, -1.8183262164815828, -1.8980644184899598, -1.8958504646233485, -1.506279955657464, -1.5269971537717353, -0.8852056959788579, -1.6547892853760797, 0.44962484357048854},
    {-1.8319487063554856, -1.2288098104998761, -1.4519979238317182, -2.2188956804866007, 0.5004224419431923, -2.077969603778823, -1.086629790550845, -1.6832593737082604, 1.1326797748974484, 1.5294187106553898, -1.6543563470412477, -1.4247359921357743, 1.270148918359263, -0.9392870459297049, 1.9446805872919635, -1.1595133445769135, -2.083504696997878, -0.3248471231271827, 2.4755689535744687, -1.8929379911265185, -2.32246340948894, -0.478464448442602, -0.5238359280780478, -2.0170199511644267, 0.5114537874559704, -1.499643910012383, -1.5339355188698907, 2.547702519139323, -0.570409542284049, -1.0084499255233037, -0.87421564362663, 0.019946403483784722},
    {-1.9486915777483413, -2.3604882734440387, -2.0453695725200713, -1.859566337828581, -2.5752525247002307, -2.116090142989946, -2.057362990236534, -2.1259916967989323, -2.429800995814444, -1.5949196272570327, -2.211670146655576, -2.248241697058645, 0.2881054075797946, -1.9106382509193518, -1.548794666586406, -2.3963771392623765, -1.8646008414010657, -2.819728455514537, -2.2238563663988358, -2.074776488518894, -1.3233450501375714, -2.0467229072097206, -2.4216935962050625, -1.5765639956936204, -2.4653068510147844, -1.8905915813058558, -2.4142912626123367, -1.8012350608119845, -1.8976686577881812, -0.891121729996996, -2.5701657385569074, -2.2448681044362035},
    {-1.612149892468759, -2.606802035332464, -1.7820579332102486, -1.7839149133543761, -2.5421536057007392, -1.7457309022612264, -1.6089912130006045, -2.1822597999361584, -2.0926498943083818, -1.051842878999575, -2.0146880923137704, -1.883244412209439, -0.031285319620925144, -1.7996997521758387, -1.7982235535267286, -2.0059729917894975, -1.9654226802067982, -2.222859391576134, -1.6672260994106045, -1.7812933959617212, -1.4687198228082212, -2.3269686524632327, -2.0563705439221573, -1.2967945416887217, -2.5166561696854184, -1.4817844971311958, -1.8196626607971904, -1.3208717851649174, -2.0782741400911324, -1.0350228660054188, -1.8990512951845056, -2.033899740287268},
    {-2.6894987503698866, -2.6803269924774535, -2.335923899282069, -2.8105040935138343, -1.7824945798039777, -2.6061385440622025, -2.3925577372367393, -2.6899065105285334, -0.8132026567799975, -0.09875687929248861, -2.281239452136976, -2.501357152233622, 0.4150821164152098, -2.1785710778433436, 0.24728567929041528, -2.48657839579001, -2.321444175378837, -2.5774487893134834, 0.8562511410411714, -2.399330829763468, -2.6770212484300946, -2.594562748906363, -2.3927882445058097, -2.445339545606104, -1.3831415255515653, -2.7474293111198493, -2.705099907032918, 0.3494441546327772, -2.42333064389029, -1.9053473659578946, -2.2889609657423797, -1.555388026600345},
    {-2.468988450314547, -2.6330419632705495, -2.6401770302817056, -2.555877661210542, -1.521835921031469, -2.679536344202114, -2.131595061248871, -2.5514816711869495, -1.1710618316972354, -0.33137420004527623, -2.3587154239888037, -2.491328835352809, 0.8673527074088181, -1.8960628713191352, -0.27499775268745064, -2.5264889462731595, -2.4496008782584933, -2.557331483815686, -0.43256327114593046, -2.325690345611089, -2.543165694887633, -2.1774487197916583, -2.5623009594383004, -2.5170499831511908, -1.9637928766603663, -2.2329082717970903, -2.2835775378636947, -0.5364232199922992, -2.4465200997310537, -2.132375964307711, -2.5305349695169737, -1.4110975629846587},
    {-2.6273043685427284, -2.7033728143213445, -2.583208757286754, -2.829311754911969, -2.2353804895268685, -2.601893530207628, -2.4957369714154063, -2.8808978072201583, -1.411937195716671, -0.20356426944446068, -2.797643831967219, -2.878700820682054, 0.4024651523081596, -2.2531803601284275, -1.017267742169877, -2.7037322746927366, -2.589731569198882, -3.0571177006616126, -0.49476604958269077, -2.4893368079890315, -2.3929219142978857, -2.344913248324694, -3.019824559611767, -2.9331099479312517, -2.3202823814610705, -2.633375642682066, -2.673016909711987, -0.34312331119860817, -2.6207943841405505, -2.6189127376109047, -2.476745374550147, -1.5152661427569643},
    {-2.4996608087737817, -2.4577653324118347, -2.217266818809219, -2.2046481638050914, -2.2069467797827342, -1.8365907919545155, -2.193532330837169, -2.5039276621745548, -1.170676520066006, -0.029785686765955027, -2.4242124749281353, -2.572747307158604, 0.7788543949871461, -1.7436478233850092, -0.8367875579951981, -2.4932798586162415, -2.2809795077147554, -2.370530396015767, -0.40784467831406573, -2.257880661484019, -2.377365763761351, -2.2242118099321906, -2.7471689049359695, -2.3470496861025847, -1.9276980178976777, -2.421411327622941, -2.569852569770985, -0.2431806132609223, -2.5234254078817084, -2.0301161560857177, -1.8718831439387895, -1.6006480345666196},
    {-2.895317035789554, -2.502438133661201, -2.752473857695634, -2.717368943215457, -2.3478438112731834, -2.577384006686887, -2.6520267371842166, -2.9514653584476327, -1.5920191958248338, 0.3006261124600636, -2.198179347087104, -2.5501030997551846, 1.1972588441861771, -1.6180323661866443, -0.32929707438456807, -2.9413803067363173, -2.656863564518989, -2.847384834911265, 0.008179878224431952, -2.8634441113301934, -2.3306149997015275, -2.3029928647139677, -2.913943281269269, -2.2470122439254365, -2.3193262811517497, -2.2196691494930163, -2.625290717260828, -0.20015417175464764, -2.317040788415904, -1.8603682671674493, -2.587058867145292, -1.5488941478946119},
    {-3.2893541546882887, -3.210746832673043, -3.1861490516596014, -2.9432627451925186, -2.0419020457176047, -2.8137231398535207, -2.939677866912888, -2.8622508665293895, -1.9113218717246867, -0.12356062671215699, -2.6978767403996695, -2.7344569799357994, 1.1417774349917045, -2.5526245005036956, -0.27138207324438024, -3.0558797561279856, -2.706070946999835, -3.2743464641795734, -0.22559512361470602, -2.9939290612085987, -2.8189962689878985, -2.718017605059433, -3.07691784094504, -2.9133544710955785, -2.666708127133124, -2.8801872194629836, -2.9883286302036827, -0.17410546038137323, -2.6427078361557794, -2.541553657600219, -3.158483144356029, -1.3954151769842222},
    {-2.212015641906245, -2.75540524806827, -2.675482576908573, -2.054474296808334, -2.726121801124206, -2.6442025170733383, -2.2299205661704087, -2.7710361183588916, -2.147618461967134, -0.44794136096518905, -2.4355814472746595, -2.6040672041547754, 0.38149965533232316, -2.5903276022730277, -1.6212044078076244, -2.592406645910038, -2.1469933897710782, -2.5687118938952995, -1.0386730368747534, -2.4937366851464406, -2.202234310832546, -2.372529054666338, -2.7524362162418483, -2.2787339822537263, -2.296013629780283, -2.5817841363560556, -2.881821461615194, -0.8498696599465401, -2.3822141952477343, -2.4078596336698435, -2.5605373660179866, -1.8958825055047073},
    {-2.850555345385609, -3.043929944208823, -2.932568003310335, -2.3711237033749506, -2.4353219865157776, -2.588003113555597, -2.6526425346982423, -2.915038718482953, -2.4411347630422364, -0.6903827217252467, -2.782458205422505, -3.09244585725801, 0.40579391712903246, -2.588652931573955, -1.4702211434896069, -2.8451645710854128, -2.504198764886701, -2.8276283291561857, -0.725772656307521, -2.8311508189476484, -2.6407854400850184, -2.533620311871563, -3.17056791991438, -2.549656904184194, -2.842269861019408, -2.96141477858633, -3.0954892293720717, -1.0560030067372468, -2.839390086575484, -2.2853203391709993, -2.8128292995934276, -2.2302323138621905},
    {-2.928829805655381, -3.2422586598914998, -3.1182237420702643, -2.728476646163151, -3.1592205901891375, -3.062906359327567, -2.966341379712054, -2.9571927533431377, -1.9830842187051312, -0.3614305570385267, -2.9492160176552837, -2.93850317076103, 0.5955358286547838, -2.706135059997112, -1.5473850497573247, -3.2388809021170393, -2.985226336525291, -3.1563363717975466, -1.3617943392394798, -2.899786475030913, -2.937596173931329, -2.6310382727718276, -3.245962458370342, -2.9235333609893033, -2.891099213515642, -3.184530761265148, -2.885187643848673, -0.9223805334250068, -2.9744415067213126, -2.6358007369872096, -3.1668131736124017, -1.875402217477118},
    {-3.2846763051405445, -3.294326963501868, -3.059265272388154, -3.2907450619233756, -3.181776248352786, -3.086677406006121, -2.9357732045179774, -2.9881926560406136, -2.6236961141196447, -0.49516726403930006, -2.828594846332717, -3.2164368454673555, 0.43122039036168835, -2.451898595312879, -1.26519126565374, -2.9811300516091985, -3.357823640080888, -3.125156854018795, -1.7995476572400873, -2.693636314174959, -2.9794721835211133, -2.2777255620378964, -3.1178191101841977, -2.70791215410352, -3.30907496540101, -3.147088415314698, -3.175400276976831, -1.4565029239133245, -3.0700603505335993, -2.2167021206810587, -3.311409189437939, -2.5148304584395027},
    {-2.9218922636980227, -3.0249913436261786, -2.9491498273137515, -2.599216904727027, -2.7315723144562276, -3.07681372641995, -2.910449183733149, -3.019067375961797, -2.151707372814264, -0.8018348482666849, -2.927802528634739, -2.821923064295091, 0.9145663026031404, -2.8494931859945734, -0.3733822099148208, -2.880268847965377, -2.7441147697670973, -3.3284382860840656, -1.2622821819083203, -2.7669900066441304, -2.5391718408811164, -2.3914988499138454, -2.9024274606159084, -2.664966030019279, -2.952252144500138, -2.6706674767322434, -3.2569472998326976, -1.1650571584753042, -3.0131161379503855, -2.119808519404464, -3.1338166377009538, -2.234536094189364},
    {-2.806709056481085, -2.9553203220754787, -2.9617974040466293, -2.823050815535802, -2.519714110663463, -2.620177005558921, -2.519980354403907, -2.7663255565908553, -3.089942161890457, -1.408032342133343, -2.3359975204289145, -2.6617017023069542, 0.5402926401100695, -2.3500459758125243, -0.7703452036058643, -2.6720838244298064, -2.6206925651015935, -3.1450493773057855, -1.761947811450508, -2.625690402252809, -2.723792489184858, -2.353629442260068, -2.723183014183019, -2.3799231854719025, -3.3543875924099895, -2.359161002515166, -2.6530476201177637, -2.0436464025787457, -2.4851157335027785, -1.6750960669241657, -3.078216847952776, -2.5403443304710844},
    {-2.216846221130551, -2.520510667698244, -2.161787692405686, -2.2527517662469605, -2.197799466294691, -2.5142795283874055, -2.221201991141128, -2.6437783871125484, -2.038299684859809, -0.6198176212950547, -2.3336599417947586, -2.209656536486483, 1.1114125013030354, -1.7251925398300663, -0.661601304311361, -2.365209370355763, -2.371206043502715, -2.2200641717357845, -0.8079028052735124, -2.3219537717108016, -2.1627281269381347, -1.7033279012987308, -2.4621098508611134, -1.750658100798977, -2.4388336463904445, -2.0289235289469576, -2.4196153192384307, -0.7603491600418752, -2.326601351677414, -1.543736801622488, -2.380222651847371, -1.993253530984306},
    {-1.8139375428831928, -2.3215288459919985, -2.1445362781740234, -2.1266907206596293, -1.2749902986259867, -1.7527566901588068, -1.6055411356781897, -2.0125131559793963, -1.7367635243206323, -0.08379278523772374, -1.5708504415639875, -1.6995877077289836, 1.3662358013625542, -1.6179916697918493, 0.822717248748578, -1.73527085826166, -2.0743838177279796, -2.1187318489490834, 0.2698809202927122, -2.0532843453517247, -2.167472524708089, -1.2999504137705966, -2.081487434657926, -1.5358575564015604, -1.9271133943579846, -1.5515934811940604, -2.0623475818080874, 0.3911182416190422, -1.608777671019053, -1.2833549230930135, -1.9736823666914616, -1.0842590516252841},
    {-2.4397811986650204, -2.639552428350641, -2.5265564069390534, -2.7147157988089523, -3.0340872860560046, -2.259676158861313, -2.306839466602993, -2.714068438069771, -2.7451306155529793, -1.202343643505151, -2.059486997361885, -2.501207177976966, 0.6937068864503627, -2.0323812014402423, -1.3622678937473098, -2.487784978639641, -2.3254398546590074, -2.9246681099145775, -2.0498491754671915, -2.4592786980376866, -2.3567909501374475, -1.7571155951169994, -3.1305741717786515, -1.5992912538160555, -2.7911544681031826, -2.1620854312346682, -2.7643591258314935, -1.7699601679852597, -2.563682525520333, -1.1359805685614393, -2.5479034727079584, -2.5911093370545184},
    {-3.6582447230757182, -3.3859042035855613, -3.322976832518988, -2.991531527469841, -3.447765123398095, -3.305972977606225, -3.229132564301468, -3.3915007688650105, -2.8122229719258467, -1.0543911107482078, -3.009777671407097, -3.3571285917251745, 1.0922048043389623, -2.534950021968492, -1.4884443620962176, -3.6194227089367654, -2.7980253084489077, -3.2318130458794596, -1.9828149165228997, -3.158376009786033, -2.7858919141027743, -2.360418592364507, -3.7364976742881737, -2.2928606090655608, -3.134541943810311, -3.0955561777179756, -3.703536369369342, -1.7511056565936627, -3.110052480261088, -1.8179990628225022, -3.296520229837632, -2.553834177095935},
    {-3.59836598770753, -3.6009710587542583, -3.280172091722555, -2.8969680047807866, -3.161021385632585, -3.3858802975692424, -3.282270143475874, -3.787485782878932, -3.0777060780941605, -0.9720401453306976, -3.5931061347510314, -3.379415090837831, 1.2386415557128905, -2.8859431280139796, -1.724132326553004, -3.3928583986953407, -2.900460957449524, -3.444926299132997, -1.8985376464491683, -3.5470633438607577, -3.079361909034448, -2.749715376111238, -3.608067607391299, -2.5625743813158968, -3.3655802155583943, -3.1697007672872273, -3.782504433128701, -1.2640865715236858, -3.394402562792331, -2.425391502944696, -3.395966765190803, -2.8966769927210003},
    {-2.582790203359864, -2.824520934148259, -2.7470730620418413, -2.70708740688942, -1.6000524148588213, -2.7347129333046865, -2.296617706177809, -2.6552630135588142, -1.9459713306536037, -0.031573395100545146, -2.236424505248344, -2.3293566354143302, 2.3942339626119526, -2.2551448621039767, 1.682749386867438, -2.4982753920534844, -2.7866363694471383, -2.9017527339393383, 0.5084640912394683, -2.684301900663467, -2.7297056569784615, -1.9411732126471786, -2.5731231110192634, -2.1283254565074317, -2.543938881997265, -2.022966393888498, -2.993975281698343, 0.8444986863868083, -2.0500244569174617, -1.6755297127043625, -2.8479220192323558, -1.696104121081448},
    {-2.028745159027653, -2.530546966099489, -2.3926720726196, -1.9336954626609086, -1.8600241587041262, -2.119174953701589, -1.764309656543429, -2.3569774969129993, -2.538096355988044, -0.20242831563358615, -1.7103069546057355, -2.285517361467848, 2.7089274399757532, -1.5080588754628133, 0.7599721436897752, -2.5457557380043245, -1.8204512845330363, -2.88891556170447, -1.2183532756127846, -2.5647349159348662, -1.9028254082116856, -1.1062848285031561, -2.8014321134268876, -1.0960731629342235, -2.975335747029178, -1.4943991563801924, -2.7269620714730873, -0.8448149981090853, -1.9510752758414125, -0.5826652271204156, -2.3718305831890962, -1.3724927440802375},
    {-2.7256899753811332, -2.926097460412741, -2.7088787791925424, -2.2101479689213965, -3.0762232356145938, -2.8071163148130367, -2.744439572134017, -3.3021517393749686, -2.9657360565617803, -1.205918931941687, -2.5896405665153854, -3.0359183984133224, 2.0534215030372773, -2.566803287340812, -1.2804355109257215, -3.2751118962841663, -2.2854700714118086, -3.5702953160300432, -2.2360230858444625, -2.8162365375084435, -2.2892165424894624, -2.5692889502837954, -3.332584108429637, -1.8821329740621742, -3.529596857264846, -2.703406361190153, -3.3111330519296045, -2.0699627811400925, -2.8458224224457704, -1.8784211570532696, -3.2620212885059376, -2.2721645402778146},
    {-3.3590322651201614, -3.399878164162227, -3.0712313031192897, -2.8239280010438135, -3.1684805692390796, -3.1659374340919033, -3.31067514015245, -3.4125608411861412, -2.9452992675133833, -1.377621960435316, -3.1887128058721657, -3.4008575393057026, 1.2588047963030757, -2.913488626352993, -1.8334550147663935, -3.2159390151661618, -2.8997504586503844, -3.4248647096803433, -2.054748703994521, -3.1691338941373584, -2.7267931359949276, -3.031079288902487, -3.530827039688888, -2.7493362970573108, -3.39433998819567, -3.2204280617506575, -3.5667107950243233, -1.8639455599993928, -3.156737058795984, -2.372658423932146, -3.4343014075228475, -2.5449864534493276},
    {-2.392678296128885, -2.8659867957321374, -2.925242740952051, -2.3278648224329848, -2.5683050734420623, -2.5226918993409386, -2.4217475597981934, -2.922787819270692, -3.6457031718997563, -1.6548511832148318, -2.2928651999357563, -2.525423299877836, 1.45025496027769, -2.3972725341493057, -0.9582288571371775, -2.875523870055463, -2.4868756614324363, -3.223073536606014, -2.578039674304493, -2.445840932359909, -2.081867824077497, -2.115955834648589, -3.1792163484312663, -1.1984565639513418, -3.6762536501086522, -1.8897950573731703, -2.7467515936631757, -2.4211340616459602, -2.4250838217064716, -0.8799217388714853, -2.9912099624506006, -2.3496925326460367},
    {-3.0209013768945723, -2.9530563864420962, -2.910902226280597, -2.5067171713526477, -2.6484479021848824, -2.620782228141792, -2.555399244300063, -2.861254321241316, -2.8234385465147027, -0.7295036754703531, -2.6253853625414174, -2.761991727479639, 2.372881692856661, -2.668942872742798, -0.15618868191175572, -3.1483027958882084, -2.573556891985923, -3.250076275295465, -1.3750401614545043, -2.992241617558997, -2.4602369479251394, -2.1864439830560585, -2.9234167350379088, -1.6656909772872026, -3.199966027206569, -2.635712338342922, -3.067627086684955, -1.502516563469566, -2.506222690496585, -1.5185575054742224, -3.128866015967641, -1.7308554692945914},
    {-3.2560413388059075, -2.952827549895146, -3.2128547535074143, -2.8332116686238833, -3.059505189869794, -2.938673765736714, -2.7202028099805675, -3.446807455422713, -3.2546672368362883, -1.0649874338481307, -2.695395460407763, -2.934459427385624, 1.3780519881628093, -2.738470671083839, -0.5722335383088074, -3.3542123316477497, -2.781393749907751, -3.3427904418370575, -1.988692881348585, -2.9698853417616613, -2.3793078944181065, -2.6321970288167518, -3.2676652175260457, -1.8461110541342953, -3.478250399263171, -2.8274105639615037, -3.409999376754473, -1.9256509259542156, -2.773978612635602, -1.725629363425816, -3.186582410004708, -2.3404703582202755},
    {-3.043875855010296, -3.1628867647202683, -3.0168967703813143, -2.4973070870865643, -2.8709064534183915, -2.5858373608817327, -2.4365619546338944, -3.0023596504996317, -3.3819788545178846, -1.5256551520658896, -2.666836254897099, -2.732950630679492, 1.6631105005834241, -2.392240059834691, -0.7854321828313401, -3.2294134999210558, -2.7907538047975224, -3.6017463297808283, -2.1302354737273204, -2.93918340604607, -2.533336702906463, -2.290897211433187, -3.1601116912285665, -1.7187766137156426, -3.8075001617513595, -2.6460448321905004, -3.2672110456120156, -2.266074467819827, -2.878688649618574, -1.2370003224416268, -3.216021199976185, -2.270824620870327},
    {-2.6861611294834677, -2.951307241292646, -2.789675491435138, -2.177648815713895, -2.665771749524597, -2.6326074369109675, -2.602017194429675, -2.726227979823579, -3.084555605392055, -0.9774833967006676, -2.1868437004028456, -2.446488246937039, 2.1199296460728108, -2.567441840712422, -0.6900332239067525, -2.6472608276076213, -2.315198865319928, -3.414897616247711, -2.188548606190877, -2.874044192222639, -1.8941168748438002, -1.947502785824889, -2.918316899232889, -1.6777820611518366, -3.414948448775992, -2.20240168237575, -2.8905052968424125, -2.0643329862805007, -2.524936169557173, -1.5454326172216892, -2.996902464100151, -1.6943701755494267},
    {1.229940206454473, -1.1744380332375324, -1.060149235378995, -0.9350928907971838, 1.6103108603953133, 0.5814413272743278, 0.7889462202997868, 1.3998889086390238, -1.6916301497998998, -2.2199980680196143, 1.3224161851107519, 1.4456974032027852, -2.480371557740116, 1.1893103677028987, 1.7213880446023118, 1.475516746619018, -1.71489103887776, -0.45993949143562174, 0.902336538701246, 0.740274446771091, -1.5739764489396164, 1.6523734160696655, 0.9465460131130371, 1.6000714262859308, -0.8103998152050961, 1.2523346924051673, 0.5858582279934068, -0.4805457745188392, 1.857445042082055, 1.3646254928142076, -0.710975653476759, -2.887196417368331},
    {1.6303369692823793, -1.4439859327550306, -0.7291522492674907, -1.2031160566121182, 1.718936719829278, 0.6750134477584495, 0.9074539172555515, 1.4461354267083244, -1.7432342578284474, -2.336587743254862, 1.3779841832523438, 1.447171911012419, -1.902150234455925, 1.3423275260600387, 1.6776493508161459, 1.2325433414262856, -1.0513907524115367, -0.38577118805506194, 1.0789791606794974, 0.7689971157756298, -0.8847146980692051, 1.503161735745319, 1.360101661595058, 1.2976625609397254, -0.8288724361035438, 1.4545807408617475, 0.5914993122536542, 0.2836177485097733, 1.951472755611598, 1.5629459234316971, -0.7965925028850309, -2.7153419282895137},
    {1.7760397740268, -2.0500585190872473, -1.5023467725145032, -1.9040940498244985, 1.9232065783545758, 0.8085902492505078, 1.3684325262045351, 1.3793336702505714, -2.39948705195826, -3.2753316723395587, 1.9272145516771584, 1.2853231740589968, -2.3396607615154554, 1.487113458071553, 1.3331196806185701, 1.856941815166679, -1.5083492653944388, -0.9384812208901784, 0.531206717973052, 0.6756172332780487, -1.4806464777531796, 1.3252255431551387, 1.1040628355104318, 1.9724949146067823, -1.7805900983261007, 2.024007870528999, 0.8344196423448113, -0.8723792393613937, 2.1949726749097147, 1.521259274081024, -1.5170992503239122, -3.3647879552735076},
    {1.9087109548796188, -1.3759292670646213, -0.8832846350026446, -1.5016608756613188, 2.569560301490731, 1.0269613327168519, 1.7409980769777558, 1.6348832968741869, -1.8859118953638478, -2.919240922084532, 2.2289064144434296, 1.6534345444306175, -2.4558284863664674, 2.0641885496193892, 2.1783255293548787, 1.7797722987492544, -1.6118669963785663, -0.6834769409521891, 1.2068265615992213, 1.1703835105023184, -1.4636576989908334, 1.9627309712785372, 1.8931941619486405, 1.9864820665348104, -0.8757733558139169, 2.0093389427641246, 1.4923079594249398, -0.31014231168213474, 2.356005507202902, 2.1297520114472466, -1.146020001141218, -2.7983665995681637},
    {1.4766470288669136, -0.918432834365989, -0.6586673080978535, -1.137115326749566, 2.454437993190949, 0.8846764727407314, 1.5514219162255714, 1.6789224024277307, -1.7301038898977257, -2.6987238545802192, 1.721537331044989, 1.8440656737338037, -2.5789460765833883, 1.6164702705983456, 1.7718089915342146, 1.9875346552061712, -1.3771056182604275, -0.45019548994337183, 1.5286918873343476, 0.9009846778277302, -1.1414328269981837, 1.1868586569419324, 1.6794055645751218, 1.423722410529042, -0.999713070667552, 1.7691115380944642, 1.2546154750068925, -0.12752187245173624, 2.258100967014641, 1.5352042001287045, -1.0498212132949631, -2.540196291353738},
    {1.5045770110679284, -1.2769050802473665, -1.0343487839080123, -1.117163944870433, 2.140268482216874, 1.0987699010907819, 1.5876005740423762, 1.7192100397015084, -2.130755977232772, -3.064366988223678, 1.5926060474537953, 1.774293526019969, -2.4738137461209777, 1.3793432605171956, 1.518219176778131, 2.034820616634965, -1.375303243416243, -0.1527800661872751, 0.9544923364241081, 1.0851515450310318, -0.7896637059446961, 1.2086596388929787, 1.2821827457889694, 1.5800628944005717, -1.6841188100509814, 1.7396769390124402, 1.1631011930303405, -0.7951763623964903, 2.026027489976803, 1.4925434933226642, -0.9248828738628324, -2.7984886018164525},
    {1.7211296018497109, -1.9008630059208844, -1.4400072413003935, -1.777989843670574, 1.6586098725513607, 1.113256377902302, 1.4188553593052224, 1.3677536550092193, -2.4651583391570298, -3.2292348707653296, 1.6451302851969853, 1.3424238143814542, -2.747278078643125, 1.2644850451702319, 1.2520729280882346, 1.6434055577383948, -2.0939077711765663, -0.7023656754914979, 0.8222106949539586, 0.880834450566251, -1.5361876380626762, 1.2339181462216184, 1.487253001854596, 1.8295425595779589, -2.0863156534851193, 1.7607801539783683, 0.9236581329671092, -0.8999259202398104, 2.0867286680006947, 1.672616486691377, -1.4196662705518817, -3.1491434775885763},
    {2.0596102062227226, -1.1044319487104555, -0.9993137432074404, -1.4741368013768508, 2.21566488023994, 1.1806422382732502, 1.4995966131877392, 1.886681713295126, -2.303115941554628, -3.298396765310115, 2.315856828838088, 2.060609866019863, -3.21059317462451, 2.1573445649436045, 1.608668755940078, 2.1856354885141327, -1.392553369554982, -0.14847130176359696, 1.0438023134233607, 1.2291472381255768, -1.3223885888994726, 1.8007556627431724, 1.6818479458553264, 1.8599462764179013, -1.2054500280369365, 1.8204758553476947, 1.4227562708282662, -0.3897375826045108, 2.4765654482022934, 2.0384190270818867, -1.101202225632435, -3.1712819930175993},
    {1.613058890198054, -1.5359654444174626, -1.3284745868382837, -1.7609451854126523, 2.282274806187207, 0.8839674898824542, 1.6442884378305702, 1.7596067915880564, -2.3007466048543352, -3.2497614265888193, 2.4135130075337927, 1.850264643256531, -3.397219555816123, 2.3270704082978444, 1.4700343107320266, 2.267475751816385, -1.8703938575363328, -0.24990916059279292, 0.7716516622906362, 0.933569726954451, -1.734186838804579, 2.1740037839956012, 1.7047407864936233, 2.2066801756589833, -1.415401119212171, 1.9058164468306964, 1.4552030734560213, -0.4942885919676176, 2.577310806335508, 2.0316116803134543, -0.975038817539554, -3.4217326167002167},
    {1.6899421634724672, -2.023779750619927, -1.4581153241457618, -1.710520192401769, 2.1837555424048567, 0.8654728978660651, 1.5777221668852839, 1.296466267537358, -2.020765087021824, -3.2928190568882476, 2.3396160650458557, 1.7803625718611118, -3.248505130571669, 2.203921831049596, 1.7886855379623394, 2.0764139291381483, -1.9599638540900544, -1.048456430061813, 1.2772822879147685, 1.0302184685871019, -1.5745584318715735, 2.2601544510377805, 1.5869188928370854, 2.366914111447999, -1.7518673680328463, 1.923936650394955, 1.0512526467334382, -0.48034969278967643, 2.2696645511083293, 2.117227884818543, -1.393639987914141, -3.374303605276702},
    {1.418495778913179, -1.5807084500666044, -1.1496278853067394, -1.1609673462482697, 2.091323237261036, 1.3303304551397799, 1.3755334024014358, 1.4168110207563818, -1.8768366191502883, -3.1033419973259084, 2.125277711918763, 1.7223200784603803, -3.079494715974151, 2.0435776446853406, 1.827529300649579, 2.0527181712221996, -1.7568722682871567, -1.0141684319704776, 1.2126244621838853, 1.2868150278998967, -1.317727893971109, 2.0424560855946847, 1.429794220978922, 2.4082278559526875, -1.371916883281113, 2.3173974530322954, 0.9497218462179523, -0.48412589454321037, 2.1992522376488655, 1.9872618346598303, -1.14492703316417, -2.9102983948991423},
    {1.8178546367951072, -1.699009435649518, -1.582663123821753, -1.559736898801931, 2.625238543327083, 1.4998392197819026, 1.8383227037755436, 1.8936749002951216, -2.4233309228146243, -2.91797464038662, 2.368703926662904, 2.1204430919140878, -3.1728166612794286, 2.4481959980526193, 1.4872809102687592, 2.142223498269945, -1.9150907352285684, -0.8644533536602881, 1.0413684404335841, 1.4843725156974712, -1.4518273063185099, 2.3378905430414063, 1.9025894974853585, 2.1026949838108, -1.3643318647119764, 2.0848643083208707, 1.0469739390304398, -0.5119616973530691, 2.59149149715651, 2.2330935219992556, -1.5857276742804929, -3.0234056405419247},
    {2.1413689742334343, -1.257084625170401, -1.3098321568053863, -1.5555800457707096, 2.6904729146706665, 1.371657992854642, 1.9421230728105507, 1.6208030035603942, -1.9346918530454447, -2.906985258259904, 2.4238909059922604, 2.248923938762416, -3.1508705412487017, 2.3262967069332747, 1.9601831384872848, 2.1714934990210546, -1.9651789215207998, -0.540210569530172, 1.232020654020085, 1.3960323552990221, -1.7613324511777622, 2.2378444199902274, 1.4105247005586987, 2.342669015997142, -1.1669433505355284, 2.2425598194994754, 1.2928209767496073, -0.5090746715899379, 2.507548037858413, 2.183434296275642, -1.2346103957083794, -3.4877385550634403},
    {2.082097762252151, -1.272678891861765, -1.2967363882408927, -1.2920891328550705, 2.429094207447492, 1.3207006150751812, 1.6166619106107185, 1.449379634779059, -2.000024489063174, -2.626404953699123, 1.9426773880671127, 2.0686445204371133, -2.4641776508756688, 1.962308698933339, 1.9377942239950097, 2.249952823013185, -1.9316276090882838, -0.3360329968290644, 0.9475061293843459, 1.237584800298915, -1.5028791097565624, 1.912231066639739, 1.5142066324642671, 2.285266558141359, -1.2001588848734799, 1.9944857197355519, 1.402275081117916, -0.5115115752209249, 2.5750193060461117, 2.2345607851610443, -1.338073640752104, -3.3313947423230794},
    {1.622724738954515, -1.3347374862306804, -1.3153703913393657, -1.6375192307382045, 2.099537912405454, 0.9730362937485297, 1.6710603495967418, 1.5955933085303113, -2.5916343843365075, -3.3198559410476896, 1.8632669949669358, 1.9884405795891127, -2.6998320463492185, 1.6602733856982603, 1.632811520782785, 2.230208146378732, -1.911435940101527, -0.44425556703293045, 0.15451772067697353, 1.337079707767932, -1.6470467760662812, 1.934405045507152, 1.3374162162341745, 1.9775966951159476, -1.6222005706843003, 1.5972448500958454, 1.3149824628678572, -1.2769956488440717, 2.346894981088838, 2.421462679973774, -1.1761879700079205, -3.3370510615996882},
    {1.6329946995303724, -2.027726645824229, -1.5898399605870235, -2.2370781819813117, 2.395799611476091, 1.1965855598890627, 1.3885309374598933, 1.668527048868736, -2.7516869723158486, -3.7251576273434934, 2.2011463495795938, 1.7417071818599346, -3.036038642584312, 1.9123876457820788, 1.7590323691942926, 1.8795803873484036, -2.1667801167566516, -0.9493637343588075, 0.520776228991926, 1.0683480326287396, -2.23877959801022, 1.9427437401743477, 1.5026498158692267, 1.9957580106638604, -1.8157487885548982, 1.830010601263779, 1.217283573909297, -1.2042033040550624, 2.2273301096904996, 2.1859570428647386, -1.7075705554267293, -3.477709975473367},
    {2.0320165146306395, -1.566575017375592, -1.7036310518173232, -2.0963505555568753, 2.234445123933681, 1.3284990192346589, 1.6140143425705118, 1.775262815347036, -2.481438326718643, -3.358673617926183, 2.4722598861146827, 2.090945355922314, -2.818204373036968, 2.295208475127919, 2.167615200477824, 2.08451647445419, -2.148072789132939, -1.1163118065319897, 1.0739242249781082, 0.9156881000493141, -2.05453620778761, 2.2076897317167132, 1.5012736413642842, 2.5082388819902337, -1.557390445991243, 2.5750679175692333, 1.3574254775970025, -0.5270533834725896, 2.4323341679877544, 2.25048138036336, -1.7190177941440572, -3.464548689845795},
    {2.0498256250173585, -1.852093046314858, -1.6367206997041754, -1.9353429041657135, 2.4464436973349617, 1.4146088968887895, 2.0150685490407656, 2.0822735408024045, -2.4324046601768283, -3.2332740807716496, 2.7454214014329907, 2.250590714281598, -3.0165156705622276, 2.07781651234498, 2.187657923847128, 2.6036414827459127, -1.9511054123713736, -0.6332379164274179, 0.9562600989125525, 1.087093874335383, -2.053475107702997, 2.215012968280273, 2.175779920292729, 2.387282111692454, -1.6312838537582584, 2.767785617208919, 1.2924240534219273, -1.142485051062571, 2.4658660577082037, 2.284651849407445, -1.6097944466554694, -3.6104652903592567},
    {1.942786578239474, -1.7057929262772684, -1.4935123560706896, -1.8625102950109451, 2.1683044759877728, 1.2672089586633288, 1.5918846993266107, 2.1619552057660525, -2.5678459792822466, -2.981031663303307, 2.4642082230173985, 2.19002156825442, -2.8456306121251163, 2.1363425989893314, 2.2088046471690417, 2.541464542630056, -2.373130459241323, -1.0246283741361715, 0.5491601234085003, 1.1071172958613085, -1.8808192777861543, 2.151360252812842, 1.919382404318618, 2.0662712585642877, -1.8627317976159898, 2.2420658685117676, 1.0649744913761476, -0.8401340091178396, 2.9743831785053936, 2.7347360917181787, -1.4638322352575819, -3.386265523410583},
    {2.441194436397453, -1.5031176749255388, -1.431267355424701, -1.6495898462270335, 2.6170432536263104, 1.311152294684822, 1.7414367930679027, 1.911859566429906, -2.573954400911338, -3.428557512248745, 2.541113565549612, 2.033965875018975, -2.6603793400545133, 2.1051445429712214, 2.466570293215736, 2.4482990919428933, -1.828640601980728, -0.7348351577503264, 0.989994126183898, 1.2956734706914974, -1.6496326018864738, 2.5156265211318822, 1.86318857596171, 2.50997513200233, -1.7001978094130434, 2.6152632217764125, 1.6124916883915559, -0.7094648862657333, 2.6836060219030275, 2.725724253075727, -1.2717133264739897, -3.326659008710519},
    {2.287345823888455, -1.9543887455331246, -1.3181704948303572, -1.565755681899281, 2.690041124724743, 1.5506939480598136, 1.8775897101033594, 2.169075465177459, -2.685063460379962, -3.3014707857393146, 2.2344294614621654, 2.2375379872919674, -3.0465736739730023, 1.9365946023282086, 1.9828610260787423, 2.2172622802045012, -1.827916647888505, -0.4019935903299168, 1.2035929027671581, 1.3023956148014337, -2.1602414749965555, 2.1797150526691706, 1.7849262356531561, 2.5073867919111983, -1.3863672202094344, 2.428619149325045, 1.7289351964086117, -0.5247294642925158, 2.55660384081868, 2.5272217360697358, -1.0985387089620002, -3.4678303008291946},
    {2.273978314925189, -2.148030152871456, -1.7284009759713714, -1.6904427080162316, 2.83675675645589, 1.4398860563483107, 1.8733070511016567, 2.072227892294863, -2.6983017651314474, -3.156065871835744, 2.6948912503267826, 2.3963178818795954, -2.918371509672828, 2.176082083675431, 2.3579823160272735, 2.539456294716161, -2.309376572560549, -0.3382342019953402, 1.287433312994584, 1.4630630776712397, -2.3386361525012065, 2.797052454303919, 2.1741290994343223, 2.5944464245779546, -1.7559033293868764, 2.6243180058474014, 1.4676498865097056, 0.013166091176308492, 2.8208871906329382, 2.5837412614131656, -1.436840802251568, -3.322167804912321},
    {2.4186824478567432, -2.053831082124933, -1.9689626031920813, -2.056494451814061, 2.674979320387515, 1.8645574067198782, 2.201242040416615, 2.282971164556006, -3.1898901796005816, -3.707711693456189, 2.735902914819964, 2.438189920846055, -3.376223242532308, 2.8081280009599507, 2.1687814329944057, 2.842772584069769, -2.2766750948516674, -0.6774803495791112, 0.6731284360770201, 1.8572536495969245, -2.371959086467409, 2.7288683992437455, 2.3571614983601377, 2.8846298847213285, -2.3471309089909047, 2.956435523757675, 1.3739634197425015, -1.2273394842316372, 3.2136160419826423, 2.935523902713222, -1.713404281589144, -3.7588915546383648},
    {2.586947692301227, -1.9876537976493893, -1.8680369836016681, -2.0967015581643986, 2.731512726206277, 1.6513170547192602, 2.0921961439122088, 2.3312982333401644, -2.94505370235853, -3.952424655038657, 2.8499770986135506, 2.7379777214105427, -3.3563765888622994, 2.574585666275312, 1.7846865014134985, 2.5998845940925848, -2.401658852711874, -0.8578785689762339, 0.6331283256494361, 1.788873280335152, -2.5505228792559222, 2.8659200473165494, 2.327988592219428, 2.8547938219756754, -1.8132467008723476, 2.9024880555249277, 1.3878186647124304, -1.3563280711476497, 3.0465121753878948, 2.604953846378143, -1.5565380969140064, -4.071451325768396},
    {2.2470182661087565, -2.1198726936769896, -1.7868493438485127, -2.0251623728419808, 3.0077142796054788, 1.6159981052856798, 2.212986460296275, 2.0952706138923474, -2.7496982603030147, -3.2728812755631123, 2.9167145132263395, 2.603183992825345, -2.9088056898527324, 2.344490796429072, 2.3985011252227006, 2.459813101421005, -2.192411434502434, -0.8738893711347605, 1.1003534583737413, 1.556462318314704, -2.4005264651247598, 2.566153533178757, 2.163108233960142, 2.6434740093605886, -1.4665668055090582, 2.7266449005315168, 1.3848168757073451, -0.3510321888891704, 2.949691485913272, 2.7837793446231136, -1.451551080375696, -3.849130338422687},
    {2.271636820376677, -2.1338058253540684, -1.8368365580434924, -2.365489822166916, 2.9742735921360746, 1.6144013286609833, 2.381085518707061, 2.4801732802297867, -3.4449738958730722, -4.011736774005618, 2.707650821476949, 2.44754467656346, -3.344256721941959, 2.6346485009148504, 1.9883233840867227, 2.6546053448965634, -2.405085812424792, -1.1817356643095027, 0.6054846112925029, 1.4716901281920118, -2.6621830195671925, 2.8040676485809573, 2.19047955114781, 2.916676921419662, -2.431727412785813, 2.456085366282116, 1.6911553904797207, -1.4997052915380813, 2.989729707038546, 3.0097337479504294, -1.4968150844799768, -4.129118409282604},
    {2.3084204879429815, -2.4621889631151217, -1.8964400359715459, -2.2851598931063206, 2.928103780704396, 1.3188222447188276, 2.293284350405176, 2.4092342139027916, -3.229930820924399, -3.906567589966676, 2.72503795659765, 2.456239160528367, -3.5970334456311397, 2.3120861788948868, 1.8989666008455761, 2.8164765993380616, -2.3299815293876054, -1.2245227958886606, 0.7384603638144799, 1.4924440794216156, -2.6691661622939766, 2.7070632899970115, 2.4338083087864053, 2.643780308398153, -2.261741845431174, 2.5131223779515923, 1.6304727555143865, -1.1662054888342877, 2.835873549739455, 3.0679682283865906, -1.7294247550889523, -3.7742000716071487},
    {2.249477367471793, -2.3197274203793605, -2.1934372320186686, -2.055608287873669, 3.0240205090694547, 1.0185088534883955, 1.7724709575798487, 1.9497630950201372, -3.3927100320231123, -3.7526599099121625, 2.4828684949253144, 2.287864576628204, -3.1017769464618987, 2.114155095087902, 2.155144119844017, 2.309915358428693, -2.2905673732632743, -1.350572157380558, 1.0629526614185676, 1.3187552151060207, -2.7404139639746705, 2.3126776399687072, 1.9085050356877884, 2.5556246243438236, -2.554474171653865, 2.31338840062196, 1.201689893990004, -1.1164735214752284, 2.691973488986061, 2.8534296784414357, -2.1216056753103856, -3.656937466134847},
    {2.170379441291778, -2.5881371956375427, -2.2370889939953043, -2.460229017663108, 3.1540121587145045, 1.0715374942774643, 2.050792377603903, 2.271328569971353, -3.477094634605581, -3.6687859400509577, 2.8678307344533907, 2.4367931794133852, -3.353933679047134, 2.189411185939987, 2.0785953768511414, 2.4176387540073443, -2.7784888973313833, -1.2984730048395279, 1.0784685871144892, 0.8766970534615758, -2.853164452725015, 2.7307144675411656, 2.072222105718586, 2.8844160355609954, -2.5883933278718416, 2.5091044337119843, 1.008421868966596, -1.1516850198646438, 3.0084133144478096, 2.835100187681052, -2.178637889293122, -4.024071816734553},
    {2.0598540141790362, -2.5470611703182033, -2.2238179778587073, -2.3409418787306877, 2.824241535812036, 1.5728461898162855, 2.194865883209125, 2.218474614876725, -3.2436029600563074, -3.7846379875453264, 2.5522085660564535, 2.5048223167922705, -3.1687867793597175, 2.3958420955003943, 2.0277107120691844, 2.7398859248280383, -2.556033304790079, -0.6997665079936514, 1.1007158887723874, 1.0783383261904986, -2.608594223043473, 2.827410045565695, 2.263221740313859, 2.7861911076824817, -2.4424758677558254, 2.3118003676040098, 1.6494483268735693, -1.0252765417986873, 3.021683914572311, 2.717589913862515, -1.9736228757217242, -3.920905003841236},
    {-1.1387976159603352, -0.8212171937618562, -1.1972288832648874, 0.5724100420110204, -2.1851792901416593, -0.5822964331260819, -1.5113485643122986, -1.4588350576401494, -1.8440870454929095, -1.0798463365012232, -0.9845550073682056, -1.4746741111900474, 0.6690399097467954, -1.793588210384848, -2.365702049379152, -1.787141797366395, -0.08911582930236481, -2.144395771277712, -2.8586751928191627, -0.6915620874640748, 0.43254851430099456, -1.6880773706961254, -2.0636160508739274, -0.13465462984984708, -2.295940875751945, -1.1896502711479742, -1.7150758803079384, -2.251602513789313, -1.4057731837864629, -0.748278728801673, -1.4522914638499296, -0.3194243515903076},
    {0.23810006136199835, -0.49657976393848013, -0.2261576203776195, -0.4598497597836935, -0.24131816281789195, 0.28933477823268966, 0.4182023745997041, 0.044513966015833094, 0.211293848711478, 0.4685672972042182, -0.2628002472018544, -0.19646765630534932, 0.7714589974259477, 0.47650580828035094, 0.7421795847698391, 0.05846941108516003, -0.13366559292928648, -0.4176221581370599, 0.6785262935921335, -0.258223966378166, -0.01173668634814613, 0.046807994311833766, -0.03907312114855496, 0.45603786898345283, -0.000780844541406933, 0.6921974176558653, -0.1605401232514139, 1.044099218068092, 0.5768554402269178, 0.8322880932115312, 0.04735090068742496, -0.8789597684092761},
    {-2.203523812579874, -2.3894594825631565, -2.1186392210101843, -1.922109276044461, -2.9185652954357315, -2.3646824987631145, -2.4658359841723216, -2.769815827205429, -1.9735508887494033, -1.3618935354592079, -2.7240477940629395, -2.776068152963055, 0.8661965061292917, -2.7839770135144946, -2.047728284597404, -2.6418753559278763, -1.9334461143792216, -2.474861943208944, -2.4337457261786697, -2.371175034036091, -1.4095016022132965, -2.726571266472246, -2.9665941659531105, -1.9853680706668007, -2.657881761728582, -2.086741681171823, -2.7924275574653428, -2.117940759794915, -2.7035806262742392, -1.446568093997963, -2.4773904119481087, -1.589554840995553},
    {-1.4276416936266978, -2.045414095727844, -1.8635640485488745, -1.5630950949375233, -2.356405478844755, -1.9000232791171494, -1.628251460658659, -2.1444419330677786, -1.7730194393425243, -1.020922021442597, -1.967617216366119, -1.9433484172844333, 0.26364230086158746, -1.727551157061105, -1.6396438721154258, -1.8986007553402038, -1.7971760083346435, -2.3595501762576605, -1.9826320935393786, -1.7977449479243128, -1.4019441334233154, -2.37221646478891, -2.4294862623130546, -0.9718462578137487, -2.2084860771406714, -1.472489713221628, -1.7883179893180459, -2.0373539336876543, -1.8045682645118368, -0.7729946897262081, -2.062440482819021, -1.5180915039453007},
    {-1.9019097052577882, -2.397695155224862, -2.073915835639997, -2.735493140634577, -1.4196153348773253, -2.0811270838759905, -1.5008259419965286, -1.824728509946976, -1.1935525173571135, -0.5443093589338078, -1.7231723176866838, -1.906863202910355, 0.3547296108637257, -1.6171154109436694, 0.43324085896795855, -2.1245254659659363, -2.3824586578159934, -2.425216635213649, 0.03846375306978251, -2.143269471099399, -2.2028682998908065, -2.0329478099186415, -2.0917114141736404, -1.8860301878203476, -1.508551851836244, -1.8358903942512916, -2.218794084795944, -0.5261807041109428, -1.6226773833452646, -1.2045898701319517, -2.426125003745007, -1.7640519440889513},
    {-1.369619334963451, -1.8752611553226404, -1.5079626921654485, -1.8275128750378926, -1.0109123616822526, -1.7863848318466404, -1.5550093499261735, -1.7715779082944667, -0.4768036969108581, 0.3473294604422219, -1.461811104878146, -1.5926919139076567, 1.161508403758419, -1.143373896388211, 0.5365127464101485, -1.5928965234912151, -1.6193989438617342, -1.6342919705644143, 0.24036912568151605, -1.7671005290185415, -1.4606935942994064, -1.5622741713443662, -1.8044156855031734, -1.241842818670277, -0.936552543540437, -1.102753016127822, -1.3831949178694172, 0.06911270315749765, -1.6345405959159105, -1.0890262169928944, -1.915812222209018, -0.7389708598299547},
    {-2.055313734584525, -2.0885732315812966, -2.192712139850199, -2.1907496143819505, -1.789606394734075, -1.7940027583685598, -1.8700240816179814, -2.2375659349174053, -0.9730303635018258, -0.1045723849700323, -1.9211772754138197, -2.371557300869128, 0.45213839719835414, -1.5915899287936819, -0.6223324997622811, -2.178359046156703, -1.9128137485949677, -2.463925314426912, -0.5886684492011889, -1.9806706378453338, -1.9634235630251797, -1.6566077784066298, -2.495470874785618, -1.9823160617504576, -1.810276166143855, -2.010579655323015, -2.3938124066473176, -0.21786394742027262, -1.9226081133273756, -1.5718093205619412, -2.1172409030300083, -1.0271777557205148},
    {-1.9899248999245376, -1.428515571634014, -1.5519950136697045, -1.24200171844146, -1.3859737625132984, -1.4695487652379675, -1.75584211883351, -1.8566295122614505, -0.6582817035151644, 0.28267345137853483, -1.3006226386224287, -1.8764396128035457, 0.7649141347836057, -1.0132848238904035, -0.6762579770793397, -1.740052910254463, -1.5627231648627453, -2.1081902259101555, -0.537559076725887, -1.6040969132389773, -1.4232284587792157, -1.6513223041453928, -1.7018722586427846, -1.4703353343269883, -1.7625109661957905, -1.7574949631694468, -1.955758463156865, -0.44901025902492725, -1.3751776140164453, -0.948904610461644, -1.37168073700547, -1.2082753057132085},
    {-2.0111661085548467, -1.6001851870805655, -1.9270139918978701, -1.6262623806203145, -1.5894060522362985, -1.4757915805978012, -1.9355648585352443, -2.1126403161591054, -1.0165103518096552, 0.5114070993878905, -1.7648053814962266, -2.0231975875438915, 0.9865636574007621, -0.9900553067200135, -0.8937129148740558, -2.079978475547708, -1.7034869187644621, -2.249365461048447, -0.7066082108636027, -2.1712289816955797, -1.7371475856599268, -1.3753081016799955, -2.2978068293001552, -1.3598151052156238, -1.4757538334488134, -1.7392588546565817, -2.0265257672807406, -0.7442065837584767, -1.8466207161749917, -1.0854921765245749, -1.7707722210687453, -1.0747041259340624},
    {-2.1652126888980914, -2.101680427071757, -2.210631794579214, -1.4339827021592497, -1.4282499641460804, -2.2652270316158463, -2.2130473305223495, -2.3462168889340553, -1.1997113507097275, 0.40851713788424765, -2.053678409455757, -1.9679194975062142, 1.4598198760026273, -2.1611690747014607, -0.47694246220362724, -2.17267889210675, -1.6675323004279194, -2.6637497351159793, -0.4832326404467609, -2.383958843822537, -1.6105061251256354, -2.0036636437808806, -2.307251095867849, -1.7563494234945587, -2.133292954932987, -2.026290174407757, -2.4662630628792295, -0.5437341101832897, -2.2787352086746, -1.9168354693680882, -2.3870499731707477, -0.724427637711479},
    {-1.4435825319338011, -1.9495387475908037, -1.9369448646981426, -0.7179939517089943, -1.8700924322286447, -1.5066251557636763, -1.7693359238833928, -2.3383664852021604, -1.2070754231417304, -0.3277884053123977, -2.0725905042825157, -2.272702252038617, 0.8497647486160217, -1.7672094176512119, -1.4035262764673353, -1.9327399270491579, -1.2423376533041772, -2.371124504256283, -0.9350338863020393, -2.045907390642971, -0.816217478754015, -1.5149992729811435, -2.1278269366788747, -1.1542141826866026, -1.9104486349417698, -1.499202056825153, -2.269181964938666, -0.9921139550633326, -1.9346937958087702, -1.8093731367444317, -1.808811913318395, -0.8019146525570365},
    {-2.450003722717761, -2.156406258635776, -2.5069395210300827, -1.569227618099832, -2.6262100423491335, -2.0545053234640234, -2.2163605432712474, -2.305429117419038, -1.888542831225122, -0.4304261544290094, -2.1502912891954877, -2.4734671708733145, 0.7194463963477826, -1.7979677464169261, -1.0386424485008796, -2.589929659989471, -1.5295021240396638, -2.5371943049522643, -1.3395551713707117, -2.182412579597315, -1.4818292038260612, -1.6360830798484667, -2.659087401940856, -1.5927345209301238, -2.4974328445227245, -2.0666637235387046, -2.5848291311650136, -1.1407727636084832, -2.496328153172736, -1.5644875821508508, -2.5096036466001435, -1.5395771257554178},
    {-2.0991796166392365, -2.102496932241895, -2.0005735085835856, -1.494021037942718, -2.4929508658147546, -2.248774232616552, -2.230074872248155, -2.27311879175937, -1.4702235688335934, 0.33272895224905663, -2.2535889085815706, -2.2987790402100052, 1.0391997249739686, -1.9109116073511774, -1.5309346072478145, -2.397818003029584, -1.743798572435099, -2.724275574133038, -1.4730421976676402, -1.8827857709147993, -1.6598223283813294, -1.389088258528782, -2.603244508279913, -1.6896492736452247, -2.588394519106886, -2.4399300155581405, -2.2226202637001284, -0.8081743482783474, -1.9789525548797315, -1.7437290594903887, -2.446658113817236, -0.8650989685367336},
    {-2.279350612425306, -2.322041121400401, -2.3623834920027567, -1.6368529866478205, -2.1938363980002302, -1.8567536898930557, -2.1040078562761217, -2.4531267672516153, -1.6541101982313489, 0.017632563014995977, -1.8173958594820954, -2.063855071898026, 1.4773021379535438, -1.517860761767438, -0.9361547015304229, -2.3612963900622113, -1.9654420142024376, -2.320978421657365, -1.49736788590895, -2.0947165293747694, -1.3728474825853654, -1.0164999673249588, -2.4942762210908587, -1.4288485008671832, -2.5579049378249343, -1.933576718556524, -2.175960783737725, -1.2441498249095253, -2.077397397022498, -1.3637283701730343, -2.0907796804140877, -1.3512756147753509},
    {-2.3565524555148154, -2.0896103358876963, -2.1966956806038063, -1.4003105794891486, -2.095359324495481, -2.120370801596231, -2.339494464059004, -2.5067583053956564, -1.7469062884275945, -0.4643822942489582, -2.283426465813439, -2.5593522364885146, 1.3883415687214302, -2.1596565246571244, -0.3206252167331031, -2.267368490030371, -1.3327701518386872, -2.514718063944369, -1.568010516930635, -1.8641641689477475, -1.3743967052397623, -1.680623058677814, -2.7713769930267045, -1.7034639849776367, -2.7266504515433816, -1.877458407008052, -2.3197205440795727, -1.3998685183117434, -2.449918021829529, -1.4776387804793316, -2.0003960006958725, -0.8747295338935602},
    {-1.935022456939049, -2.497176868499162, -2.2745812070716944, -1.5542965484524993, -1.8653597773454211, -1.7314177598217642, -1.4839756057950624, -2.143449172789463, -2.3793921285157427, -1.3930220205881, -1.2908518611189614, -1.9892600022017546, 0.8952910485485445, -1.6095817255167213, -0.4480585791298575, -2.1392846719125633, -1.68246892921059, -2.531132808682251, -1.7327557078905325, -1.7695392041718028, -1.3341343400336674, -1.2009745091873798, -2.281273163182223, -1.315591072147573, -2.606480991804718, -1.532906872110205, -2.0744078953648355, -1.857058684364782, -1.8367255009250458, -0.919859812331692, -2.4464236539444792, -1.5680718073606192},
    {-1.9502550725359094, -1.842149953665005, -1.411735145130032, -1.3406840977575085, -1.9168972877310766, -1.9062996403576162, -1.5378542655076821, -1.9898416732614135, -1.9296173138299517, -0.7957431257348753, -1.8250268198386201, -1.8240213727368855, 1.5859947594237724, -1.4948686361230874, -1.366067319403806, -2.0201285277536623, -1.3656237742439297, -1.859635942279521, -1.977186838720816, -1.9516475154711719, -0.6258193100092359, -0.932329422994455, -2.1837923943313298, -1.1344589759976798, -2.3478712786194866, -1.6344659328116857, -2.0752949380816608, -1.7751495165020585, -1.9126228020415552, -1.1008087873771502, -1.3254662229154737, -1.2185072101949905},
    {-1.7515063397105697, -2.4190210049755945, -1.728312912380763, -1.6440700363697465, -1.6897053215671087, -1.4937346768730664, -1.6000207785543594, -2.125004715029556, -2.419980441870856, -0.5228749143521422, -1.3010062366678359, -1.6945103636633894, 1.5946060820900727, -1.4949480668156956, -0.49640283355586423, -1.75896742871065, -1.8532481761508504, -2.6739483437989757, -1.7582556472922386, -2.0037066870483793, -1.09906951760699, -1.004078952712305, -2.3552296955135708, -1.072578351057375, -2.7886786904922163, -1.4367408253110843, -1.9747990589678455, -1.7013134533105416, -1.6892218572304987, -0.8630306237910508, -2.172908132269456, -1.5260509966234652},
    {-1.5488389586408537, -2.07526851695442, -1.5690687723301813, -1.6420292988979859, -2.3765658254822752, -1.3917899222201444, -1.536639209476859, -2.029649722875865, -2.2491376608717704, -0.7044930298275994, -1.206077226845823, -1.8325823469089777, 1.4346244098419065, -1.0084004282614594, -0.7896658382059555, -1.8147765262827422, -1.554955627459054, -2.66019802519462, -1.9794562930501323, -1.6179971391153172, -1.1199209461932955, -0.9772076682704401, -2.4716579837407826, -0.6539805362353592, -2.7900849624203152, -1.2185070081228067, -2.202327610852153, -2.0612041175018327, -1.4638985665245396, -0.44286203765757726, -1.976186393349853, -1.646870648157584},
    {-2.6508895331549316, -2.4316469651280284, -2.458457355300828, -1.7066347174403238, -2.6228239274675453, -2.4999680415227825, -2.1546126668074748, -2.813330923745339, -2.3031003737455635, -0.6750298145434542, -2.4086422337155433, -2.6044429971758905, 1.4953988121254662, -1.5758008177675427, -1.2998701149859058, -2.7957877299083274, -1.9076832347845791, -2.8020265844967063, -2.1266594519470163, -2.3686320487517807, -1.5294165757288734, -1.4798749056912268, -3.235106733545136, -1.1708750947310664, -2.962048882490485, -2.3955103138984106, -3.124921226987977, -2.138494700618682, -2.6649024121390332, -0.744988137236562, -2.4021918184014246, -1.8045278574938273},
    {-2.462403632659296, -2.815263018882934, -2.6115533080330544, -1.5005054029446518, -2.73607912632462, -2.428742933251699, -2.415701155860321, -2.9305984560020666, -2.716958944372985, -0.8058673671886022, -2.339110737486935, -2.8130703408351367, 2.1865723100565173, -1.6823930558719016, -1.6050675100824565, -2.8782057113147483, -1.6683184259928134, -3.2273780146224262, -2.4380648761509645, -2.495914197432393, -1.0562167832278977, -1.619457139210112, -3.1857640841893664, -1.1494474660477685, -3.3648510815618624, -1.9773417005891833, -2.9049569355898757, -2.6239046884998087, -2.4813194054912247, -1.1495516797068557, -2.4354733163363225, -1.8844544211993766},
    {-1.9563794610745864, -2.453022985682279, -2.4898667707164797, -1.5993219861029535, -2.425507171356134, -2.112508013824713, -1.7052199588322121, -2.4213080774158793, -3.2601546023208705, -1.6614779060776088, -1.5251250540665224, -2.2568385568261218, 2.4628383458133767, -1.7160437795597858, -0.9570802433073777, -2.577138109301947, -2.024950537386892, -3.5910501957674947, -3.0274183236003127, -2.49858858944428, -1.0633340222024552, -1.3964120895021133, -2.794367122754074, -0.8298119770416237, -3.796407531057178, -1.0048254627984001, -2.7075229874088116, -3.4402653882108707, -1.942975673697951, -0.5281497181847022, -2.661485074864673, -1.7866664570137099},
    {-1.3336806831715688, -1.828198556265519, -1.6928265583624729, -0.9568071557472301, -2.3390986629526265, -1.1108163377722737, -1.5430531076710639, -1.933071992790425, -3.3672521873020687, -1.4176953643653925, -1.298577005589184, -1.7099068928826306, 2.3336044289955766, -1.0990485994552595, -1.2147049016662987, -2.040995071158191, -1.0259126855055802, -3.522772594324066, -3.6908273625112287, -1.9871981924220345, -0.2670421813928091, -1.1237037461004868, -2.6809226642455983, 0.045593899656183004, -3.701778730292318, -0.7700178557920241, -2.1829090061429, -4.083687314462453, -1.6641720904527566, -0.012298957058926887, -1.9770061334867775, -1.2534469347021953},
    {-1.887196466634559, -2.2988903427043654, -1.9400128616030627, -1.3661239722679728, -2.826911576813363, -2.04463060481721, -1.9873414130545286, -2.709716908376132, -3.2804085559880996, -1.2316361009957604, -1.865602164059784, -2.2382327700923814, 2.3279265202384765, -1.845843528948435, -1.6446753841174877, -2.703548428640563, -1.2134134580636298, -3.306162091989787, -3.6411920114434646, -2.2814656336878647, -0.7559663626192135, -1.7788260661947042, -2.896420805012493, -1.0437785988646537, -3.916480687625287, -1.3970507096095104, -2.7808130728733826, -3.6525080915201054, -2.3155178016714095, -1.1897181824752687, -2.5028544267021413, -1.6126277054068054},
    {-2.5493377544312614, -2.788433204179444, -2.667523272394515, -1.9332720040527154, -2.6453487409680356, -2.415485168131229, -2.4170462831509067, -2.776173396372318, -3.269537241217892, -1.6690398562126818, -2.4502199966644804, -2.8469744857811614, 1.5735256799609398, -2.0848784450763653, -2.014787240663229, -2.6611472235625286, -1.9292228329167034, -3.2212884476266717, -2.9353124272118043, -2.614412545372088, -1.6380022974108983, -1.8062493238157307, -3.19825008305753, -1.2339416138526043, -3.409174847384825, -1.9407745315309528, -3.2305660517373718, -3.3177953736383614, -2.3753618694976955, -1.4176545332271049, -2.9949349983897284, -2.2754749612093876},
    {-1.7209431626301621, -2.5728403296569873, -2.5171982486849775, -1.4457558253169083, -2.4939752314218153, -1.9087446873340659, -1.7125380789945526, -2.524969712578053, -3.4749316567273185, -2.122973082305767, -1.5988915866164095, -2.1795927780325584, 1.8925965345307294, -1.9749251047257463, -1.3362069202933637, -2.393794333133188, -1.6312736890796875, -3.5690397219735286, -3.501597893670308, -1.986143934993357, -1.3842812184252549, -1.549886572955727, -2.8697125387589724, -0.38468781246413725, -3.6761064533891856, -1.1425844709448367, -2.4397701355695474, -3.77312991672107, -2.006246955465094, -0.3233883529293526, -2.80643346759302, -2.141095559701095},
    {-2.389886700999315, -2.375016752894221, -2.2379564559015326, -1.235013599121059, -3.115263003797534, -1.7898809136865934, -2.2960305962316228, -2.7941618189312263, -3.3753679518583195, -1.3527423036311552, -2.0429161547054195, -2.835119177997684, 2.6694167487192044, -2.1259366597375067, -1.3635819190456338, -2.893112657719134, -1.6154509275517885, -3.8207379774548347, -3.603355823225154, -2.339723041696826, -1.078286011377363, -1.9898380226452967, -3.096886044487665, -0.612747118699291, -4.012128661479127, -1.6593585078722313, -3.191827129751649, -3.5295004259709017, -2.1705137088796396, -0.7701682888023909, -2.999954155230405, -1.1680780686281789},
    {-2.2854216749778997, -2.8025662555434914, -2.5262521577368133, -1.4609695199076291, -3.04978437676783, -1.7648119383735603, -1.9510098198345873, -2.863232826117922, -3.423096408328668, -1.4415663148806184, -2.0687091662125763, -2.6932686757971918, 1.9960191311551532, -2.194400715530747, -1.8798680151877014, -2.5687594766588964, -1.7475764638983255, -3.77103113028912, -3.6905040518759042, -2.5847059625199464, -1.2414802545984158, -1.6779244251968164, -3.2956699367223004, -0.7194095043402926, -3.8598426139728574, -1.9860156089405328, -3.1373635553774637, -3.914259206532711, -2.4272260117350744, -0.9691659322456503, -3.245791012435594, -1.4814575819607168},
    {-2.107970462753094, -2.52020709266256, -2.5023324241352274, -1.6906787265904317, -2.8910176293032412, -1.6837815976661885, -1.718798641585864, -2.6991512719608033, -3.616123224388045, -1.8924864241569805, -1.9490046925166882, -2.4323556000726523, 1.8380215919330656, -1.6310044536516308, -1.6656362483206821, -2.5327980358274185, -1.441881826346967, -3.849387376708112, -3.511619543853102, -2.2323035938672633, -1.24542948772103, -1.5273765501531336, -3.0822569262149098, -0.8060237010833278, -3.982951232504698, -1.451451299902374, -2.846147659162723, -4.056753859267681, -2.3664824343726605, -0.6423446202213476, -2.933799431646782, -1.6846444515768182},
    {-2.111581871975187, -2.323594816065964, -2.156424893936468, -0.8654592272030412, -2.9393129903573243, -1.4182160493160243, -1.624318848945481, -2.3880942795320466, -3.7207280311300592, -1.628641543803189, -1.7953737081320051, -2.188416948714431, 2.3406288078738635, -1.680860014543451, -2.072016347673065, -2.4269732977609166, -1.162022678621615, -3.3627630789059553, -4.147928365592874, -2.183732940509837, -0.33104922996883596, -1.303837889711468, -2.8471333403632313, -0.40418600133438604, -4.019558401277294, -1.294455981845304, -2.546498647022842, -4.229326998800357, -2.161830096574525, -0.5539547455963897, -2.187721869964614, -1.4024245047905455}
};

static const float b1[32] = {5.016932954549523, 5.094336063751826, 4.954611088237298, 5.078950420188812, 5.217082913976015, 4.772903683956556, 4.731069644885162, 4.992004944817502, 5.535185042901299, 5.53361066359643, 4.958813367902814, 4.914688272234071, 5.711004699141802, 4.991694149112437, 5.583562115094395, 4.904178662040085, 5.211911570645914, 5.111351396089453, 5.379240056380391, 4.69321736672984, 5.133032733971613, 4.978913541500329, 4.983983264675146, 5.0750865946004975, 5.393649909986286, 5.032426311307663, 4.891991034509463, 5.512516366263956, 5.072384538676136, 4.791532898744339, 5.103100901967489, 5.435912698813539};

static const float w2[32][16] = {
    {3.938781311341419, 3.65769261387084, 3.6650796928729434, 3.7004644513041396, 3.6994168196932313, 2.5398707821017927, 3.7023285870474045, 3.6052298697545675, 3.8364316222783033, 3.476130242422331, 4.271143718172139, 3.9028124432645654, 3.970238119795449, 3.9420220078930246, 3.8181152713984527, -0.31902801821083937},
    {4.594417834649761, 4.365138862272065, 4.262886894142253, 3.7808856299241236, 4.290857453977312, 2.90181158433819, 3.8715270246755282, 4.1115476467466605, 4.313919931555922, 4.306868137343064, 4.580525147867716, 4.248543678385365, 4.267546795363696, 3.9975794008723193, 3.9493610575566835, -0.08086239615226667},
    {4.312496470931001, 3.9365803979794416, 4.488427822206287, 3.9846687661966813, 3.9415163780490987, 2.8785748120656427, 3.845850008311167, 4.090456935523425, 3.9054946530990167, 4.01862990370275, 4.143932149405531, 4.266958995205741, 3.9022208825695497, 4.00874753967097, 3.938401537874937, -0.18823705724337547},
    {4.361082030449553, 4.262818231351743, 4.521012828068122, 3.7537052261169785, 4.459152346366431, 2.7665219248543527, 3.8136278839268454, 3.9422955773011163, 4.240122706110575, 3.7941932944908263, 4.105511321759091, 4.437423310440269, 4.136542874510007, 3.8854672723024564, 3.6650910614124417, -0.3270310135528418},
    {4.672514494103551, 4.234936701241831, 4.767428293624587, 4.2653462076890944, 4.421312225043367, 3.178360974713665, 4.744344567975633, 4.616712831718879, 4.727875707289954, 4.6940898462658485, 4.401391315366767, 4.300536813754365, 4.855556075513044, 5.040293277930735, 4.304481365688001, 0.07199331938760152},
    {4.000324189416427, 3.8662676899893778, 4.121684394094877, 3.877645236072275, 4.141003277968615, 2.4355474552840115, 3.9257369339627735, 3.8185050985686546, 3.9587445508359385, 3.7844872089342556, 3.8474861528078157, 4.172643378216162, 4.28557125602112, 3.6996986629967323, 3.8520720078763744, 0.022067279121955715},
    {3.737429909231929, 4.221063444845656, 3.990643614708818, 3.4143671726014113, 3.9696794648210543, 2.0417762816617273, 3.706393609824441, 4.020245540006128, 3.6773677497327815, 3.769188443530445, 4.0368607299684705, 3.821051492181993, 3.744130003217407, 3.8915505084369513, 3.5605596658850027, -0.3431890026686274},
    {4.2870500408239, 3.863217006365903, 3.9246015220689454, 3.3440742310392353, 3.893851282964364, 2.4026696258246125, 3.5060516274375266, 3.5073430523837867, 3.853995584780372, 3.8830434492055725, 4.097089860817935, 3.8629315888828746, 3.694279441481756, 3.890253524607441, 3.5665373995726126, 0.15562331662430076},
    {4.822562465817468, 4.445746569635138, 4.657858794324412, 4.603129874019166, 4.819743930999142, 3.2184999957511726, 4.505194075198265, 4.765094334437481, 5.332071646802472, 4.657843992304016, 5.003629282346992, 5.0400684897295625, 4.735231963123942, 4.747534888796634, 4.680445157215034, -0.3343769556375788},
    {4.7383160431768605, 4.882323777291407, 5.232975807721695, 4.628838863713807, 4.514185312957395, 2.8925375860298495, 4.501542956778045, 4.937783808489122, 5.087930445357728, 4.830048616053613, 5.226686882933477, 4.490157409365618, 4.528673416924524, 5.344624134907212, 4.6466615170011645, -0.49551007114350526},
    {4.181883194328035, 3.9070851102722233, 4.1009820549838505, 3.542139277392288, 3.6764884344338955, 2.270040925209915, 3.6334156381171625, 3.779944421862981, 4.2194104848870095, 3.6380927242928762, 3.713251634630127, 4.207537403335975, 4.401341026331631, 4.196308944783965, 3.6390758841751056, -0.32408223780080064},
    {3.804914499675264, 4.017484414170518, 4.010842582120414, 3.6689966466021344, 4.1060335710687434, 2.1435786258460414, 3.755412747879858, 3.774935582426426, 4.163015920772362, 3.9533101427505453, 3.827765106445791, 4.2392464867879935, 4.249924575905024, 4.331608831972706, 3.7321705510507237, 0.05489189782737191},
    {4.314182292934317, 4.693702394036511, 5.218928018419766, 5.081445049853799, 4.345912078230509, 2.4597246552171788, 4.705618538902361, 4.7880655756439, 4.497170164294581, 4.839582875616726, 4.976281964622669, 4.961094788836215, 4.5166927220057715, 5.029883362399059, 4.566203210332171, -0.019350293973581366},
    {4.011536104410102, 4.174400125905626, 3.9872677285535447, 3.4690214394642966, 4.071232810147872, 2.268484690092125, 3.565951507033332, 3.479750220950519, 3.919787555389887, 4.103024514799356, 4.020756925106557, 3.675772814740929, 4.35277289750457, 3.8783151253744546, 3.602481357870439, -0.36089620432999936},
    {5.2110188301384985, 4.780065554855006, 5.3154851921799935, 4.9289386422011825, 4.796140011545163, 2.739395663032345, 5.248158896535082, 4.763843575510294, 4.735046330953498, 4.764796187470656, 5.093059063559481, 4.6425846596911375, 4.966722741353775, 4.971928017810574, 4.654484694576841, -0.41028150827829035},
    {4.332889393800542, 4.340596454097829, 4.107098346793813, 3.8642084882506738, 4.112326663109004, 2.4315626774574723, 3.8785172709525475, 3.922421228771592, 4.330051137754991, 3.9200913967369537, 3.8376991455568907, 3.7711422845862037, 3.7110939674101964, 4.296354042155475, 3.8087238548467237, -0.11370248495668193},
    {4.132864414393827, 3.935949673369366, 3.831112881728459, 3.9019212139216, 4.075710195274317, 2.3484660192816462, 4.307491365386167, 4.103549703676302, 4.244025552206292, 3.7057016169361163, 4.3057979727462605, 4.2214971229976435, 4.043716772870839, 4.055169441737717, 3.5280067606049643, 0.020115260670345},
    {4.321333131010225, 4.153276926420696, 4.22996504971558, 4.004235353418666, 4.3182253211700425, 2.713294198182881, 3.990345969122525, 3.9104872622493008, 4.578820174628991, 4.071860028019336, 4.043723284543798, 4.1439219203686815, 4.489504731821523, 3.9999388443420747, 3.542725822788101, -0.11771788827979256},
    {4.752886369475793, 4.971186249394482, 4.760440701365386, 4.541395946406522, 5.214371789163075, 3.0541685567005565, 4.757396413042885, 4.450371982070317, 5.071358694729337, 4.9577757039880925, 5.125545647023031, 4.937241902534892, 4.750169160760519, 4.75429704778292, 4.834540697442881, 0.050944869915288696},
    {4.259250402291439, 4.059323555757184, 3.8751587214529732, 3.789438875318803, 3.9435464341155657, 2.3418317847071433, 3.842561975469462, 3.6583877958237774, 3.9028479262338682, 3.496846575704224, 3.6740181915021877, 4.231964836207242, 3.8581005932698287, 3.9078731476465287, 3.666001178388445, 0.009493257621663047},
    {4.528195854100953, 4.038598409400409, 3.9516449222565377, 3.793333209030733, 3.872308382933838, 2.4650959328449913, 3.8525712928151568, 3.501110549065067, 4.349519904752942, 4.076955164267187, 4.1229662514591645, 4.404419317319239, 4.455075855741202, 4.423585859877331, 4.0498518180941625, -0.3830013721702391},
    {4.05378012523103, 4.27967908731346, 4.382292723356205, 3.8195065524880674, 4.223689118359462, 2.6040389516744575, 3.8341777191269193, 3.7101525082308453, 3.953307695526835, 3.920826133522528, 4.260130199552599, 4.296164939866797, 4.472241332948656, 3.860477534945248, 3.783164447440405, -0.27955697106857214},
    {3.8638375208868467, 4.056697681056142, 3.969946106866482, 3.6596622561824033, 3.860010314945345, 2.41902695760871, 4.055804880887752, 3.697499545831389, 4.308864009038656, 3.775155302511555, 4.356688520002062, 4.256367784656565, 4.234205080333448, 4.289303906109304, 3.6532832203588996, -0.37494274583526704},
    {3.9346581537543295, 4.062852529543725, 3.893100341635269, 3.5703323694097, 3.6208441182989, 2.8560259924874063, 3.769625237600238, 3.803140996474587, 4.052951910419271, 3.8145071445696734, 4.205529106739456, 4.173356176647153, 3.720223065965673, 3.7625598653259043, 3.882597679522595, -0.086434658946115},
    {4.4566289143826525, 4.815837254032319, 4.577219175933359, 4.725912014808003, 4.631676159500729, 3.0745816228066993, 4.5263041991764235, 4.487562582312888, 4.935948629536238, 4.826029475758957, 4.563456344203901, 4.396935426195756, 4.9245854407916045, 5.159618558319696, 4.386617109400809, -0.3064904507890234},
    {3.9599006301117954, 4.12786929607042, 4.1692123772994165, 3.467900074208174, 4.097288757943026, 2.197566195732358, 3.795846349538381, 3.9695181231925907, 4.31019628753472, 3.672092048496195, 3.8827363423517127, 3.803326339271505, 4.005122107655608, 3.975055690037753, 3.6507505873966215, 0.13382315715798593},
    {3.557043919058501, 4.0937476828360415, 3.5873506461089764, 3.5603781684739517, 3.959181163880272, 2.3249344915082237, 3.75114813504436, 3.6315450008168146, 3.9022469634896524, 3.481729338205006, 4.225290182818364, 3.5974156436537257, 4.086463375119198, 4.0965944139866455, 3.227794458558278, 0.292881855442504},
    {4.795363356035297, 4.594133179390133, 4.742585872616277, 4.445315917499638, 4.910930646709359, 2.8735805267732646, 4.461222971003512, 4.286428137867625, 4.9897700466606105, 4.94022170052936, 4.9422125443739535, 4.391544790431193, 4.617654846025819, 5.031594699903168, 4.8711836911539494, 0.2810479621527813},
    {3.964070664423151, 4.243487942116984, 4.261364213085126, 3.490253463201752, 3.9478282687062163, 2.8491830589980056, 4.145738431623016, 3.9204687481113454, 4.093830205272098, 3.7599307203331693, 4.231400281719772, 4.121667739993903, 4.013300458429268, 3.780339995546317, 3.458311014856992, -0.005902273577735974},
    {3.9040985062862843, 4.211578972808247, 3.9889955305505596, 3.707157235208812, 3.9127167357670323, 2.5365531929467355, 4.287756386596617, 4.294014212782514, 3.9260774963697282, 4.223914558863947, 4.163638786824336, 4.438531878895032, 4.373786262316191, 4.310120377017016, 3.9739212296445854, -0.2629731140178278},
    {4.1053451002749055, 4.161137940762707, 3.857740479482987, 4.175238334653517, 3.8037724827539785, 2.5306289283723955, 4.2689947845648035, 3.499400852562669, 3.826218192072394, 3.832113817022688, 4.344650017414662, 3.7946577623018154, 3.97628018512663, 4.009732908962748, 3.8295823314868613, -0.39125022245057345},
    {5.059902851287111, 4.4535031710224455, 4.764286357989912, 4.751534576452764, 4.413850036510449, 3.1517009091455375, 5.138014559462259, 4.454583645520963, 4.785298163859384, 4.805896047026428, 5.1898719678245335, 5.03596082104882, 4.622819775603987, 4.949456377452745, 4.3272464040930005, 0.14287623293817656}
};

static const float b2[16] = {4.429852178285982, 4.471868469643424, 4.35639103491127, 4.681232216626019, 4.564672713152358, 3.8587611060217797, 4.565965404709192, 4.566264052777569, 4.308704933280224, 4.504719025020286, 4.2953936269652235, 4.4154945306518405, 4.509977763460563, 4.397507552184614, 4.488017953512983, -0.16014125475186175};

static const float w3[16][12] = {
    {-3.2898132391482315, -3.4840013886926213, -3.579902523868264, -2.6934513998605127, -3.3711617828549265, -3.132482009769384, -3.380935310428921, -2.9101997545496325, -3.265396730421711, -3.2415952836336794, -2.78556692564068, -2.9175698709939684},
    {-3.197056833034775, -2.881761180276418, -3.2712595069315396, -3.1208857307902775, -3.0292743702267675, -2.749372256601135, -3.445875334576809, -3.4603846805683314, -3.618938062599226, -2.767464255668176, -3.4975917549309465, -2.829646537869709},
    {-3.541941419734541, -3.404685374467359, -3.211760109279013, -2.705302794922003, -2.8690028542904957, -2.9909503504194674, -3.7503730520610254, -3.4766592585002054, -2.8826673778411207, -3.600630140906539, -3.2278118467826498, -3.4984653347494215},
    {-2.64150322409333, -3.1501553908191644, -3.2191606332836114, -2.7249890797367207, -3.2809849023085835, -3.201968448361934, -3.3863211817045715, -3.019836575576673, -2.7761945490333435, -2.6216169285416777, -3.509099350481991, -2.8535673023692856},
    {-2.667869338152564, -3.4677687741313186, -3.285837051567513, -3.4494291225751317, -2.704816361854422, -2.7764891627168518, -2.983591949823029, -3.0991489773487695, -2.9787121104786953, -3.0456271184220176, -3.276552706446923, -2.8417653245410626},
    {-2.2245907327104026, -2.129708938035571, -1.5480918390813942, -1.712995668803928, -1.9560563351609714, -2.344663101845121, -2.018578669176846, -1.7622067202650904, -1.7755422391454516, -2.2461219099165834, -1.4260921076556716, -1.9194648341937632},
    {-2.995779799767313, -3.2774457302349993, -3.094723225420681, -3.226710080224749, -3.0206210595102485, -3.1444847851100484, -3.0141537107626517, -3.458615349664936, -2.6532802190028737, -3.3992190870080545, -2.928236756801903, -3.2171985436041455},
    {-3.1793517550639296, -3.063534421616792, -2.8309154640589127, -3.4544465806714264, -3.0791903945589842, -3.144554655444393, -3.2088456165412165, -2.577893923272601, -2.4795344586001633, -2.987266029277277, -2.656585531792176, -2.761806172314042},
    {-3.0354313821244236, -3.3038721345363573, -3.4452933448243743, -3.1976985941004568, -3.565642307012009, -3.5672605588494686, -3.228283678120483, -2.7233089441857774, -3.3088878954786796, -2.9482869025976552, -3.1277695565123236, -3.4782405971280785},
    {-2.880899147881685, -3.069133647798266, -2.6981468063019207, -3.3311070297626437, -3.070648557518258, -2.8554082859700807, -2.803995370437808, -3.0353774286848543, -3.4118884775199225, -3.213486521335523, -3.625173527237933, -3.144371199202576},
    {-3.3888400792296918, -3.0203644918415087, -3.324941235358683, -3.324453361294385, -3.491411495751001, -3.6235268622127057, -3.3811404219060623, -3.2400962521289576, -3.723035846608243, -2.967626989148294, -3.1210736225504676, -3.0254268824900525},
    {-2.957554508865762, -2.9840256437866124, -3.4956985941221976, -3.592093672360047, -2.766293059983099, -2.8806178947813867, -2.8539733686515874, -3.6425752027945792, -3.274651583479584, -3.182815466799834, -2.8317153353717885, -3.6533723028646072},
    {-3.549412559722326, -2.9019537380669678, -3.1790763730598752, -3.553109708131447, -3.2982780590972265, -2.9441424737816586, -2.7634883381842292, -3.508076875889428, -3.6146636622910537, -3.1770358006171175, -3.2641334196131595, -3.065445553340655},
    {-3.3944106096905733, -3.043365118009932, -2.72149463094992, -2.677569412791666, -3.0819787600130497, -3.2528439594759937, -2.828863591863424, -3.0777070255799774, -3.1910808264719965, -3.2618834564131505, -3.690924662299926, -3.6800509303092483},
    {-2.949333850671641, -2.775967416123463, -2.769724561974467, -2.9889412869780414, -3.1429600359745398, -3.5881096649526327, -2.8220323852382023, -2.7327479961338295, -2.7959866044136317, -3.2292723708547393, -2.655793082872433, -2.866786561997629},
    {-0.05036734209268551, 0.09861013365830143, 0.1388035572879343, -0.2767720382296273, 0.2524367102934122, 0.2723887712851961, -0.08220655324738858, 0.33342128124097703, -0.28744583057995, 0.19075131497908937, -0.39842210139196205, 0.38401013810895174}
};

static const float b3[12] = {-1.9864556372502375, -1.937868755688454, -2.04499922557815, -1.7627685275463865, -2.553268339316032, -1.8726357846581076, -1.682929321631049, -1.4079999098467602, -1.4593692250370627, -1.7660834155015224, -1.2379329919289905, -1.8054706430662095};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
