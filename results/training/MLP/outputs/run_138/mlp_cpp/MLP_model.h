#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.4792025943627836, -2.894453318327311, 0.40090040162729446, -2.759905677311279, -2.680808357327362, -1.75178889585699, -0.15125280932827767, -4.114527597104351, -4.035650865077127, -1.5721270214629641, 0.5841403922189418, 1.1046980068035928, -2.686061226352058, -0.013889489876954566, -0.16258027408720152, -2.453558444742438, -1.8732221284259047, 0.08094408206781485, 1.077737592142397, 0.8879838717049582, -1.1570398909386055, -2.74175938946581, 1.0300601442389068, -1.8172249411158654, -0.36216905923775894, -0.9400027865622078, -3.6145168881665573, -0.05557276620259329, -4.043338146724272, 0.5703690894711634, -3.790237719456855, -0.2518298278784639},
    {-2.7300085439038897, -1.6233134953496013, 0.32495698816689084, 0.3831469210846047, -0.3529117402789699, -0.28190180900776646, -1.428538106856458, 3.360570512728567, 2.689951124521285, 0.93944134893939, -1.189157869548281, -1.01831673142314, -0.13897170104344184, -2.120578613467815, -0.3390634349434329, 1.3337972763276567, -0.6978840221182381, -0.5909555082032355, 0.8027256513852621, 1.1831932760758292, 1.734628225676229, 0.207991282367774, -0.2893939010047543, -1.067974269226231, -1.2130734009163113, 1.2703739090363442, 1.0657141013221694, 0.29059442640889693, -1.6961339823961272, -2.564543796202541, 2.2912973768094833, -0.3243793242364171},
    {-0.6675637884675442, 1.825651147339587, -0.905088820032401, 3.5254996489404298, 1.40129631002636, -0.2248289324880019, 0.8307398203555096, -1.1578108348288023, 2.0639082509800475, 1.8178705652767595, 1.308761440313755, 0.592463009812762, 1.7708415835126612, 0.16093764262417068, 1.652427397926564, 0.07753922620148476, -1.0407226014195543, -0.819971472478464, -1.2993404357624176, 0.15921472462453107, 2.7501046208272344, -3.185391695733259, -0.332054668968488, -0.7876394339554982, 1.9502165967032177, -0.8805195308050521, 0.6431572795600544, 0.13173873873490335, 1.9185508873784352, -0.20265092356546713, -0.2577537803451321, 0.8698115625038385},
    {0.8146997399993672, 1.9414819706060826, -0.34902649667568086, 2.704799083064939, 1.2813507027564301, -0.869870746224036, -0.3895593379137089, 0.5524332182834144, -1.5795373370585821, 1.9775255934664508, 0.1267557846688607, -1.5079663749029175, 0.37337701325592193, 1.3872133606235935, 1.4739421534493007, -2.2029934204168566, 2.511277771715218, -0.8105931055266605, -1.5059615601737038, -1.390263995786398, -0.7807076964161311, 0.08737846282820246, -1.7544174322212127, -2.1174456739081386, -0.5177124870264784, -2.6361834837885043, -0.3985707254573443, 0.9376728189335379, -0.19775763489324144, 0.5810045314223622, 1.3878167177772676, -1.005883101142463},
    {-0.6565546691192867, 1.611815348367465, 1.5895472402829125, 1.7381468987413884, 0.6302587190350581, 1.3913221398016864, -0.972469334998183, 0.000839125679823338, 1.2057591772218328, 1.7044883844112322, 1.4845264070011759, -1.6928975058283418, 4.22547498289394, 0.04300620844153308, 1.1846050153455039, 1.430716100057189, 3.1986832760102475, -0.42234501584834816, -0.6569658632160932, -2.0018824434336158, 1.0140092838338643, 0.648111744942364, 0.7689262603486925, -0.2999826228729279, 2.135506726344293, 0.4408918113024532, 1.9522675102928722, 2.680909855889446, 3.717173536416757, 0.25322013654373704, 1.9655807999115604, 0.3874368724473616},
    {-1.365986077799067, 4.8048277815933105, 1.0774319680410265, 1.2268261553648978, 2.5198435105728696, 0.4933154047088086, 0.6662025873032569, 2.79844641937292, 4.627301831676678, -0.268297496581978, -1.1191494301632274, 1.173486935153474, 0.8411659317344663, 2.4875696117559674, 0.8959230696274778, 1.828157498184041, 1.1360218129379083, 0.26715029257867584, -0.920848893970051, -3.569117760279985, 0.045270194721668884, 1.5258079970449336, 0.5720697613155368, 3.7272078097120156, 3.166605051501056, -0.09019575481744234, 2.915996694166857, 0.6191324034450896, 5.668892194931464, 1.1702085279194627, 1.898990035472372, -0.42478703956495145},
    {-1.0131716994625184, 3.029829866125425, 1.821140836646761, 3.400481959382329, 4.246645781697125, 1.5854188203959019, 0.770566653657347, 2.777825735256217, 2.910711736925131, 2.0142040700490345, 0.16710878978201874, -0.27742043959228546, 3.2963624596364443, 2.986155890778893, 0.26405031047500416, 4.810270544763429, 3.2642738599144177, -0.06015038184895604, -2.9453551473911883, -2.248607602569448, -0.08639966470616944, 1.4008294264157344, -0.13252987197782948, 0.956126186760735, 3.1986554449701576, -0.5385374952315216, 2.3525313185037073, 1.9715397594685824, 3.3135844912472447, 0.2477093045111243, 0.9799386397933844, 1.083377506199219},
    {0.0013332775372044533, 1.6211711843947814, -0.07348035758130586, -1.0848735958850646, 1.7260051604630275, -0.3520464364930945, 0.4869397543844014, 0.516465875336998, 1.384508053659842, 4.278382657041727, 0.6403625392156265, -2.7691997165049442, 0.8859051811532512, -0.8368888457927449, 2.0460311332241754, -0.411596083528522, 1.0631794428073997, -1.443764596674926, -0.9492124673623902, 0.880030848248668, -2.58902004287615, -0.8266313865667501, 0.4898068865047213, -1.6006728084687791, 2.3988991537804445, 1.1427947751101697, -2.078749409798977, 1.2751627341017184, 3.1166296707908354, -3.7932018688438203, 0.5753104709719818, 0.8600417174212498},
    {-0.3763012070841701, -1.1863886256889786, 1.0902982193274582, -0.6619683387866951, 2.6872259219633237, -1.3051606949966483, -1.094075113483644, -1.2189782931841147, 0.24453856273000737, 2.6169334124374615, -0.17438482556444695, -0.6857060798527446, -1.2766412603778854, 2.08716631204618, 1.1913392872090438, 1.6955784429186915, 1.2051349810752916, 0.12219352743016806, 0.152222450576337, -0.13747063333908843, -0.08129806671266356, 0.7811638654309375, 1.7401726341907082, 1.8324452769592978, 4.282078499348722, 0.8433445258097164, 0.625504632165066, -0.3685533683917484, 1.5756182758263015, 0.1662334693560724, -0.026349619340171385, -0.5673803455479187},
    {-4.757289274798616, -0.9461725271219609, 1.7062637815485184, -0.8384479191363513, 0.8826406347953756, -0.11497209856404081, -1.4696399675845955, 0.6976852816808455, 2.671514749042732, -0.872621988773695, -1.671176829897594, -1.7375744885639042, -1.5254132488660213, 0.05796761907711987, -0.5314940904003421, 0.23290839318920722, 3.5005408063923467, 3.0170489841652794, 1.0651504943373928, 2.906889506057338, 1.4584251875193748, 0.29815691271637057, -0.9307969806879529, 1.4270288858243703, 0.7273190717663776, 2.4577074555503122, 3.0543203267730026, -2.9556538392625415, -1.2543653158474488, -0.6714963372923759, -1.0772230444439235, -0.29015195105788116},
    {1.2940356970288438, 0.3465991776925429, -0.9256245540796253, 0.9029101871152476, 1.6534400845734076, -1.1641739358100096, -1.4908656518024639, -0.09647949537749696, -0.04453157842639443, -1.1987951305609137, -3.075271524178127, -1.4154289602859613, -0.09088345719746811, 2.571768650184902, 1.2960618245096023, 0.8408884485831049, 0.20042735687627014, 0.34902443473256844, 1.1201548914651667, -0.8093037580303909, 1.3368562670043775, 1.3269328471461412, -0.8304326467222088, 1.7733704282565075, -0.6872851105065433, 0.5246893814149768, 1.3242401929352254, -1.1762959462221148, 0.39505388582206585, -5.016107816481564, -0.08182142329686105, -0.872860864485684},
    {-1.7857678412848537, -0.2397327663023902, -0.598875326977163, -2.5964626143331353, -1.3428643779124585, -2.077728175290723, -1.1778299666025172, 1.4467191626496838, 0.06150221756209867, -1.463615085746578, -0.0004324674789234261, 1.3991934857738337, -2.051731758552373, -2.7304017148397177, -0.737436915549148, -2.142717328312602, -0.7168521119127642, -0.7236579812113382, 1.9399815993434817, -0.4418576939243249, -0.3792464103451459, 0.21841345969132575, 1.3679613255702847, -2.19196784504684, -1.4024579606496335, 0.3168781841544051, 0.4435376724442254, 1.5374510274829678, -1.6765432210968538, -0.6602592891427518, 0.0013111995288852265, -1.3692528475186287},
    {-1.5740361925288089, -2.239223613850732, 2.677322529465764, -0.33043734077221526, 2.5678666348584747, 0.7903678650997698, 2.260579585345096, 0.8369317821805418, 0.39163023494512883, 0.7562740169386504, -1.0358033139693081, 1.7576191144217999, 3.184991223690985, 2.437570450851534, -0.03519778379386369, 4.63618105999495, 1.0545848311248596, -4.191268609539652, 0.556141954801663, 1.2496380627070232, 1.0442088597337853, 0.27163684861486975, 1.8198169750004345, -0.0250798508780164, -0.7505298621900831, 1.7428839952786006, 1.8129130886775462, -3.1838517066039036, 1.205694116534735, 0.6704569695426965, 1.1573192281072626, -1.4937562223520373},
    {-0.16493940024115109, 0.43067003269617915, 0.5714071308004518, 2.1875328766320976, 2.012097296018187, -0.3963505268695453, -1.761256030996727, 1.2096305746939917, 1.274983039445852, 0.2502274267279814, 1.334904443844647, 1.5788363789517095, -2.4338468008718044, -4.028599336910462, 0.11005777463704321, 0.8285027931064362, 0.9524649054339271, 1.6816477705765573, -2.5339044127305947, 0.24515558143968913, -2.16056234902651, 2.7426766032122063, -0.5006055772257311, 0.47982043279648373, -0.21388005425356113, -0.4181549679982427, -0.15147316035100558, -0.8210981645177468, -0.19395382485404247, 1.643207629684255, -2.1002509970336765, 1.587507555833095},
    {-0.8309572496347241, 0.5976054603758091, 0.39923765758074453, 1.058542196657552, 3.057682721013777, 2.7591621275975804, 2.845374239864512, 2.5084554506798273, -0.7368277456230005, -0.6046636100748074, -0.4644709239548293, -1.58083131589481, 0.005096562488071741, -1.5627255446044908, -2.129963143514502, -0.8195437632366134, 0.1538638955558289, 3.8214093761213643, -0.026485013808049632, -1.5833403095333747, -1.117292283688709, 1.8267929592578465, -0.11436165799789358, -1.8542953138178142, -0.18180447307101988, -3.3217244697710524, -1.075570594177207, -1.8783014115576293, 1.881181091900438, 3.4180591682948647, -1.9653394899347314, -1.3341827107889612},
    {-1.437528709856799, -1.1150130591547331, 2.29728063227097, 0.868246920423175, 3.0693399630238174, 1.5677570970748922, 1.8669368812118896, -0.6309207000131939, -0.26739896312790995, -0.07354230878295945, 0.525169484196184, 2.5267828537346704, -0.5191993136069827, 2.3303813209354542, -2.1944270341869774, 1.1935677419573436, -1.267714440515858, 0.9214175783441262, -2.7652540193075867, 0.38558417405176226, -0.2675707802611487, 1.13619661192204, -0.04530107477090894, 2.2645383639138634, -1.8046836435270603, 3.1010318151662917, -0.8834222239188445, -0.029117026666694017, 2.970698456515295, 1.4623814302052582, -0.42865063038388274, 1.401261340276955},
    {0.8661966884097242, 1.1158138111307878, 1.8212474543694266, 3.083270071084615, 2.1388826382679555, -0.033743972289578594, -2.4916548634474536, 0.6457371314907094, -0.24358047393423582, -1.5026568993394036, -0.06378556911035958, 2.6486093138320737, 0.80253024633808, 0.05380080397049856, -2.1360410649300627, 3.3797292591556505, -1.4772990054782502, 2.2839036418111927, -2.0888295980359297, -1.1951107536937686, -2.4812323163534367, -0.38712394025145125, -0.8802724943202876, -2.5778981844647286, -2.0298538372094184, -1.240440502922716, 2.178351523881643, -0.2575198615256475, 1.773533375694209, 2.193917764596726, -1.2674611053898908, -1.324153526240118},
    {-2.9750991938316447, 0.5942969820017336, 0.8257360208906893, 2.3478429667277103, 2.2614187202105227, 0.6714181781148619, -1.8358534445974235, 0.7436072177717484, 2.307152114626096, -2.8677954981864153, -1.0081212030364677, 1.3686692208279545, -1.6816443367230147, -1.6050893398310309, -1.7875604489161088, 3.338817315448159, 0.3471041576302982, 3.72882504581662, 1.204562988618403, -1.6167750558495304, -1.7700482531388873, 1.0199771422983812, 0.006566141863404424, 2.764770491195195, -1.8347241418890188, -0.9236310492898111, 2.2457181526999026, -1.1607255627131023, -1.7204149308314465, 1.7943479645732492, -0.6867658889281423, 1.019412900454647},
    {4.784556152256219, 1.1245517542600167, 1.048105227016073, -1.0754077101773216, -0.05750761100094247, 0.2765558037173682, 0.1861430345465648, 1.343874688604612, -1.014558586704295, -0.25953199421706274, -1.8139155961386482, 3.692760120070091, 1.4480548710809962, -1.4774286183956442, 0.5087131264609155, 0.05737982197302175, 1.6536192862532886, -3.610463515886916, 0.21771193758769802, -2.8330407551296655, -1.540027959426983, -1.521353055891723, 0.0784403158862612, -1.0938174387341144, 0.7225429966491392, -2.6865128831881457, -1.1618339490037155, 0.5431440687097872, 1.940866832907872, 3.687489242366, -0.6718247593792933, 0.6551618336577143},
    {1.4193943000160874, -1.511722956890917, 0.7808788150850121, 1.8999867198765938, 0.826828861950502, -4.555901092482805, -0.8523137868062262, 2.795224252892552, -1.5235887071607555, -1.9262835854217804, 3.180616713247158, 1.6526128460282425, -0.05602827398773404, -1.3894877721963892, 0.7502721043395841, 1.5622769248342918, 0.050381956919750545, 2.1995446996786887, -1.8430489851180372, -1.4478965062454336, -0.10603747634019009, -3.294338384614272, -1.3588422019739994, -0.7936236371297143, -1.0956359650434209, -1.434913175994964, 0.9002585707308067, -0.007941321460631104, -2.267410317326576, -0.44494481975053524, 0.4180684095183622, 0.7360192801020528},
    {0.7018871065380973, -0.008378373280830714, -0.9343867794925957, 0.29227895980224056, 1.0542928394579507, -0.05467784182567746, -1.810518310547458, -1.9702459669276198, -1.0528818102808206, -0.9474712172359426, 1.1492491889600194, 1.6574845114571393, 0.8274163374880994, -1.6601115940718445, -3.441159406148937, -2.5297802017794977, 0.2022177667229314, 0.832869369422687, 0.8277068728084618, 0.05382537818862228, -3.7089553161708855, -1.3870492018570277, -0.7113120313419757, -0.7799931244968977, -2.209274058683306, -3.6410133172437895, -0.37224985715629305, -0.3471524791041973, -0.9944112710732578, 1.789602672712137, -3.336070289822631, 1.7454332993924335},
    {2.3537934267596174, 1.5355086163270903, -2.5341949419031415, 3.006841236079951, 0.7003550218256175, -0.7088530009071023, -1.1925322481118454, 2.03547969842201, -1.9953741189490837, -3.807674428225462, 1.6722133699818644, 0.6056314510268862, -1.526430631629037, -0.14895369482384943, -1.2256571125187155, -0.49600059979619127, -0.7417336089592215, 0.5517054912220647, -1.121667297809976, -2.2967486556180727, 0.3519760792459055, -0.24349367811270464, -1.1488004272822157, -1.9386302446555408, -1.4710636667179295, -1.6863907711485895, -1.1008798416510233, -2.6522728983244566, -0.00962448895939042, 0.058307428225996834, -0.8847594203263623, 1.1394806769922654},
    {0.9224909097360166, 0.011933079692655344, -0.94413797965996, 1.7863153575807276, -1.3547113218155389, 0.3535501213035332, -0.7229530560756489, 0.7051761031825508, -2.4146108837560325, -1.680689602407859, 2.769358579187114, 2.279272875545431, 0.6154360883466005, -1.4999360867667662, -2.351774924275679, -2.05382275104568, 1.8190468312420407, 1.630184420346875, -1.4536428733982272, -0.5913422865691034, -3.1732913922158037, -0.2697184265077297, -3.4193591772177254, -2.679487671539647, -2.2507014662441307, -2.8325091702566754, -0.7734525451191855, -0.15078830835145676, 0.3771683586934986, 1.0215380082643926, 1.3918079389716522, -0.24752453060684165},
    {3.281862968794195, -0.5073827562798929, -3.47762159342038, 1.114989585981357, -1.5036219965224396, -0.07980616052765357, -2.9950827240151785, 0.9521599748119147, -0.45835268719005273, -4.246441122704488, 0.7536429140536469, 0.8159160085844122, 0.05965618976170255, -2.2473942287911663, 0.7221927189647697, -3.4287587382972093, 0.6658199438019946, -2.8613994156396907, 0.3562265577438229, -1.3377392354373447, 0.24543924713087834, -2.819948953892148, -2.651236138931289, -1.6123335189517845, -0.10143027708390676, -4.113078586929164, -1.1445367564359041, 0.07563638133184901, -4.211945052686594, -1.5470989327330849, -2.401574355128276, 0.9597168743422247},
    {0.962591238565034, 1.8531166339384952, -1.8449492140416952, 4.4630352988606905, -1.3548158830123878, -1.6120789840009622, -1.0992511270893581, -0.24788496464907836, -1.82269510131522, 0.4312761077020972, 1.0136045627372217, -0.23368779295726655, -1.4934060777632017, -2.0069630636643634, -0.09729916668532586, -0.30230020839332705, 0.045995897961315944, -1.0975005175352162, 0.7724102354888286, -0.3733585003196294, -1.0464937586210445, 0.1687351060288834, -3.678203091824676, -2.5989366910241354, -2.7744928708841514, -2.242250148466512, -2.715913727594127, -0.204123103707699, -0.5649666840106328, -1.7406440819156206, -0.4734035578074954, 1.058851402884314},
    {4.531763010295955, 0.2646869436929286, -3.3061911580613947, -0.2879091628978162, -3.1629119126392284, -1.2257943432403617, 0.20474974614701977, 1.7552854567517155, -1.6549562536914217, -2.3471899649510917, 0.8918440876654047, -0.07851792219144445, 1.6622004133391264, -1.5180159532238022, -0.5137827310135947, -2.9358186375292057, 2.230433210351169, -2.786118000674231, -0.4897119428554342, -0.8189222790108143, -1.6477120246770225, -2.261977301138422, -1.0025379867307482, -2.559738959102862, -0.13118437282852916, -2.8138673031424317, -0.9784602011752668, 1.8897556204694215, -0.9874330944137425, -1.4274654142422627, -0.8007010015457069, 0.8150646142827701},
    {2.585624858944727, -1.0098806276969636, -4.208051623863136, -1.5727051115798252, -2.0337037102945352, -0.9558997803547742, -2.0325937688533546, 1.8268573117480245, -5.475464952670698, -3.8999492368639803, -1.8211685961376247, -0.17796832637410392, -0.4431778792021779, -2.2869402011477007, -1.9634754661931373, -2.9158518763317605, -1.8556382835368328, 0.09639203814166608, 0.867241327495348, -0.6988938553176534, -0.8230376324193694, -1.25516301972892, -1.3609357409855456, -4.749734688045513, -2.8657310365831443, 0.745413190534376, 0.6307570336482033, -0.9417369817672843, -3.9066140490640775, -2.0056004610175093, -2.6383381564903425, -1.9757234603934766},
    {-0.040052442919796406, 1.664037244416392, -2.3308725417491614, -1.1922244559366868, -1.5724998148926974, 0.7320920647474528, -0.05128027653534219, -0.2142618358690703, 1.7638132216435174, -0.6185096365838684, 0.10436542407468116, 1.4422474369658331, 0.9274782109681896, -1.484516803266052, 1.510937300110414, -1.7973938570731975, -0.5162738193068639, -3.5945347869497493, 1.9188243720483127, -0.4537220002664342, 0.13863407519802864, -1.4414809634678254, -0.5559725931338496, 0.6118207023985233, -1.8914240451022724, -0.940819615617657, 0.10819879921558677, -0.48556374788473156, 1.6055434032857365, -3.2937229231011393, -2.080640328226162, -1.5659886260261173},
    {1.0537377286868432, -1.2105544949075546, -1.6475875390468786, 2.716162223666368, -3.079021819890239, -2.1349815492075566, -3.4708185711296293, 0.21794592155995288, 1.0310666953236052, -2.6681735422316386, 0.097107744962397, -0.04636814852813026, 0.9557658873716934, -1.0237773729061708, -0.631057863602776, -0.5770277019065062, -1.2624181966040002, -1.4088114158804106, -2.21487601056285, -2.3740434508002517, -0.866529325064401, -1.6562888660411188, -3.608567156339742, 1.0295431126503978, -1.603077450813814, -4.454911456610728, 0.38465589258629146, 0.45164706374786295, -2.0614602556064905, -2.5147856546842706, -3.660126061225148, -0.43735827258767845},
    {0.11583957217542837, 0.4344645462282845, 0.48579238176801615, 1.0044886407823868, 0.06447614389062012, 0.8763857663776804, -1.1667739251772888, 2.6127948668365883, 0.4770987412983784, 0.8605071848792547, -1.4313673080724016, 1.394787019632669, -0.1721383470488065, -2.006817346742184, -1.9252660119775633, -1.773104037514961, 2.5816788207062595, -1.082682919406286, -1.3433389124866075, -1.7982132682738146, 0.3213426468005427, -0.9467903896723494, -1.8811075744528947, -1.8062716435452963, -2.3230107333858863, 0.22080608050514067, 0.004878960691752732, 2.374646429976362, -0.07031529738761468, -3.577342095974427, -0.905194452405211, 1.520682303948338},
    {0.5296630753704746, -0.30236880824243056, -4.413112924192944, -2.814103498950416, -1.939173009366492, -2.5635432735427783, 0.3356971076335216, -3.560047728845397, -2.542423122096737, -1.2488591731230239, -1.5863073538396026, 1.247795568372861, -1.1660931070335594, 0.28677131164524344, -0.32634582722153443, -3.938736904600594, -0.8701267434025554, -0.16253088454381873, 1.7821782784155418, 0.8900563565693792, -4.30732523091044, -4.9335282231487945, 0.7665999579029178, -2.9518324717106106, 0.41137973076970263, -1.7707572381903103, -5.090608272963634, -1.1945141329655755, -3.785744608831157, 0.09245593868808387, -2.624400891690984, -1.1877634211998083},
    {1.201136198659899, -1.816459594233376, -2.1000745938573218, -1.0754254432639716, -0.7619764724558353, -0.8784310910615788, 0.09748940003234116, -4.472201479097107, -3.3866032721119823, -2.984664282990383, -1.5117397673151765, -0.8139551709004537, -1.4684083692391172, 0.3181873065049476, -0.4500721443130669, -1.6993858777498614, -0.5725609355755829, -1.9934370215246686, 1.0729107995007345, 1.044729942435982, -1.6939667692455997, -2.65013849692173, -1.7382532918220894, -0.8450248582340716, 0.7553794076063926, -2.2308286810160927, -2.92291457294258, 0.7889708715785619, -4.511219433409648, 1.488766164555409, -1.0910101558937186, -3.9205238906249322},
    {0.2494479054429532, -0.47496381007981864, -2.694469421060153, -1.6873231547559027, -1.597248862798622, -0.4403290087018774, 1.1823512243774574, -1.713066359004555, -2.4121753500285275, 0.07069878460615793, 0.22290196370204093, 1.029529457789167, -2.3919542177275206, -1.492032819070315, 2.2272980181876565, -0.6270753518163406, 1.883608062483075, 3.505673158295977, -0.3956911592476684, 0.6144439014892034, -3.782152411095815, 0.19735836017629996, -1.9288099202360074, -2.718075833780745, 2.8235545852555473, -1.5354941133246984, -2.8152541404221, -1.9882373354438219, -1.825309850616672, 0.34079170081218696, -1.2047216058981878, 0.6194916144337521},
    {-1.1688781963533128, -0.1355116860079127, -2.6825697179571213, -1.016046918007631, -3.501158606192149, -2.0060520666694868, -1.7327875908998889, -1.8979077051591688, -1.4025218968168196, 0.07375289835758211, -1.4758949080421238, 1.1600320750579498, 0.5193924897141642, -0.3884996741756878, 3.220967409959561, -0.7279851471807941, -0.22485005658700083, 1.7114733431522273, 1.5491999203703213, 1.2805086017636043, -1.0568554689372336, -4.013944975665117, -0.20673788662441736, -1.2612772643481458, 0.5208621878323292, -0.7117843223739474, -0.564069785137607, -2.5382223215026714, -1.9398492711517867, -1.7032024123194018, -0.9080866095916501, -1.9680539677665583},
    {1.4195742227837505, -0.7667039456424374, -0.009378965076227916, -0.29156765772750226, -1.2222399277578144, -0.8909519973382198, 0.3846305201917371, 0.003823006439410282, 0.06079846849596782, -0.6718157951154904, 1.6221668420323268, 2.6391643439638983, 2.12325329310816, 2.7491907188835807, 0.33040395940732226, -1.2139506520145742, -0.0029747391911334855, 0.28887174465620136, 1.0931370888687024, -0.4756221789480765, -0.12041030378600202, -2.090344156528265, 1.7819651256031996, -1.021088366569666, 3.9112255411358174, 0.08584535864912413, 0.23907293985646, 3.099074404830866, 0.3495486161924891, 0.6437129668758291, 0.6814725417981411, 1.8918137668639892},
    {1.8959333279414556, 0.4388615834147066, 0.07608139208669065, -0.9705508315011664, -3.5071571198772404, -3.1996291422439334, -1.8212896055672985, 0.2297065473658152, -0.016354286759143615, -2.0857361394349097, 1.283034643407444, 0.04210912708696361, 1.3554867048149595, 1.3631111674042147, 0.38372735393406676, -0.9468514836300816, 0.22334419687605384, 0.3635311464526913, 1.0590300412659175, 1.8147852246775533, 0.7045215766056716, 0.28048555771989064, -2.275176765723032, 0.055707838810708524, 0.7245084644822812, -2.0092213623143094, -3.139155846844614, -0.5451897938441425, 0.6131941877928374, -0.2693463798265465, 2.1113053327237337, -0.9560514001244439},
    {0.33634562264970685, -0.520252992412724, 0.5566287463630425, -1.101015139699054, 0.33884579793646113, -0.08532247282104036, 2.624433855248264, -2.4298234609025147, 1.7391867308618763, -1.1641854872953512, 0.6039587206027487, 2.2140138338856676, -1.6344388611319565, 0.47745170107105056, 1.913559835932529, -1.9028765932460687, -0.3004335848991508, -2.1246405743598378, -1.9615953367011032, -0.6971419595446245, -0.9311263311462362, -1.6039707954904698, -1.6110840731640583, 0.44765738628055324, 0.8919972066492988, -2.63939388667337, 0.5812244180627326, 0.8294189911827806, -0.6857631137753855, -1.0845012895361437, 0.18066998440696166, 0.2121867791816958},
    {-1.330804957554072, -1.9782448200949596, 0.2929112793975523, -0.20970225975455697, 0.09490678373044867, -1.709312348039844, -1.702829798087778, 0.15423676820106344, -1.7013947314413005, 1.8040210037924604, 1.5518561110283349, 0.6598650131979257, -2.552370642215727, 0.7841595745578475, -0.1961529899155574, -0.8620404867687692, 0.7100614487955598, -0.16684708729841166, 1.0832189273185295, 0.046613745684805176, 1.4659399632402044, -3.9155491700699394, -2.242174977954698, -0.3891514802294278, -0.5626461760120227, -0.20944168164293345, -1.2816898559550112, -2.7078216435173936, 0.16724957854811912, -0.14861472129316913, 0.3049356646948497, -0.6601574693657707},
    {-3.2614070982364036, -1.0455034217494157, 0.2645499481955907, 2.3174415187798645, 0.12155777935991026, -3.121565494223436, -2.1800878695884243, 0.4557131975597928, 0.4822691788214227, -2.644559796065313, 2.422442365255008, 0.03335257145306638, -0.5172823117489006, 0.3027281618639573, 0.028720914811159876, -0.38214704700596575, 0.23040281848036456, 1.5993280255333995, -0.027218973597099218, -1.5736966327003916, 1.5842412072877503, -1.002951274840612, -1.804545202565439, 0.43543366482607937, 0.2910619370726156, -0.6286409157727726, 1.6855657689195929, -1.9206550013108954, -0.7906473966173182, -0.567872898379733, -1.2223665662234064, -2.9009890671853555},
    {-2.3455145636074004, 2.303503950303114, 0.9494569360179214, 0.2648937725414211, -0.7883994256391682, 1.5537527130116315, 0.5189031801186376, 0.3678224153136187, 2.9742148589421205, 2.3193511756660508, 1.7766233046696653, 2.3825024473897596, 1.9271399692257525, -1.407329531676766, -0.4634689166533174, 2.7141862088571242, 1.4825553752301084, 0.7673576170166541, -1.3323883024558245, -0.7769755409892795, 1.6052680975039575, -1.94054417171791, 1.0086281954234249, -0.3323475909730152, 0.18244182184162638, -0.49619988256679903, 0.09852016343406941, 0.33914843169874187, 0.5610636717677066, -1.5271082382281482, 1.0211141497616296, -0.6522674327830786},
    {-0.4509835565014528, -1.3665768549980335, -0.2691888473912981, 0.3799766927013363, 0.9717871961353312, 0.6431318724688556, 1.851380144374129, -1.7121436560609455, -0.5879593534052101, 2.7469759262706495, 0.2758151597708391, 1.3623555102951215, -1.7668847480875447, 2.93604307113537, -1.26001432087022, 0.24942879208062155, 1.9768946328019728, -1.934262020280746, 0.1963806240239109, 4.0092188247015645, 0.9273801353726978, -0.2986334045374159, -0.5638449511645022, -3.0690884179051876, -0.6345427525188615, -1.90761693223182, -0.8181218844220547, 0.6496552757805709, 0.14158056415480083, -1.4727263028211413, 1.8556988652024642, -2.0218920410812604},
    {0.9022939614259715, -0.9788933681345717, -0.9678857858726847, -0.5776979668428346, -0.8527585301325274, 0.6113774966175112, -0.7375629128166472, 0.4403447582458416, -2.019248936485182, 2.58007359222757, 3.9678117270725046, -1.9576187033791894, -0.7638530397761037, -1.9430834618483883, 2.3149350433305695, -0.6340600114753379, -2.4987585698045742, -0.6813432222636994, 2.1971368820925874, -2.391923466973672, -0.7835370900824464, -1.3172251188848119, 0.6420026049657998, 1.6262427250494536, -0.728154195238236, 0.7300235591714803, 0.749510334684805, -0.3758238746940486, -0.8443793876288984, -0.6404854274785897, -1.1464866080680811, 0.38309528780061364},
    {2.6049446632539155, 1.900939139005324, 0.3256958516353964, -0.05724957661408889, -0.36059254506516436, 0.03500345538711011, -2.2631429777638856, -0.6088577965679901, -1.7132015288847489, 0.3067441157304675, 2.186141580918166, -0.7373313737977143, -1.384827322165871, -2.477891116757316, 0.22738128247946043, 0.006684761515848923, 1.5892083534586872, -0.9241820233928095, -1.3389892050370291, -1.7837888125322157, -2.454558610350423, -1.5489799521152847, -1.0364349539264697, -1.2486967378849314, -2.387573738216867, 0.013426792348029504, 1.708392544596468, -1.270516034088019, -1.2124011289495535, -0.7257788329116217, -2.2211431368431787, 0.31499733188986906},
    {0.9718670688021381, -2.676025703404231, -1.0392585081669283, -2.0680055256862335, -1.5260714644466076, 1.2135151610564487, 3.480368099929841, -0.273469540779906, 2.7773853020239248, -0.9800724557436783, -0.04954262471703293, 3.000760349418917, -1.6064602862085233, -1.0437910076929175, -0.7403956537953149, 1.5612765180824149, -3.0046755408107346, 2.156355345102327, 0.12827479453492474, -0.5564208717179829, 0.16062901806561802, -1.2917167391414406, 1.5826565684200864, -0.7235737028321619, -1.3377880124421848, -0.6226291878634458, 3.051982422337537, -0.9018646793314085, 0.31851023408375106, 1.1950805370770998, 1.0307189575004365, -1.3476658060764117},
    {0.6917028466236939, 1.022180201423235, 2.276598130676321, -1.5525524832954747, -1.9095579030765089, 0.046635159375197285, -0.9596502611316379, 0.9970074546517047, 0.49363793752471297, 1.9525300430735149, 0.05348910347614522, 2.9495306479996013, -0.3545316734434907, 0.24298169474365972, -2.8915643894468626, -0.35900527317585534, -1.714725773623466, -0.533238957826261, 1.977720281327939, -0.3053810408393634, 0.19430681380419845, -1.478083686406419, 2.2676400604964995, 0.676086870985477, -0.9387582269929279, -2.9513105142673095, 0.3898487307699462, 0.7872190201995868, 0.736612551837043, -1.5532725261277682, 1.854313395248435, 0.7242566691667488},
    {-1.9004271610497203, -2.7490368451922786, -0.8824619937858107, 0.19597278884511707, -1.344358038704748, -0.8974301245818189, -1.4003702429035318, -1.8431735992885896, 1.2773179525449736, -0.5376202649899569, 1.4098114077029016, -1.310367643090857, 0.5646493363522581, 1.8082761516830284, 1.5046137712558953, 1.0835855136151944, 1.4998341109502, 0.8269480417547029, -2.305616129675122, -0.8389404122341932, 2.03163669054348, -0.8293371772960576, 0.3221925464261971, -1.2792785507802023, -0.24050677723153413, -2.6595128082966557, 1.0295387811496086, 0.03474092575949014, 0.2615069825765949, -0.337086212336347, -0.683995425432, -0.9961182759635049},
    {0.036768358025306196, -0.24797731456773964, 0.6647550415788014, 2.637980988706804, 0.5861976874412395, 0.38725192843943146, 0.13082805464196967, -2.8106359732101174, -1.376548527881829, 1.2608752993440915, 0.40021568312788236, 0.1544664975830873, -0.510455386017731, 0.43604910973250255, -3.4037461022295696, 1.7590627874747007, -0.5672036627072574, -0.3579948886863905, 1.6764592759451824, -2.4259247368263264, 1.4432030151996542, -0.6953147169620906, -2.198401292442687, -0.04141167308385023, -0.49095639576073463, -0.457670017325227, -0.10564764984804352, -1.4064011351746668, -2.0619165935630535, 0.7871672223717667, -0.20088632093982184, 0.8979808705284443},
    {-0.5507366751016112, 0.03229937131810759, 2.9526785014564014, -0.8947892536899817, 0.14399381099672393, -0.34345141960930864, 1.7212606809295228, 0.5330789164772264, -1.1300123677787504, 0.436718444499467, 1.811934005906221, 1.1638661234803913, -0.5087352218484033, 0.18473429489421545, -0.6938711713105248, 0.7327349740203745, 2.114561363134301, -3.1345547087456, -2.6390355805958547, 0.9743905167189627, -0.7969016426170674, 0.8338479400727681, -1.8094768480676855, -1.9357780057412197, -0.9153216612216497, 0.15111940996979936, -2.091132496117365, -1.4809101993678875, 0.4779315841007103, -1.0665670480177674, -0.0961525215614331, 1.5175304528255624},
    {-0.06748496255593975, 0.35739015792809425, 0.8138643999420934, -0.006804024113700139, 0.08418744329961911, 1.6549575954493232, 1.5875246963270089, 1.7459765464528123, 1.793100391152707, -0.32499028376070543, 1.0464012122891548, 0.47905901805181333, -3.5459547719312967, -2.7979587726762167, -1.594110113590893, 0.9854514308879672, -0.4228273142953022, -1.4054642259434422, -0.5548447338265142, 1.2021491336888628, -0.7215104339399843, -1.6822635602867668, 0.2331968657621843, -2.7218112062015023, -0.07444109286262199, -1.7709906480345894, 0.7351591467771186, -1.9983217861995908, -1.1811383480263749, 1.3578777202190409, -0.13167375608356102, 2.7035214749922294},
    {-0.2750198907876998, 0.3291459016455423, -0.9547641480781877, -1.54256247629306, -1.7813260524632069, -0.7338170569231521, 0.6739454208146781, -3.3161416005754303, -0.5048741529188504, 1.467632981107962, 0.8401506122178521, -1.2678378739527976, 0.8631869270530527, -0.961840523829275, -2.5393671648620586, 1.2543299376254982, 0.7229693107083287, 0.3198745763738545, -0.37836987322776305, 1.6262574291883274, -0.09724287811953879, -2.0739036162281237, -1.5154613534676344, -2.3484060065585686, -0.23761672922888571, -0.1829352813098199, 0.3308698871057112, 0.352888062460061, -0.4299995375579329, 0.383898467354283, -2.5303696694393083, -0.9780162504145505},
    {0.4506522887471144, 1.4569593871764763, 0.1102120711866946, 1.777140847746363, 0.09493588907732074, 0.0016002023244835657, 1.0439401703096012, 1.0616464655412934, 1.1061016904591021, -0.1233337244903214, 0.1002111248999142, 0.4675610818714892, -1.9061514613695993, 0.43141095361200205, -0.18307338571013235, -0.19888836336985408, 0.005698865199910407, -1.9551865713494616, -0.019259622154488256, 2.6307554133758018, -1.413035871254825, -2.5681706445313304, -0.3705613545934985, -2.1628112279016847, 2.264365658435619, -0.6186730393433123, 0.15420315138587712, 0.5025779573076733, 0.3278516900053027, -0.9564776513809098, -1.9693811588852554, -1.0472636211773079},
    {-3.5834993708810576, -0.1347857504523537, -1.1406059821059622, 0.21543736593949678, -1.1756497715483483, 1.4460751825666867, 1.4619536235966675, 2.4658745133724116, -1.1359451862939967, -0.04957487908541363, -0.012015707196745067, 1.9187540385699158, 0.33966793990629796, 0.09371602055858654, -0.997558263514064, 2.2992370118739456, -1.084497507651239, -2.2591741780014987, 3.1553970331310732, 0.2597081563142096, -2.011306862028499, 1.2975531743422561, -0.1145338944864451, -1.7962569526308718, 0.13035171032150847, 0.33522990616355114, 1.8640923427600953, 0.7549957101601413, 2.8973598591592533, -0.2874483708881271, 2.681740948448103, 0.07366654455226378},
    {-1.3746747644946034, -1.957130127217193, -3.4322773245765177, 0.2754446414557965, -1.8189539999182691, -1.200495456333865, -0.113465925472391, -0.22006520148714742, -1.4438101212627028, 0.14454148133169561, 0.1444819577981348, 2.324514532472172, 0.7592137586512879, -0.9397872786873841, -1.6096237448985249, -1.52743558945661, 0.31051831693062576, -0.25163043951307523, 3.5117592707815506, 0.0867197800215567, 0.8180089123795024, -1.877595440463044, 0.46037076425002416, -1.3654814659068373, -0.4574233060724485, -1.3014486330584183, -4.23835067740304, 3.7666408944335497, -2.0951391901057965, 2.1628994561356416, 2.9306502226981643, -0.9156289571456568},
    {1.0205506809061717, 0.21815291591102776, -1.05218791197407, 1.5485221515296754, 0.30480744479374783, -1.3062903211483619, -2.4428039281000604, 2.950229421119464, -2.072981413188999, -1.7911373229196659, -0.7035113290684955, 1.8137820979772148, -2.058836560898273, -0.7298807039268883, 0.1313121024066513, 1.760469429231514, -1.67168163889263, -0.9346590884410029, 3.5520662163824523, -0.04291781794277665, 0.126150454377833, -1.230482140038392, 1.3619681097024119, 0.6455032698974613, -0.623526889230229, -2.4103202781892406, -0.4303523448624975, 1.3558899261994033, 0.8809602774449821, 0.8079937375592661, -0.5473807264185867, -1.0409526143884624},
    {-3.4755044808646454, -2.4346391306394146, 1.3826978054289278, -1.2846191625743302, -1.5075686477157875, 0.26823960791940715, -1.0740228353465595, -0.3870095892030565, 0.6594596707227673, -2.464291420512428, -2.404180343371871, 2.0332537441694565, 4.291474176448872, 0.23824395212966684, 0.9850394556345111, 0.20367424303673792, -1.887682006435825, -1.0406353490257219, -1.670577199248706, -2.01180381506269, -0.4752667228328219, -0.6890745793995181, -0.11873893708274078, 1.4325092697678545, -0.8604189561634827, 0.42943738839426804, -2.0564196765967315, -0.003985966633682278, -0.37470729539074943, -0.504384623069156, 0.8740530749920319, 1.0558265457407545},
    {1.0319575093472422, 2.519191682587571, -1.3665548904377443, -1.2374889002559375, -0.12949047539869332, -1.0921625008457567, -1.4541287583981608, -0.507335874059855, 1.4593613653911082, -1.2756745238711795, 0.35181018232671996, 0.31346735668110703, -1.13772155181236, -1.2828217243513362, -0.6228042626393197, 0.708721239138934, 1.847358143649325, 2.9265356094245614, 0.8855650818207733, -0.9935635193493884, -1.7348860720694672, 1.5133420253430034, -0.007626541956286913, -0.058808894248367084, -0.025590588853131268, -1.085874018326026, -0.43569754929177695, 2.022228595847394, -1.8337331004615545, -0.8380604830225927, 0.6949626674746983, -1.4988058350228033},
    {-1.0284927053857436, 1.6780611439317807, 2.884337185834904, 1.1162784255360658, 0.8719821422139684, 0.053144824182900195, 0.1289647908372766, 2.3721868849091607, -2.968417557386302, 0.6380023906947672, -1.162736345304938, 1.0048709563955573, 1.153986808612832, 1.821399413337165, -1.2057006933872447, -0.6306748314513068, 1.258783904177191, 0.05002145898282806, 0.06125096902356261, 0.11943538160849786, -0.23697848850158287, -1.4467166356797572, 2.5556621855275914, -0.339714019346853, -0.7402232892904006, -1.9793513721956117, 0.6165638253784204, -0.6023737493856618, 0.5169062134430473, 1.047399600155865, -0.28951311305622734, -3.32438735916418},
    {-0.37768036768046265, -1.0763564474241814, 0.41693676924385253, -1.0791094406139756, 1.4945506302802252, -0.6111669990148427, 0.702987172024978, 1.3381700738490494, -0.48431245118546484, -2.614281352739987, -0.18476816437382848, 1.284375781934366, -0.8612291493276741, -2.474633626306416, -0.8970373119473596, -1.872148829912253, -2.460142450474799, -0.5117621385335459, 1.5821336494741867, -1.9959872180295921, -0.10059376194722489, 0.6758167058218689, -0.6819072482460711, -0.9569807160709389, -1.599310496351059, -1.5132797638411162, 1.3476558700309509, 2.2448187202195484, -1.3641214827820782, -1.3918576876804518, -2.0035234621999476, 1.1135568687678272},
    {-1.2673790767017126, 1.5714460531780194, 2.5462462643266233, 2.949255583749914, 0.11196152561478513, -0.23823365660783202, 1.4419543755314408, 0.7451599334130602, -2.3385430663989184, 0.4617992224916754, -1.6222648294474014, 0.4641106661127825, -0.7020825835813184, -2.94928355615472, 1.8286330949086862, -0.5784772379940681, -0.8285037215650773, -0.28592593207740225, 1.2707094045405158, -0.44195682293390354, -1.3091054500850847, -2.2061745622722952, -0.6364348537599928, -2.8245588478150045, 0.6427178375951897, -2.0094989844312274, 0.10774690383805495, 0.6750608381288011, -0.0962909430730716, -1.0330327453134367, -0.93583439699556, -1.78265498138376},
    {-2.0885185629691914, -1.4942588694693881, 2.4329700526421787, 1.2119865069155267, -1.5684898374903156, -2.5445742502470075, -0.3231174098711736, 1.1601330664547969, 1.3424037474114672, 2.183524482472645, 1.4065684756239518, -0.1657857153103773, 1.5273702956343538, -1.7675656593234832, -0.35069849864188846, -1.9653467420024846, 0.17317457037453773, -1.262533627128111, -0.16111269923008886, -0.5013502016765369, 0.9456511506191614, -0.7605211059004011, -0.4535358375449583, -1.5872653229992673, 0.926002074447489, -1.9501695636405052, 0.27335327422062794, 0.01803541654815636, 1.1402960506471087, 0.9212615839293679, 0.16370933381775715, 0.8686347594127998},
    {-0.33742656344254307, 1.1745155783859946, 1.4691981923805548, 2.483947805993895, 1.3972388996412406, 0.24129532629443118, 0.42681951739522833, 2.9404159165971575, -0.2630804145869921, -0.2677406419611438, -0.307225928026441, 0.31020663585485, -2.1937177455581955, 1.1475553333801423, -0.3036250993138331, 1.1276370723378102, 2.317026148812304, -1.1934505118184058, -0.5895498509456356, -0.3204150347527453, -0.2054737722241769, 1.820252971016766, 0.4579716605485524, 1.4262787177530905, 1.4174471720526132, -0.6236100172148267, 1.017665265845302, 0.373008835896939, 0.6311330504900395, -1.4340906581200494, 1.5069341300122514, -1.485241646826223},
    {-0.61633075552077, -0.11729571428474653, -1.2765764940974424, -1.1216692272039535, -1.1809199067310232, -0.22739457412345263, -0.3559705590568187, 0.22358307187177534, -0.9283040326743474, 1.3659750454291255, 1.1958754138285916, -1.1250823588269596, 0.4512352104406732, 1.6210833764667874, -1.9907107360314877, 0.7159507113946948, -1.089363675344052, -0.9997731171392438, -1.7044985771777816, 1.0813087598708313, 1.8343798783502179, -0.6668659598597799, 3.8289724952366164, -0.4969149765104298, 1.0548662719874513, 0.7942903732780777, -0.15576688553118279, -0.7003801672689949, 0.3492647229289734, -1.340507122920875, -0.34014658262500774, -1.2035207415042872},
    {2.037062779017914, 1.0682356042909693, 1.2078357049016097, -1.7299181504333823, 1.1697111121898658, 1.7676023593498735, 2.850825568468595, -1.2976225493168243, -2.4511952259449084, -1.3276461625354534, -1.8142312825928408, -0.02748456904084408, 3.218166358017272, 1.284541133366874, 0.21314875786537865, -2.7083359914228606, -1.455502593561635, 1.4043132833374505, 0.1220872475916238, 1.915447179892668, 0.7120568199448595, -2.293916017497191, 0.7246265713574053, 1.9631590546506186, 1.630576122737282, 0.3670098711795854, 3.4477505978569334, 0.5894546952441763, 1.3811493467185794, -0.21713532121508555, -1.4537952271772334, -3.171275573313607},
    {1.2663637238850567, 2.049807027762396, -1.209116598244893, -0.5575960388305031, -1.0755786422629081, -1.4100240979160552, -0.1872825173711265, -0.06010358485432689, -2.9590580426515505, -0.7595178994153334, 0.29721502751005824, -0.13087935704998616, -0.10678046231388336, 0.788203010912973, 0.8540174223935093, -0.6018506079739369, -4.880963025369421, -0.2557490767572311, 0.9948566789948203, 1.4016986455599498, -0.12830525573624194, -1.5641421448127837, -0.37771980103561414, 0.3087250259999791, -0.12136213363586215, -1.8718187604187835, 0.5341405945923122, -1.6173820019297274, 1.193086569529065, -1.0353892584094642, -1.3769939196673602, -1.2169913399378165},
    {-1.0211292282658333, 0.32020045660816676, -0.04609962522144911, -0.751333680349905, 0.19248712039858984, -1.7964063605454315, -1.761651822109224, -1.9417635407650709, -0.6863981617307424, -0.8985983033645034, 3.219763082024855, -0.2123444414825654, -0.0544467576834732, 0.27623538680577164, -0.5612489638211553, -0.9747576374202663, -0.8226637058802914, 1.1116457037437557, 0.9860086720457929, -2.3048409191384183, 1.5251856906715022, -0.28409862839990074, -0.4973175319798845, 0.05257819674999855, -0.7851119779817609, 0.6587048280060444, 0.5191450838238973, 1.2654965116419385, 0.48584408011867547, -0.4028736683044334, 0.7161254032661665, 1.3027762058937902},
    {-1.5052395069284275, -1.6328045055028415, -0.03160392908786419, -0.03956555702959157, -0.1709874191459777, -1.925584259948033, -0.19747554242873935, -0.5303048014795065, 0.36255039622930746, -1.4419261537939236, 1.3398658549968143, -0.5282766789653907, -0.492961560237246, -1.767055345238205, 0.49556281940908586, -0.6601723908590156, 2.1331311161435376, 2.424917510962601, -0.7972013022819324, 0.418422350469424, -2.5833251799232197, -0.2584780228326236, -0.7209797571164577, -0.9080362692842249, -2.1669117736277714, 1.8998424496157826, 1.0206491737528032, 0.6645779373262755, -0.4349878625817724, -0.8766079287162731, -2.7456565742446184, 1.3827877623823228},
    {-1.0865646005083212, 0.03244086165380565, 2.6423335226888662, 0.44887947046248816, 0.7937914562246221, -1.6837873271288455, -0.9401900745395836, 2.3792931476195887, 1.334459056509848, 0.29773819700793097, 0.16832391685537446, -2.872862135066269, -0.412405711203656, -1.7491014006028485, 1.4798387028091087, 1.5406393022324338, 2.036891958331219, -0.4888567308515477, 1.9083332405483047, 0.9918537477454996, -0.22251563381214118, -0.7713758294948222, -0.9238129837036068, -2.5587426814526015, -1.773762225985984, -0.03037523395439655, 0.6079482841706315, 0.024771359420249564, -0.6242479874351923, -0.692541885455882, -2.5336429569672343, 0.8748324010954407},
    {-2.0501781137497583, 0.6761094699173924, 0.8203222414649636, -0.20633065073280182, 1.484763535412747, 0.15993412193615103, 2.719202109310037, -0.5032684692893911, -0.3831300432472745, -1.3469626096223721, -1.5834098665245089, 0.34876421355031473, -0.3719293654864733, 1.4650175581701868, 1.2233903934432737, 0.09204384801744903, 0.3848069574594913, -1.369654270178363, 0.562463496649178, -2.4586669901283913, -3.093575493063539, -2.957871543811789, -2.097600227276159, -1.2890653932165848, 0.4193721629742796, -0.9023371292462572, -2.4306244302931725, 1.930478572790751, 1.7720244453023586, 0.7648421378962253, -0.9618534678000807, 0.5819848891906977},
    {-0.5959188355542352, -2.15340702984936, 0.8753874164477867, 0.07893000550121403, 1.232276121263728, -0.7196522238990847, 0.23089589912813377, -0.7610049424504259, 0.5660583030497361, -0.3625425128567402, -2.088129669199944, 1.747885931148129, -0.4693256953246732, 1.1753717251911, -0.16235939621834353, 1.1543337327904717, 0.7069896888627433, 2.483346666946603, 1.3845791644038425, -1.914716148378209, 0.43145670661033897, 0.16020710187901002, -0.13136147738962836, 1.6155832296141686, -1.9178981035015883, -1.546096951563071, 0.9029029822141434, -0.2912474658640884, -1.8720301449507664, 0.8191904024525042, 0.5076240732957181, 0.6831502229834738},
    {1.2040208870970985, 0.6551349566993651, 0.09896632373687365, 0.04795409817638734, -0.6125323261370874, 0.25299505645919534, -0.05292167786185661, -0.7521323043322315, 0.15896530013330107, -0.12020221997592782, 1.5566470455085912, 0.7096548872476631, 0.14725931986273402, -0.24661548726009697, 1.1754072388807257, -0.5140672929666344, -0.5729328585218433, -0.4690928430597309, -1.993002305092203, 0.7480339238770444, 2.8125259733820553, 1.0167480250385956, 1.961944610697043, -0.25298966370946496, 1.3624914644940713, -1.6693385628790027, 2.1767934073881223, -1.526756767933178, -0.9843027161635797, 2.46339856896071, -0.07089840507295368, 0.17904077504367688},
    {-0.058671827876967904, 2.7477381849351845, -0.8958200651304181, 0.9795058661816806, -2.9214570977924956, -2.5879981870476647, -0.9517287392497104, -0.7627220739654139, -0.6166546485745515, -0.703183579116795, 1.7290035825484942, 1.162091113804099, 0.9065420914581482, 1.1119907973846344, -1.406384198412576, 0.34509628130766945, 1.0998275994124211, 2.2852708179328123, 1.1549581331043428, 2.604496602154182, -0.6020952360744298, 2.2383351580403166, 1.2110138603480882, -1.1894974147021997, 1.0311576799837203, -0.934869565154538, -0.010405032052857281, -1.2555071456489226, -0.18265422303377898, -0.6817879350659083, -2.3388345482798445, -0.8971388093358619},
    {1.289796037939181, 0.9720416278327466, -1.5575137850102827, 1.230687563550047, -0.948960630873331, -0.3799368789464121, -0.5649035234543994, -0.7122486002703223, -0.42912314354904396, -0.1219757439054124, -1.3438616521683595, 1.19528384683389, 1.0849410919550513, 2.635702884284045, 0.8092269628294266, -0.13372187418325368, -1.8337666518148092, 1.0250886384755378, 0.5042266390298169, 1.9139351332506633, 0.5034705462410073, 2.518683559772421, 0.43503207382719283, -0.20868944913964768, -1.5130259559240558, -1.2888869315892457, -0.06397312602496089, 1.8598612031080848, 1.2259830139450145, -1.5149067135498306, 1.032971210457073, -1.009606687955383},
    {-0.6245721407021108, 1.8522218852615977, 1.8684031964269698, -1.2588923483704928, -1.0394078144179273, -1.1020253686396073, 0.013007465835815421, 0.16562107479511104, -0.2783974317436571, -0.6203440906592093, 1.57916204864218, -0.13790557193079458, 1.0369955825552146, 1.6067858020532708, -0.32709640761351216, 0.9493858453680576, -1.4825016696566173, 0.845084835377448, 0.3956377151629805, -0.24477519248792545, -1.8351502780475177, 0.9821466956720517, 0.7641372675761293, 1.0159302992320123, 0.2870953041729842, 2.142815001910566, -1.4723795202495162, -0.3266772561672216, -1.1145274200859394, -1.2361168387095869, -0.6591406181818985, 1.737894338013193},
    {-1.4367819716593626, 0.9642064112913229, -1.4089411214259446, 1.4276767986971275, -1.966051758675157, -0.051344083284916325, -0.27527597719804503, 0.8291800772307502, 0.7998679732438225, -0.7581495564472924, -0.96064448048097, 0.6024340548544433, -0.5566375565846708, 0.4351946888939366, -1.2216122164233871, -1.149995500236698, 1.5172729897412063, -0.21224110726442855, 1.0217287678038423, 1.6400938151813464, -1.380934782864394, 0.5544185974636658, -1.8944055725305264, 1.7910238461114794, -0.17958779192328325, 1.550487087781035, -0.9451584934746097, 1.4257359575341095, -1.7485213968617899, 0.2854018342755707, -0.9195557774540082, -0.025270755239930973},
    {0.7816336236160745, -1.3705625342985623, -1.9349885559002975, -1.2640892728088653, -0.832500703776232, 0.8681769936466063, 0.7196301510936405, 0.13330157345502353, -0.6261180326566206, -1.1345487061481927, -0.31362052037882865, -0.29874910897065693, -0.032523117461279304, -1.3714316214189806, -0.7346158374775348, -2.0454570779111805, 0.9897681293532483, -0.7138550829403919, -1.264038753888187, 0.3997004874413469, -2.8585890046702915, 2.7733297175715523, 2.149702971936967, 0.1961951349204358, 2.097277635811631, -1.8813924104093123, 2.8287711683184225, 1.2161819196382464, -0.4971464939356125, -0.1969475156454551, -0.6312707573212227, 1.2544802129547665},
    {-0.4539085909636016, 1.1614082810560113, 2.220155996195664, 1.196553823106562, 1.614045344720837, -1.0575187520495326, 0.44727939266621586, 2.20718082463347, 1.3082046686516513, -1.2630212926360214, -1.385905119328333, 0.4112833401431903, -1.3678068802763776, 1.2956511364505214, -0.558352915882136, 2.206998493492358, -0.5136348839086573, -3.0500367382007885, 1.366747675036335, -1.2475742421359086, 0.2200806540435634, 0.86796889952462, -1.982802346627671, 0.37459048787139226, 0.7002954136334899, -1.35911808111291, 0.9374232878949282, -1.8803064070754099, 0.6835482783184047, -0.2335123311124031, -1.8086758165082235, 0.6852141617419593},
    {-0.19286882327157479, -2.60824958377603, 0.9323170200826214, -0.42112620372003484, -0.2584899282048702, -0.28783247623812486, 1.1018072568071897, 0.5964320170151238, 0.27541486000904897, 2.2363976678017092, 0.4387756742643964, -3.4158014946033695, 0.08792990143920437, -0.8945043058837288, -1.2207575637898165, 0.07467887587649501, -0.12383201436698732, -0.40209911508111124, 0.296064917714852, -0.8845070158409818, 0.05544749151653972, 0.5888327293232017, 0.9668435087479457, -1.8065170620147255, -1.4356365717867021, -1.227350016480914, 0.07192240807496765, -0.14846720300219435, -0.2738159235465069, 0.3413498807463267, -0.8481857465772911, 1.090500235438908},
    {-0.2654413422858326, 1.7303169013412643, -1.171026158204827, -1.4188359271119553, 0.47645617379284955, 1.4408422550909172, 0.869511568916682, -1.0135506626892679, -0.06063512472721786, 1.3771618510784, -0.6830612353579326, 0.1468848537335074, -0.018263989404401573, -0.19015519182597504, 4.080526938754109, 0.5144062236483565, 1.5035719387390172, 1.9409449400015313, 1.0256693914782546, 0.8485482541368294, 1.119724892963563, 1.4411087447728106, 0.6187196908382016, -2.3817811681516265, 0.09255525289991318, -0.2907940630890145, 0.140267509291533, -1.2009779798299518, -0.10692163028022807, -0.22515493870487754, -0.46161483941246906, 0.5876362198667497},
    {-2.606017789890431, 1.6332340982245885, -0.8009042640424128, 0.330971514363275, -0.9416666918242236, 0.3571614492271237, 1.6836109286886638, -0.8631926488217542, -0.6203125553825546, -0.3170693167754699, -0.03695858280491227, 0.35300485415421545, -0.8438896605098665, 1.3845975279295057, 2.938190950300312, 0.396187701608255, 0.3451900886315006, 1.0617488057086821, 1.2040839314487384, 1.6838130003511793, -0.5538565617348904, 3.264305659074112, -1.5319185070508556, 1.2163853886280622, 0.42909059382092657, 2.126191185863172, 0.3186360436642501, -2.6095586518692007, 2.168722465336255, -1.9057417985615732, -0.6225949591554694, -1.1750946126954962},
    {1.340301621347005, -0.5174409427061831, 0.4335556460593864, -1.8879203165561504, 0.9412223158339401, -2.3740333787025016, 0.6895498947729372, -2.454192746206377, 2.0585503303968835, 0.7965209287087672, 2.3732200036715634, -1.9795957337644712, 1.0490646257392722, 1.4739986416448216, -0.08263016573883367, -1.0146708490396807, -0.04260075273742521, 0.8583510514371282, 0.25992973360397215, 0.7847706068997576, -0.5474285980870117, -2.2492445240878176, -1.3068915149809988, 0.8516680060386242, -0.9241831671629747, 1.034550335061523, 1.2195237076954952, -0.2163310347750425, 0.7608004347580519, -3.682322099809757, -0.4687010645177486, -0.8432587642644778},
    {0.8040652574771627, -1.5933160364400993, 0.931354939243307, 0.9775625612990221, -3.417369174062084, -0.23553680541119046, -1.0178569100651165, -0.8035913404499511, -1.2799184163237507, -1.3567381159168013, -0.597466979229276, 0.11209195555990849, 2.490050749199838, -0.1598224322970116, 1.3280252637957912, 0.6874781512902389, -1.1715608447801982, 0.9986873604877105, -1.5552971562215103, -2.262116347222416, 0.31330382044095784, 0.5192155176272212, 1.2683097918909854, 0.4271717516186055, -2.7755532356989847, 1.8833743620299075, -1.1404760422247318, -0.21517176112528497, -0.11999056011620425, 1.7666769534962703, -0.8381062132077719, -1.451085014839333},
    {-0.5862709865456409, -2.6664653882497675, -0.8550558311382791, 2.804011461997637, -2.712550575861321, -0.4123030113725207, -0.7370157972833177, 1.9616549638695144, -1.1438554272911945, 0.6508464632838193, 2.5730446814857024, -1.19128653896355, -0.6388577805299218, -2.944502169869361, -2.0008918536467357, 1.682825543579091, 1.2063277025826196, -1.1825321144667869, -1.0432709962285072, -0.6474296134586657, 1.1934044402456137, 0.3586193891522596, 0.5884443085103096, 0.5934920557700442, 0.4750609838509861, 1.7956277416038569, -0.7136263491911456, 0.1356435282201139, -1.4596875752452714, -0.2607169835351851, 1.0989952953444173, 0.6112922467494881},
    {0.5680356192760573, 0.6546457099154677, 0.06655094716532783, 0.7668830774509592, 2.352760313650463, 1.213037529397399, -1.2521007596568436, 1.4832416190141444, -0.36717612273001193, 0.6538642835977637, 0.3296790170572764, -1.263306439707648, -0.4887910257508258, 0.251665837475523, -1.5924198415951687, -2.3404228764793453, 1.1392444581142855, -0.8955273865613285, -0.49349509431867694, -0.2602450829911006, -1.2042790828146128, 2.9447462639090913, -1.5887859339010535, -1.0769380789039507, -0.6217511894947436, 0.9206901953089655, -1.3468601295295999, -0.7248286104150012, 1.1696013783408288, -1.6625102875449331, -0.9936564086606993, 1.9566374989384676},
    {-0.9021956758380585, 1.467025154199407, 0.5098393657457647, -1.9212273634607742, 2.2186094748603686, 0.7585498473403265, -0.025554834403433393, 0.12541861781766778, -2.5630281758089914, 1.21428483176676, 1.6517475443300496, 1.208957546368347, 0.3778420119768411, 1.6332253232255316, -1.706262217324799, 0.9795129882741233, -2.2432706400846096, 0.15297169414039655, -0.37594549531202376, -1.084309492362551, 0.0858961022807313, -1.0537916805474448, 2.860324964857973, 0.46667513449996245, -3.220166798105382, 1.1929441328321706, -1.3044716020856733, 1.472446844463456, -0.3232644142884895, 0.4851935780612539, 0.20187501551146278, -1.6878194962576296},
    {1.9189743700948767, -0.4512134136447048, -1.6850283555850967, -1.4529216343557267, -0.8858328057936649, -1.9542396976296494, 1.2010021329935991, 0.4707915847006617, 0.8547846735983508, 2.461765048578767, 0.16173649344075164, -0.07544742641669804, 1.2876212297487715, 1.3231295800891572, -1.4763728479998734, -0.4678579991924486, -0.6143052962856559, -0.438441510760733, 1.2367862812972283, -0.35637074779935984, 0.9309748973391795, -0.10744784913743242, 0.8650765122130049, 1.7032053666126026, 2.3743734199181317, 0.12672073269218342, 0.39444473589603163, -0.6142087979612288, -0.5997045414887492, 1.532904205200013, -1.2070791187805454, -2.808614682032769},
    {0.5580352941653425, -0.0938182245780699, -1.1970237820130147, -0.6601761435492192, -1.1222481809805367, -1.0323902349341583, 0.2677430222989912, -0.8973663559238464, 0.8454852509644899, 0.3774619908799674, -1.0242158719600545, 2.877745572949102, -1.57035378774234, 0.734649909700978, -0.5228715896547739, -1.0226714903366025, 2.920615212860155, -0.8844634112017237, -1.1817919318869543, -2.882085524502021, -1.8936341493224293, -2.2158057216016918, -0.07740581308217136, 0.4891817153175122, -0.18608055175087548, 0.7132183167587982, 0.3563798744355671, -0.7684202390619665, -0.3235546733451813, 0.6298283627417418, 0.43918447445360137, -0.8382639520185055},
    {-1.9012217889658198, -1.3019918023867205, -0.06477212020464793, -1.1477418378889184, 0.699277638080467, -1.83058407069454, 0.7630387497912845, 0.3897317191099379, -1.4409552244468418, 0.4946511169862378, -0.1073730979367224, -0.360037303251049, 0.15390990328490145, -1.3114944581736065, 0.7892645436513984, 0.5104348620044079, 0.2021227664306831, -1.0333379976822057, 1.6932286770642941, 0.7395230757185003, -1.8460793115174052, -1.101970508317796, -0.6056223893369116, 0.31542374953466235, 0.13818850870921817, -0.5899089476507017, 0.07387101423557918, 1.1639206100823296, -0.03385044829331368, 0.40116203684067864, -0.5088728198212116, 1.5988940420613034},
    {0.32384645794705547, 0.0540799055245518, -0.18377354354442246, -3.1935950508606052, -0.9551709457181292, 0.8076583746489936, 1.388123650373243, -0.25132762423231336, -1.008737800241126, 0.03787540463185966, 1.6243940139822663, -0.5060211535121456, 1.566867296950051, -0.8724490267070079, 1.066510777136949, 0.2848007269754687, -2.5488692668574657, -1.7147487354108026, -1.4286226116910177, -0.500049184573133, 1.3686548903073479, 1.9266928662646843, 1.8013922262938875, 3.242292287457923, 1.0972753991471662, -1.7640098446865404, 1.3173195182824606, 0.1464403736950325, 3.5561439536019366, -0.7724075043637755, 0.5950310595688945, -0.32471466863651394},
    {0.7246000445060836, -0.7669758434946093, -0.21371625676883588, -0.3679758215239234, 0.07873827318230275, -0.07016818164093865, 0.6388791036640421, 0.43909486028892336, -0.6147233146984363, 1.169122996507981, 0.615819055914562, 1.2991520198166724, 0.06083383457707889, 1.9062570606681484, 0.9560538211606572, -2.2478965926389147, 1.1765165176611685, -0.4501120272713074, 2.5404339273307412, -2.3234610971068594, -0.9100078451328479, -2.2468401583509467, -0.8396954948074411, 2.5666526016449707, -1.197249476469305, -0.010463186493728285, -0.8839788046950987, 0.40934623806965525, -2.7852732978289705, -0.741428285254119, 1.4989655600366185, -0.10671847910716142},
    {0.5569296249166232, 1.8272381444223516, -0.07757604756410844, 1.0429994200987096, 0.6292319770391346, 0.8546564189376157, -2.237068226218776, -1.9700979312075364, -0.42281377031096723, 1.0406649639054364, -1.747765027411641, 0.2787820909172258, -0.9780868154026475, -1.0500570037186117, 0.037372780481653975, -0.9126671083871923, 1.6297656715523514, 0.3890180489739507, -0.04476824549370115, 0.40908024584924213, 0.43448932642141397, -1.0461500034027993, -0.9692608329124157, 1.2568176457230618, -0.6867268329340268, 2.4618513085183413, -0.37673536706971394, -1.874371946463265, -2.012078955246647, 0.0646078257702499, -0.02721323557171012, 1.2204564835169693},
    {1.3923431609963093, -3.9493463487012943, -4.154574528460789, -3.337188830223998, -1.1543495121917124, -2.297776305260139, -0.38465983753376465, -1.8518517754258845, -3.4491663102969645, -1.07443095659159, -0.9970201289285138, -0.6877551955004078, 1.3512259548731398, -3.200302364937505, -1.0986402959501298, -2.9276029393047516, -2.1924181265881435, 0.2393161184008779, 2.7898849472875193, -1.24102660116333, -4.538011952668168, -1.8614135580027824, -1.0393979341016744, -1.8439990017221937, -0.6068198680642987, -3.124569632750414, -4.145173171420689, -0.7321906084787334, -2.1500771783446497, 0.8169727510875596, 0.21045074480806697, -0.8756977366452595},
    {-0.6518090979669992, -2.7526699905122443, -0.248477055396038, -0.6848930176115364, -2.0934312047286805, -2.6018381558994426, 0.5155868104078194, -2.67622433200181, -2.587304717683947, -1.0569297877925048, 0.010710859012733871, 2.0541968159358612, -0.8744231977233567, -2.7778971516842494, -0.8848212786411521, -1.8531003627744704, -3.069842639775142, 1.2051819955506722, -0.42945764657068575, -0.0006537971985283312, -1.707825877164722, -2.2868721226160136, -1.8641947015893143, -2.9199559971932763, 0.04672426376512608, -5.100074200915497, -2.055981563148522, 0.3489403493081699, -3.3682184848256926, -0.4817632408171885, -1.6789356000603481, -2.7405140025676062},
    {-0.35423696567718477, -1.907396597941425, -1.2943456444231805, -3.1065704849093962, -3.1011950740601706, -2.6745870183866516, 0.7269242901445535, -0.6521701075489962, -3.1911679562466984, -1.1073823333219721, -2.125703067547036, 2.3012939772471195, -1.4750234323799896, -2.7506073297564995, 2.602682161584311, -3.117686670157381, -1.690190242552894, 2.582196496312752, 1.6889179957704368, 0.41771580588284024, -0.9030363734806269, 0.47862558811798617, 0.6742772047123798, 0.1844459835579048, 0.5301846342542333, -1.5694814876078869, -4.694340089972448, -2.915903695418447, -2.760070616798463, 1.391728108773378, 0.06309477430552275, 0.24606699852621894},
    {-0.3146210224707028, -0.24952660912647198, -1.012283049003937, -0.3115720358836026, -2.668053764376847, -1.363362112225391, -0.47004250803697534, -1.2702401041408575, -3.192749862303836, -0.11532980892058792, 1.03902163466094, -1.1443015575626965, -1.385292784185485, -1.034126526382144, 2.636703119855786, -1.0268173723776364, -0.9785758505455537, 0.9581546745713598, 0.8719086372007886, 0.7789943495548449, -2.507769356178665, -3.7772099971671915, 1.768519722324886, -4.181375203041, -1.3377784994083006, 0.03155464135609439, -1.5438399129211058, -1.2578319070447126, -2.085655339723625, -0.3595946959999147, -0.18132767452803109, 0.7758714477446527},
    {0.9668294249388459, 1.3416121477739822, -1.1074670091561516, 0.28571842721930135, -1.104406213499359, -1.701526039248373, 2.2937408980116945, -1.3612588866903386, 2.0308824309405744, -1.380513116160249, -0.9134139876743764, 1.4505554242008951, 1.356338112441749, 2.795798032510011, -0.9007801402476799, -1.0336716523433087, 0.7623725678487708, -0.4874106430896628, 1.7634230156088233, -0.40985139273608173, 2.758264383227953, -0.4282964054177316, -0.21775233928055684, -1.7099198212360418, 2.4819358107114033, -3.073309768932439, 1.1695752999203233, 2.769738159630247, -1.621364775503234, 1.648819914024979, -1.1484730100717648, -0.1905780087245961},
    {-0.27010730570748626, -0.3049401710278534, -0.564211349309652, 1.7782762086898705, 0.14632288517287817, -4.840222585496856, -1.4167871033607575, -0.6893577607524569, -2.780516311379298, -1.3928439008764775, 1.1913427714199936, -1.1163646257366195, -1.3763642951857302, -0.07160229652342648, 2.411910497665788, 0.6097884730254718, -1.092320655884775, 0.5994065936499343, 2.648660793868987, -1.463517741668933, -2.1143348531423425, -0.7051013365594423, -1.69887967949283, -0.7854824020168943, 2.4760731106899008, -1.5814182853945218, -0.8238956616641342, 1.1039465475374188, 0.02887068850485282, 0.5367410363407368, -1.3772331611260011, -2.7616405426276036},
    {-0.33312952691016645, 1.1810623119035786, 1.7122286975941459, 0.4742014101273553, 1.7180914560898592, -0.406353167144759, 1.5694775856450576, 2.926063295539902, 1.1129351929693068, -0.6493670828440385, 0.9344606134607278, 2.5816816820459825, -1.4383028712798032, -3.7953151282654876, 4.124930480424993, -1.661731100147066, 2.2242654235753045, -1.5981735822003496, 2.014323419686245, -0.974181534676601, 0.581441526078705, -0.046789591385532806, -2.4317166586244503, 1.637981370687696, -0.9045385932442348, 0.0327529732385792, 0.6620140906817815, 0.2920606533187171, -0.569869650116137, 2.604864578590227, -2.473046918256668, 2.232964435868094},
    {-2.4532236821412345, -0.433829007807652, -2.1453979999707573, 0.5738701017873906, -1.0481419294820935, -0.6165329239714871, -3.156928924581578, -0.7376086049962018, 0.3708423163445591, 1.6693469687074198, -0.5883428225292341, 0.5443287199519985, -2.165374533046451, 0.6901964142057645, -0.5302980392070131, -1.101288802376644, -1.8624770869512206, -0.11051613300736918, 0.2946993569083199, 1.5556907659449921, -0.1285084716838802, -1.3988008366488813, -1.9527718434230468, -2.874705936634865, -3.2897841139326265, -0.12153616083525719, -1.2697455042233137, 1.5828187175547181, -0.6764861856563967, 2.9415835094345786, -2.857466641592408, -0.36476993396825347},
    {-1.2683647307341517, -1.6730360959943926, 0.37106473319876904, -1.5177011608064914, -1.4074045861277698, -1.8536191579106958, -0.6912085697350221, -0.8853548380731905, -0.2815765242278734, -1.0873494275001783, -0.02017802305496642, 2.428092073514918, -0.7850834837761743, -1.6531415125937088, -0.05702694965870972, -2.1874205794235286, -2.540045735035599, 2.9136442956820727, -0.6923437627555306, -0.8245492890287934, -0.3014199202983821, 0.9283647012762596, -4.118108229863079, 0.02619888750492369, 0.09590498500986476, -1.168324640235284, 0.7941127838501006, -0.9983056623196201, -0.16580807737074488, -2.3165918205296583, -0.25515373501924726, 0.15142069885609574},
    {-3.195989935024606, 0.4637386352359552, 2.170525013814084, 0.19574713490799814, -0.6259000065001803, -1.788044775338091, -0.5329543460708412, 1.0229783688379523, -1.647723953146822, 2.009892400137639, 1.6791385292775283, -0.016128404135318384, -1.2178703646785138, -2.935803844744358, 3.5908022197022276, 1.6557503389017467, 0.07000011525824784, 0.4931661044292054, 0.008910807142839088, -0.826854234948848, 0.7142348313971283, -1.5284876557467832, 1.9638706423046492, -3.9970463232669755, 0.9212952014932089, 0.4374077760879138, 1.782369424152305, 0.8862791341454636, -0.4660350200438854, -4.49319288317361, 2.313689574052597, 0.4436551144818791},
    {-1.3297572488419234, -0.8219963516876111, -3.6441335758535183, 0.06537253695581863, 0.36820542197932876, -0.6252424731878289, 0.45109166661501837, -1.6975363912563042, 0.16806581647929963, 1.8193895052358862, -0.3157481926115947, 1.7667414656241591, -0.9606023460177975, -0.15411197300821725, -2.1989165409704787, 0.07961818797847522, 0.5155476225837605, 0.6224538638932625, 0.448893368758377, 0.8610414147386662, 0.37674600626081595, 1.0415992189909773, -2.5573631823744596, -0.6287707614872516, 1.041912152962662, -2.097095289598972, 0.867868411032932, -1.2730585765738593, -1.8936838555396431, -0.45512945563372437, 3.4028319449241264, -0.09970893624111311},
    {-0.2579198176484457, -1.5378273844829642, -4.7929506007073694, -0.17166874294602796, -0.8739302618907211, -1.855796005846243, -0.5922866761375505, -0.06632830504610368, -1.7286192180607067, 1.8244374576324842, 2.5816559727101205, 1.6068360055761686, 1.4585520695766416, -0.7715791158640125, 1.8844179429841088, 1.3128641751469083, 0.6235117324788791, 2.349276582989694, 2.4545092775016877, 1.9900235366520151, 1.8683949574763665, 0.393347256159039, 0.049536565879106764, -1.9881234876934335, 0.5067577972415714, 2.5140859899810764, 0.3215058784725034, -2.3853514935974123, -0.5771676981956737, -0.999375054561694, -1.3640616062252164, 0.21155308237468345},
    {-0.6904236879426642, 1.9066828867148071, 0.26856618388664005, 0.5286562717733577, -1.4098772483356663, 1.0760511549765102, -0.4872767948518514, -0.05264163528411102, -0.08411912885505195, 1.32910491316104, 0.7226220970138059, -1.6478470988214367, 0.2592681859584662, -2.554081900827989, 0.36358439374006063, -0.813413299213573, -0.10487384676965784, -0.11266388110314762, -1.3316933919634903, -2.5385794780417994, -1.2679207437221258, -0.1997916530310381, -1.2772058066141108, -0.15949524573229557, -0.8122190832230597, 0.7299356780751015, 1.1367005124379663, 0.836594758235046, -0.033983623177161755, -0.1589621008533584, -1.4119289290139545, -0.08596569947346377},
    {-2.5744548133862835, -2.404177483326893, -0.8001314025400189, -2.1221084113665474, -2.2870237158455398, -1.785682632239824, 2.865510965223647, 0.4418189000470498, -0.41470741009387513, -1.8752392994021987, -2.9027274936393677, -0.5697444814550243, -3.6202028942307907, -1.3270309470530643, -3.429007487994975, -1.7147689923415266, -1.1786256864233668, 1.157487529275658, -0.9300434239827086, -0.42984495498640857, -0.7665355933447583, 0.159685714567057, 1.2814420340360628, -2.056484330174061, -0.7390444728911282, -2.3829156834007583, 2.1803063809049275, 1.1145597686433297, -0.4881929168424825, 1.5074992803444913, 0.349011397547406, -3.249678777547359},
    {-1.767562844417066, -1.661759199721019, 0.4458341034231073, -2.4581493372892105, -0.5600544967396547, -2.133414620356249, -2.1167035672875003, 1.2353802429282361, -0.002262943866808734, 2.7532861601691225, 1.4237829094697483, -0.04836131349765894, 0.23237171541912094, -2.1355111058911556, -1.3344022046206205, 0.4192103895343085, -2.1748048713779906, -1.4088468437666974, -1.7460455540076665, 0.058577501672609306, 0.6537942373613911, -0.8856873542176052, 0.33552473766289254, -0.5896281681669295, 0.33803460500213695, 1.683894106328451, -1.576751269752159, -0.21146146377699457, 3.3277657732814823, -1.7956274103854435, 0.7933351321104394, 0.16615715155936112},
    {-0.8097534505222252, -1.7944093582178196, -0.47176464240844546, 0.7363799807076603, -0.32208679517346656, -0.6700733084986188, -0.1894986442251293, 0.7235626571106408, -1.3204243893969618, -0.34862429411029855, 0.8894412287453164, 1.1242738030209627, -2.7997245236715282, -0.6976675655646323, -0.7343160919096465, 0.8947369094956625, 0.5886269174797764, 0.2856764656541123, -1.6513843482460897, 0.19717771573009485, -1.3017135310746963, 1.125611744871558, 0.6417248442675257, -2.187940292407987, 1.9248852940741026, 0.999215878321849, -0.051302618013122206, -1.4475478834693607, 0.0543179843469449, -0.5275387911819184, -1.1900537257453048, -1.3027532163897495},
    {-1.670849616996071, -1.5914842641364297, 1.7267801967250496, -1.6277748445588187, 0.8359904813880819, -1.6709518356786757, 1.4984530541892627, -1.3229821817034333, -1.0897752120548583, 1.1815227128440051, 0.2327645014057645, -0.34566936728994085, -2.438354174817513, -0.7641423210658211, -0.8931927707903249, 0.7799796191142397, 0.8111689402236905, -0.20127471795971646, 0.9757674382348954, -1.1123676648529586, -1.568837303630411, -4.561050069653763, -0.3290159152492204, 0.17955909665142714, -2.1681268596818737, -2.460512523170801, 1.6084091262083622, -0.8854237928356328, -2.9401349639475756, 0.04258794868953152, 1.8793932506906788, -0.681408659838834},
    {-2.683527650809989, -0.40879677967197836, 0.22431249307963716, -0.4040573367278116, 0.7014007775509408, -0.908466788184494, 2.5566190621866345, 0.2245991751045252, 2.1698390541777046, 0.4989038120238125, 0.8138944578386701, 1.7019798979745457, 0.33013999921822357, 0.6250067692340313, 1.5801951914629615, 1.7024997288155421, 2.4340200823246816, -0.4114388552051835, 0.712079885342046, -1.210438870326801, -0.7072634345943201, 0.03208359599068755, 1.2763721579229919, -1.6268499162101626, -0.8811396889403084, 0.08726549560058611, -0.506804132761662, -1.5254888961246018, 1.3292727154065576, -1.7519428697026465, -0.3805500563892019, 1.772496642794022},
    {-1.726508079394679, 0.3189059753831203, -0.5170649036720094, -1.5024157689070077, 0.5041139617027421, -1.2233863582523976, 1.2025902358037432, -1.764387233970244, 0.7073230283735442, -0.68911083330858, -0.7062216634157875, -0.6097823434049916, -2.590091749159473, -2.562018142185984, 0.1833988014910578, 0.4515923145265944, -2.925464377980966, 0.2693352296931036, 0.7759447968242169, -0.7554625832446258, -0.816890979910799, -1.5984705308534466, -0.6249317143485016, -2.963221034117055, 0.771460858994507, -1.4222915088737809, 0.715857873676955, -0.6621313851504385, -0.26198566794294725, -0.5744416583652273, 1.1003848655093202, 1.0932284803576051},
    {-0.7066042644521808, 2.052889680982384, -0.6493300483193769, -1.6666936131652088, -0.7225377107127591, 0.6260415121939263, 1.162741342650155, -3.462788831650785, 0.4269324549593605, 0.6087607251642322, 0.17130850841361653, 0.45003098962786925, 1.3080229368359886, -0.25791961425648247, -1.6679326261863647, -0.8852880641709865, -1.1308760486928475, 0.3725036662836347, -0.9033281481154476, -1.456979452046486, 1.7173125021207614, -1.3524715759660608, -0.8799952875754727, -0.9213079911218304, -2.110104310887797, -0.5534112908826361, -1.4279067521446691, 0.6089565435689014, -0.9255193937493125, -1.4712425987720756, 0.6596792717460656, 0.6529538633503622},
    {-0.4721566353824909, -1.0085531611257135, 0.6572172759419582, -1.109554535397845, -3.0602898780328074, 1.0576901843688076, -0.5331381436196174, -1.1315085165379544, -1.8328427248859294, -0.6597786823350471, 0.8559498799455313, 0.15006318693464438, -1.9790307210155118, -1.4943637816281161, 1.675222994969677, -0.32668059360863694, -1.4297277211001385, -3.385064268704056, -1.7923948507910632, 2.7335741986984474, -2.747622362397559, -0.11584430029879723, -0.02794835480446716, -0.259151910210052, -0.09321642738591007, 0.1660788752654357, -2.613555993262024, 0.7831081494351548, -0.625571893558322, -3.5190602944280824, 0.12407019371294131, -0.9495805001320808},
    {0.6851828766730504, 0.9110683396757717, -3.597880686461168, -1.4373522020891554, 0.39871027521439145, -1.0640961801565014, 1.4638377079396574, 0.8724624026731322, -2.3760689223001257, -0.8158055073278158, -1.4571101068524415, 2.0342345140992073, 2.5709588184107224, 0.1195493177083206, 0.9712392989832579, 0.641452609469227, 1.1246869612287558, -0.6001722275091804, 1.3234823539173195, -0.05832098539031234, -0.2870770573806313, -1.4149530143849274, 0.5185177901141939, -0.052436276658186065, 0.08395311150944115, -1.5635898420897676, -1.543678559942324, 1.6633797244769506, 0.8959075792177561, 0.4889550226751709, 0.11234986899002013, -0.7847031652586449},
    {0.03927203054446078, -1.7543419017593502, -0.11352688479982123, -0.9535918902296415, 0.5453135612147301, -2.1795636241275997, 1.5969699643947821, 0.6302227332603719, -1.4727853661167523, 1.1430359869240612, 0.17568540338735714, 3.209394347476465, -0.3614977487590317, -2.0672610592555722, -0.7528189169668293, -0.010066306327106634, -1.8265217060327776, 1.4298447034542368, 2.332286507874446, -2.3249404525121777, 2.3759348442467445, -0.6199186618763929, 2.0425347030407464, 1.0479482679764722, 0.2120283816996722, 1.1628738383103645, -4.175108771102676, 1.1451544913086813, 0.17733787856128075, -0.5704350074701297, 0.41966551691305226, 0.7023547577000884},
    {0.1846556077654864, -2.3573342898557685, 0.16953843987883566, -0.5726909364657065, 0.5844186694847316, -0.8842618476727026, -1.8274858303577646, 1.1694254488723692, -0.603660511533773, -1.7457303713457613, 1.726041411279462, -0.5583183430279637, 0.08459641638020524, -0.6641679283347937, 2.4544866228845175, 0.5431069452049136, -1.5655316465419598, 0.11228627663238852, 1.0204709090557682, 1.494888913223767, -1.9282519565452152, -2.968662033221638, -2.18287857625666, 0.610331902577638, 0.21653315254452551, -1.92444135159267, -0.4245701802701666, 0.1835251963971902, -2.5094535247454672, 0.5330173082832754, 0.5003992585647474, -2.0647025183752192},
    {-1.5157732388942171, -3.2514448127335136, 1.3960475794075087, -0.7609369422346588, 0.7260980178210594, -0.6058092374320032, 0.5222774046516424, -0.9269534065340604, 0.48846070873552877, -0.4665880573788171, -2.0736754804453676, 0.7906968682989817, 0.46321964611747035, -0.3440994967621861, 1.3051265978330475, 0.7150635369843857, 0.8139896567062529, -0.19081940565395453, -2.711772649469659, -2.1542000098107534, -2.327625088274168, -0.11794778049777348, 1.3762698621493719, -0.19107812034966906, -1.7515613351327552, -0.8630908723878767, -1.6224986679572142, 0.28928771809718684, -0.6775029445148697, -1.6274136564229604, -0.16130114470705378, 0.9971306211369262},
    {-1.85770277231118, 0.293689933953223, -1.6290009911894914, -1.3389062224360329, -1.9196049715496022, 0.20629611710371434, -0.9774364054632516, 0.2660163584881986, 1.5578061949980782, -1.534605196218026, 0.6413602814256627, -0.8577751682955452, -0.11290931605323747, 0.4610281561134075, 0.4313111180699085, 1.1849197861021323, 3.17561142262763, 2.3451632945337892, 0.6633152777806676, 2.1811707068922015, 1.4858066536121683, 0.5149729866368392, 1.8697970408388471, -0.30036306577032545, 0.35386984043318626, -0.5658242080478267, 3.0878015064544093, 2.137054567911111, -0.33967824010614917, 1.3227263461376033, 1.3187592015915846, 0.4803289044737074},
    {0.8652736129240208, 1.1735175609473696, 2.5926017586802863, 0.9752978064250623, 0.08859796867458145, -1.218650876526135, 0.5229115897695878, 1.9206118200422762, -0.06952904603873511, -0.5405730766737123, -4.135033521477043, 1.5534942351594738, 0.3440120922712588, -0.9296866079296483, 0.009050736453003864, 1.6425104549270124, 3.384026818939523, 1.5899598964968849, 1.619767423576371, 1.2936627226052462, -0.32812230597564307, -0.24906032517041718, 0.7199216571031356, -3.1038581210910285, -2.373527648954658, 1.074527325454557, 1.3089474760454076, -0.41737379406895764, -0.8410150775121916, 0.6301586541500446, -0.2888182430732741, -4.189639093543124},
    {-1.3420438304323548, -1.087590653034784, 1.5584831383637983, -3.25478037378845, 0.46529258446745375, -1.0994751976180248, -0.31110963017062826, 1.4776040335495804, -1.183309188136979, -0.43537597080120344, 1.111052188331777, -0.05814803261385052, -0.36181440780624363, -2.780648841085226, 0.37497613580703626, -1.3777977909296155, -0.22353622868845008, -0.38335120285870306, 0.8865845118023089, -2.673180274732638, -1.6782695414452844, 0.5732758114200256, 0.37552271031612416, -0.24776377274406555, 0.5768496397323676, -0.7047147971741752, 1.6005208425704254, 0.13035838495787774, -1.3508516685088305, -1.8269697794532092, 0.4311341931816674, -1.8395472941741977},
    {-1.1748558348121187, 0.20092125577967895, 2.656624205380741, -0.15811716749968618, -0.5446503604929439, -0.955725157454479, 2.5997962661915825, 1.959481301165926, -1.6847997767655274, -1.1094569730484096, -0.44288511788498414, 1.9483692841779399, -0.5834311503019776, -1.3026298698358656, 0.5357555198716539, -1.790485579199681, -0.7177799059343655, -1.2223414416930316, -0.35158933159721323, -0.3993558042154296, 0.6037767608380317, -3.295462895236189, 0.43618350520971616, -1.6296746471584833, 2.0438602301602287, -1.0668976598224418, 1.1935571541558285, 1.0933493065093167, -1.119431148462241, 0.40272680518780707, -0.1045299438026255, 0.3346526456384871},
    {-1.4060587837365106, -0.46887317418988295, 0.8890903842475065, 0.250985728855027, -3.0100783252474543, -3.440008844479586, -1.1040536942037986, 1.3389589827441988, 1.7254350034092927, -0.9513297700590873, 0.9307356880005735, 1.2268520982371147, 0.0851534546701424, -2.6110437570568514, -0.04289372870253787, -4.272416024784412, -1.6442543677117396, -1.6463706285714055, -2.632675076640677, 0.67939457268294, -1.1366964794502885, 1.1329848590950726, -0.9447401480459288, 0.5484860942958505, -0.45930294561406715, 0.549616553189231, -2.604878900678978, 0.7244845214124719, -0.31486117176308864, -0.4577360318740245, -0.6476988752303067, 0.25123865022763386}
};

static const float b1[32] = {6.733285092876883, 6.330356942722738, 6.39504720504144, 6.940404975686367, 6.48242989299249, 5.943312414859191, 6.678620681370006, 6.200742365274258, 7.048792726108989, 5.6072951630485495, 5.846019692449614, 5.613519069846493, 5.781944880328778, 6.423734561047257, 6.19184430188183, 6.399633164270429, 6.950304680016626, 6.429598131977223, 5.0460497736954935, 5.736887687176507, 5.143070067880924, 6.715971759120954, 5.660093143344527, 6.790554677971748, 6.570678160423874, 6.443425861606218, 6.678220593143572, 5.729467506535988, 6.872386875513459, 5.598905762585202, 4.404153800845035, 6.733192201114791};

static const float w2[32][16] = {
    {3.142021389231905, 2.8718602677555243, 6.23670111593372, 2.5844972911421964, 3.275239668292889, 2.714989785457947, 2.969141097572257, -1.3621230057883036, 5.359432908978388, 2.4772050185674344, 5.708840509780891, 3.8685421191524485, 5.085295914836823, 4.543736701624656, 2.4995096980376372, -0.5346397804438489},
    {5.749285757103361, 4.034699781315452, 5.296385920794901, 3.403683279229585, 4.041800231174238, 1.5367412176423048, 2.2869803751856006, 0.13384957781810353, 5.358094597678463, 1.8342496296918758, 4.8549269313492305, 2.2469031324509925, 3.700279802275103, 5.243135357576489, 2.7381088642096776, -1.1364073415476454},
    {3.1637626152598433, 1.4270514391462361, 5.805987059534968, 4.436417806323242, 3.5952641040365334, 2.785916468142261, 2.407416978809585, -0.9731114604034509, 2.929282508157822, 2.6218032244193736, 4.779846057718684, 4.898996736054267, 4.280492739155745, 4.669372174839759, 2.965083392359399, -1.8615284803432532},
    {2.4530879813364455, 3.2008042417840548, 6.036358034304924, 2.2373258507641434, 4.747793313062241, 2.26226150341068, 2.8073207247872625, 0.7036755723158151, 3.7341327716021158, 1.3810611443372995, 5.512885438257251, 3.227241195126943, 5.386102864784228, 5.061909525647376, 3.209267071267563, -0.30337584887788716},
    {4.604903197364486, 3.2051906488161173, 6.847534644624145, 2.41726969645691, 2.9965651719473194, 4.899684687666409, 3.200005399754848, -1.7168965432778232, 2.657675400273867, 1.842703793552673, 4.510339490836695, 5.359006548882674, 4.624359751896939, 6.395163341609275, 2.9391658730763375, 0.6813198709294305},
    {4.157841081089423, 1.3333438070296728, 4.141330638170971, 2.684211323946942, 3.3337248916617153, 4.846547050049133, 3.8253824150347806, -0.9234919167548645, 4.7734136034886605, 1.187310392676712, 5.468677336554025, 4.54811891494457, 5.744767703667711, 5.7159225436143375, 2.6697216663013004, 0.8967129075206606},
    {3.1377135631401925, 4.165544759892158, 5.398290667305165, 2.017973954377308, 3.6980405770840834, 1.0455016996605813, 1.871613415299447, -0.21721204902592822, 5.294442556714472, 0.7251269893234471, 5.883810180305489, 3.3123596374657978, 5.077402881949994, 2.701703587283888, 4.027797581558907, 0.7926927287673874},
    {5.718801359506243, 2.7326732752556095, 5.642564287352461, 4.116131394419744, 2.2292763400651934, 3.470379630161117, 3.376441496679966, -0.17973333993340224, 6.2127528919504815, 2.5705190908544995, 3.8870951050606353, 3.0597469509606214, 6.387906682244956, 5.224140848672609, 3.2718726396336417, 0.21353378618382693},
    {3.80832369471841, 2.2163076813861564, 6.700721132224164, 3.5380120960393673, 4.547004231648783, 1.696477761871214, 4.016683436775539, -1.4872470994540568, 4.927118734325053, 2.4581612316325456, 5.384964534603199, 4.260197476544703, 6.0912714641558905, 5.360560590152818, 3.6874875186911678, -1.089125552380742},
    {3.7276847016036534, 1.7433741331952786, 4.606901994633015, 1.8711262958421369, 5.080848589622022, 2.644052604081881, 4.3222609240558585, -0.8915062828018134, 5.406860675369304, 2.407537898109354, 3.704069474460113, 2.8585127271761728, 5.782932557103033, 4.567032050607218, 3.2698491685603934, -0.697469508362659},
    {4.271121688135338, 2.7806622992256997, 5.3947308984130995, 3.593324856390591, 4.543435306266923, 4.000139863135479, 3.666251970208997, -0.6890052454113108, 5.837685132980104, 2.506817683052124, 5.3220709144157645, 4.863381064091196, 3.282505523436562, 4.909926734862401, 2.2516376889956318, -0.4129104436106677},
    {2.9090707148924024, 1.8210984829273382, 5.085897878504692, 4.072975993838836, 4.741974047686198, 2.2453648234054295, 3.289504769299437, -0.45416552767097107, 5.639619188767602, 2.699590139875769, 3.0806674200196813, 4.284759439139913, 3.2502801622096595, 5.269664684037937, 0.8554600082525496, -2.074019874639083},
    {4.275388063964489, 2.58675954355588, 4.845040315917598, 4.1137848218001, 3.7107260808820945, 3.949307047531828, 3.059801571554325, -2.8636899888157625, 3.4537278380559226, 1.7654791182398213, 4.389671133703468, 4.973358127909719, 4.081851234930229, 3.9877701579146896, 3.8809456175544184, 0.5419735631034149},
    {5.566964717843155, 3.761807207462117, 4.809914086561293, 4.722319494100066, 0.8867453892122923, 1.9178202900830321, 3.14962696364133, -1.5928302270602954, 4.0916188493894206, 2.2524904015027434, 5.802895607292499, 4.153075674392822, 4.5036261156176, 5.519923392934873, 1.82568122510241, -0.7560505675612149},
    {3.619074283591263, 4.63708920758312, 4.274588313967976, 3.7932323263856182, 3.122159911515648, 3.1992551873885313, 2.3676041002661194, -0.8727672816401124, 4.271364390734963, 3.086218823192145, 5.2531222670217135, 3.745594553947366, 5.086533346215771, 4.645491388404235, 3.8575224688476237, 0.962721851609161},
    {2.4090125865412877, 6.41887445808501, 5.385889502449148, 4.345583595402023, 3.5451696473785956, 3.674638930335763, 3.016633426706763, 0.5014376384149684, 5.153758713514436, 3.892984834258264, 6.561742514365881, 3.350096264835757, 5.762330583816886, 5.398307148395022, 2.7782073122432736, -1.84690465637803},
    {5.676235367177325, 3.152183114855722, 6.151641584188893, 4.239282521476022, 2.7445616485961293, 1.6659878170919447, 2.1783083833150476, -1.8823512920150858, 6.398250928304275, 2.2619003087880856, 5.387872954597627, 5.958995402769342, 4.386234193841192, 3.2992950771332783, 3.8531849050441562, -0.05395185516116585},
    {3.750799785199282, 3.284814369048529, 5.4140620961456865, 1.3432370804926221, 0.9309927946544627, 2.391700097095846, 2.357032550006493, -0.9589727975451734, 4.527816842818129, 1.3146027684376518, 5.44313905790799, 3.1936640727045966, 5.924109660210073, 4.548638228378354, 3.9721664996006845, -0.6168977274633959},
    {3.4420304282635468, 0.3178678202213366, 3.735089262303665, 4.176558070207494, 3.8037681886849164, 2.5486182962851904, 2.9791296745407627, 0.9796744397080167, 4.303812119609844, 2.5757991087410663, 4.654422493924571, 5.226382512696678, 3.70527446850545, 3.5611025134963685, 3.7371889568413663, 1.9642587283304966},
    {5.498239324785453, 3.4231412281686824, 4.489715335041122, 2.612232976240019, 4.531100251828102, 5.1620343772089, 1.385921047665303, 0.63500138926506, 4.177180862623056, 3.4625067710679525, 5.055782671393795, 3.9668775244264958, 3.6877162829859382, 5.698362166200217, 2.642608959459806, -0.18396906598292947},
    {4.89294500774312, 3.288615649791565, 4.554714706335134, 4.5049672854287985, 3.964108302239559, 2.6594690417138387, 3.1839724082078398, 2.559559267257501, 5.575478197327086, 1.979903997097979, 3.5638064545899257, 3.4185782385362837, 4.250389398820523, 3.994474965179677, 1.8879538271727236, 1.8996490446854686},
    {1.6486440886213427, 2.2176579114449044, 6.545835077260875, 3.354428664552095, 4.802914021463982, 2.8724425539489227, 2.319419637355387, 0.2948967521347868, 4.332796740457526, 0.661537586314185, 5.510709575240625, 5.68769811021622, 6.991842026077651, 4.010235311273736, 2.3731280930176815, -2.4758192599855326},
    {4.844251731806098, 2.889686197400515, 6.79269357231796, 2.5542385207501734, 1.6671781978885725, 1.617627185913207, 5.393188400988732, 1.0072963938812847, 5.872183276098303, 3.030168325898178, 5.289875100204111, 4.7177646360173515, 3.6042475298684233, 4.19138937198559, 5.4768656232285755, 0.3738961716160084},
    {4.696710675412943, 2.7969388638608184, 6.287619540034103, 2.088820944950923, 5.255962862539575, 1.646847627829998, 2.2937244955933984, -0.5242480697282985, 5.590044132093554, 1.8065528419735002, 4.797303550825109, 3.17627815666278, 5.475980894729861, 5.054795703082341, 4.260986543167274, -0.6278510955028138},
    {4.532008432873378, 3.4636783099022947, 5.45927426288419, 2.8712175037584062, 2.8008004533936237, 2.5360501920572034, 2.25624532106243, 1.17760328955124, 3.763912443080996, 2.4924697655412626, 5.811157998745206, 4.4531285627897095, 5.260837460993491, 6.08804065767221, 2.7956828540132372, -0.08952683986263753},
    {4.850086701951772, 3.2154476661624813, 4.887605444661914, 4.040387846853248, 3.767731584082868, 1.6572085125404306, 2.637562418054811, -0.15180090174260918, 4.144590754319193, 0.9045809334287798, 6.089709518384449, 6.953180645082904, 5.159085598893837, 5.602142096845302, 1.865264749201176, -1.0469507679259764},
    {4.070509341455273, 2.4606391929658082, 6.976088258606727, 3.883740190794364, 6.185037368059179, 0.694361756248381, 3.69649046214419, -0.31082850207784424, 6.054188040103723, 1.7341316049494708, 4.243646319888821, 4.0036008343991165, 4.039161180579611, 5.947504926759333, 3.346571910081515, -1.5818413603546617},
    {3.414938280719146, 4.807921890204645, 3.9645061497045955, 1.5957065397746912, 2.918973348676395, 1.9608773068086087, 3.49123118028317, 0.67227004590575, 6.660650012816963, 2.8425306379788964, 7.486079440922746, 4.049140202592339, 5.307341768573945, 3.62997089487507, 3.8196297248043973, 0.049696617666357905},
    {2.932738251640037, 3.715245967165868, 5.067018565125814, 4.484501339302575, 3.7143990438815635, 0.8849253790365408, 3.1163597177783675, -0.07135819723271031, 5.519821415898003, 2.5677814028661126, 5.1370293048244395, 6.3558064899530295, 6.005075038817182, 6.147981734121505, 4.249419868064695, -1.8696514360058636},
    {3.8105672013669696, 4.692416556733491, 4.4007834958831635, 4.170469646020551, 4.149042097097276, 4.344794886399908, 2.9755707168812773, 0.5319296193381065, 4.483454917470017, 0.4204562034112789, 4.157944056656558, 5.258905881868232, 4.7017589785669704, 4.2163216776846175, 3.924264733469236, -0.31129631850401895},
    {1.9230516260651391, 3.739545451388941, 3.7862105135050874, 3.1078817176287163, 3.072966053016605, 2.798714737202468, 1.3531638960470784, -0.1249054158397579, 4.437143224770209, 2.0504167406501748, 3.915914463039154, 3.0744233820987694, 4.00900110078976, 4.1655935686497045, 4.025854934665042, 0.06861035780448484},
    {4.366932531223132, 3.978907567578269, 6.370669103321976, 3.2117350488621135, 2.1947102182512626, 1.4821248669556215, 1.6793665908741908, 1.5481317374565238, 3.27261731495628, 2.0064128382134165, 5.698971081913969, 2.7068484945294053, 5.1292085772104326, 5.537743448471658, 4.798871165896771, -0.2581002912931375}
};

static const float b2[16] = {5.132491474527886, 4.449908374098262, 6.4105230881902635, 4.28044022863285, 4.284433284685731, 3.145217970503815, 3.0496804453227746, -0.6226349736217149, 5.7761373551330575, 2.7340710533761334, 6.2115880972859525, 5.534616322311799, 5.83403250325758, 6.136299851228701, 4.468887955827153, -0.22166706571092296};

static const float w3[16][12] = {
    {-2.7205701575814083, -4.1283287990592, -2.5982958296826966, -2.0863690698168376, -3.926600518750791, -3.365053131812649, -2.633773315076806, -2.496648402901832, -4.506955638373903, -3.294922123449482, -2.9466473659926202, -2.4877693293161234},
    {-1.8604333183579762, -2.0575761749892143, -3.027358935042547, -3.13094290530658, -3.302302378649842, -2.469597013822501, -3.9317624882957367, -2.451809395856248, -2.1036455348231704, -1.9024469024171031, -1.6699481870001605, -3.8326151561963147},
    {-4.44293382246843, -3.251870223980714, -4.598188125578565, -5.046349135837196, -3.997377681421418, -3.4408962166886794, -3.8526854412407925, -3.4511833643170107, -3.0349217710076664, -3.884672619872503, -3.6262242578943855, -5.835926600454706},
    {-2.8641774315893413, -5.195662484441272, -2.164360868053921, -1.94339922844022, -1.9372970046598557, -2.806136599946378, -2.855324460889498, -2.8338975958316324, -3.8237407209216028, -1.782786172135173, -2.690410608544323, -3.8324445013132493},
    {-2.5544821705462555, -3.0653383749600156, -4.350781858788681, -3.551676183606474, -3.7883577684571654, -3.6343739336822165, -3.455081116541992, -2.920794832319212, -2.770699565102919, -2.867869018695373, -1.7625211953422792, -0.8700192182831444},
    {-2.000692337943946, -1.7200417169713558, -1.6499974996625388, -1.8514951062065643, -3.1606532106450023, -2.72861880966874, -2.7831814048699304, -1.2573495702805466, -0.653020673300353, -2.6983471297143597, -2.3483085192363813, -2.8133611728612435},
    {-2.8085197141580265, -2.834844141377842, -2.5719901862513868, -1.9718556303274157, -2.44167607441952, -0.968747416530462, -3.1619095075581, -3.0200013376407466, -2.1201260063664145, -1.0507561696757604, -3.5574574699798918, -2.367954292199741},
    {-1.2892529694323167, -0.3840934131418312, 0.8252989950951484, -1.244707206688693, 0.022128888097714072, 0.5559578436525151, 0.23431079333482518, -0.4321446399624151, -1.1758513436737767, -0.82816129986283, -1.291275598786677, -0.2740270143858397},
    {-2.5572389795323276, -5.088467619310887, -2.475526986577966, -3.4105863041626447, -3.4913095632396467, -3.963010074345086, -4.287632550915324, -4.281363000976142, -2.7564574382847047, -3.635192415375179, -3.964162512339916, -3.5498593340842057},
    {-1.8886964586366766, -0.9446639495313949, -3.9264048648922345, -2.7330570241781147, -2.9840874846804497, -2.968534844526687, -0.36076857332412465, -2.4688088439412286, -1.3851457248760726, -2.471094658177205, -1.0415950521008264, -0.7005220904592689},
    {-3.7096337636433216, -3.3292568281058568, -3.9098931690643566, -4.056331689875661, -3.223267494659427, -2.2528728539914713, -4.133544158485519, -5.42756400960158, -2.833527131348884, -3.8491176070936275, -3.960763835547324, -2.813081039083503},
    {-3.8766920512702874, -1.9940182515106841, -5.612783202743992, -4.245762126811608, -1.5954480680977563, -4.016834075003883, -3.0714252765896237, -2.4383798567643025, -3.1560021573047523, -3.5672825415503255, -2.6617306042490503, -3.6925034396142724},
    {-3.1747189676342393, -4.389245060974613, -2.994218821731695, -2.458030661328929, -4.266230338135101, -6.051699824150328, -3.5017315903489434, -4.6583727087576134, -5.392279928514306, -3.8329592804999812, -4.451779489532309, -2.3998347245447733},
    {-4.883652705876487, -3.677285383613124, -2.7375658712069866, -3.9802851008963644, -3.4408916804719802, -2.809785302304335, -3.2910812755510963, -3.4324148511191046, -4.3844584036545395, -4.492153780765745, -4.798922413640596, -4.736122407307493},
    {-4.117474919897643, -1.3967982463396256, -1.8891175767967359, -2.995174668546088, -3.2269893741881837, -2.443578266814695, -2.118894361541871, -1.7179988321515005, -4.3924254821124, -3.910376869707414, -3.3183087072725037, -3.1559249432282557},
    {-0.7168271979085075, 0.24499721839801297, -0.9358601166445888, -0.9815189499080016, -0.8772000848622873, 1.3577879228358443, -1.9498301453241402, -0.30529429008822623, -0.12155359770875103, 1.9983712992373452, 0.09970221733430747, -1.8082857880050591}
};

static const float b3[12] = {-2.8527495349503087, -2.63924464989392, -2.669432124536937, -2.9329482346392015, -2.672868603045072, -2.746155073794698, -2.919036982738301, -3.0027343217381226, -2.5613709799799875, -2.7360715192262726, -2.4883428368255363, -2.8249449105645996};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
