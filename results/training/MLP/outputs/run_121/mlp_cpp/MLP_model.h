#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.05096654956959036, 1.5435670228958789, -0.7876920990353136, 1.3322879126153073, 1.533457468604385, 1.8754327621263596, 1.9926250795062919, -0.666146762721749, 1.3888896703667442, 0.0017697065387603094, -0.895714373127974, 1.0589322189501724, -0.18381347272192883, 1.3976345113532844, 0.12236965836880946, 1.5053004891170214},
    {-0.14663279523645267, 0.039233988827970606, 0.15901060130408573, 1.1091391944754665, 0.17385940992432328, -1.449102589653747, -1.1348463070267678, 0.7724351718821483, -1.2533013598048575, -0.5337473013733497, 0.059227755270489575, -1.7662924881254087, -0.042394266305546845, -2.161392876164814, -0.7243798586009497, -0.5308007466473512},
    {-0.2544690250094645, 0.050127738193779116, 0.4893281156126962, 0.08858921305000553, 0.206646718979141, -1.023222468050688, 0.05900902908850218, 0.5048096119193536, -0.3871130407498992, -0.27871880733793886, 0.07367378813272539, -2.07056928970445, 0.8530042633149257, 0.8134524121762748, 0.318358700628684, -1.9014697212592895},
    {-1.671062694219922, -1.2140668804620238, -0.5038814542805643, -0.5825786489981432, 0.5408741749777921, -0.67425579223075, 1.9197867238079704, -0.4940325862589626, 0.8389427644010583, -1.64177673790975, -2.184662735162763, -0.9153773349305563, 0.31355982231065443, 0.2657060484920047, -0.6862728895716577, -1.3664417948764487},
    {-0.7067116537993866, -1.7989096707829362, -1.5489513547918643, -1.2528662619034203, -2.1682754493187106, -1.2949641455823624, -0.9176236930977469, 0.7824654406162839, -1.1250126150313744, -1.038211876192405, -0.6751647210736393, -1.2730656140117849, -0.3507395984188407, -0.4121567199035745, -1.0362465760309894, -1.778157240816642},
    {0.2136307000369839, 0.8817662307005552, 1.4253563459879723, -0.8817112860778626, -0.4665899634913473, 0.4212343690356796, 0.6215063464355504, 1.818773114980477, 1.0121778437017772, 0.6532078197912936, 1.5396906853588406, 1.2130221850501661, 1.509753453360639, 1.8205911051561818, 1.5298090620687461, 1.1577595946189594},
    {-0.036044337398549064, -0.07250369980725824, 1.7504280919304278, -0.6703177911968057, 0.6300021699765654, -0.31722802200627526, 1.8583049996362093, 1.1865774894016348, -0.2830374472524299, -0.41844039082066886, 0.5025635689429071, 0.4189544073754458, 1.049294059282702, 2.24499144545519, 1.4956072471576682, 1.0777761312537164},
    {-1.2475123886744586, -0.8614452238974974, -0.9751499591290459, -0.6792120419836766, -0.8274410246013486, -1.241363721377638, -0.198055569947255, 1.2133643813230754, -1.0938214718749855, -0.5706905530119911, -0.007806594575157375, -1.6977551420098187, 0.5728454322169443, -0.3233252417479457, -0.6605331330072871, -0.481033611893009},
    {-1.0190156427530692, -0.930182308678053, -0.977160991889811, -0.03931271980239468, 0.16636193908870828, -1.5998960503933917, 1.0451440051723044, 0.9231422292936938, -0.9496267107593468, -0.3819489303948353, -1.2480568414882374, -1.725779607956034, 0.11154356339576611, -0.6276667465549818, -0.7973160872084719, -1.0794664126788873},
    {0.6155770997941956, 0.7014991049943129, 1.9062954594226091, 1.4194778277745292, 1.0254374912287172, -0.12645886660167882, 0.11423311786752585, 0.07221808602878721, 0.3787146816127363, 0.870950939628557, 1.5959714613535523, 1.7842476999323849, 0.6542632576170428, -0.03534084633385022, 1.0329164819766483, 2.3930323395037285},
    {-0.6663904163592488, -1.4748868555445842, -0.3021300945657421, -1.3307286691586875, -0.6369369681509882, -0.4212208918320839, -1.1660451128740041, -0.12514036158964562, -1.2042368893833644, -0.7971382814662742, -0.5090865658752429, -0.24744167631213124, -0.6375747861653139, -0.7896557191534941, -0.6191932908767688, 0.46012025528187644},
    {-0.6957993400496283, 0.41252989421459024, 0.833087466016764, 1.5068087521092106, 1.0096243291850706, 0.6969603515387176, 0.05995790220577708, -0.4827798384473088, 0.32756707758823694, 0.49900582303943025, -0.2587435816339784, -0.09044717422403975, 0.14782399415408087, 0.419188080910708, 0.21459435953729394, -0.4173100256842234},
    {1.1359781667520032, 0.6077749215716701, 1.2357743755222526, 0.26151160241597504, 0.34349081716708313, 0.003088511037410167, -0.17741106290753966, 0.1842161050921219, -1.0065561152309874, 1.2670455796614568, 1.0424957528756729, -1.1421021419309265, -0.44634402317185945, 0.26544733464655756, 1.0157893691660957, 0.6179854242442514},
    {-0.72879055315713, -0.5795560953860404, 1.0436358299532518, -0.7287074771940604, 0.2550698624077215, 0.8860123765965653, -0.17195908706038746, 0.4925107882596017, 0.39562300091020286, -0.7060008794880206, -1.1333007970433933, -0.31070721714897587, 0.656371884001837, -0.09416982344211092, 0.4271382630482031, 1.2025616091806972},
    {0.21018714751596299, 1.2305181121165336, 0.5653128832450192, -0.5714041449136035, 1.3395298279379872, 2.622074179104659, 2.0140853874971913, 1.4447571957517023, 0.9475244083107616, 1.5051013524399661, 0.15984127880365406, 0.8791761727503623, 0.7116020799858861, 2.114476006800221, 2.0087831550713804, 1.1387897759902883},
    {0.7897325834057284, 1.3940927528448526, 1.517903798531523, -0.1668386080693627, 1.108795299765945, 1.374748766935311, 0.6631382901723423, 0.7168920285161473, -0.40505067284434015, 1.4261448804930281, 0.657511373522351, -0.18184606865699382, 0.4535808091888924, 0.8356164213703718, 1.6243783985140967, 1.725850590454262},
    {-0.4280313003565027, -0.040501231223394774, 0.10407574173222844, -1.5542247606310235, 0.7227107180403709, 0.8745138398996768, 0.5277550026192649, 0.9092167315006524, 0.37613067966223623, -0.8062426526504874, -1.2089661436421075, 0.5150422078819984, 0.5500218966912568, -0.4341775403454954, 0.345055318924161, 0.794703144929607},
    {-0.5395380710802234, -0.29031219224120086, 0.289857592094112, -0.897960988229255, -0.3547491281192421, 0.23609561396632606, -0.08442795797629066, 0.7438870314532279, -0.36063939536593365, -0.24427057665553636, -0.9706040272370972, -0.018292528680429125, -0.3696404855719785, -0.452617577370362, 0.3191278488883385, 0.32380489320121514},
    {-0.6077910430174731, -1.1418687302966564, -1.0025770366960411, -1.1537175883184583, -0.5627333610272193, -0.9686522236830831, -0.4446093113300344, 0.23636551096135902, -0.6320634554436803, -0.6179854650131189, -1.6435586473241572, -1.7153143431529934, -0.5462207389100985, -0.9910789847911621, -1.1461447340267514, -1.4478285395119532},
    {0.42381769600165625, 0.7807201479456028, 0.4530906184665524, 0.22995905628131788, 1.4182278650168145, 1.3012532977935851, 1.5021007876373151, 0.2313805450054987, 0.5791004806613815, -0.006892836539490081, 0.4671351066469601, 1.270327090096864, 0.8843723964230876, 0.1009237811354764, 0.41658245660306764, 0.9438274490589795},
    {-1.087465989234093, -1.1755691087595475, -0.5611754555094219, -0.9679608499213327, -0.39625779111818227, 0.5252435834655339, 0.5985492655297042, 0.17264596936680363, 0.2945833198187733, -0.33564309081229166, -0.7782426303392103, -1.0065732949067228, -0.12164838703451439, 0.002795735943260051, -0.8070639259317124, -0.9179947506277782},
    {0.16413381968621918, -0.3707738559025863, 0.15437941951516257, -0.7916708757583559, 0.40935504888088714, 1.566956961933761, 0.4823202016583066, 0.1740305375039376, 1.0880568600523206, -0.24340483595475843, 0.10297281151247045, 1.2971522083307236, 0.3236287510534084, -0.3977628444797212, -0.15281551875666333, 1.6731815136032424},
    {0.0015700868912656618, -0.10908001957649692, 0.8477952913331502, -0.24883362918767843, 0.7049935633327561, 1.7372480872974054, 0.5292814691647619, -0.09209048049727543, 1.0554509562369276, 0.4614583989219068, 0.7653540452966467, -0.5701176428195137, 0.5086887950387895, 0.9842977485938735, 0.2338559476356104, -0.11985979144210084},
    {0.08535037851426445, -0.49805210023519236, 0.33192438554651055, 0.5139970299524086, 0.3939216005219124, 0.9768519132062462, -0.13659343334352222, -0.24915909121611396, 1.0937974984905223, 0.6324186741224236, 1.9411681415336366, 1.2650766643758284, 1.0424048321131094, -0.45396342967662384, -0.9526556031882311, 0.12297745618935571},
    {-0.3316967496325396, -1.1180786586958325, -0.766216810416351, -0.22564181151714421, 0.6334544761895446, 0.8526733632319057, -0.5700796078875179, -0.062059352425644664, 0.3426509141477656, -1.2655293663228093, -0.683394950798836, 1.1053993295738394, -0.2591373254312919, -0.3051444274739579, -0.8049333485464656, 0.14719524128423755},
    {-0.6509881701405998, -1.0401304667355598, -1.3928237435562452, 0.04419150434167044, 0.6305578103710189, -0.49086234520346944, -0.2696790214710718, -0.9062321453970966, 0.2575724324047127, -1.2029350938147096, -0.6415494546837128, 0.40900634099381294, -0.6469809598407703, -1.1481337955080524, -1.3140989612069796, -1.677365719046532},
    {-0.3186054417031783, -0.9001773595825873, 0.011957237656213576, -0.17890978385581335, 0.7050398286254247, 1.1698758907323776, -0.3472711525269594, -0.9076283828273807, -0.026474243430091957, -0.24001014637124207, 0.44691846008576236, 1.6921898430366897, -0.5506241692081444, 0.16170297775814998, -0.6175513555443942, 0.17750321952650583},
    {0.0853594473956517, -1.96883451433723, -1.133450919446901, -0.8578813402376299, -0.8565816807205295, -0.7657186430546172, -1.0500495063971493, -0.7086429969057527, -1.057465127721064, -1.0618190114656643, 0.10598707407690602, -1.3803171256547144, -1.339256910448748, -0.9347942406405158, -1.105112671149885, -1.9978003736146357},
    {-0.5860725095515783, -0.5117501385114506, 0.42371117714404744, -0.030373290009532414, 0.44873861381182883, 0.8303419816424028, -0.5889679823584028, -0.08633517509379103, 1.2769756101603313, -0.9100317817851552, 0.1853321357425793, 1.2951103631957068, 0.7722062884158626, -0.06967410466888947, -0.4816697687767739, 0.045504945633737894},
    {-1.066787128566271, -2.236972604977258, -1.4705638521512934, -1.3561843600215422, -1.7809890598933422, -0.5402576767864832, -1.6563970765007119, 0.07870666068798353, -0.9448577037492207, -1.312038880407503, -1.283023987774823, -1.1957290646290073, -0.7231237714349702, -0.7977593329673951, -1.2207301330277, -1.577051577673739},
    {1.355144638314661, 1.169042672488345, -1.8019095368736742, -0.845250098804863, 0.9772647246489611, 1.37494972352603, 1.0531972949757864, -0.14124442564610004, 1.2261067188885892, -1.6391700305055115, -1.9026370728759014, 1.5361281653763774, -2.081285727059101, -1.3035427103917772, 0.06499466458555633, 1.800942063344113},
    {1.0098507371171497, 0.9083913971141439, -1.5193832511942496, -0.2747251142866337, 1.7585301829510234, 0.7137565010290433, 0.837269217757312, -0.19191658190823635, 0.5056035714897246, -1.8825191425148884, -1.4077379604090852, 0.7312704031933437, -1.3580199175232552, -0.8738708007254445, -0.9499252669594365, 1.3589898238590727},
    {1.3734988354173983, 1.3416858271860967, 0.4214512223262107, 0.8433316912557088, 1.4835011293379348, 0.9014057358302886, 0.7390054410174404, -0.22333637966841322, 1.312152437863827, -0.2829461589851525, 0.2023386604796724, 1.0453872189399658, -0.2017886555726168, 0.6864530568560633, 0.502775291097981, 1.321397629240893},
    {1.1946912310052114, 1.498820184072674, -0.12636563411400786, 0.09346214070878356, 1.1625922067973493, 0.7378862217989482, 0.622980522806738, -0.12753809533424856, 1.3698255626164242, -0.28784628074339785, -0.08420828738418681, 1.2967699754156985, -0.2519007878366528, -0.08035663504199558, -0.014230234099036369, 1.117218430009922},
    {1.4294533018944011, 0.9711276747830145, -0.4791218527106409, -0.6118294612459337, 0.9789049384827014, 0.7941294253461513, 0.7634916646943153, -0.05052720307827864, 0.9401513599950337, -1.0944683645966247, -0.05818508911599638, 1.2102282181314652, -0.5464439395110632, -0.287687032525563, -0.06756793246049492, 0.9105272463371871},
    {0.43208547887676707, 0.23083413558225585, -0.5732562663274408, -0.2603540817424343, 0.5567903460838657, 0.1395903537240642, -0.05681097086630926, -0.2603765756084191, -0.1988544476892145, -0.5828287130832263, -0.2190901084069759, 0.8598045496077862, -0.5254980388277095, -0.37345939526945315, -0.3695301694968961, 0.01187015672929222},
    {0.8052494761204264, 0.6667354274486181, -0.19392652627428106, -0.3826808215025373, 0.23504091273925085, 0.373069728701347, -0.23267801600318613, -0.32420426895492277, 0.23562817349198795, -0.6348234288553355, -0.08084986197704283, 0.2631897433927234, -0.27991880891714527, 0.19115432391998968, 0.33540688832973875, 0.07143894252148654},
    {0.44546352773275794, 0.08754724047176123, -0.36547762931405076, -0.3579228927159336, 0.0026813371289984627, 0.11598808632069935, -0.11320496532190143, -0.2728967293770549, 0.13632188675507145, -0.12540074365872658, -0.3446921730249183, -0.20945736577839985, -0.3293726678952767, 0.22977003751279912, 0.03263060608103625, 0.015566707051479396},
    {0.581738801167848, -0.5289493020119644, -0.9871537262257389, -0.7100282083242746, 0.2429098369456697, -0.30145519550357763, -0.17270072453354063, -0.19962797330558577, 0.03474263057187344, -1.1476543830870591, -0.9191286053962094, -0.3239158052691646, -0.844178467369951, -0.552200132952316, -0.7416752880032093, -0.29875637526101995},
    {-0.5226374266491666, 0.38143799249636623, 0.0918096203491744, -0.11105854322809795, 0.6808077707910061, 0.31074345739727127, 0.09211279009611403, 0.030394722197049254, 0.33813467770476635, 0.07459874974352618, 0.18771404229915914, 0.07052301029999317, -0.024492102750171107, 0.17114718873578338, -0.10189098720379232, -0.14067621572131508},
    {0.9696045486226227, 1.0580182732911219, 0.267662061113031, 0.7664270688647953, 1.2962595612208365, 0.7376880838699599, 0.6084125046202561, 0.040939217974710194, 0.4157948486279251, 0.2634482048543295, -0.13067451428920046, 1.2379679458005606, -0.11968659221232666, 0.07521913704090566, 0.6612356061903613, 0.7111940720851307},
    {1.0492214276919865, 1.3387564187057392, 0.5221615969473429, 0.46459527857396116, 1.391001879734083, 1.048229670511963, 0.5816636962790219, -0.06163972390375158, 1.4034642276753895, 0.8977669463712238, 0.6113556973053732, 1.1839931040670617, 0.4639808334393297, 0.5069414800077935, 0.8171268346929575, 1.2939222990885244},
    {-0.16888023591540424, 0.0667104487964859, 0.28199671768925, 0.6410076306982013, 0.45205280435023437, 0.20282819015244394, 0.4606529166493921, 0.2578264003793302, 0.7057169738208121, 0.07203409728945163, 0.14118915970815732, 0.5900247578804033, 0.39814242364177405, -0.0424649301076106, 0.36012624925730874, 0.6955033507404669},
    {-0.6502710695417978, -0.5688065198057235, -0.3296191756949503, 0.010867579736964285, -0.6444868981010969, -0.35774313523586965, -0.13947935559497182, -0.13959218710474838, -0.4313744892770081, -0.0958174910230797, -0.15775482743212804, -0.9423281955211985, -0.47432637281651074, -0.3950560964027554, -0.4949242980354232, -0.5328283005825751},
    {-0.4630098088667038, -0.3404118404561103, -0.14002163210687074, 0.4062546692383061, -0.22960269087363294, -0.2586410796205433, 0.4192457048361729, 0.2943341672715489, 0.19267223262757166, -0.12461692013680445, 0.1657097383697722, -0.17402864520262937, 0.2177671108919546, 0.0035755861997591133, -0.1691834225423193, -0.12924040067186982},
    {0.24420061217342603, 0.2919918423453162, 0.4860993295539055, 0.5269539838470606, 1.4472502547797617, 0.4849573984088593, 0.5004917363046925, -0.15475201656280083, 0.8354393178544255, 0.10992158498679015, 0.37246677212494606, 1.169363125972151, 0.287413146685784, 0.45295690733173727, -0.06284191957180166, 0.295298855912725},
    {0.7505651009388269, 0.5528737505804224, -0.13801167690925362, -0.059175322013255025, 0.2603344242508305, 0.35410719201005525, 0.3273225371478459, -0.17462438568172264, 0.6016007435379833, -0.2430488164480938, 0.23908696688132855, -0.03474378071561576, 0.14072700882719974, -0.09016012490127619, -0.4787835033987042, -0.10576888922653763},
    {-0.1172703416715473, -0.48887901354745456, -0.5169365540068928, -0.2989187702951527, -0.7254894160067976, -0.7986216742591165, -0.8053244288411926, -0.3205757105416159, -0.5246718197391564, -0.6927542905701616, -0.27469007128686224, -0.7689251742605381, -0.12322107317974118, -0.3393971765864599, -1.1589480671236934, -0.8972321196805365},
    {0.45103054736902337, 1.3139348820955135, 0.5143777726243743, 0.8866941392450208, 0.6869918883378668, 0.4174364994874437, 0.6412894664918269, 0.2512466848046178, 0.6299733722432377, 0.7013154943930235, 0.46556479605373713, 0.6024201577659852, 0.42115881614751133, 0.3440519201726203, 0.6068504866830716, 0.6633757673857681},
    {-0.405121300262715, -0.6759637310513906, -0.25714508001174324, 0.09935060527862455, -0.8128195556833745, -0.39072563473217115, -0.6202246343034367, -0.1369149218137638, -1.011273627968903, -0.22458891415576818, -0.42475135697007615, -1.0111257092932813, 0.16661900859679132, 0.03339250169413843, -0.7840130247319713, -1.0441582390530941},
    {-0.26830765437531845, 0.534639000334998, 0.6394468787555909, 0.6264835880047954, 0.3651168436919621, 0.4463568650587067, 0.1996572491571599, -0.03339809929179483, -0.28675400572777443, 0.3317056076668842, 0.5377654650953227, -0.10924356299259944, 0.6720442018766284, 0.4483676604329335, 0.2139755581480617, -0.21583932560787422},
    {-0.2271187193242247, -0.3597706763827456, -0.30947215843765785, -0.4450943681021741, -0.37152017153152317, -0.5826572408093833, -0.4298405174400644, 0.19303776143975893, -0.7132882331004431, -0.7710404645306957, -0.3746816688818903, -0.776410209237289, 0.0042689538435607445, -0.4337264827229995, -0.1714878158297779, -0.6154570274912585},
    {0.2915313299549075, 0.5612878465624331, 0.1717060490856711, -0.014463783662197794, 0.547219265718788, 0.3630647228672105, 0.16626777166588597, 0.09008673227921615, 0.40372691141286304, -0.034781588034480095, 0.1401607528261087, 0.5967416454361881, 0.4441901318671366, 0.26687497167199126, -0.06442835458060003, 0.40068645779324485},
    {-0.2683359525706009, -0.19540023637542295, 0.0875269822446583, -0.26607928361772015, 0.19549606576036446, -0.25689252551808145, -0.5844565928706718, 0.03028461945315281, -0.32682446505369506, -0.34868526692230745, -0.33046123062615546, -0.10716124794458685, -0.03644328593407148, -0.40869043664099747, 0.20654975632267925, -0.19789264655129254},
    {-0.021985465042993993, -0.6126959360373008, -0.6177159256531009, -0.7301550522923542, -0.12640033580409307, -0.06975695970145988, -0.25253225060378315, 0.06055790656109705, -0.19716062516185967, -0.4133771091971307, -0.5550205095604833, -0.41728910857420365, 0.015939702929691244, -0.1733444570060354, -0.3899371472962093, -0.6185053201640451},
    {-0.19677173796459724, -0.7525311609003322, -0.5898729677673904, -0.3218984291138029, 0.010891563810460844, -0.564785503958808, -0.41733464578773655, 0.050836001424479194, -0.41665364665852894, -0.4512817661154514, -0.31587804499006295, -0.16099178072601258, 0.11326337069011445, -0.04656898156738038, -0.693892060730924, -0.5167359945552167},
    {0.043067897480565796, 0.5517779694761824, 0.4115450201701436, 0.5431659932414451, 0.621517300699535, 0.08800891341292937, -0.05348855314632395, -0.08185403229913381, 0.12407009736672651, 0.3111509917037284, 0.19013968056513125, 0.7739739359185687, 0.3002281326254654, 0.2769508257009299, 0.6768774884978846, 0.2895473470943787},
    {-0.4567249988348439, -0.8242099209194018, 0.035981046519143585, -0.13759380278249023, -0.2245639518897242, -0.22939671128266717, -0.7176951421067622, 0.008970275127307328, -0.4345980482721031, -0.34653637763895767, 0.07169253078447878, -0.2573981822030029, -0.45999003924171916, 0.007026483200599102, -0.10048688285033999, -0.932076639652771},
    {0.4957534221207704, 0.24182250370935485, 0.42583596183706224, 0.6246585755277024, 0.7612584383339631, 0.6475137772721233, 0.5192845256415831, 0.4550400272199357, 0.06878399915988155, 0.21100622713698103, 0.0973394809826525, 1.3577208240828318, 0.6561670442212132, 0.1151242070088897, 0.5107901630737257, 0.5818910888402002},
    {-0.2875532248466973, 0.16619633276115897, 0.12642968134104002, 0.30298678655082706, 0.16615413833057444, 0.16799561132889507, 0.16685359982452289, 0.2714301790955063, -0.13845744456645476, 0.2273064016837258, -0.17208987988868762, 0.2645559468993669, 0.6421619595940414, 0.15565249516030932, 0.5348790164648576, -0.015303020577771213},
    {-1.498007377607323, -1.1170305347826786, -0.32323110824798645, -0.12791528303510308, -1.128305651512267, -1.2378030404437568, -1.2793775426409049, -0.010904284886407274, -1.601991126582306, -0.0961016607979186, 0.06789756216347166, -1.3297996703803214, 0.045060155642375845, 0.12741299756609528, -0.8727568085070277, -1.5714823303933607},
    {0.2388115227849165, 0.13532308910771584, -0.22667867438424982, -0.9453694792664187, -0.3227849745943664, -0.3921099240138376, 0.2519736195396057, 0.22427563071466905, -0.4220103447112119, -0.8606941438485359, -0.2826768622780006, -0.46585131223156867, -0.7043322916986356, -0.23755368916764544, -1.2136976938378201, -0.7446807313770543},
    {1.4943423775333142, 0.8832690524126369, 0.44156748296593473, 0.2612613012573697, 1.08232113512496, 0.9391452742105765, 1.1100223131351943, 0.02362506639439526, 1.1524280295302496, 0.05281870571558989, 0.24214039639137977, 1.1802798822554463, -0.28714672302286237, 0.12793106616534075, 0.5708847589031932, 1.3259902006703557},
    {1.3806981622175376, 0.6406166855016172, 0.14353367017070146, 0.3543986233482019, 0.6535195307476677, 0.70815931509699, 0.7701554668863867, -0.12440163019993294, 0.6603322579979904, 0.3816828895571913, -0.09031406587463232, 0.8097234741026392, 0.30152913385153474, -0.08488140576061982, 0.5574369400411813, 0.9195200162219167},
    {1.1766179448404293, 0.6515608986232351, 0.2703599958709897, 0.3051906667372867, 0.8560646756639544, 0.6649421680411177, 0.7165376348423447, 0.04092130238309693, 0.6181621250060705, 0.23895062162732178, -0.0037133661582236387, 0.9713750061486626, 0.39096259710610964, 0.25250092846953437, 1.0826971539294596, 1.0012423862155697},
    {0.6656332909458912, -0.05036830575262758, -0.34418542423686377, -0.3461219346032289, 0.2823399170814951, 0.30860063537171784, 0.07925455119546557, -0.3064262312429393, -0.05286109142990735, -0.24378855151830117, -0.20267633106321525, 0.1348931565633824, -0.26725466330587366, -0.4399880196116372, 0.04283001855848145, 0.03860868072946874},
    {1.0524025836871351, 1.1997598374346443, 0.4959942152752574, 0.045740331358788994, 0.951530783053207, 0.8008085560798993, 0.9683381166340818, -0.15571269171890173, 0.7320198127656093, 0.5514052251467905, 0.43251810848299993, 0.6905828941986675, 0.6241001384140308, 0.45714157633550606, 0.7174258561498533, 1.1796567789107126},
    {1.0821523730206934, 0.44595793856548677, -0.33249832783144756, -0.23812543175530973, 0.5009015124889222, 0.46075165758995507, 0.5737615735392415, -0.10917798336325349, 0.5253659379076785, -0.13803413807873388, -0.33774321387927414, 0.446623016698701, -0.15274877934715914, -0.14444188879888561, 0.03937298900970219, 0.5801299476351927},
    {1.0816289059258881, 0.3859802758566406, -0.5240882289963019, -0.10934350006268015, 0.6129087668023573, 0.6350203006560693, 0.2969271742973463, -0.014504548531168279, 0.46045271270608923, -0.44583135484529945, -0.49862735753931653, 0.2700486308742348, -0.38079378775661776, -0.380548083064694, 0.1115320184492122, 0.5713550298316384},
    {0.7444763615546195, 0.7053406077716281, 0.35987207641633, 0.06713165835389652, 0.8949528997382897, 0.5207397167715542, 0.7471077807636698, 0.00404324982994759, 0.4457144485641908, 0.4458870641714767, 0.322552906868248, 0.8518139241231677, 0.4350443761604064, 0.2144600111610062, 0.2780601224754418, 0.8699389434031861},
    {0.7434144949521545, 0.8310650895071495, -0.0078120941181659175, 0.0876017516766437, 0.9165851720215603, 0.5318677447476015, 0.8366739843852192, -0.15084492378373715, 0.9074882380842938, 0.2380135742706413, -0.09358891825876367, 1.231711371922467, 0.15455631817413304, -0.2562071969369202, 0.5683833171420188, 0.9685825866996741},
    {0.9754015392937234, 0.10885670562032455, -0.48080938445129034, -0.16814772640848843, 0.08838289023151193, 0.23487061643143267, 0.32588165636404254, -0.37621872336665335, 0.19537896799737164, -0.6974278311607818, -0.24637209039641086, 0.1851351995712308, -0.04626665443159263, -0.4676071317484855, -0.27048221790136195, 0.040089345086449624},
    {0.20921878870822663, -0.21011393444492663, -0.5629271306648098, -0.3010302130375673, -0.26119969298527024, -0.06637066726806834, -0.10876162346777178, 0.019465402267749527, -0.1784044524625375, -0.5390856324920665, -0.664918905117322, -0.37640787575870815, -0.3272166485651647, -0.24638002550019944, -0.6398447039939443, -0.02531709673946117},
    {0.1716285365199557, 0.2362765877415227, -0.2833033800046291, -0.3357487999433256, -0.04459775643686689, -0.2338582877008526, -0.1531156132620986, -0.35758249750101295, 0.2755189411882693, -0.19536360320107332, 0.24759496260194397, 0.12017261208501508, -0.0807039997465302, -0.06815506270972779, 0.16418490020374388, 0.05879144156090635},
    {-0.6517351145247158, 0.11987027225881969, 0.03618744269896342, -0.03653664349464641, -0.15094822908006794, -0.19786203831681565, 0.1780393883721028, -0.077065041583966, 0.04075746981479887, -0.34697638926978247, -0.283111337943458, -0.4907437323258247, -0.27441311395450607, -0.30537111147618873, -0.08916276430939796, -0.33002227141365814},
    {-0.02070035202475714, 0.5756281007403696, 0.4679587280402189, 0.6757371816822557, 0.5567397002821444, 0.00936739342158518, 0.16864690645055286, 0.2974097535751599, 0.4483337936315927, 0.7311077660730438, 0.43772905330729567, 0.29451492627933296, 0.2109332954180337, 0.5962740739768936, 0.457147279296663, 0.5869172177438162},
    {-0.11823248730975384, 0.17874635980325335, 0.21350191275745165, 0.009908715702946087, 0.0954307380557552, 0.3998365032985156, 0.18150354210366243, -0.15660711904386365, 0.22620702483136812, 0.2423921351700669, 0.4762524126147578, 0.2105614498388739, 0.17814316682565046, 0.14363177318583248, 0.3324866528604748, -0.059206694751521634},
    {0.8382348886554553, -0.14719877986692528, -0.6777810102931636, -0.41704757879010446, -0.21815583765828814, 0.29688296902106226, 0.13803773963940877, -0.44739563719774705, 0.30642049980344815, -0.4560667910938377, -0.8414786321948283, 0.17408871553389071, -0.3529147897364098, -0.8656247156067168, -0.3783827153285094, -0.01760681863441974},
    {0.11244585092667211, 0.5686175197543821, 0.4209770231816333, 0.047702112452095116, 0.7904915130739204, 0.30870730804292873, 0.5035592345646941, 0.16226004775836284, 0.4799446613969693, 0.3280722926188788, 0.137791959308077, 0.7217839029325545, 0.4912818880428005, 0.18603615607308802, 0.2130570931910348, 0.1302464684046766},
    {0.7205020790970341, 0.7134053001308651, 0.18224203492299693, 0.18468941680874032, 0.8278868158450872, 0.5142547727876551, 0.5639415871438657, 0.12001463807441046, 0.60784103162581, 0.45304273467997735, 0.2763974802644117, 0.8107038376753003, 0.5091579757024773, 0.45799997411341076, 0.4893386364268309, 0.6134074420844353},
    {-0.5213105281144369, -0.2836381374976214, 0.11189913355579416, 0.3359658915412914, 0.04107977128665096, -0.08434152507422102, -0.13725647166130453, 0.20783043056065026, 0.03313389701235527, 0.16451205468029967, -0.11334649209958239, -0.4009495150168217, -0.1054512154372912, 0.1451044296846067, 0.42264419796530095, 0.013471682737829269},
    {-0.5844369943255374, -0.0828800215039826, 0.053391672962609674, -0.08905744412867156, -0.3969885179387244, -0.28870136620349784, -0.18295789490893857, 0.13750625608286957, -0.07042385897031479, 0.12489425980578141, 0.3989295975264611, -0.25865658836321814, -0.21096031319854025, -0.040567019640461596, 0.12582147289795323, -0.18400872143048885},
    {0.7543583758332958, 0.83301434539873, 0.2451203155928735, 0.5113875102346381, 0.5378062355403068, 0.7125711930474553, 1.0285824472957548, 0.19224046107801915, 0.5271265450545217, 0.337557580256784, 0.2766892898795167, 0.7815157757091082, 0.37846837211125073, 0.2597220842395934, 0.14859267045834385, 1.0036139344084232},
    {0.6052292717425629, -0.3805777563013213, -0.32463291981217735, -0.544349745580412, -0.4203115723019162, -0.5190166515918618, -0.4559584775290998, -0.36889600709960385, -0.40925720957070566, -0.5232746857805554, -0.5173134578866062, -0.2068813027385122, -0.15654419649959858, -0.5788526033236362, -0.5737637946119283, -0.34791472412479596},
    {0.4516775342573717, 0.2837815677051448, -0.15111556203678478, -0.07671686993513334, -0.15046055643333742, 0.1177589795753437, 0.04068380009374669, 0.26224407088770674, 0.015193779682516223, -0.3056221394985126, 0.044982466549609836, 0.07805525664280268, -0.18781210962358263, -0.07876565897969344, 0.20764915133182604, 0.13610392912889221},
    {0.03810124851323776, -0.06383350221026172, 0.07857035566137466, -0.03417806235170195, -0.24394491849933525, 0.04893679086280424, 0.08515096454071482, 0.024657433775226712, -0.19691869624648356, -0.01641915237160027, 0.07026050133524249, -0.2073786954504271, 0.2122803478609596, 0.5458654545976546, -0.0512672457473127, -0.4675584314781747},
    {0.6302449465772192, -0.18601784949767589, -0.22946737494968264, -0.26158710557102316, -0.0535648147847676, -0.10390701911336378, 0.09263457699229086, -0.22426612740062205, -0.008551298634317707, -0.3683331068693654, -0.32020374978781163, -0.15365300306141524, 0.016243476336496504, -0.6046976781929073, 0.09766944623495995, -0.17983358834149835},
    {0.35813082902031856, 0.34759749235512366, 0.22787083132975697, 0.2987619589346565, -0.16322325548430364, 0.05354127488275455, 0.3020863966068788, 0.09624792965347095, 0.1029297036552544, -0.04141088928972434, -0.07237858730960976, -0.2737964462646021, 0.23943629802984237, 0.46827918672831403, -0.10056853162928046, 0.10431589559450802},
    {-0.7896680988717542, -1.1135991032925947, -0.14678593627325673, -0.3870366922111015, -0.5737553138223668, -0.5901410017091872, -0.5774346134900891, -0.41810677788277545, -0.6915655937761312, 0.015527203076916333, -0.41117767541359695, -0.5724559267352187, -0.018976727083007468, -0.23340935585589911, -0.6166294625000264, -0.5668879719335884},
    {-0.23531073933735783, -0.49159696523616486, -0.13204100898276175, -0.5048225131273678, -0.48863177019232684, -0.2290052671340779, -0.40944707071491293, -0.11358439060140221, -0.39937763446759467, -0.08333311600309462, -0.5744002853292671, -0.1986767041980564, -0.06670215130386702, -0.2497229294738037, -0.4716719568732894, -0.5404576870981685},
    {1.4967010702461148, 1.1872543644160334, -1.7072475033157395, -1.4632120601696643, 1.3999659401515152, 1.09499634990507, 1.1823395274037105, 0.5419727626630795, 1.0531758442777792, -1.686620397892222, -1.043581876755017, 1.9964015414602023, -2.631113600747584, -2.223338670885624, -0.05159806542433928, 1.5763564591679886},
    {0.8575370280276403, 0.6777667377351909, -1.2327533662986807, -1.1440840984873182, 1.6959688248121185, 0.8777857704083859, 1.080664573603069, 0.4869363532122578, -0.18651664949310728, -1.4411144404988347, -0.6558394124307367, 1.080987352113855, -1.761573906219857, -2.086111452468548, -0.6777961853024755, 0.9121384203544499},
    {1.2430596053221459, 0.9042437486191013, 0.22498860495675663, -0.013962256731519063, 1.4529260869724094, 0.8681493697931405, 0.8369397849559506, -0.10316179695149433, 1.3207295127721366, 0.021712318947596176, 0.34774243096068064, 1.3392177055422836, -0.4598968721722329, 0.009488457778841627, 0.036560157276088495, 1.390435838974902},
    {1.465460036638701, 1.3144105000316253, -0.12997011750675708, 0.04857139214223904, 1.0231502050333006, 0.6685778560866638, 0.6548615969334212, -0.3289218760138938, 1.3899645753708174, -0.13147586612875037, -0.20518118598495214, 0.9783032393582459, -0.3408331716229002, 0.09820866419172103, -0.25442105518009883, 1.1642677939861363},
    {1.4241216035111317, 1.001154531697015, -0.002679199846443945, -0.010846649830299548, 1.0867120601683207, 0.6686525599850172, 0.608673116314487, -0.21439297028988663, 0.9742523612875948, -0.19271052148860499, -0.07403261408253589, 1.1656404751083183, -0.35398665497928017, -0.2680442259916724, 0.1593236152416899, 0.9723617308746837},
    {0.6989449101773471, 1.0944785277996418, 0.10506271236870922, -0.03558433759512522, 1.038128329302792, 0.8192801342829267, 0.13755029334940044, 0.1959370305614134, 0.7766739252491537, 0.22125825920749917, 0.215505238714037, 1.2405015524079124, 0.18408630306286958, 0.2309954775322476, 0.13052719897996673, 0.9830848401953002},
    {0.31573955077976024, -0.23524763568440174, -0.23806604104576282, -0.5167604190023646, -0.2033415584056628, -0.4498209603301536, -0.18952063845479158, 0.2799237067666543, -0.20976848632543094, -0.40940219916444165, -0.5678796988877182, -0.25862109406457356, -0.3606676095848108, -0.458642962850589, -0.23442049803149656, -0.15709721699073492},
    {0.6156610211623628, 0.649578154582983, 0.33697273909075054, 0.1504864238786399, 1.0991814513395826, 0.6503525327537387, 0.567491149156206, 0.2792992698592506, 0.7869333935895942, 0.4492785595554112, -0.03740682132496404, 0.475840395389089, 0.3533605577691354, 0.2811236785803563, 0.36236342352306855, 0.7493769880535436},
    {0.8090556767000918, 0.4846031545767375, -0.8296192922260082, -0.7643202455847268, 0.8028698634362293, 0.2584799178803506, 0.5832324257461063, 0.08192481010895, 0.132258532261922, -0.8006445912069188, -0.48214795902578855, 0.9110625500345508, -0.7024853359009187, -0.2049017897835805, -0.20506257508250086, 0.38768936712863905},
    {-0.4414406651550697, 0.7068379604987726, 0.4838141039484373, 0.1727549805902857, 0.49961526490621, 0.16766622652028482, 0.0701305166265937, 0.3485988183044143, 0.3095797792553551, 0.4466451277161885, 0.4327564524348763, 0.402222897602867, 0.29202121260845226, 0.6495638026967939, 0.1224695607914663, 0.5769660908638728},
    {0.5515425475908853, 0.30084516860212257, -0.8980249732478092, -0.743172685052517, 0.34418484527133064, 0.22925410267841842, -0.11954784720406346, -0.017787594094243277, 0.060121558913585255, -0.822051369671921, -0.07685692162848519, 0.642734846005312, -0.45165916943113665, -0.37922735192152757, -0.5148355327336295, -0.047611111862377375},
    {0.7296004915502261, 0.6221397553509872, -0.1893556715645617, -0.39944099730315996, 1.0120863738134804, 0.5364953328885014, 0.26625853100699437, -0.49977204210517917, 0.7046195051055564, -0.19445074648789926, -0.19524124027196174, 1.0616366763247684, -0.48530787237533984, -0.5419336868330513, 0.32913227085448293, 0.1893221690003898},
    {0.4014124246006845, 0.6273183145085967, 0.4892576106413681, 0.6030072287792895, 0.8214194255247078, 0.6828452300665683, 0.30872034696864215, 0.2631924585316345, 0.4731434952355783, 0.8745537416156045, 0.5769627336301139, 1.238315703359436, 0.42836327894472953, 0.2823650800786364, 0.7654650468200686, 0.8586147763995396},
    {-0.524046629764985, -0.6791352745283648, -0.2556422612059539, 0.1899328054085063, -0.5737040510809424, -0.32383947286726983, -0.24942052353367838, -0.42316645911900397, -0.2908471450264701, -0.06239370762021102, -0.18020022712831382, -0.27421358248653654, -0.13492797847970317, -0.5034867436812445, -0.5278913216215414, -0.5317458004066206},
    {0.42749706509407015, 0.45768038062077077, 0.4001713042491975, 0.279268279604518, 0.19686911533332252, 0.33509978453858014, 0.46520175315555706, -0.12015720542016084, 0.6904365083130972, 0.1257667166792147, 0.4353648936379323, 0.31763202634141185, -0.1063809333441402, 0.23858152917793962, 0.3619720804607735, 0.38312592341078433},
    {-0.2292745490859314, -0.05187329283791756, 0.43890004719725384, 0.5331228825640438, 0.7627219397556771, 0.48920753795360633, 0.04040826459439071, 0.5136064896640319, 0.20466602847686433, 0.4535526922754906, 0.5474867545907464, 0.8771087508625612, 0.4066235641330186, 0.38962910767978487, -0.3783566315716126, 0.5837179200301512},
    {0.6532598444469476, 0.2940634524629246, 0.03479570763742893, -0.08206306184953135, 0.6162691102064172, 0.33792285478465195, 0.7933490880799645, -0.12837490107066463, 0.20477125492291318, -0.29032251917535135, 0.02871626526831135, 0.6311872295903985, 0.06881491038666811, -0.5076260275322696, 0.02159120310708549, 0.7323433732386038},
    {0.17154703958411963, -0.3166942263274943, -0.6133220418281145, -0.6723971066688263, -0.3381302773584318, -0.6752673673746765, -0.23567852686210372, -0.3017124819632774, -0.10192694202318775, -0.5407260820342464, -0.691686724295728, -0.05033357552993908, -0.3613625329026207, -0.4428933990978075, -0.9328189553191694, -0.6830332107622696},
    {0.43251325754053555, 0.3936443295828287, 0.036299112014336755, -0.6196387662961861, 0.49124293437781236, 0.38780900141014407, 0.23856637322026855, 0.3195163944995252, 0.496218646489567, -0.5778785500395469, -0.2548285381731881, 0.5096996591260966, -0.443796784813824, -0.11051215950396245, 0.09802217589720154, 0.07011108346011427},
    {-0.5484398851325473, -0.41932119084226027, -0.7699635508871326, -0.6807241033937133, -0.7303408487630102, -0.4645347475164327, -0.7269866218554926, -0.29533548642386975, -0.6000766194779645, -0.5386494501397305, -0.2561206202607225, -0.5622493708122077, -0.6281439865362076, -0.8984764137139937, -0.7224062385982599, -0.8578639177218662},
    {-0.12115064595166272, 0.01102188514974566, 0.17710997464586467, 0.2443934952531939, -0.08215343306208939, 0.1243985157655672, 0.24575708503097085, -0.16612707000532645, -0.026402396440502338, 0.13864022611846047, 0.623564956648476, 0.5019209018401946, -0.054769049822890846, -0.2628764125736493, -0.30402231145007974, 0.004986834087276941},
    {0.37584118055961035, 0.5747624465542183, 0.17144305148598987, 0.21319885534009078, 0.3643916090076446, 0.3151995395658586, 0.6480482733964553, -0.02480677136010171, 0.24955647496168928, 0.17029349275304903, 0.42134038445889443, 0.7752073959627002, 0.031423531678514, 0.2033282120355242, 0.36140435382002434, 0.3380357264014825},
    {0.35156412795090836, 0.993015106620672, 0.34640545761828095, 0.31808477110605177, 0.896893104499788, 0.5216516838981341, 0.3851470566435526, 0.009676346840579898, 0.7188704979141872, 0.5282366539499177, 0.33718632887419997, 0.6931935298485126, 0.1388640282557733, 0.19925667645603368, -0.024887404632439995, 0.5840795815350222},
    {0.3809067509201347, 0.3950323274951736, 0.21244605593916815, 0.17690837273031182, 1.004413574769178, 0.4755118063803968, 0.3418550231751874, -0.06545521914827507, 0.7567926443321403, 0.3243150552464522, 0.5532121665289622, 1.1009101483852466, 0.28947041633364634, 0.3098686840244977, 0.3106683521728612, 0.43873130246632663},
    {0.010254214745326925, -0.472317141539869, -0.6815207370444747, -0.40937425483226564, -0.006135678049753641, -0.22765695737872627, -0.6436877806654768, -0.48789778039908405, -0.18267289728275377, -0.9158120403052378, -0.5386901631680031, -0.05849713894658153, -0.5405091712738848, -0.54831668506307, -0.5730276259367053, -0.14661216016090406},
    {0.07385006539712913, -0.36091132116828434, -0.2802284054242815, 0.029150211181007486, 0.07949363881044193, -0.2631711653986002, -0.05170941701439674, -0.3617968214505097, -0.44005114055941796, -0.359298840719819, -0.17409526952933496, 0.4941663049971725, -0.163308549685145, -0.19489377628822785, -0.011276811876518994, -0.3195790911900476},
    {0.11017107736405093, 0.3575232971654603, -0.06166046377722504, 0.7042328067273851, 0.8154160886865716, 0.38594435142468353, 0.13042254387780886, 0.17398771093169274, 0.5677916804629589, 0.5247177438512171, 0.3535220483826002, 1.0024104614548655, 0.04468780599899521, -0.01645161837849484, 0.9681734476348606, 0.6496362072996947},
    {-0.9343941414287699, -1.1901827668123421, -0.5927311102301761, -0.3275402994188493, -0.8736362410140494, -1.0710375104611831, -0.998134954549237, -0.3603432356628452, -0.8134107324720494, -0.8308277547408276, -0.5215456799512198, -0.6845925654592664, -0.6448461813831019, -0.17359744592792162, -1.0507439900884754, -1.3418287651570404},
    {0.3425996908819027, -0.12597718089492585, -0.4605755690702389, -0.35246311849243983, 0.17361614518915772, 0.4326813208934137, -0.15013012662796268, -0.04448955533515599, -0.47169564999596136, -0.8233926108854545, -0.5305499820436275, 0.38504120520290536, -0.39483361663650013, -0.35397638721544794, -0.20977995813643438, -0.30254399780019925},
    {0.1573555472649854, 0.48012494931269173, 0.4208339513816455, 0.11138195535276706, 0.44551623396291157, 0.13587591277289737, 0.19751714691257183, 0.2294262568074216, 0.31813586654981324, 0.14467780769774996, 0.4786631552549092, 0.07227473261701661, 0.15459982779261044, -0.22145675238407309, 0.8628156778530208, 0.41279724818347957}
};

static const float b1[16] = {2.478065264994204, 2.5867507494318898, 2.1013090439939286, 2.3402845761956477, 2.9434393999575126, 2.910391445874481, 2.7847433610142978, 1.6239527558602722, 1.9588025060775924, 2.2060292906953345, 2.457294946882559, 3.063893566229971, 2.4587734399948706, 2.4367447624696905, 1.9967232228819811, 2.9176602170438306};

static const float w2[16][12] = {
    {-1.0033042121957705, -2.1861919854170804, -2.1372488640144405, -0.5534119260722757, -0.4216934207070874, -1.9185707531198426, -1.6934034118349082, -0.8380093850284728, -1.8604047052844632, -0.5943506316358819, -1.0642850064871443, -1.2747957169746529},
    {-1.8736934056738461, -1.5090551521365667, -1.7558507476909613, -2.0043619115834432, -1.3909275447621652, -0.9967524163770206, -1.8531703499232877, -1.1157096152821246, -1.987007470447888, -1.8916379221942823, -1.7021446730254994, -1.0436459503223097},
    {0.13093068905116015, -1.312144654074607, -1.6276854769583784, -1.403391657913545, -1.479651409556874, -1.3589004986541124, -2.752489378011004, -1.9913367927228867, -1.2935046534874597, -1.3059415249975947, -1.3344365216766532, -0.9514088923062491},
    {-2.282920483050914, -1.5809707772931456, -2.1804088398575106, -0.44647110586902844, -1.759355247450742, -1.8956724750457907, -1.476144003475576, -0.5084030443158377, -1.695698005925198, -2.094036445161566, -1.6395238720365926, 0.10662563764416888},
    {-1.734578362072039, -2.3008377156576163, -2.711908924303281, -1.4658473488423192, -1.7725052506196342, -0.9042218260176534, -1.377368944327189, -1.9149755085803242, -0.9821954850932254, -1.6349525290248408, -1.9066830047290635, -1.1554588799568448},
    {-2.086194407429475, -0.739647576392916, -0.6701949591190317, -1.6688074221780629, -1.1133099034564937, -2.5818406604475155, -2.0709408853035915, -0.8471279584060982, -0.520794270187202, -0.9465658323156279, -2.166418226885211, -2.0977980309382156},
    {-1.785722346453731, -1.7727060622724935, -1.947606793417742, -1.3754458065087891, -2.076952777788221, -0.7975908847073384, -0.4324414187264572, -1.5118708594750747, -0.8875285589881716, -1.2399015834835725, -1.4582447206792528, -1.647639378222585},
    {-0.9730090261900717, 0.05526317395059538, -1.170563473738742, -1.2618300801274693, -0.2113533288359545, 0.25690819707937484, -0.6519254700388175, -1.3395474323581118, -1.4321734315361958, -1.3572584307553426, -2.1363381779159036, -1.2100304689226036},
    {-1.6104592853617334, -1.6923044284490254, 0.29441332275801035, -1.8862564705526212, -0.9971600078417537, -1.446938375937629, -0.7762364671689329, -1.80534840260564, -1.3068905650256368, -1.868681979830117, -1.7424310180975795, -0.9974380169565046},
    {-1.885954017438986, -1.7299670070219935, -2.1244161382541127, -1.1816850856671455, -0.985179915313063, -0.668219208850334, -1.082867386412227, -0.42552731138165834, -1.1484930677037408, -1.249866420313676, -1.9799686496938869, -2.5460330478213486},
    {-1.3320256394911751, -1.8947948600726994, -1.9457889322090665, -0.499864351904342, -0.7582036573063843, -1.503616503026793, -1.8010810585234325, -1.6619156581227494, -1.2471652590330913, -1.8525911696824389, -0.01957130679596525, -2.078330296586686},
    {-1.629728559529377, -1.045887374193315, -0.933379115384488, -1.9719142826879312, -2.195986025838604, -1.5141312024172282, -1.7468405869640466, -1.9440601855837643, -1.7467936540730327, -1.8359678215687816, -0.3282434213320932, -1.761779107386249},
    {-1.2273915265542037, -1.0436272894819074, -0.6183479975215646, -1.6496195372243978, -0.9672307019285393, -1.9048919293453346, -0.8822772527587047, -2.4061069024567363, -1.663873384486802, -2.0305384894626197, -2.2123540901654524, -0.890534876893536},
    {-1.5338940644695904, -1.5204496436439814, -0.7338094727582605, -2.2825011832699365, -1.4688347329595592, -2.089681403799607, -0.45914600127841154, -1.1331528508800721, -1.912211962088592, 0.09648415171917259, -1.5153924292452696, -1.4717380643659579},
    {-1.1615018080347697, -1.644051817537476, -1.3587478522990877, -1.855537504574904, -1.467849511883854, -1.0173374663091466, -1.3847959834703754, -1.3213525517612326, -1.5608263832150227, -0.6671264405447472, -1.2238473315747846, -1.421197317103156},
    {-0.8157040259429712, -0.6598946323549294, -2.076113159443896, -1.2106168499976018, -2.0914150771080386, -1.7822774420574001, -1.656090221521518, -2.1033150172208392, -2.2042198121536645, -2.169992870576145, -1.8454992114697961, -2.3279658902409897}
};

static const float b2[12] = {-1.2807518800845341, -1.5654637759858594, -0.6434420559900635, -0.7178302089721508, -0.8830222646891694, -0.5511348316071838, -0.7685201388550139, -1.174731110163178, -0.6573573973981832, -0.8798868870469696, -0.12970688359885268, -0.5166395377015643};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
