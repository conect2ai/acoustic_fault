#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.728134822914347, 1.2575895147796219, 0.9911901177222949, -1.202053242947251, -1.768559242152398, -1.7228208763752648, 3.2911300193355255, -0.18523886423033672, 0.024742527228675766, -2.7872361455121566, 1.829950483707814, -1.0682584691091326, -0.4412986547037889, 1.5511541636122352, -1.2969982808669631, -1.531029184091528, 2.1072755443121123, 0.3060947649563192, 4.478817455942359, -1.2186017157744407, 1.1935920481878368, -0.9630891072336146, -0.8359439686115824, 0.8507492446677078, -2.1810448857094693, 1.0233685917446083, 0.9917741118111969, -1.5306737117829288, 3.2399467813329297, -0.9193920699664206, 1.6509316815125925, 1.6679516730976132},
    {2.7982314750816144, -0.04442554081301848, -1.5501991961618184, -0.5834395314697091, -1.46371607797825, -1.694905217908362, 2.2729608460226753, -1.3462371746501607, 0.5455392122585463, 0.37278200473234796, 1.3436182957624154, -1.6640751902168271, 1.8627754372636083, 1.166330448807529, -1.5150873481009053, -2.5534407711861853, 1.8402379006261238, 1.3990777537762344, 1.5876955710087257, -2.9286086136929157, -0.596632068320896, -0.0039943284646556535, 2.4450282662711706, 2.8863522596262197, -2.6356622174803825, -0.06588913523919988, 1.0650000491466958, -1.302846396898378, 0.48207330628202993, 0.30706921700941275, 0.9397532010073779, 4.864241215203672},
    {1.6455189852322714, -0.7787091776546962, 0.028595212469015835, -2.059811927245671, 0.1653434176792983, -2.6668493095822403, 1.9232517027995668, -0.5168714801747705, 1.2711579116844969, -1.0077070512527317, -0.6731843555306978, -1.205040553748345, -1.3042117212943027, -0.2764766234308051, 0.2378039524302674, -4.019592277643285, 3.6539703159016197, 0.41743764239719106, -0.9595222457987417, -3.3544851450912563, -2.4804040591382854, 1.1682092445533634, 3.088667938420094, 2.8039101409967393, -5.293761557722684, -1.6387797905002919, -1.0901553726834012, -3.1122521797650573, 3.1409186547930155, -3.3655796571247008, 2.7798312700195784, 1.8532641735171922},
    {1.705211987399288, -2.6588118030037777, -1.2150925659954097, -2.8419084213796633, -2.8652626865300435, -2.020099582103361, 1.7059911185127303, -1.4995003040683041, 0.607881117988714, -2.3491264538882857, -2.301522103288404, -0.48167397366339765, -2.650782728000088, -1.3104786378779953, -0.42985013854370835, -4.2028290054074136, 2.6310955612151568, 0.10336698710199493, -2.8074443087183587, -4.442220248253903, -1.9864965865896858, -2.60386832393336, 1.2400868279180672, 3.0310304047684395, -3.933433427355074, -3.8137291982105923, -0.15099988329333133, -3.188043528296299, 0.8673750995901718, -4.329325251696564, 2.6441468379609363, -0.3685817874810207},
    {-1.249983977760143, -3.284387543239277, -3.733526500674692, -3.201247361663298, -0.154736372102826, -3.526545524411391, 0.029054296514499527, -3.2245692110107522, -2.2627949864967953, -3.129053820538404, -5.754570576846187, -3.9944711817198124, -1.8872532718144772, -1.7007856716636065, -1.2130985847545095, -4.048276075720728, 2.157628062799488, -1.9351209337002229, -1.3445747200024005, -3.657430394587074, -3.14535295041166, -3.685598997986446, -1.551657776800056, 0.5846128874008599, -4.630641024481416, -4.658983931812094, -0.633857064606309, -0.742740886197017, 0.8295632866968512, -3.453170493251484, -0.5503174959756525, 0.8006211967023608},
    {-3.230422251984138, -3.4924690144660877, -3.838951312015647, -2.296014840234001, -1.1963815277191414, -3.2905190694700734, -0.9131486312550046, -3.900035517758591, -3.2592967683519842, -3.872616676509435, -1.4444541967824724, -2.8648961747914656, -4.906522626655341, -2.6047742176825435, -1.8968691927942496, -4.0995961826272005, 2.062900322111996, -1.9894282970828958, -4.58775442141652, -3.384155769850331, -3.8590947991508155, -3.1163965779565515, 0.643053992527821, -0.9922102615829619, -3.7897813136505114, -4.2948571407135345, -4.211236955601877, -0.8975695352710147, 1.2161093718661944, -1.9399432050841594, 2.6915630249781453, -1.9842107595273826},
    {0.46839044259733037, -2.196954358896902, -1.7471170256053958, -0.8445825157277661, -3.045796326910439, -3.9811744569951912, -1.7607079702088264, -4.063044378797671, -2.9721503068975847, -2.2993319512840786, -3.1876718738265426, -1.4175437474746173, -2.119175428217147, 0.8338006798051661, -2.534481221069637, -4.778024131712354, 0.772282424655449, -2.450141523019834, -1.7119246884096284, -3.138733791646042, -3.187236129330596, -4.9180278995221345, -0.1713200284477153, -0.709871032448947, -5.009198923313699, -1.963689007865274, -3.334991389057213, -3.0792917170002747, -0.21018110683568184, -2.0456327056845756, 1.0442078438913154, 0.8470370725533255},
    {-2.63315408138262, -2.86630688738504, -2.747445574178975, -2.2765890311454644, -2.5495657698870087, -3.158711748424343, -0.1786573231156006, -4.5800128619151295, -2.912866024634518, -2.2220098838799456, -1.4004261879734674, -2.5289814286495376, -3.0198808224777545, -4.1111597822629244, -3.7307018462884356, -4.018432336461052, 0.5222368767779721, -1.8821853264893489, -3.119642143294097, -4.023531462395073, -2.278451530722532, -2.8520548697164325, -0.08517083562864936, 0.19561298351102194, -3.8931474933384527, -3.724382281369423, -3.2933804410723018, -2.517291782586076, -0.5987307713619515, -2.861579099664479, -1.0621846992105801, -1.1375578072835437},
    {-0.9727795347670358, -3.6278367268524114, -5.263986000069807, -2.528141726222551, -2.6923508936726726, -2.762399684430722, 0.052656810264592624, -3.3825529836106356, -1.4656743124587335, -3.4389887980851817, -3.3604862744835584, -1.7287751594853225, -2.5181779720177278, -2.9231136691782433, -3.5262679660172886, -5.968433697002631, 0.04118272073842413, -0.8174925076788288, -2.5569170055770924, -2.5474647237111356, -2.759772282123587, -1.8451932023630404, -0.29860388874648547, 0.021825599288897393, -2.837087733239266, -3.687900796350687, -1.6004624150993407, -3.846496373633684, 0.7503758257969458, -4.783738720670403, 1.2028474603336112, -1.1238266092522677},
    {-0.6099934738637907, -2.727231274965324, -4.603728099226157, -2.8146673908362096, -4.272128703240512, -3.4967151879379967, 2.2997553419913666, -3.408623145369137, -0.3294858748039108, -3.0122175652562513, -0.9424905719713159, -1.80240520605669, -1.3627310130518373, -0.006198961035769703, -2.57255721670671, -2.4455768151790114, -1.1263532650835628, -0.6668494519073432, -0.6445615618185826, -3.69822594281768, -1.075726460438339, -0.276546050738912, -0.7618857346596432, 1.6267141199552804, -3.590267253886372, -2.2500669777009294, -0.5554926082029511, -2.7413454686576895, 0.8351329428279768, -1.2417069510090517, 2.0281520626928233, 0.4519077642976008},
    {-0.4531699419761942, -3.3636216027717936, -0.3177836503461598, -2.4826184636396245, -4.421264212755768, -2.4873096607819516, 0.8240819769915695, -3.810260001854375, -2.6217233417153354, -1.6169229779392935, -1.4308754391565706, -1.5442429330401752, -2.244516147151892, -1.425723040934622, 0.06337837359042044, -4.16239368542623, 0.26512306892333454, 0.06766660314199444, -1.7631297465947409, -3.4270251701281316, -3.175741574519957, -3.6747149663347978, 0.85334996938867, 1.6122732561930349, -2.1192256653892554, -1.9803071832477472, -0.557041469576353, -1.9759566189617261, 0.9191640295233391, -1.842226990923113, 1.9152869165895354, 1.592241243135805},
    {-1.0535560233344392, -0.46657087965947974, -4.211959109374544, -2.1617311231087366, -3.1317293901164196, -5.781306686499259, 1.4776233208384961, -2.1266451662428034, -0.8388705238700686, -2.8815163737649687, -2.663227711472306, -3.2941282821488667, -2.456536008830031, -2.110686822126192, -0.1113750768253434, -5.213583859416651, 1.7227648360996837, -0.979425413429883, -0.9520702123252128, -1.39258375800223, -1.7402045405191588, -3.7882992931226394, 0.48053530638967734, -0.4223073518025428, -2.350232170276481, -4.783070764314394, 0.8410913805303806, -2.4483810502025305, 0.21448658888341648, -1.7555353898504331, 1.0744423321293297, 0.8315902265467127},
    {-0.689492781340582, -2.651594323965204, -2.8915266638150725, -4.303491011047242, -1.1728922044935877, -3.5279555650406684, -0.5356146487939165, -2.7682560470364876, 1.2875987129195359, -3.108437417904796, -2.8869809211734427, -1.6515524354484166, -2.0276572501187835, -5.201229501467902, -1.8736098675104849, -2.542329897457376, 3.097025243363257, -0.1466035633234098, -2.6723496239587514, -4.003138080168314, -2.9364359175254724, -2.917906323964406, 0.6854557908145236, 0.9254208015282458, -3.9045842698203357, -3.466159528449304, -0.6033307112256807, -3.221003938871602, 0.22843127970013274, -4.307332214368042, 0.9688905141588476, 0.7924522662301652},
    {-0.9729079252064134, 0.14105867095514507, -2.528694675581457, -0.6364992285659047, -2.3224543316569815, -2.0477726188241947, 0.11141358165591438, -3.655834368544145, -0.0949085888607779, -2.467173033125495, -2.5435755982533528, -2.4519008875885766, -3.4749021814024372, -2.1011520107574166, -0.8722524431273576, -3.7737206762597855, 3.8330542311487323, -2.0080416971767123, -2.1234661237075847, -2.7257505294293627, -2.6364115298849837, -3.661898828214619, 0.906000906877005, 1.5066051127390554, -2.2780343258108045, -3.5485364573294276, -3.3776643786042757, -3.104889544762822, 1.700240068243249, -3.9428197724317036, 0.9586133431133556, 0.49534374950300325},
    {-0.1192104295923336, -2.029647626579602, -1.4419670878558477, -3.3864631121594426, -3.539447170667215, -3.11580926668994, -0.3702345607811494, -1.975324751863685, -1.1694072641682098, -1.6423656598290322, -2.855165284384448, -3.812471593764273, -2.7554440630142785, -1.272858772711137, -1.9747844883500256, -3.4088777627828217, 1.8498248519026, -1.375566731674391, -0.6788091458003099, -3.501659841454848, -4.715343155526612, -3.436744187435366, 0.7503182705622907, 0.872357614442957, -2.305081262399516, -2.5238238963763604, -1.7907941316687703, -2.9046521730147754, 0.33812598838721414, 0.16681495708717853, 1.8834545033428265, -0.1938604503550299},
    {-1.0144188949028388, -2.686267604540186, -4.966343159937669, -1.674921997819072, -1.623698198209122, -3.4538575902661584, 0.06933462416296882, -3.2164777867525993, -0.9097062453094465, -3.1707163274378822, -2.518596484622946, -2.900460882441445, -3.1098071634040023, -2.3516103999894615, -1.0577722924252437, -2.8377287899819668, 3.088906924450578, -2.607879287548653, 0.26795835801204654, -3.6466395696453953, -2.7627316815609526, -3.4648824074357236, -0.5632325122470181, 0.16343811097484465, -3.413171008013474, -4.353112004026073, -1.6776080627821441, -2.1859787089981344, 3.2273005736199623, -4.106618790320251, 2.070002101782665, 1.9342656382355683},
    {-0.25405891108515427, -1.6482439691012107, -4.326274009097974, -1.497009899622527, -0.9459416785246726, -1.3591048654356437, 1.4573070739604645, -1.6615877906682315, 1.9246663766181915, -2.6024525275690986, -2.3603073619033696, -2.8003924914542067, -1.532486205988363, -0.3481064229965355, -1.982959478949717, -5.243375564111392, 1.3941782363064201, -0.20504740577043515, -1.6289273003654983, -5.0183037782042375, -3.8298682405928774, -3.9661991230140714, 0.6839631684176417, 2.1863305170124456, -3.325609760420428, -3.5460790022109734, -0.9133031553568499, -2.7014170489018614, 1.3951321461581607, -0.5046436589371159, 3.553651504351288, 0.8580872461443794},
    {0.13458827492908784, -3.340681873180112, -2.9613758043881107, -0.9567660613735063, -2.6887740839885987, -2.31887120875434, 0.20011228887354107, -0.39421516006686025, 0.13754782509469632, -1.9853265725861104, -2.086771729850547, -1.9454788198367248, -2.58900631129986, -1.0393950927353912, -1.295307646286289, -4.9321207809716245, 2.680487925438817, -0.6812912942395604, -3.599366139105528, -4.575021115960959, -0.7513728178395466, -2.312818486020935, 1.8964916962600475, 0.8941760270783514, -4.1534747211689895, -0.8609425148050506, -0.5728846887084716, -3.131987653004922, 1.866081605572068, -3.1480333481450167, 3.5235045786184456, 1.8768913383063324},
    {1.6368842273605295, -3.9011551577575294, -1.305462254303976, -3.2165365120710407, 0.06868753140362566, -3.504897135797598, 1.5874968109474903, -2.388916161881865, -0.05010171722548583, -2.1874799880135214, -1.4104493094948924, -1.0287659234801363, -3.530057011571186, 0.7144585636229074, -3.123318150724293, -2.9886519184066853, 3.8658669878743965, -1.0616493261854574, -1.205831668866417, -4.964198452340791, -2.8001829294538645, -1.814951855796011, 0.6875554342617369, 2.5428234535679626, -5.250320423443474, -1.3391050834646774, -0.4889423275792803, -3.15854490565742, 0.90669613067222, -2.3002905132593234, 1.4818766208898553, 1.5133410085382337},
    {1.8970793729093496, -1.0656425854192662, -3.8862687332639014, -3.214782928645374, -2.6307986459091883, -3.353378665512947, 1.649121865011701, -3.7058491786750065, -0.5037945370905167, -1.634693785089714, -0.6075314819337814, -2.9988643490429756, -4.305365360087053, -1.3796122746479549, -0.6007666733048499, -3.925007235789368, 2.7527735403283797, -0.9108209050488647, -0.13238315999596634, -4.8198452425103815, -2.9258428173463424, -4.818742365478209, -0.726691990421343, 2.294667374541698, -2.5670015922492007, -3.3096723483746313, -1.4701341864492432, -3.52978852806575, 3.079727662210946, -4.033456810992552, 3.1556188640178076, 1.4058971747122666},
    {-0.36330449125505687, -2.7683750847422246, -2.3642747397759583, -0.5940064763618639, -1.9470622490615648, -1.611964388826248, 2.1182961856520346, -2.9823010384950734, 0.9658921148324577, -3.6884774844787778, -2.606452813962365, -3.0991887253392294, -3.5191827838756513, -0.5565112469817279, -1.8159419796450083, -3.506970329953512, 2.241217570740109, -1.2824578816976795, -2.4393341005953086, -1.727517655256438, -1.0749747523802162, -3.391365529378502, 1.3312430726298006, 3.0340278262904756, -5.231177974728266, -2.589084233866292, -0.5463262049740267, -2.2866062252808796, 1.6513111788603028, -5.146887582786034, 2.659910333335271, 3.292276493319386},
    {-0.17478804161466854, -0.08590411045721699, -1.443051320099461, -0.12003073601319952, -2.7684598909595772, -1.2538245946979507, 4.078285381331473, -2.3810244406674967, 0.2951250319061945, -2.1409949168453637, 0.2014003862101667, -2.1440645543308237, -1.4613436212545823, 0.050641253257070244, -1.8023779367738775, -2.8138216964393803, 2.6207229915753545, -0.5395071409351803, -2.2444288545998394, -3.5197093806274453, -2.839201373883076, -2.2143624165003617, 1.0828099573332792, 2.264263741669081, -3.3090618849745908, -1.1234552465302383, -1.4475999295530682, -2.4483037577062268, 2.89348788047915, -1.724214859062376, 1.1826635091099358, 2.66421002034177},
    {1.4355824058824822, 0.054964495421050814, -2.931136389416908, -0.22973840089126898, -0.6373312735867698, -2.5612947592042263, 2.6251571579097015, -1.1934110782458962, 0.6765917086977987, -3.1139097435498813, -0.15450822732268568, -1.085661809397216, -0.6106842807684915, 0.12881187616914874, -2.076375832808027, -1.8901183383181888, 3.3712395260049934, -0.11172994093048674, -0.28992456746582396, -3.042226055793057, 0.8732570847962147, -1.0540876704850501, 1.711164153374234, 2.731588089788344, -2.2051044971530516, -1.902781538364966, 0.5355908177425214, -2.6501448530223533, 1.285799556421574, -2.0388964068783713, 2.2792621683567185, 3.214605193745571},
    {0.6251782525321128, -1.7289185610249778, -2.522706415946618, 0.06125569666650372, -1.828414059330564, -0.010987755357557274, 3.3274844963795056, -1.6498664837615797, 1.4690971290949038, -1.4506238975131507, -2.2872637704551084, -2.0817265736119985, -2.421681043499946, -0.10796473847333356, 0.17724390119360864, -3.61015357756224, 1.5237723557196736, 1.45817562973155, -0.10357428602754284, -2.780629146482265, -1.8559100013487773, -1.4274628919323986, 1.2013334762421253, 4.610707083775318, -3.01862907023667, -0.8741040828673934, 0.7570342754753285, -3.266201548251714, 3.521468828477605, -2.421754667418505, 1.4454511872558014, 1.5174460797342368},
    {1.2514509258894326, -1.8316544963488273, -2.722131879122961, -2.4031225873578546, -3.1429303003043474, -1.283921784372631, -0.18102972902727543, -3.796419136310375, -1.3876176142250858, -0.8460110362441992, -3.1634594249996377, -1.430250903475866, -2.671262392987096, 1.4964573719961918, -0.7068525320226249, -3.5227680386762312, 1.7704966683905743, 1.0657315417470805, -2.4970752864602, -3.7125800786222367, -2.0184761521404604, -1.0742344756721718, 0.8334636894922322, 2.7862392010241126, -3.9053012901557818, -3.265935815723584, 0.9303006569971409, -4.763177571376674, 0.6299935110496131, -1.561960201868299, 0.7020444566612956, 3.0801460350642356},
    {0.5870408383696766, -1.8943735366531624, -3.407134835790133, -4.971530910460068, -1.0931755711334346, -2.7047853799178028, 2.373841570243823, -1.3906079664826694, 0.1273153698937626, -1.7033496084966462, -1.1621279890335525, -0.364108499236661, -1.2737211683458807, 0.16287325895780846, -0.5831353352487196, -5.912998143567981, 3.1330444359078675, -0.8160913472177937, 0.15319079581296743, -3.7215385619436163, -1.8897474197486819, -2.4993715344568455, 0.6584627141326995, 2.5726191675393935, -3.563040364914169, -1.18679293310027, -0.5003569415733677, -0.88753758481374, 0.7769367006482932, -3.399664227769529, 1.2753111889758455, 1.7426552959843484},
    {0.058343222876999015, -1.0130516887120982, -1.8498754012663179, -2.8112915981645443, -2.777654068764956, -1.9930503802444677, 1.4836909913459333, -3.2959519214249906, 0.3601988342865858, -3.1284028590231268, 0.701169434014641, -1.1944127513333533, -0.5103033256090025, -0.42981542888174695, -2.724166477224545, -3.1916293139447243, 2.5006204189580026, -0.7959239540926708, -1.9424665620652017, -2.951773257003401, -0.936349494565246, -3.9882398864760993, 1.459362349576391, 3.8017838278305245, -3.834211377602761, -1.2428822533923383, 0.6922191438361791, -2.575377648966307, 1.5402881045595715, -3.1532792300077968, 3.6427440804940354, 2.1065886595050802},
    {1.0425542125085792, -3.025972819835897, -1.440936229050984, -1.2126416583955684, -3.1839076421230987, -3.2300103469255284, 3.5986496305243283, -2.2504978301243366, 0.47039190664140584, -2.269360728434878, 0.2823452124077352, -1.4841847580887126, -0.288736346883595, -0.10459775661762842, -2.4019392504039154, -4.045627431089527, 1.1679978755218596, -1.0941619638524087, -0.5393243035362547, -2.8557991704047105, -1.8095259463681779, -3.080891545036265, 2.137392550695206, 2.183916214534935, -3.530438925742438, -2.766342018199543, -2.409040787809436, -3.1837397876122164, 1.6039584566927512, -2.286006281265396, 2.4351378098688556, 1.348340133905242},
    {1.6744448115869512, 0.4467375599423484, -1.512865721855069, -1.6055493350657652, -2.553161085752647, -1.961225718486905, 3.0688050901467405, -3.5089644202365697, -0.2778488061628129, -1.941087591053763, -1.0806961111172648, -2.376568644178571, -1.3435770260305742, 1.4949763650423167, -1.26088783952141, -4.678536483597895, 3.0059015281977035, -1.1157147351102374, 0.02627507864586491, -2.4023254210144627, -1.4539855652870852, -1.2285429015102063, 1.6764598340660204, 4.523965295143535, -3.2124466710191855, -1.5941217019450529, -2.10297241266221, -3.385757219969594, 0.3655619857170627, -4.70962018588467, 1.3189836990341532, 3.08000438741853},
    {1.1162881532731264, 0.2764419496178284, -1.5181951156835347, -1.5979779878206242, -2.818434592242189, -1.3963068121933089, 1.9205556066626115, -1.4195132123436691, 1.1239622887091376, -3.712225031295444, -1.9273187795842917, -1.4694458803093304, -1.312100392331408, -1.2516804385143774, -2.5162852871417587, -3.56878863796688, 2.7837915162251425, -0.6460140063685608, 0.7428887286056568, -2.2796894612694554, -1.8907507505783046, -2.4998406725899374, 2.8114922000277107, 2.42436021900637, -3.8584280211822044, -3.222545071384074, -0.7818887209612924, -0.5611448499567119, 2.0815428000870444, 0.3566374288295716, 3.068180589850943, 2.684175782811842},
    {-0.1715958448891768, -0.9328576917254972, -0.986752696473404, 1.9967178738731648, -2.552108570764168, 1.2093770863292024, -0.8103549677732005, 0.5612584242099615, -1.8218015490568602, 4.063630832341332, -0.019029359706074965, -0.9440347901144742, -0.4087463405908874, -1.0184720452687546, 0.7702628390464944, -1.2541769222215065, 1.0105628545072163, -0.21429485861921868, -2.8703013716786323, -0.8434554507001571, -0.5346394663463937, -1.795583974858337, -0.005185084963945648, 0.15178522296248245, 0.29542391390801137, 0.7076615659421261, 0.9494534512263979, -0.4289532150955045, -0.08284304587724635, -3.302031121993028, 0.9695504046734934, 0.16228771029234287},
    {-1.367376295758914, -1.047269385551853, -0.2101612867697364, 0.4429019935750172, -0.6882024244579843, -0.0816647372512998, 1.254384885074976, -2.2661879738113524, 0.1023752851576557, -0.4092870026403981, 1.474235911484228, 0.30577269455003075, -1.571512684795096, -1.3585359879505277, -2.1369853211982663, -2.1400858112911645, -2.381163886459225, -0.7940516578918226, -1.0240584293683703, -1.9982328492400963, -1.8939638623506447, -3.213129236283264, 0.8774129704938582, 0.7282301148566898, -1.1266573748769568, 1.2920771904168928, 1.0125679041258007, 0.6513469854188094, -0.9517226651945813, 0.9967645728787261, 0.04142870044448284, 2.743783279211895},
    {-3.633200188643516, -1.176791355578067, -1.9617930633216156, -2.825518339222907, -1.6359283353076004, -2.1158886773731074, -1.3813748427652284, -3.5511333952328634, -1.4739977422613324, -1.129886764200208, -1.4118805584517504, -1.9688573120892838, -1.3983658781099388, -3.6137558842648243, -3.0033132414719472, -2.4510205536420386, -0.08644683781732844, -2.5332541178110826, -2.2813178650929307, -1.5312778152837758, -1.7047115471078946, -2.037051366154914, -2.128723842797276, -1.3468283860753445, -2.6224604232182123, -0.7564264667882336, -2.1820866315813743, -1.269594524998302, 1.907887829249541, -2.0393105937788567, 1.8092866488852108, -3.364879786688713},
    {-0.9956831334780301, -0.5162730267668615, -0.6060451656515252, -2.0922873163047115, 0.803559721829245, 0.40575457520565067, -0.7864941993097917, -0.9409011577731592, -1.313106197495762, 0.05660948873708737, -0.8073802313293251, -1.245058394708822, -0.40313499409525766, -2.5003594391419397, -1.3780757547051883, 0.9561692168902954, 1.3566138714964613, -0.544801797870804, -1.9432587967731991, -0.4479770081705467, -0.6108655819848373, -0.589733093868987, -0.7836038743297263, -2.2058422764124535, -2.0775172385650533, -2.445992500719459, 0.1964796313217188, 0.24128998733928694, 0.057224620863755134, 0.1338426742011438, -0.4134746484906285, -1.716001023302748},
    {-0.5931890635413124, -3.719370485552553, 0.06701456817999327, -2.3189193543558972, -0.9866782886386721, -0.4498539773478075, -0.5817512100412318, -1.2482815431400023, -0.4763959325949356, -1.6699567466826497, -1.3583018740475545, -0.29699085968180977, -1.3342275571745001, -2.3442342410367423, -2.699991450134052, -1.4545368857633303, 1.097520834313999, -1.0931298537787801, -1.0908844065778285, -3.1977094698093143, -0.8013333508116793, -2.17657437597127, -1.6604785069164925, -1.5909968737601978, -1.4042949817302628, -2.624941053262554, -1.5343930209535603, 0.7543548445699556, 0.010741535355113182, -0.5308843694323963, 0.9356321411997998, -0.3562304786099228},
    {-1.7194922556519656, -2.55072965521148, -3.5613931252268234, -1.6898165424008043, -0.05812823528676145, -1.1000785201082788, -0.09214577957396809, -0.7195357278745239, -1.7115788233694362, -1.7819434084716008, -1.6224911580129722, -1.3989402508364541, -1.9422482777347017, -2.0609713896882846, -1.349605435388887, -0.9532339423378943, -0.05088333369318691, -2.150592575003575, -0.7760832228451489, -0.5464431483095225, -1.6532193013665804, -3.876054663689053, -1.4437736120011286, -0.6538057554039237, -3.08050540862149, -1.1167634249759897, -1.4676230454883459, -0.8108979729697173, 2.2480492152008478, -2.62836808436165, 0.6022733912774431, -1.4870495325324158},
    {-3.0778729053212475, -2.226251022813145, -1.210211273967044, -2.5151874942162937, -1.862369665140725, -1.414473230020995, -1.620526491767845, -3.6446708264438197, -1.357640259178133, -1.1636317364051816, -1.3227531267507047, -1.688285055795382, -2.323146470661328, -2.7886915524678857, -2.3796223224474278, -1.9408864125759113, -1.325494289739327, -0.5132456045375599, -1.6944854761300467, -1.02321966014327, -1.8142580129920851, -2.926720778783245, 0.671524496409796, -0.11575452218448187, -3.319006030657877, -0.8376739039333061, -0.662266238885391, -2.272891236500859, 1.3765105749659492, -1.9005448856556872, 1.0471794166856774, -1.2918145023259504},
    {0.09052258460646144, -2.0322947869671384, -0.5450946079056059, -2.874882670608005, -1.9629660462862941, -3.596770214539716, -0.8629098284653619, -1.4775622526425618, -1.9610053557327116, -0.38707309079396235, -1.1560269249839925, -1.5803149700871144, -0.8865409331594518, -4.695004301560673, -3.3681015691099696, -0.5564165649933451, 1.040412557785664, -1.749632199167393, -2.061520317134302, -2.113964641786439, -1.493344066811271, -2.6694312619652116, -2.160803584239437, 0.8911939766019857, -1.0478458278308982, -0.7212206922109178, 0.3582258100145332, -0.8448234493056649, 1.0489580280843596, -1.5763807867880446, -0.06795874540571933, -1.5140725706706577},
    {-3.226515210102749, -1.683299974678249, -1.2244373496343943, -2.3391998115312242, -1.0982636636867664, -0.6691410324782199, -2.4266672695119587, -1.3860406928150713, -2.911491166857284, -0.961504647125054, -1.5411772673564896, -1.1148988560174993, -1.5166330638720213, -0.9036396015147721, -1.4112942023650088, -2.294123416681731, 1.3223820931787962, -0.1645879037044849, -2.22611022737921, -0.4645981235760524, -2.3442751771934485, -2.190505597466083, -2.130928000983445, -0.05176201539320848, -3.4728564053989386, -0.0922592076465875, -1.2057450874868294, -1.244577991491363, 0.40445828896924446, -0.24283617755646478, 2.2600010484114814, -1.069015173530337},
    {-0.6020733947887346, -1.1434455861434383, -2.6057607004630245, -1.9390396301951565, -0.8564198406901254, -2.0435697168224505, 0.005983541781600093, -1.12389848172274, -1.9981768789671985, -1.8722670527932554, -0.4536157015562317, -2.6439881446680356, -1.2543076779874605, -0.7071649414462479, -2.1976917263476063, -1.5914345096078504, -0.031314997938254444, -2.421844925376472, -2.5701288231430146, -3.987281693612561, -0.6603127377544497, -0.21974247181224363, -1.416195794980014, -0.9462931742432963, -4.0365740135081145, -0.45248496278248623, -2.0758808722555266, -1.4503019193115256, 2.059340968006174, -2.4359501270429456, 2.451533813528788, -2.2428420026881044},
    {0.07764620120343235, -3.3880879042561953, -2.2661742504654376, -1.2779693576506446, -1.0233484842119267, -0.5142662568159706, -0.9424500363269764, -3.3567362010518127, -1.2795046842294326, -1.248354410619674, -0.5622966259693306, -2.206951212027792, -1.6253003075930559, -2.2063379230939963, -0.6870959517995181, -0.5266573073063436, 0.6646445523650206, -1.2606868649788034, -2.4695982208261364, -3.2093600241370517, -3.157800730640642, -0.9598914526122169, -3.140158319780767, -1.074426301006822, 1.3847546424835147, -2.8405169456812933, -1.5836094157785092, -1.4214352600184532, -0.4052383199177279, -2.180036816656364, 2.8187269660485876, -1.4028043616604677},
    {-2.9179362074234034, -2.975367016404699, -2.1177379717541576, -2.721044747142516, -1.5555191411226525, -1.6514127995399532, 0.8402193419906893, -0.13208520940155907, -2.245242229814295, -1.6015605487858526, -1.8012353155169112, -0.7188727841495763, -0.5415657252675008, -3.479322801678913, -0.9355865604638466, -2.0066866270723582, -0.32476638355225, -3.244065386618935, -0.09229046262573305, -1.3148557511352, -1.7130533255791869, -0.8287403352161767, -1.2627759844857005, -1.4524721174980848, -0.5859757141248926, -1.7137021480986419, -0.8933166218872309, -2.249856455973153, 1.6489282375492311, -2.9187070650181592, -1.2351486169876649, -2.8183449006839405},
    {-1.0462679717163796, -2.4611293824920337, -1.3509724398702867, -3.7071608985910016, -1.652423042990468, -2.3846460929730635, -0.09322562691697736, -2.3174283452126105, -3.171088492913529, -0.6191029178252998, -1.2977629634951733, -1.4587101595809349, -0.6811620338632737, -2.2044111016161763, -3.12226006612651, 0.10399396789812966, -0.19805959826007227, -3.6429007568259615, -2.2278699148652, -0.6655635034934685, -2.6397468904058896, -1.6817127257907245, -0.8761207957993493, -1.0454874576588145, -0.8664731107208702, -2.079495432741198, -1.4798533610926277, -1.8042923516218041, 0.3536660821426685, -0.45948529974208063, -0.9201965585419052, -0.4472737321472167},
    {-3.541839360996547, -4.258940633715733, -2.4712069047777483, -1.3069031438814407, -0.7365554812056827, -0.2839173965398884, -0.8695943581128055, -1.2834568682362166, -3.352272322788158, -4.5519782817924455, -1.4884744330076785, -0.4486629709311846, -1.843465370291572, -2.3212857690187025, 0.33315635556175444, -2.6124162728817364, -1.9141252401140683, -2.4449505240742577, -1.4228907521395664, -2.2360831142107407, -2.352338423153431, -2.2031391259076885, -2.543816271103358, -0.18635117238019006, 0.044092105077633795, -1.3659823400729174, 1.8894810453408633, -4.740469435929384, 0.8249256127691491, -2.944725270056824, -0.05298982028061765, -2.9767055696520592},
    {-4.656183951366989, -2.8487573234128476, -0.37565174421744457, -3.365415039309102, -1.3657057283874339, -2.310886562789382, -1.2621245647333998, -1.779517144828258, -1.525496903489772, -0.7577672762187003, -0.024137882275031563, -1.2659113070225285, -0.746759432285115, -2.2889967126338324, -2.5238520937405675, -0.8591333915184579, 0.16072097114111797, -1.7403048352490007, -0.9617020815401973, 0.3242040395342151, -2.5819867736378628, -2.0623047455339774, -3.068391629628382, -0.8787412021155917, -2.4322702007533525, -1.805944405075472, 0.9807293410968965, -0.7206064362361512, 0.14507348610228676, -3.2045244026930746, 0.8242389232831313, -2.77309335247751},
    {-1.6068888305995388, -3.9499001904446702, 1.1268789540039412, -1.3471620159292186, -1.4805228710263187, -1.691084042005897, -0.6808800045212082, -1.2139956428553675, -3.3873289559972153, -1.9399182738571314, -1.7746319958368413, -3.7792866335876907, -0.8745654052625245, -3.7448561972926666, -2.5315939046455815, -0.3589826903435538, -2.1028134681251447, -1.052614859322721, -0.7289335365625275, -1.4944501269670651, -2.0582933242195516, -2.981628189530208, -4.010632322871059, -0.14101193004130333, -2.524972550271447, -1.34958838946969, -0.853134890570293, -0.033694950552413505, -0.5282212797677215, -1.1762521818188807, 1.7923372725223237, -2.002328164165819},
    {-0.6169606350076305, -1.692012071526298, -1.7960665074072, -0.5741049037745594, 0.31678279357558775, -1.8364018965644353, -1.2937040466256244, -1.4052691602845828, -2.829909741210388, -2.3846816730605402, -3.4617747452793286, -2.406550690683437, -1.9417505926365275, -3.4819577738289826, -1.8741145596402415, -2.686820367398936, -0.43211281046319977, -1.6138349272991337, -1.2464312472312642, -2.2201601795552155, -3.0504250105637456, -0.4956415452218916, -3.3430664913435155, -0.7711115111967032, -0.5467549203331663, -3.587983527232475, 0.25246854541678426, -2.130626099940069, -0.3388600968325105, 0.31912662145648174, -0.09497472248128244, -2.5248782530185805},
    {-0.4186194625888777, -1.7310921444467837, -1.2788231985225902, -2.536483762775733, 0.4238727137921028, -3.1253262761179785, -1.645946719898629, -0.9566485780240069, -2.6753884904527356, -3.1663479048496566, -2.805462865309847, -1.9533408254983797, -0.5068979116912888, -2.7624903302996264, -1.5292742654343363, -0.7867616319108695, 1.1296668938179684, -0.6549790645453522, -0.3271713711783172, -1.971267897518328, -2.1732515981057308, -1.3046808211118932, -1.750928069778034, -2.8011368810636137, -1.9374527647320878, -1.0171847962840614, -0.9962027031207011, -3.52380115584649, 1.540952544649006, -1.87306091465398, -0.10797754581663264, -1.7072465581789487},
    {-2.6077792026187585, -2.7283902411890324, -4.655569318773966, -2.0362405606585936, 0.3961782120636763, -3.488103101413678, -0.5430345544354496, -2.773771788943986, -1.496624000771898, -0.683919635577662, -2.3527305392215268, -2.3467605285618656, -1.24494817798795, -3.3150307001211776, -2.630017826814603, 0.6818056318309376, 0.2718014714570664, -2.715351851512525, -3.219591638155053, -0.19722644001334463, -2.263273091849126, -1.3840764537759442, -2.6729517716646183, -1.1130880270504047, -3.1327710039087893, -2.5257236002106835, -1.7858165114941054, 0.798740130758534, -1.2297063887523407, 0.585901832686034, 0.6491315159056117, -1.6157337495914639},
    {-3.0907514997771, -2.4323894308047596, -1.58231370248654, -2.6028051229693836, -0.1512221851429712, -3.2524932255497574, -2.8410460873885404, -2.451057753564724, -4.493879219859306, -1.9633925415966502, -1.1931222528566123, -2.7795835562693947, -0.14095186266854826, -2.0889644587103566, -2.0833856704166807, -3.587101313175625, -0.3293794864808301, -2.2419910289051947, -1.528284788325922, -2.688198566687274, -1.7625326678897504, -4.1971710460638665, -1.7588565804013092, -2.089173760146435, -4.942494268963526, -1.9219496695412368, -1.3475167825394192, -4.233036397608511, 1.4882028116747605, -2.217633048736222, 1.1394111609382418, -2.0440762801009713},
    {-3.066391497454525, -2.424529334900808, -2.277390878114835, -2.976495098517892, -0.6401324291446745, -3.965284313604668, -0.7417512899178219, -1.6237894462511115, -3.2013610068653087, -3.5096831969886364, -2.316766891199562, -2.7064320835606708, -1.7761178991352649, -0.5899892176999596, -0.007696033906634356, -3.348726434813711, 1.2704396974817829, -3.309641393192235, -2.61424245554597, -1.876119305291296, -3.5612171637911767, -4.3449605123188135, -1.167703353792298, -0.5526482408361929, -1.4522316366490313, -2.666580433963191, -0.33524962804917063, -3.1973767528562016, 0.6840257327689886, -1.286308345590614, 0.1464318255044842, -2.5411489085391223},
    {0.7152135363660278, -2.4071571156229306, -2.733988268538791, -2.369894649893194, -0.4813362791327537, -2.4369013389130787, 0.9066430758261409, -2.405032305482021, -2.8271609942726017, -3.726910698906284, 0.12421872493818377, -1.9530461990674615, -0.43095228829432897, -1.866841456494134, -0.8472748761936124, -3.2453747253651937, 0.6617398158581078, -0.4188430596764967, -1.2858303891399165, -2.537660948818328, -2.6195844933143184, 0.10300358112229974, -1.8993189553012866, -0.17695437515224194, -0.978280474766063, -1.3699878709493194, -1.1146031044386342, -0.8918494394041514, 3.501378854949611, -2.58760669784988, 0.5531745143616028, -0.5136774261142915},
    {-0.02888640455599272, -2.9615737402985536, -0.633026551319844, -2.9456580922070095, 0.6915696985356086, -1.4077054206898245, -1.3554135313698943, 0.026111670280363163, -4.159632160350892, 2.718665382517655, -1.4255878623753246, -1.0261716858851626, 0.5031820698038393, -2.876450980354598, -2.6592860109298986, 0.39496975774443777, 0.3245927710614753, -1.2430526413050884, 0.015769539904233184, 0.7638958474181305, 0.17602755283550797, -2.6979717141856865, -2.8599039436266183, -0.38870608362291686, -1.675922240093422, -1.0865180808055084, -0.8091805588892823, -1.9382577187529537, 0.4011595485590765, -1.0004784485338352, -0.07461707457063772, -0.9966320670620231},
    {-2.866173452170974, -2.396160818879891, -2.0255395780436958, -3.996080656113284, -0.5325275893024647, -1.2753182975594992, -0.831602801818279, -1.8823233310058145, -2.041180635028928, -1.669549821904873, -2.6716583480150673, -0.5475262227165227, -0.01365199398620352, -3.407395690178501, -1.9872181480031705, -2.832415126029171, -0.2537693675599667, -1.030776175673156, -1.6438756126375489, -1.708883450627659, -2.250095312737123, -2.2986505348887203, -2.4693269736161483, -0.8745195933037947, -0.23210996771902506, -2.17639095596085, -1.8644049281420625, -2.318831017781949, 1.4944896234722942, -2.2379362903706213, -1.2677151426646147, -1.7084617076068525},
    {0.11619715244403812, -4.618966520290305, -2.7946719586129234, -2.6017914443390366, -3.581572665017663, -2.7555751231328003, -0.490090331722586, -3.3504253664411885, -2.3335116440328463, -3.019223304487255, -2.932075965606996, -1.8802575814888307, -1.0036538828240165, -2.436078811842608, -1.7105312453942254, -2.9532133217246033, -1.835358465238024, -1.126184778494444, -2.1921020008846144, -1.41426471837917, -1.964060543610856, -0.3502013682942178, -3.869270790274151, -1.12870189545267, -2.733401518268268, -2.3743398967503584, -1.1148072583663606, -2.8019329486139175, 0.6053861102832634, -2.1206091622953998, -1.2019072529930637, -1.5463539358824177},
    {-1.5944286405678034, -2.503428212936725, -1.868537814339397, -3.2570321354454155, -3.5522618645856845, -1.9210454837466697, -0.35185447155909866, -2.1819087555338146, -4.981019221171795, 0.07995105021557962, -2.0428074554262947, -1.2609285288785141, -0.9519848203395274, -4.004800935166663, -1.2159159228530603, -2.093601570067741, 1.0220813308563568, -1.700560935517152, -2.097383829490265, -2.3605401438697977, -1.7942296075747493, -2.7652397718902813, -2.3293084105396473, -0.999373392607475, -2.1844031202079255, -2.4232094026104107, -1.0942628614743177, -1.3104367101708616, -0.6959976866140836, -2.023833415191911, -0.21884533711617998, -0.9235440998500484},
    {-1.9792535226738333, -2.3544282947367976, -3.1032448541353186, -1.8479096933024306, -2.082123579176736, -1.9662164668673716, -0.5439965280143997, -2.759640897128772, -3.64660539613386, -0.5522390459855842, -3.749820044879554, -1.2777581106127789, -1.6940191463771554, -2.3530778581533647, -2.8278424524246235, -0.652185955697743, 1.3055341750475915, -2.7236818490144015, -3.2411368673367233, -1.3674801234240164, -1.8283511420400613, -5.249458862491205, -2.9858327805331926, 1.2248075988288956, -3.9957634720997346, -0.3384720136884079, -0.493275901137973, 0.6149606129557633, 0.8379569912937544, -3.837507610222065, 1.5231776598904119, 0.842051346921232},
    {-2.78780939512897, -4.346484941190444, -1.6131875183154, -2.6818435001363174, 0.2732481696463781, -2.171550494882844, -0.6614057830462748, -1.6351506473175574, -4.364563634465729, -3.43455716521024, -3.68180025353099, -1.9232802534631852, -0.35934248076922287, -1.8943213193630766, -3.5869120214882986, -3.0967611467401164, -0.1119687914747039, -0.836580988508234, -5.45388965853391, -1.154805221690245, -3.2957717973739973, -3.825369243122148, -4.052353310899772, -0.7677155368599289, -3.9994219402861964, -3.2849343685365557, -2.1735244969756815, -2.7820961672934144, 0.9574346632269748, -2.064731089088472, 1.6075959460087688, -2.2008202392811342},
    {-2.0393631752914168, -2.3560539326085044, -1.982143438598276, -3.438771901313758, -1.1243684013993713, -1.428131982416392, -0.9627451271364057, 0.01820254436391256, -0.8941970324021503, -0.8641278127263298, -3.369506792006739, -0.606743503760206, -1.913404758296982, -4.3836258099115355, -4.065335409071942, -1.7489810631584548, -0.6570160680341206, -2.5038537775418757, -2.59016911790744, -2.2094973182744395, -4.450801859095429, -4.737727860381916, -4.3283276069659795, -1.1324582281795657, -2.2103146177277924, -2.136051194009958, -2.516800787072116, -1.6344841139744166, 0.7004859563497432, -3.22455919313421, -0.9001587651057457, -0.910152154152439},
    {-1.891832353707402, -2.398241428790196, -2.375967875347718, -2.969118326354266, -1.6960174214233028, -3.2530903018430863, -0.5530265294377391, 0.032424960012070424, -2.186706081978709, -2.311015737163078, -0.15727567819324118, -1.6268846782421673, -1.401426384687341, -1.3595756166932247, -3.187274304645251, -3.6842404657840113, 2.44211963061805, -2.2875656123689545, -2.3540449438038373, -1.119656325990298, -1.3159471477182032, -3.4515839481758563, -4.760257360501267, -1.1924515017984607, -2.6672703133184648, -2.477736168663411, -2.556142106971174, -0.234290489234184, 1.4769089656272925, -1.1106245716129959, -1.2999178978620907, -3.1294561493109017},
    {-0.8360011061389094, -0.31695960250463506, -2.4330616926385327, -0.5014638298369078, 1.6321999675425272, 2.007920602436422, 0.43727435667921993, 0.38416550454982684, -1.1211616880187467, -1.277606763287059, 0.7111681848326912, -0.16622710066480925, 1.9095692150276597, -0.9513402958058839, -0.5837207452865809, 1.3138404102052046, -0.5191764096867152, 2.6822756886796815, 1.2510418568808856, -0.28638942544540635, -0.09114675416506027, 0.8518556089428944, 1.679795761474203, 2.089696212346285, 0.40283797015387535, 0.13195186555512456, -0.16522171753056497, 0.13676385204827252, 0.20177422486387245, -1.491337521624328, 0.19331045987941864, -2.7036358061609698},
    {-0.32878843902483085, -0.09992641710809903, -0.4610099968917263, 1.4100397338742847, 2.292976116687473, 2.5044694668056957, -0.31825028304695174, 2.264226995540504, 0.005516216437573568, -1.462927532684661, -2.3996899569681425, 3.1162407051812093, 0.03622820049644796, 1.2246164095617755, 0.1358801652852516, 0.3569326723809066, -1.1248638548060097, 2.147191046783918, 2.268568268411048, -1.6096574856622614, 1.6992961926203058, -0.6566196159888003, 1.8918979863115502, -1.6072352437854118, 0.5884494493231832, -0.7324697537792468, -0.6182246764810735, 0.23139427346947106, 0.2685177916541784, -0.34079196380683324, -1.603095732086076, -2.1970057266891616},
    {-0.5490323488458195, -1.1528533916578325, -3.1591322493199203, -1.0125310839868236, 3.5196771362620805, 2.337179271835986, -0.6967056972916164, 3.0420927079388487, -2.4794658072213527, -0.5400018117086279, -0.9393809718551113, 0.9298814544456008, -0.7604823524269259, -0.8971195445718116, -2.594087891594315, -1.364387309518813, -1.3557372749921182, 0.1882760121080172, 2.7636104494229206, -0.08781779847850378, -0.581077145667241, 1.0923088746928578, -1.167581423490632, -2.5109339613964106, -1.3782302922882796, 0.30029367349953767, 2.1318132209935823, 2.569459255977801, -1.221439220051488, -3.521058022761316, -1.719813400171275, 0.526929083822734},
    {-1.007366246370521, -0.503979886853836, -0.8518903441754607, -0.14630029932426386, -0.15594205410613474, 2.1804497148913446, -0.1845238567725055, 2.593080994490363, -1.7287265919501988, -0.1446467086080492, -1.363883068719983, 2.061246441514657, -1.1972022859974305, 2.8551904893696736, 0.10227709281147195, 1.8773885512778168, -1.8341927980611963, 1.2272943117978306, 1.9920176094856419, 1.1907681082904025, -2.131400389312363, 0.46667181226234383, 0.15640435165961783, -1.758097683858997, -0.12869467794665634, -0.757854136396068, 2.225535387558913, 3.177482165413304, 1.346982466855335, -0.1253763052166696, -0.7583299294734991, -0.809398957582684},
    {0.19324093956765692, -1.0724647205003734, 0.5835371729188775, 0.577651800502049, 1.951092931512758, 4.791940140872122, 0.933980405091835, 2.8277894789782234, -1.2320970313746356, -0.942062371687847, -0.7239718280306002, 1.664028762954196, -1.9683030958650123, 0.27952985634451044, 1.0956162783594439, 0.5144161500630081, 0.16772427996940825, 1.678314373021159, 1.7250467288313205, -0.08506048364865752, -0.23446966125640883, 0.35947143849373353, 0.7373173177021246, -2.292762837087404, 1.4159507849987643, -1.1286890289708655, 1.3262854003031943, 0.8545922260180493, -0.7905934975154283, 0.6664321875129762, -0.8299181536844754, -1.146662072404235},
    {-1.497917650594067, -2.073083003977229, -1.5195415803167054, 0.20410286683063805, 1.6069085922729065, 1.1752970815339265, -1.7334684237492521, 0.4677944264249658, -0.7812371990525805, -0.5381036952399278, -1.5546484121958728, 1.3878977921552504, -4.92417335848534, 1.2711604843420092, 0.7228649730190034, 0.2198446561657667, -2.894169867604886, 0.7520360899374773, 2.6770156341797366, 0.8754039018446269, -0.8458465408844219, 1.0502557735840194, 1.6815703747485347, -1.9079049527459042, -0.27326400656365485, -1.3214075406414019, 1.4100426614407278, -0.5714698321499285, 0.9670863695022563, -2.347131863757948, -1.0127148923433171, -1.0957985783467277},
    {-1.0359780093895383, -1.3706290182529648, -2.523125110703346, -0.36970450286052, 2.8864369155190945, 1.7844300958753923, 0.13317312020208205, 0.6653304786123021, -3.1149846318676695, 0.6617053793261017, 0.8436898067196503, 2.257162035125506, -2.6087417532801758, 0.14124303256435944, 0.8888469733104861, -0.3736636377907099, -0.8640065019258895, 1.0707887478887468, 1.960596689576192, 0.2146766568621696, -0.015004341100477837, 0.42924699060215843, 0.16381660184755595, -2.9717559127560143, 0.0979207319500057, -0.7324399664487694, 2.076692974817353, 0.01409043387742638, 2.4836322883198116, -0.9813979317951473, 0.21076089487369903, -2.461681582713109},
    {-0.30183643281546496, -2.250574506215226, -2.4578830427834126, -1.4684457473978454, 1.9793994449719312, 0.6853621656880075, -1.4454953932822732, 1.5776677194722502, -0.24363931387750845, 1.5429452203689464, -3.2135117185020223, 1.687056695462857, -2.566810653160439, -0.9540000668255332, 0.7993362023969364, 1.0911830359336598, -0.9389164723816628, 3.2143813477508703, 0.22036901147505658, -0.15321395310798933, -0.38197916396490095, -1.1375149188197946, 0.030271967865862837, -2.797183513037337, -0.9124325029467657, -1.2082058320499032, 2.192756334182279, 1.5613840461389379, 1.0087931977535598, -3.769754054423603, -0.18601371814953013, -1.1856976942837936},
    {-0.69851187067114, -1.304904557542445, 0.619677007717302, 1.3095309708618599, 1.9988623932611451, 2.0377591634201706, 0.15069682067270437, 1.0101895536146854, -2.614118761328339, -1.3278897607827094, -1.12357142511656, 0.4777537806390099, -2.0624235304885765, 0.00463117495250635, -0.3922685347203741, 1.0929396769700048, -1.9792858745308592, 0.5832650770647988, 2.717970293818971, 1.4486139359720895, 0.7453291136905097, 1.096877221559287, -0.6096536181689106, -1.4569052651742505, -0.14073153397384275, -2.2438288919983043, 2.6747985297136943, 0.4630476105159364, 0.22854630235731221, -1.001833892651669, -2.5970252124889206, -0.4185684312465208},
    {-3.5618371445389143, -2.838323362296609, -1.3594848045714936, 0.036990430263049184, 1.7441017532661807, 2.573395170842712, 0.7537263668665132, 2.237320033983192, 0.22941268579419538, 0.5426660035926105, -1.66706476002974, 1.2091594773233987, 0.8244452828244223, -0.06414319002436668, -0.30043466070996705, 0.5481481215236789, -0.6629551211281529, 1.8173782358612005, 1.6826349722887026, 0.552006853253174, 0.46255956575889284, -1.0792028179979192, 1.7132919174325836, -1.9624733269964225, 0.35050189811451854, -1.5081099811716627, 0.9158992754178862, 2.3301270814512365, -1.4872714244685192, -2.986156660653037, -0.9166456191730544, 0.28502689673036286},
    {-0.06490099244085507, -1.259131869536278, 0.5337473499707712, 0.8563310954631599, 1.5725157451682386, 1.0175677343471439, -1.3918290887285205, -0.2578132652613338, -1.2928730461604818, -0.4899284913390581, -1.198895422731849, 0.31859959891977624, -1.459324950517733, -0.8534865772323172, -1.2698101278601512, -0.1718093161314869, -0.7080627483071281, 2.7279451183918546, 1.9583052596409671, 1.5051108234927444, 1.4120755940184342, -0.8814011058721704, -1.2591967632021397, -2.2430513753610857, -0.6124149573646099, -0.10272094397581318, -0.18615334720868135, 2.385951213341124, -1.7761563052970206, -0.6178008124077103, 1.2605762636746736, -1.2882263323615877},
    {-0.3251756818207183, 1.4360627286774799, 0.1657546959172802, -2.309211023907954, 0.4306452167769934, 0.78275410258776, -0.6450879284862362, 1.7041893899431075, -0.1781816876673686, -2.1012262717091583, -0.4214882424409584, 1.461723374195238, -1.9832242703260914, -0.5573566801604193, 0.970912256847199, 0.720823224049883, -2.10014111773551, 1.4948832556802412, 3.9991494311016145, 2.1567704257728355, 0.2805098615134399, 1.391172100743661, 2.461736894159038, -1.1389254086073521, -0.6449111778122366, -0.19136152306304355, 2.1713833004661858, 2.172070377262711, -1.0889697411097896, -1.8368905551031127, -0.676816304437153, -1.1515756431477848},
    {-2.5505918536832746, -1.5382620233224322, -0.3048232948547571, 0.8088817557843744, 0.889139016927727, 1.649978523926028, -0.9938957397661091, 0.9677418449882268, -0.2907834611957646, -0.9350569814213593, 0.25812186332096804, 2.2359648082632337, 2.5906778458494735, -0.2822670782132743, -2.06643659492689, 0.5568977763397099, -1.6827412953017529, 2.4439746559246815, 2.2414720997180058, 2.3338718073859885, 0.8285813558298455, 1.0735212958743827, 1.0539743280582723, -2.0542329516513798, 1.129101265096406, -0.12527376030746154, 1.1498512902050666, 2.4806834730057994, 0.6129953751973649, -2.3980040777960503, -0.22400066602206528, -1.9162522300951457},
    {-4.265943425367538, 1.2001803516768144, 0.16119417388422602, -0.9851133417581036, 1.1543473075152446, 2.911140412416219, 0.31046906675317204, 2.9880942011004357, -0.5499655875980449, -0.27755848267788347, -0.6629346564289389, 2.9471728543747298, -0.8541959476061912, 0.6145936297400221, -1.9906703863341437, 0.7606169234223762, 1.5387092702701395, 1.8601245640996122, 1.0294067720474291, 1.3682558615212899, -1.8861463341310447, -1.2408873313708375, 0.759255894056682, -1.461931778705666, 1.5820076207168656, 0.8494780348601185, 4.397572897989427, 2.297116071828264, 0.7052692896820486, 0.01926285614084618, 0.09569796443402279, -1.5142766380465094},
    {-3.518619001463497, -0.045213006213074, -1.2815596562594491, -0.5799606714950437, -1.3241417577226202, 0.6883252653638738, -0.4381144626562643, 1.3613513485574111, -1.352165503546841, 1.1228487515471632, -0.6334326613884769, 2.5426458419216664, -2.674996722885615, 1.0469535953164066, -1.0498980061287764, 2.1130819392555735, -0.804569165990535, 1.6635997439136294, 2.786974882368336, 1.6603141507280905, -1.1984339516939526, 0.6319978027591409, -1.5931694772806322, -2.541721835441863, 0.059175431261429164, -1.055557504629016, 0.8861769239979362, 2.185277971521906, -0.6733213620640192, -0.8744171021214747, 0.3219270023591286, -1.2755114457444878},
    {-1.396686401684157, -3.077179993147984, -0.37387214735111074, 1.5239462720410681, 2.823115380779206, 0.509309756665021, 0.5334174609212464, 0.36143644430523897, -1.3628081070062121, -1.6749726961440412, -1.6810432600970602, 1.1747911373486004, -1.4980898505300213, 1.158251861502929, 1.3259598450682928, 1.1452458130218977, -0.6368431753018019, 1.7291207417545094, 2.117916149802772, 0.025150833302873904, -1.0934321721938436, 0.8414024041567277, -0.31412566415725873, -2.4447068005927437, 0.181077136611891, -1.5556067000441618, 1.6040060028123178, 2.8997471278484244, -0.7226226747484055, -0.22047892777986827, -1.172523204654802, -2.523161354971145},
    {-2.003302629755118, -2.3261217874878275, -0.5664893755947424, 1.1337106775419536, 1.4510671140279106, 3.337408975649381, 1.2468386401373444, 1.9442907255645456, -1.9274452435939928, -1.2208741308926738, 0.4652554129287052, 1.2148072391233518, -1.6616943848000516, 0.29867616986728646, 1.8770495516270587, -0.5970137462933323, 1.337499733204424, 2.1255985095997065, 1.4445491010237574, 0.596989596663043, -2.408222378186185, 2.0781799989448007, 0.01174526185415372, -0.9029471121366172, 2.0021886177861457, -2.1643793356757732, 2.4409791717763785, 2.0553187868767924, -0.08165711607251912, -2.3951635778302522, 0.3841302358642378, -2.0455120088122216},
    {-1.593655932052341, -2.2657780460498973, 1.0990561682112436, -3.131262628042856, 1.820943026308307, 1.087677038368153, 0.4996148796510907, 1.402737235734256, -1.117596625925882, 0.13213094120876862, -0.6749034161046776, 3.2023582871783107, -2.419123529727458, -0.7356984037098775, 0.5515907351908695, -0.6395334926252831, -0.2462622242520685, 2.9219453763017, 2.44526666576089, 1.7891937708261498, -1.9823296929864642, 0.8921061630401405, -0.08969851031501488, -0.4062513857689692, 0.9864935123639281, -0.7598395545230191, 1.9521874558511272, 2.9284973215376313, -0.6786343021543279, -3.41000216499047, 0.31254796304076976, -1.3720342808322503},
    {-2.695945254773288, -3.3332749896453158, 3.041333528600437, -0.03376326778326077, 2.3513821131303096, 3.227363298633165, -0.9240716846147087, 1.2248371687719934, -2.056827297785817, -1.1540507763289216, -2.20817734243759, 1.1065947388879218, -2.2043558510903893, -0.8523164054094144, -0.5346729380442105, 0.4341855849685425, 0.11188196758435841, 1.9257096814649506, 2.040411924046294, -2.2331302608220964, -3.0854122325066213, 0.29324600261949035, -0.35786619598320685, -4.3158429934770455, -1.1886439637543942, -0.604403656183519, -1.3503297644566477, 0.9602427117253892, -0.7362813935598888, -1.5139942501078902, 0.19535729498484203, 1.030009229546969},
    {-2.128544221966673, -2.3754784500306663, -1.038729883301998, -0.8338586163621818, 0.025791618292842895, 2.4298899710394517, 0.10081865111404552, 3.7206053830708563, 0.272726897373085, -1.6900184572221706, 0.44913394024328607, 1.7929747155830535, -2.1556404653749293, 1.3285472712647397, 1.428935928616437, -0.3977483473415438, -1.4525120592554976, 3.0886633699946535, 2.1045191014910403, 3.1148521859862757, -1.0691476853912691, 1.2882054908623917, 0.2051550352390467, -2.5878969813266064, -1.401524492474321, -0.5894497127521464, -1.0038264098977285, 2.4886090628474844, -1.9964766232446298, -1.6867228583026646, 1.6358561061336494, -1.520656901028775},
    {-2.1305855958100546, -1.4358581797453762, 1.0635994959285642, 3.190299341969298, 0.9415793160947303, 3.922413740658867, 0.8192829160492402, 0.5024792654757227, -1.3991215360169955, 2.081920812649232, 1.3410851584925285, 1.0832028683696915, -2.088661898387297, -0.3920015856617055, -0.9151845421268436, -0.8618537337473161, 1.5406688562976387, 2.0423147639692667, 2.1364391636347606, 1.1021631194864505, -0.8807255456280206, 1.3429537482683687, 1.036588025648376, -0.3341121538305541, 0.41751786846455335, -0.2586375388069678, -0.7504511982938954, 3.459365909532527, -1.8037372774849154, -3.3892027275406704, 0.10466067783862477, -3.018686295454188},
    {-2.7440666785191214, -0.35887430588479213, 1.8174556822999408, 0.5112521693320332, 2.9217149222982304, 3.002154688572092, 0.2262119978987233, 3.2093356147916263, -1.593395621274327, -1.154540259377771, -0.251794165463765, 2.502534302665022, -0.4155432705679991, -1.0210010364106286, 0.9481030820151769, 0.1536423713285352, 0.17976883703705188, 3.5023706379617523, 0.9598718513529039, 0.9082173048801989, -2.2284340867783903, 3.25656489956761, 0.23770646753416483, -2.6289787663877267, 1.142389258029119, 3.195517930492468, 0.6895842103700391, 0.1894102133400038, -1.7369579035201246, -1.010781424419945, 2.286394352981633, -2.017823298672737},
    {-2.9699755743557987, -1.462797747064372, -0.16029205285968431, 0.7702793707868766, 1.0317042321739807, 1.9531964685864258, 0.37982377695678426, 0.5927766237929054, -1.4948450663273234, 0.11721456018881911, -1.6523075027941165, 2.7579613778739436, -3.570994122468448, -0.6764500944101007, 2.1015458984683324, 2.163592461188047, 0.04890353737803648, 2.6903438796561066, 1.0779118649843045, -1.1149482653937883, -2.922179303240923, 0.9225650398301614, 1.0313200726608156, -2.351005569626609, 1.2023441451919268, -0.32932899788875164, 0.18490831659044785, 4.447216392395995, 0.9327117924623898, 1.5615795535659889, -0.7070301614784217, -4.89758447379932},
    {-3.5026333664078524, -3.6167804488701054, 1.3657490773187468, 0.9298507997027743, 0.8239017944594734, 2.2898523926355767, 1.7482932875474442, 1.8809688403085434, -2.0395611389665436, -0.9724147852185666, -0.8768922421706232, 1.6294132761904685, -1.4716777114235085, -0.6886060460856834, 0.06928229050387334, 0.12272548162064278, 0.034463503660970285, 0.09871039186135955, 1.4135818042928339, 0.08158033654978372, -2.3823679161854416, 1.2909431155626354, 0.26094311657418995, -0.9025655832884043, 1.5248679244306673, 0.21768982044357427, -0.9258623403737705, -0.04009109430021553, 0.0479145372474433, -1.1452992016747765, -0.27832546950677045, -2.7817641338286765},
    {-3.641459284471405, -2.363169217444032, -1.3606505620702356, -0.31226661115241416, 0.49904951766835637, 0.5937229067594166, 0.8093010208451608, 2.4244375835573524, -0.8919253202468632, -1.6011181220029997, -0.4644630765631254, 0.8218956205932532, -3.3660074373372844, -0.8607898443220976, -0.1442382603456011, 1.6648683515617766, -0.1816702362004488, -0.5586505396514622, 2.4658534189714505, 0.6717128509285174, -1.2547410361919233, 1.1760757898838616, -0.5564793806283802, -1.8213206554617198, -0.43647125499641487, -2.188811319607246, 0.7990019622491252, 0.3073945837086071, -1.3335526773470383, -0.7161161053337447, 1.664598140577654, -0.4352497217036445},
    {-2.1134941148611377, -4.196157836230704, -1.277027870359744, -2.3059216586173688, 1.478018724392388, 0.6210477119141958, 0.3720005032955553, 0.8041012258426194, -0.26868093280692384, -2.0072800942597926, -3.105647482196119, -0.09671341706868108, -3.624669509922719, -4.52399806790063, -0.8876158905899533, 2.071400596855977, -2.256974974551743, 2.2477530605738836, 3.6613473522619744, -0.2520974963942135, -0.5660399714166909, -1.4803943055637019, -0.0030839063880041106, -2.545648572049158, 0.44566704535911217, -0.6730993381461658, 0.9101696767780688, 0.7018061739393942, -0.04204381742197933, -2.1423524274205334, -0.5685780346051728, -1.5520995251850858},
    {-2.311700468876556, -2.257924420265922, -1.0286655186200513, 0.012976524131074585, 0.33355588587632384, 1.1505928665514313, -1.1606905164822545, 0.25517334881349707, -1.5791396008026675, 0.5283120706954546, -2.4198865323618435, 3.6909862253120505, -2.1075401118253527, 2.0126367171105244, 1.2911361853776588, 0.12242827164758886, -0.3297639503865902, 3.167739405252005, 4.756805203242671, -0.08200357422010925, -0.32483142852583413, 1.5635518827243915, 0.6312351611613203, -1.9857556600807218, -0.2583924359780316, 0.5800140545659261, 1.7719620473818352, 2.6785633047770263, -2.3665997349461656, -1.4167528032545986, 0.7281094907577857, -3.176776134895488},
    {-2.6780309449243744, -2.2703752989597827, -1.0562822301019499, 0.0884121549525689, 1.5098514769002174, 1.1506505795448934, 2.3998580517528256, 3.404860763436132, -2.1191485846129234, -1.6563962495126938, -0.3120692336419392, 2.9070593595473584, -2.012394149835863, -1.5644293422439397, -1.2393237519828604, 0.2583742607470619, 0.5166145619413288, -0.29752035387039516, 1.6805552136247213, 0.01929088377607029, -1.3024691565320365, 2.4446557040646333, -0.17287130063260808, -1.990376237778843, 0.2250800729238362, -0.4552691921891316, 1.9938905550499266, 2.710952491336481, 0.33569210846202263, -0.3631432334862174, 0.6523317983579741, -0.10852245432584579},
    {-3.027898116733861, -1.4786686092262646, -0.3524294406139709, -0.109515382145069, 0.730591768477035, 1.5474297603010274, 0.3965348223652793, 1.5071309304414524, -0.9602672451560174, -2.1065550449966124, -0.3533657481319094, 0.7585374296745355, -1.0196493995926528, 0.4347886916923895, 3.022030164264101, -1.4511820029026181, 1.11035979502492, 2.0498585035198156, 3.136813981522633, 1.7706300263799455, -0.13887839520343076, 1.468014382529271, 0.1878861186067397, -0.905707084533051, -0.9338085821960259, -0.5862386239338723, 0.8302462473292921, 1.7437859912958646, -0.14564193701471861, -0.9574264750122983, -0.7314561518926967, -3.0029741962759147},
    {-3.282897891507621, -1.890624607946027, 1.6762004678428088, 1.0362826043980444, 2.182697951904335, 2.003136021119201, -0.1155856865211361, 0.5120935837274796, -2.279110658097641, -1.3249290633757578, 0.005977521117986222, 1.3296294797035924, -2.289332828265439, 0.13096598026543863, 2.1908754747641708, 1.1026153011084763, -1.0494182159202643, 2.120759133950789, 1.686848474782901, 0.9177874360831665, -3.0478947656234348, 3.2902253773833294, 0.31725007484976786, -1.714061876247301, -1.8863944141452886, 0.26579736720742875, 2.210846827326206, 0.35438313900769025, -0.7839353170474966, -2.753192897111671, -0.08762347198362545, -2.5024131005625114},
    {-2.3212408636097117, -1.8030419532481787, 1.9023941335224948, 1.0756122117199094, -0.38814434797785274, 0.7619348102258688, -2.5488985617725786, 1.5835642769292229, -0.2902815218003779, 0.6071689124757892, -0.11581329432999903, -0.5742986667160382, -0.564083576421801, -1.09829252093564, -0.9058226334527607, 0.7701741978149093, -1.3452921140544272, -0.5811449706111859, -0.12903462502157476, 1.3263232414199468, -2.2287552726575797, -0.7437967835027044, -1.454575585351629, 0.7882018845747877, 0.868775064715507, -0.7447386604189701, -0.8923053831810459, 0.8461109942748728, 0.07255074996301847, -2.2856169689101073, -0.02505081500639034, -1.8230525898718304},
    {-0.6417644690235685, -1.7802311788924605, 0.5575932459208656, 0.425792405677157, -1.192105609052443, -0.380141278988235, 0.8490684885072688, 1.0601212055327798, -2.0466243692712673, 1.1873013493371087, 0.03126695106622987, 0.7357535837261462, -1.188542990374384, -2.0896905627062377, -0.9204388472867697, -1.7457925557464622, -1.2593779586596903, 1.5717987405066385, -3.380391048612255, 2.158892376157176, -1.1836345923701064, -1.144936891876347, -1.5588207594810017, -0.6692953177971027, 1.8346311475065584, 0.9716364900281546, -1.3499422053580452, -0.05478867171833683, -1.7514265009922951, 1.784406923948636, -0.6649132954255113, -2.2863527678770494},
    {-1.4981628885348628, -1.661090874451705, -1.587254590746152, -1.5427985600601355, -2.090424279424289, -0.7055854759281873, -0.5432033149363846, -0.19058703899242305, -0.5792570615926811, 0.7251036162527759, -1.762163285853837, -2.9394805284237755, -0.709655338932823, -0.6802113863246426, -3.600753004433578, 0.14398621682395366, 0.7488940442994967, -0.03795130722586735, -1.5521666480373575, -0.4130741102978668, -2.02785448753506, -2.0751084362486276, -2.6170344834572776, 2.6634668546570084, -3.0433524040977495, -0.22059228950145945, -1.7328627525905027, -1.4626498397212888, 0.9583351422943387, -2.7752449057848185, 0.7816860555206566, -1.992158633149507},
    {-1.7005155551788496, -0.5792654088659392, -1.5217942995003335, -2.1416820625469186, -2.2963716378195316, -0.3863790241264973, 0.13239633110999574, 0.9407463007118735, -1.1303065027965908, 0.975720810864089, -0.15349619193315245, 0.7626045658112929, -0.9754310373195468, 0.015712831670438847, -0.552587437000707, 0.1383793806851418, -2.07589355954424, 1.0560950412617167, 0.11057203928566971, -1.823192152197845, -0.9023743482805828, -0.9020870551226764, -2.5225486923144267, -0.8503198671517541, -0.039268109030042145, 0.22055282866809964, -0.39940493194083176, 1.330393141318891, 0.09367095880979576, 0.9213142762416878, -0.20369130474855096, 0.915341975082313},
    {0.05204986965216562, -1.2701442267901448, -3.6897402712893896, -0.8642106873115892, -0.5969178556666674, -0.07299857943162082, -2.9769006300075818, -1.253593396049425, 1.0795051144921672, -2.3973275284899875, -1.8722618010303718, -1.045781667132795, -1.7870272149314765, -1.2335979499944825, -0.8717427762829288, -0.8715405965564499, 0.333617291273855, -1.0490993757520806, -1.4748194556548853, -2.0686554667496484, -0.250418376548342, -2.25513984175365, -1.8585379818021173, -2.0509922211673604, -0.7402117795368437, -2.4304610838189213, -0.9759469495225892, -0.8397206203091391, -1.7361929157343978, -1.2948541903292983, 1.0394206125666603, 2.033462176625339},
    {-1.172216797530706, 1.433594152572761, -2.049828955915713, 0.851660685111691, -2.1184660453355897, -1.31345615080779, -1.4008325841704907, -1.1006917195341865, -0.9940694964832574, -0.5203295056603162, -3.5244132588473733, 0.4549108101350245, -0.9792142119807297, -1.5092246398230162, 0.09303752675868956, -1.1281191700923714, 3.0061150489936357, -2.5034894008764943, -3.635892229856804, -0.013910037746254583, -0.022940736635102744, -1.1408101438128961, -0.2765175242284665, 0.3300117693515213, -0.8894458054062766, 0.18622346252220812, -0.39285915395741217, -1.2057527707329572, 0.6906496940689021, -1.0219790828736302, 1.7323608110994195, -0.7118891872224415},
    {0.8976757681341913, -1.8406564863877923, -1.1596440871563596, -2.5488483903246415, -0.4510670944386329, -2.37735697173434, 0.33696923988463284, -1.0208892110407932, -2.390428964675679, -0.7188083883169375, -1.837968769622016, -0.8298236925683609, 0.7141077082761766, -0.43782576762795905, -1.4543927772772074, 0.6660274489983896, -1.2237579696792624, -2.0296354830659777, -1.3690680823672692, 1.0317052329490675, -0.12189278319657801, -3.237871623652319, -1.0240727604203799, -0.320143684074065, 0.01638566177928149, 1.7210456389454007, -2.2062798638752166, -1.4535000094013064, -0.7895954868324329, -1.7211206943630986, 0.7314284355131836, -0.9202144287873484},
    {-0.8703368535473173, -0.39031433455838843, -2.489434439645618, -2.3463158885669655, -1.9032102354270612, -2.2947546864261175, 1.4171079626047118, -1.2922079451437425, -0.06772707423634726, -0.46673975755299213, -0.1717197479702025, -1.7206683231058908, -0.7073678622104544, -4.212968079279527, -0.004273312047980409, -0.06479717133211814, -1.0646100028085548, -0.5784427014894914, -0.927404226796903, 1.0118621843566962, -1.0613896895638526, -2.309543899353355, -1.8189150980747921, 1.6156807934317041, -0.2547264580443286, -1.6599860692911756, -0.9371321904254754, 0.24997913446542466, 0.5781903991822225, -0.048453882093632904, -0.8054587110142044, -1.0998483056453314},
    {-1.1825149068273415, -0.20209988748189534, -3.431629584266466, 1.056292124066477, 0.28692842798886803, -2.0433644723472235, -0.008577143112884966, 0.924008768254376, -0.12268874692299393, -1.6342688284357396, -0.34998262072094205, -0.6659784332465362, -1.4077482726406265, -3.2816759430200624, 0.10276165923713805, -0.336125109860405, 0.46968919166817263, 0.7573251287952066, 1.0331636974652811, -0.22255792030500254, 1.4782722150081915, -1.6451874888102935, -2.0870829324376055, 0.09505311153282121, -0.365461398602389, 1.8624565267237967, -2.3720949159616502, -1.3857531728399657, -1.2262838869255925, -0.5375631958073265, -1.1417362690722912, -0.6091881961207866},
    {-2.0379229607457576, -1.7227670110286626, -0.3790476629329042, 0.038755622571998834, -2.154163167465203, -0.5548679213096408, -1.1798846333818844, -1.745133274433921, 0.008422508634095355, -2.0957867809662165, -3.45251571818398, -2.82618873900722, -1.9249570799195033, -2.1186248728659947, -2.034784566442577, -0.32204644358024714, -0.4107685650868897, -0.018895871421105007, -1.3248890245774805, -0.9366598895460172, -1.9399353538877622, -3.1026754984425313, -0.6744637697766557, 0.7356384321345363, -4.349286561187697, -0.6616956048336975, 0.43655461100003207, -3.5627027014162342, -0.8581890528082526, -0.49509715774174534, 0.7650619614282453, -1.0471601706545952},
    {-2.1217932695819086, -1.7732221728482258, -0.7025350008839344, -2.793096160063126, -1.8740220861224048, -2.04164049383242, 0.398319429915085, -2.5912839576792335, -0.3742278308035121, 0.28384849014565927, 1.5010221159591615, -1.6890319646669152, -0.8118211749374691, -2.093318094397793, -3.621827354133212, 0.7115065668625754, 0.8872071769671155, -0.6199155671550641, -0.039590863175735534, -0.14290966327905508, -1.3662332761068512, -0.07043074751123841, -2.609847716702265, -1.07366389798745, -0.9578208980223235, 0.041727779197384844, 0.32494895452703465, 1.3612219151507112, -1.5182965575790786, -3.1748837588974737, -0.821585134474692, -0.6530826079842813},
    {0.21929415855582077, 0.11381760001938518, -2.260320229494361, -1.9446208280638961, 0.7685420313899434, -0.8780442021952946, -1.6583361028099213, -1.6159741894711128, -2.8032080057872313, 0.1916034159638225, 0.44454789708433895, -1.1969365764928745, 0.17502901811388905, -1.2100730427591508, -0.9242494334134453, -1.1744946818120814, -0.03185617108868026, 0.1142600932742172, -0.7757393944075256, -0.6162932210094086, -2.550502882206024, -3.1001604146604884, -2.542018082594185, 0.6871763390512847, -1.7325585606722378, -3.3271003533902226, -1.3056166162386176, 0.11434518758483224, -0.6624754365256794, -1.0872719865322147, -1.1435739754239354, -1.46141677816624},
    {0.37385166877614884, -2.585265856263966, -1.4072106216843472, -3.1868136241100626, 0.6044466287713306, -0.5844177860937328, -0.7298845548747042, -1.148753101987422, -3.234232452179888, -0.25887149833978695, 0.6308815930101284, 0.13318939664639548, -1.2720163546227758, -2.793832942962233, -0.8009495171263374, 1.4091540491169106, -0.9514291174684386, -1.8909981393805584, -1.0698272354895277, 1.387483856420492, -3.585346771726006, -0.7110208774940329, -3.9382710018926894, 1.461922753186673, -1.6746370895187324, -1.7350550286552207, -4.6126687405823485, -0.9651487889306267, 0.8740334180989123, -1.5841764167316887, 0.21510293199136588, -1.9606781047893669},
    {-1.9083731244020412, -2.2820416913096455, -2.3113805007360506, -2.2643835330060806, 1.4921655704461363, -3.15364147681369, -0.040311056437530635, -0.9799288518497168, -0.8175016180372284, -2.4811984848674666, -1.8654316453812325, -0.8113215760852706, 1.2116232727303504, -2.0975100392869104, -3.2822647897992425, 2.277748502050284, -0.25425447852854594, -2.246410843991679, -1.47648497453232, -2.5182828696262227, -0.8669940709586036, -3.817726932307219, -2.997374900635479, -0.8078546267455821, -1.644459564986668, -0.6590183433098379, 0.45639086206543156, -0.9336438865672451, 0.30442013755309705, -0.2669895816779062, 1.023011840375077, 2.0065691617257513},
    {-1.6385920357673123, -2.2718480006952113, -0.5017887848665845, -3.0744540060001624, 0.19831667700926986, -0.40269228065274215, -0.5942020858750267, -2.3725326740873385, -2.014749692004548, -0.7408671143710891, -1.5175515439670209, -1.7485048573303827, -0.2408898561088541, -3.9292453145053448, -1.9993942447993511, -0.5647316083699065, -1.2151108468698448, -2.4474296614514373, -1.9706015200268385, 0.7696488473828772, -2.5407647660256765, 0.16733520947281438, -3.709308739881081, -0.6317526025530464, -0.4091522699570745, -2.125129259179937, -1.0450499658756158, -1.4097300325830457, 0.8266837572904988, -1.6507124872910164, -0.5839070564171372, -0.7711083041201842},
    {-1.687098751105964, -2.004541213417023, -0.6125524683123466, -2.259120739220081, -0.3779605134373128, -1.4646797693856797, -1.4502666828574262, 0.35224415017851995, -1.1495142099355367, -2.599417806671722, -1.6987147332492534, -2.818209443627052, -0.8683546339632625, -2.7251276346079623, -2.123940674530762, -1.543793978809281, -0.7144354538086365, 0.14943951990963233, -1.3768252025675756, 0.20375804780725557, -2.335445738888868, -0.3025301915216005, -1.6929579081482182, 0.6336870198831838, -1.2171914409697417, -2.096022174920295, -1.2023493152672426, 0.4739895957521607, 2.248894623158477, -2.292986783047317, 0.3910100178897395, 0.19107149321548633},
    {0.38672113309663064, -2.7388572520485557, -1.3194578420274452, -2.3591356932457104, 1.8624538109890234, 0.5408014533315122, -4.576837536978573, 1.3020128523722196, -2.106461298193325, -2.6153525920682292, -1.4564780981959935, -1.4533778215947202, -1.1393463891847888, -2.7030716372765555, -0.43088000076275124, 0.08433882334028418, 0.3604845860136588, 0.5526570053695143, -0.5516873207954375, -0.9830640747805734, 1.1453960399370915, -1.487915869733583, -2.7081089123180235, -0.41026365838677686, -0.6823552172099558, -2.286951594611055, -2.973055033886385, -0.42866302924469507, -0.3040840156149855, 0.29387051221611254, 2.089065489586147, -2.2493154085610922},
    {-0.2183301614190093, -3.806156423652177, -3.900772608940576, -2.6447761029042764, -0.5109118184959965, -2.609849183950463, -1.5915714351095855, 0.5585746748188314, -3.1611922184935652, -1.4887610373309246, -2.2017626857029176, -2.3094186911915355, -1.8786347185172623, -3.638719433587583, -0.4358692043849109, 1.401908206082457, 0.6799823380462252, -2.673308587784941, -2.003543199460013, -1.3902740953943031, -2.999675678754263, -2.3647005602119773, -4.159518898003163, -1.2735818919113342, -1.1774242725771138, -0.950289573408716, 0.2262952374279497, -1.6610206806753527, 0.96750401380856, -1.381040618969272, -0.19553925000029837, -2.765260612873588},
    {-0.7908987265138367, -1.155682956474642, -0.5945693792081282, -2.2560588193047058, 0.6260244879936688, -2.0056080427375895, -1.5867995679572082, -1.3843741541687664, -3.1820171727195934, -3.0977777915945803, -0.8364497754018015, -3.4991934678556387, -1.9507025036092138, -2.0694807143105756, -3.896313490422264, -0.7270305537142862, -0.30165667001075636, -2.7458787788665306, -2.8737432948374195, 0.001018462044525363, -0.5595672579889046, -2.4603103963060344, -1.836959930795723, -0.2520180915045172, -4.003765251888228, -1.3620735565522897, -1.4834609154251275, -1.673514547404284, 0.013198139634106145, -0.2649900554212067, 0.08227048412264756, -1.0371250054220635},
    {-2.2828400697997333, -2.9993849468000793, -2.2859551665516125, -1.7622009535184662, 1.1357186496539853, -3.453605284921305, -2.113911364136608, -1.8138378532198824, -3.9881428040244393, -1.5246217171676972, -1.6690685621792962, -0.42972085269758736, 0.045629169666640476, -2.615826131000988, -0.6660538471338597, -1.118109036884152, -1.2203968319943252, -1.2234785680567455, -1.2945995430766326, -1.07724321180454, -2.118372324825292, -3.3042478222937146, -1.501912527437106, -2.121624497571305, -2.0090564539507167, -1.666782044614156, 0.21719244177628425, -0.9594168061065567, 0.8534679310450387, -2.1074831596569923, -1.3782693228140555, -1.7216646083390084},
    {-0.9517060464323222, -0.33284204957569874, -2.66051715204716, -1.7112042340449374, -1.9400386916745473, -1.727539319833096, -0.5677311940728003, -1.3697701078743854, -3.909620509657524, -1.0069367111547165, -1.9355828235770223, -2.1655997117111196, 0.009586519586788737, -3.755326766270513, -1.5793063701998884, 0.6965992155114439, 0.02288937929002064, -2.1081179392119838, -1.140908940093073, -0.9657101908504738, -1.8884429026820024, -2.819069005257185, -5.150567838271994, -1.9666743966716305, -0.011547544733509833, -1.4786490677980388, -0.010085546992548693, -3.0620328793627496, 0.5522989526052962, -1.3422551310431723, 0.21568832154550568, -0.7318962917022449},
    {-3.1287526746956216, -4.47552736292548, -1.7564795751912388, -4.949788109560208, 0.28784118754993626, 0.34213990455269877, -4.750641281450094, -0.9566392417150549, -4.5775981343774585, -4.672561855012427, -1.912932014454901, -1.1349420158822234, -1.8277727089942908, -3.2514826347077204, -1.1576721617265582, -2.268125381832064, -1.1008175663847355, -2.5188422051217985, -3.1200371269469325, -0.45674029089129425, -2.835995704478876, -1.8629712443504363, -2.1780929194386776, -0.5916135869654682, -0.3722960581586242, -1.1475195854973987, -1.4094302776894958, -0.23178722382204095, 0.1450783258163438, -0.31532118422865646, 0.334800083683135, -3.215305515510261},
    {-1.782507187358562, -3.67950040400364, 0.5575706431966921, -3.8282435779228114, 2.240053582129866, -0.9828097049908527, -3.090338851029426, -0.8614896373397148, -2.489395001544547, -1.0070655502856642, -0.22468790382559817, -1.5059437039122439, -2.2746436137260426, -2.86605380504942, -3.1282193190533256, 0.7937090464643666, -1.0166619704284907, -0.38471707935743954, -1.39161163382736, 0.6878209852020362, -0.23364393517949275, -2.133246609548954, -3.6423597309082676, -0.8782631133512697, -0.04417397666067644, -1.8966444944487562, -1.870147164612674, 0.20172665922089753, 1.8513675516473058, -1.5554615127045468, -0.03652299370057279, -2.7264244348152595},
    {-2.153740721438129, -3.7346286290960466, 0.16907643046738124, -1.905402999232899, 2.551456623598728, 1.230617457103009, -3.0001752847841368, 1.05974012426778, -5.41099566477776, -2.1545449975871653, -0.9729157915432302, 0.4304701008477857, 0.6650366422535734, -4.135153550174018, -2.091695830352639, 0.6445647274003229, 0.028274128776484483, 0.1519035549832085, -2.520929728171768, 1.6227285438681944, -2.724824774259615, -3.6286877095843826, -4.424754423208528, -2.1070336908827603, 0.025077633034306872, -1.0350267283724672, 0.5383294851376529, 0.7186430751040278, -0.771418758632815, -2.643989729117633, -1.3097411484635122, -0.7999658126669432},
    {-4.119823857861348, -3.3343088778299297, -1.74965827640638, -1.1861780884417128, -0.5613897540641395, -1.7150991069318997, -1.2566868702115288, -2.4455050869648804, -4.292147891092992, -0.9654361542848363, -2.5285701599669177, -0.6440493306085382, -0.3123938834990254, -3.7499604799286876, -1.1430209283691761, -0.4215208844733211, -1.1655112381073267, -1.53393507774445, -1.721766575009518, -0.08550406923008774, -3.1607284214609175, -1.2201284020130567, -3.572993830134618, -2.620569762468894, -1.6376652377272565, -1.077715058460328, -1.5975871880006838, -2.1707102297362586, 0.1724340662044715, -3.6193241785372154, -1.0617358675601791, -1.1216229454902813},
    {-3.598405068462355, -0.5460477829886401, -0.7810967136318345, -2.4654826558377207, -0.023260216387222737, -0.9768683583096429, -3.1822469923258914, -0.5134590030535154, -3.0879083277279067, 2.6383998980573544, -0.4652687905556201, -0.30762958919499994, -0.6925349859632419, -2.399256858639028, -2.62753873523354, 0.8834600114295155, -1.6223571655819782, 0.12031293538682862, -0.9652797962058417, 1.230963619246197, -2.0349235998956354, -2.0539120110042, -3.628753955848697, -0.6637617860448701, -1.4177271608917987, -2.5707379214719204, -3.205274986551886, -0.15836184440137838, 0.5448829154893591, -2.038914165298247, -0.6588693016239059, -1.1920179624338534},
    {-3.19122919187498, -2.0433777725631357, 0.3347156814769418, -2.8981677588593353, 0.5145558228827002, -1.6595772662264803, -3.3310507974686763, -0.3108357442200951, -0.6476926147910199, -0.7908328800866722, -2.347513238012679, -0.8772274358899665, -1.3168527347986716, -4.333505774062532, -2.771084332644041, -0.6055170304045215, -0.27400266538063506, -2.9294971619650703, -1.621546481877078, -0.2982007022757102, -1.259782115696, -1.5609271936074351, -5.488878366574889, -1.2450930876453066, -1.9555100065041047, -0.07920828713005068, -2.657690760500384, 0.10964933107495857, 0.007013463628898304, -0.8827992203483261, -0.8224577989520173, -3.4607150373197566},
    {-2.5720211597544416, -3.5783158884819906, -3.1434007322114024, -1.9844778216034515, -0.02752808195491038, -0.5490364224985572, -1.096066724360571, -1.5534162969181198, -2.3381842113048483, 0.33041100918778266, -2.8002669696213887, -2.4139997941092184, 0.37366522953847436, -3.554475401111879, -1.486698404798459, -1.0358863876213538, -1.5387417811749122, -1.5842727188386547, -3.171952984570073, -0.3826227321249835, -0.46531948121934286, -4.081709383104979, -4.766453773890535, -2.8195759919897347, -2.608961931976479, 0.3082085446428937, -1.204077659481122, -1.8853381878974704, -0.4319413226426221, -1.5197006722648763, -2.393961932501591, -3.132844189464379},
    {-1.9439451029555512, -4.109865865890599, -0.2335561766344094, -1.1455159984113914, 0.8592506644461125, -3.086113366146899, -3.3471490450029884, -0.7792729196385729, -2.5958495635986503, -2.000343741316915, -1.9419088833556897, -0.2971758615389474, -1.6870239860349001, -3.2380903693617253, -0.8456466663075982, 0.5113615933749233, -2.3416210083027615, -1.188443529714649, -2.6533146556908327, 1.0945639540383882, -1.7589683988418245, -3.8950508122375918, -4.995132473305548, -1.4880380040607857, -2.304821373715745, 0.24052871779404983, -1.6001533451173504, -1.0354610912822901, 2.9400448709042433, -1.2916676730688577, -0.9219653844102945, -1.5981829669805618},
    {0.05058800334683371, -3.9895857717396614, -0.64179350526047, -3.912182044108156, 1.0952561066620758, -1.3568848569519933, -2.346735676290367, -1.2948304531229045, -3.656867763691353, -2.424765437903008, -2.8235319025312564, -0.660926606086364, 0.649373679283641, -3.925942085409166, -1.8642888307370407, -0.2882832905949091, 0.4803594541293142, -2.5781834622361575, 0.5157261135099277, 3.228393329078981, -2.5007113853244203, -2.802649470553436, -5.044258983893546, -0.14565517211312431, -1.6117552156580994, -1.3500236154446599, -0.9157879406950655, 0.20419554628118067, -1.2158197110103672, -2.250200334576462, 0.3650551602040506, -1.4448513131282392}
};

static const float b1[32] = {5.392119584258331, 6.363358954237646, 5.472245718901825, 6.199198474238133, 4.801707862280644, 5.313649971949904, 3.6010226202736315, 5.635964878630461, 5.8856544517141405, 5.350525064066337, 4.772456316659765, 4.938567350135923, 3.8707868509150107, 5.918353081959003, 4.712937526210052, 5.59507576594408, 5.314119777884827, 4.902343676409275, 5.985549173149374, 5.509225536683674, 6.206358540897781, 6.0315726736364565, 6.198015624396667, 5.66440340632867, 5.778268922513236, 5.134728178256521, 4.774397546237889, 5.381573145024432, 3.5416215732136282, 5.7941281095777475, 2.2554238129258772, 5.628142506359541};

static const float w2[32][16] = {
    {4.160253953766316, 4.510066353192265, 3.288323971567225, 3.28802086876333, 4.58210543737245, 4.974028005470545, 1.3813009950596815, 4.296122125345044, 3.790550111214941, 5.147998517731696, 2.674904724580317, 4.2090824446349355, -0.44778299198757604, 5.157044660966768, 4.118383863234983, 4.4757342984604245},
    {5.165118929847282, 1.1201990839284708, 3.9593399953018853, 3.026142731770334, 5.236975922014312, 4.096283636176471, 0.900448690457013, 2.38686656588056, 4.676940926962208, 6.793443909899515, 3.6322787870083495, 6.122171704388021, -1.4712142321879413, 6.0020753287635245, 2.9691810159690846, 3.075159393993815},
    {3.8099460386379533, 2.6306458143042897, 3.5394601300582407, 2.241169886241011, 4.242391669095109, 3.831023334799493, 1.6944820997509666, 3.855547908056611, 4.518622100679108, 5.880756274037216, 4.467518773653852, 4.733811003308461, -1.8559756364724516, 5.109176655645474, 3.4302792592748275, 4.229682208812901},
    {5.278207480391984, 1.5625377674784007, 3.2937621962121706, 4.582762341950556, 4.772525298615286, 3.23644978570833, 2.1800878734358626, 2.014219647484019, 4.079175835947501, 4.793456070061149, 4.59572673922738, 5.14771182369187, 0.6269636471806422, 3.2412163903908255, 2.450584518135658, 2.6029444553459755},
    {4.277125210011826, 2.154517388519843, 4.8253130974982605, 4.146945753231689, 4.01263007144697, 4.035804917350604, 3.7679157471721916, 2.5162321612404606, 4.979292941190563, 3.2613659143392715, 4.04949301418802, 3.527120337449704, -1.642499503756255, 3.804974243105578, 2.8593548090925798, 4.169788485962462},
    {4.471871906886704, 1.9541515570033838, 5.0960367627495335, 2.819134002636939, 3.247633508189902, 4.780568379223012, -0.19627368202300266, 2.2176801391669185, 4.883489391412643, 5.972882795702179, 4.380353792698479, 3.010580198813086, -0.8238200602435357, 5.214287179494027, 4.1229382403692, 4.074668086578549},
    {2.2247096617976942, 2.1829377235997227, 3.7346353283412883, 2.9847233103652506, 3.023542720878436, 3.6967554366864834, 0.7795625697654548, 3.613254335436598, 4.664421673691626, 4.913304365051298, 3.7471402288313467, 2.3313726253512876, -0.8134047501356594, 4.577042792820582, 4.070764454769277, 0.8116398340391784},
    {4.5893288163998465, 2.0152283819631087, 2.946069558745294, 4.435023725875305, 5.268060018856474, 4.0492328983766805, 2.073935459055429, 2.0508939574812795, 3.4128881473458925, 4.238136444521751, 2.692712587584316, 4.27437172744208, -1.047743336310069, 3.6233784239216593, 3.028157114342132, 2.5712880149917057},
    {6.270083408517303, 2.9581977540995785, 5.202123687106747, 4.0731970143961425, 4.2655448408005165, 4.4255636376528695, 2.5390272679333292, 2.557800676036992, 6.401655734607125, 5.255769324456234, 2.4296296211625994, 4.471993129501796, -0.440984367488036, 3.8437160060354145, 4.156189501034072, 4.298251121874269},
    {4.738902273457302, 3.153788166000989, 2.261623909291927, 1.2004800400060278, 5.19209541725747, 3.097381469217567, 1.128368597630915, 1.4487784736771778, 3.753977348869524, 3.7433143439200283, 2.8479730689797647, 3.6807180499151397, 0.1433140192630235, 2.763287297051881, 3.4738492270833996, 3.697798623443902},
    {4.321836633732527, 1.1231271212171856, 2.539680786367233, 4.792649652258646, 4.554855590246493, 4.319091683767239, 3.644783650099636, 2.4432811634835305, 1.7237789084839998, 3.905899979083156, 3.5836580668477556, 3.8732595541256223, -0.9542588643953985, 4.771230404434267, 3.573270559389573, 4.145591522393218},
    {3.7146467855018566, 2.1899586068078083, 2.777532956846659, 3.807179030590197, 6.293685973181055, 2.745415769049134, 3.8892909232976507, 2.175915574747331, 4.022234321845419, 4.7703595555834335, 1.9205208105803337, 2.4703826956735733, 2.0883459604213255, 3.326501550636793, 3.831080925279047, 4.581755240802477},
    {4.848002177900981, 3.123301045925052, 4.394098483479058, 3.3435420412338877, 3.086160713482807, 2.8564145849715685, 3.1571955672031664, 4.292039708902401, 2.631169759131044, 3.540217166483974, 2.3162980580398616, 2.2376984290400546, 0.4580939417363534, 4.465881946788826, 3.436471098758289, 5.520459565002669},
    {4.80866726950139, 2.5182651979351123, 4.027804684666218, 3.594867707773179, 4.274587273988784, 3.932352172847398, 2.4957474192087967, 1.6268046002247991, 5.48810254484231, 6.053607013012223, 3.9837012772968716, 4.233863239761018, -0.7066133646927237, 5.565598540087515, 3.955891733140167, 2.950554307378348},
    {3.0556592752464993, 2.291405494686723, 4.032494330752601, 3.7329468533000263, 3.1549727155003104, 4.737279001073165, 0.5798893241984011, 0.590255711312729, 4.023206422406193, 4.936165754696503, 3.6762322362601, 3.3971003106155773, 0.5095885562303745, 4.746649560328203, 3.4691897573081176, 3.6748050934552965},
    {4.867820786907166, -0.6795053389864969, 3.253262941162068, 3.5707424789610465, 4.876607024914625, 4.880035416911883, 2.1517468235890225, 2.2043531693682468, 3.144486264389274, 4.861617461677493, 4.400876865557947, 5.151488245023708, 0.17392898391910958, 5.380104829415373, 2.7902561993970836, 3.7599222649811526},
    {3.4590488440689846, 2.714046827493679, 2.7914365917571162, 2.849553345604564, 3.2793791608597056, 1.91193435429628, 2.6587377152817386, 3.029470506847744, 3.698992962682858, 6.211592071353388, 1.5770587197700119, 3.6572944475375904, -0.5654684770995831, 2.9121552982596612, 2.4596933041605107, 2.4589407671952426},
    {3.247187973723108, 1.6129135924664226, 3.2458435450799885, 5.934107103850612, 6.261436404224355, 3.8025993877715054, 1.7172521391392013, 3.8658106307775446, 4.958398373933446, 3.3865679445705412, 4.557147633716488, 4.211875417360063, 0.8750623260097236, 4.637862531640135, 3.4153003197506706, 0.967998387600525},
    {5.670369446355664, 2.9673535685595955, 4.022493368631527, 4.304333487319984, 5.730630860426909, 6.008691836465898, 0.46493313563117117, 1.3184634042608634, 4.514058117215879, 6.6001213755282535, 4.038667805860351, 4.028508500898974, -1.0577402855938907, 4.163144195552679, 3.38889243380848, 2.0054367788349503},
    {5.225351872605361, 1.4343730572480826, 1.3805357078341274, 3.7579423389138262, 4.875462001145313, 4.006847250101213, 1.6733027776582448, 3.026339073089585, 3.6133572146149713, 6.795150570575932, 3.0467124346751495, 2.70206231049313, 1.4836192289576453, 2.9872480532613634, 4.241029013985968, 5.143299005074371},
    {5.282927365261691, -0.5000619988431473, 4.37521813056063, 3.6394856340115456, 5.993311562162634, 6.553909233300358, 3.1895167874685737, 1.91776007127884, 4.835536292489999, 4.282937301725484, 3.597530207308313, 4.920157384142816, -1.0446827731623658, 5.558683594007032, 4.505222675969474, 1.8569475766054786},
    {5.391823470943324, 2.484564357933542, 2.8068103360005496, 3.350642222479055, 5.584646876326321, 3.876344238145156, 1.4975050173254159, 1.9481198220653502, 4.515013066619077, 3.7418754666706695, 2.918651180966788, 3.377287515395767, -1.2255429365737236, 2.9224313548422383, 2.5125799340433215, 1.6610722456170675},
    {6.442084427821837, 1.8870571057332048, 3.3735976782960346, 4.302958448236301, 6.566055463827833, 5.100272199704831, 1.3930089813168323, 2.644790151441821, 4.579277679557455, 4.438158961331503, 3.3756451606544275, 3.319875802488184, -0.5470133089683716, 3.707343661518555, 4.49990627746821, 4.04851234008654},
    {4.606762231277723, 0.7629337023584558, 3.31781005427362, 2.6689249184981643, 5.264445030623336, 2.9042066707727248, 2.9015773945957006, 1.985656154221566, 4.73842227209686, 4.868790934553175, 2.361050215265121, 3.901666505976811, 0.17055752154831427, 4.224066415506949, 2.3194863561823835, 3.654690046083189},
    {5.030302185237184, 2.7221047462665022, 3.9381637453824805, 4.8022520504702175, 4.279353622731171, 5.167759151297713, 1.6954693308535373, 0.4272889248229181, 3.16957121336326, 5.841480933675222, 4.495767221207312, 5.586431941007842, 0.26234474706902317, 5.1760967651321605, 3.0459920931530857, 0.9100379242428874},
    {4.567560079463437, 2.987875725764642, 2.0915592850991676, 2.5101626379565563, 3.539472349243975, 4.0292599456358476, 1.1655835045322378, 2.0343460955427, 3.5817406472557747, 4.603439647652338, 2.363706746089387, 3.5865515087451323, -0.00916059488291226, 3.3734198882723336, 1.8629387994484363, 3.2150950603343458},
    {5.161577768861832, 2.2250453835978665, 3.080535844187947, 2.907724839168882, 4.269985940775227, 4.410126718565861, 0.24036004548748047, 0.8103542822757025, 4.66483152777646, 2.422868246409664, 4.346386402691177, 3.0196116427775235, 1.5718618092601842, 2.80557407615882, 3.0507568937596274, 4.111760735487132},
    {6.494591708804993, -0.22957270011630698, 4.218044316600698, 4.577878217472448, 3.565028340369616, 3.3311903978463673, 2.4481615393036638, 0.27187181039336084, 5.0496161516104, 5.130978086230448, 4.1188610199120665, 3.732050467395779, -1.0592922667701619, 3.30141866422862, 2.291130462160317, 3.635365109882962},
    {1.4038464935075305, 2.842959439734525, 1.041340838308598, 1.600820902618662, 3.733857073802529, 1.9596324259633164, 1.2592830514585351, 1.3288925487171688, 4.579805465137122, 2.315227102581208, 3.7519188745325804, 2.897175424254446, -0.965154323106603, 0.28614444390987004, 1.2662180193535797, 2.569247523180611},
    {5.183019502586522, 2.7129032578311953, 3.836114081118215, 4.190650999717592, 6.239343051105803, 3.319534162955075, 2.5936873791319623, 2.790499746619437, 4.885252254788281, 4.217718150238874, 4.205933381876599, 3.029236519663759, -1.0353279144522043, 2.525326347667128, 4.052335220669998, 3.0645367707847595},
    {0.9217345029463051, 2.04692131936423, 1.1283791165071622, 2.6324689801402124, 2.877543393181158, 2.2858138214695223, 0.2251023815844437, 3.7923441405471343, 2.3573793960906118, 2.3204948301161545, 1.7263605859574898, 2.7273898445706317, -1.1342520732560673, 2.476793462121617, 2.4244383100983145, 2.083187413233534},
    {4.961115564092496, 2.4090392470023914, 3.0890303666179593, 4.462278313769077, 5.031864075566821, 4.255770226597178, 2.617974469571434, 2.210640929068651, 1.5902591394135992, 5.062191999640968, 3.9517083477516044, 4.10154408812236, 0.4976959158570413, 3.600643735986968, 3.6434658766768666, 4.131183966394034}
};

static const float b2[16] = {5.4947146592606275, 2.4030334553563497, 4.487335160985861, 4.239975292189763, 5.484911697154692, 4.9613244944984505, 2.67212183707029, 3.2305121046420915, 4.591410824621555, 5.639828969425621, 4.217241234732222, 4.604119767982808, -0.16200844979162912, 4.73872495428452, 4.031206465983712, 3.638361915167642};

static const float w3[16][12] = {
    {-4.8965957527182935, -2.9415285402458315, -2.403474945022452, -3.7267346523712868, -4.299309261221328, -3.997150318804418, -2.100447515639957, -1.252871562870236, -4.39021614130347, -4.408937492096367, -2.892506853574814, -3.8180917046552896},
    {-2.298719808275459, -2.7330300150444424, -1.4297399522364065, -1.7390497125981934, -1.6117634299020138, -3.7511272478719415, -0.5499738192869714, -1.1521764932144423, -1.3627333066006382, -3.7626173926669337, -3.096554437587673, -0.49133655465204895},
    {-3.3114877041146475, -1.3422890665293334, -3.3520774765805426, -1.9584458405994527, -1.9936193964330813, -3.857062186712947, -0.823129687786388, -3.139468957648928, -3.188270361247206, -2.259605432445162, -2.300110686794645, -3.1527904194569727},
    {-3.758036031710606, -3.3583110496722783, -1.674123060125604, -2.2711530097630375, -1.9397963835520744, -1.7648775231871021, -2.751749391838815, -0.7994400850392693, -2.5555139614616045, -2.4866433766983476, -4.388355978285761, -2.001991400880646},
    {-2.993150805310779, -3.556412280957697, -3.8491110263042563, -3.6070787812156047, -4.238997268293618, -3.644627324702824, -2.7301512649023763, -3.6979867233384414, -3.901321446533713, -3.1877030544197837, -4.322302696597908, -1.1818191785326544},
    {-1.629662078095097, -2.330852157623093, -3.2928247426157875, -1.6355755126631648, -3.468482453162667, -2.6281988907166918, -4.654700636217347, -3.8383743345957644, -4.071569887668859, -3.660032998839855, -1.7561764862514786, -3.20292729143886},
    {-3.102514032250669, -0.9342228407187492, -2.204752388672792, -0.9438357637041472, -2.724823941745448, -2.6162014890326857, -2.2653114138097314, -3.4912481985021406, 0.039174632835197315, -0.5370730222742993, -2.4535873960641172, -1.6686248626649123},
    {-1.6250237966535326, -2.3221624622549797, -1.2182638637191634, -2.2200783976139493, -2.80920254648739, -1.1313858331760054, -1.305864321998601, -1.2073837614546303, -1.9724818464626583, -3.623304391754741, -1.446408016798139, -2.88538621779296},
    {-2.948240091070035, -3.120732663766191, -1.9618243667988893, -2.7727710448363028, -2.637586232285365, -1.7922509876626456, -3.420489275847826, -3.3948916813639536, -2.118068633565643, -1.9012828766989711, -1.7671282889376814, -4.2198416010549735},
    {-3.846534752283418, -2.1566172591563046, -4.737141019380118, -3.2938799331244097, -3.321018400927566, -3.8043510504084868, -4.0974220450247625, -3.9748908349706413, -3.7143519220059034, -3.6783202992334436, -1.9382890154027215, -2.755917137435918},
    {-1.6265720847328802, -3.244494617908406, -2.8293762603253434, -3.9187048029734366, -3.231363811706928, -2.1565519260751653, -1.6142885540576841, -5.06333125743625, -1.3872373033033931, -2.947472853972578, -2.121901503532373, -2.8858759384522514},
    {-0.4808684986565743, -3.234425673248768, -3.375096148081655, -2.539493379501507, -2.860667538970437, -3.2884676856019994, -4.214658573723633, -3.239570256485722, -2.8110695882218506, -2.062059545772569, -4.177722054369992, -3.524308126491817},
    {0.16009705810748917, -0.5669863709902175, 0.06244913270986782, -0.41857410997614386, 1.4653923086766296, 0.11880758059310399, -1.352902431712016, 0.16548516687085915, 0.0010570039651027724, 2.253040734375789, 0.0006072039517222205, -1.3096699704726547},
    {-3.4661979008761428, -3.7285361705800284, -1.938583560520219, -3.032784123454683, -1.409377819798717, -0.925650650857156, -4.198232474451976, -3.6556696293672646, -3.1295742447740484, -1.803851687497511, -3.8807888081834934, -2.823571478523205},
    {-2.3686335710703847, -3.2848919167402273, -3.281772212836989, -3.7237885500571632, -2.1200589003929986, -3.59285250785401, -1.7634350284399434, -0.30627405451925904, -1.6982634835036459, -2.5807181304195974, -3.80055480759837, -3.0186026360718667},
    {-2.2185837691210546, -2.292166874096901, -1.993539544451958, -2.45969823401161, -1.577481487807586, -2.2373737636798463, -2.6002214534953483, -2.1111747001755483, -2.033806634559873, -2.073556139615789, -0.7603383359628995, -2.649413913516512}
};

static const float b3[12] = {-3.2146675786769006, -2.1213470950007665, -2.1730305654341775, -2.567969113713576, -2.465957039890277, -1.9391688602982786, -2.3869737014380186, -2.0576116122362627, -1.963066300622647, -2.1512819914880343, -2.065788629372047, -2.115581375760943};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
