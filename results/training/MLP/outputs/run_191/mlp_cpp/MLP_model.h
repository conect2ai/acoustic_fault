#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.8396376607897904, -0.3851236034739623, 0.2337871478144313, 0.928215214804705, 2.2167816825950877, 1.3808236652053094, -0.3792380365927567, 2.7612970608414233, -0.026572371215110448, 0.8619169051498844, -0.06805682867614257, 2.90719965819736, 8.178457083326748, 1.3522948051750192, 0.24600755856541964, 1.4003032586175221},
    {-2.2064803091831053, -2.1581710751448764, -2.329364127604679, 0.5691636252675917, 0.8860642455998715, -2.2866633292271668, -2.9371534823291836, -0.37503139806715685, -0.5343569619245538, -0.10996945562535036, -0.5627219008449561, 0.7424144279354734, 7.352775287569443, -0.10512166087946681, -2.868825671848827, -0.44652639879023287},
    {-3.5316272975701897, -5.057659178987735, -3.50618260027669, -3.4144546590281943, -2.3406290507406755, -4.081886647066374, -5.114136406742829, -1.6236680938981807, -4.599239810730454, -3.9687122189915405, -3.0333036342666255, -1.906624000390967, 9.631139462301977, -1.8664889784147416, -5.5302972850782615, -2.1529572417050327},
    {-6.066460210204278, -6.649180230169641, -6.315644975650208, -6.387810952086672, -6.278859428022504, -5.92313152742455, -6.8721606706583325, -4.734914216345922, -7.039723995055618, -7.110900612142942, -6.21795848754366, -4.989278783032042, 9.258559408282586, -5.360294824040892, -6.637054083248339, -5.3316837754027615},
    {-8.1203425718777, -8.45850038885166, -8.17375560047868, -8.297511392179857, -8.491520300519836, -8.267196516512307, -8.48344400694592, -7.127638311622474, -8.770914672227866, -8.616354519224185, -7.884609442783996, -7.809054056619584, 8.859645480112862, -7.812950083268077, -8.215174905671299, -7.299278468793254},
    {-8.050918256817479, -8.328458246955195, -8.100525184727793, -8.349543338879126, -8.629358876205444, -8.094165072758265, -8.587128813043932, -7.409813032711012, -8.614320786292875, -8.436702680308516, -7.841532721635673, -7.925679456156586, 8.423220297890339, -7.871480667189992, -8.21797193719876, -7.141621867124826},
    {-8.133756767698417, -8.251253794411511, -7.939485826339458, -8.316148114415817, -8.442535633075458, -8.075925399750437, -8.599036000073049, -7.789231149944959, -8.58766278804988, -8.47023489941405, -7.557927402732883, -7.98703389917595, 8.231992440038296, -7.914665659074948, -8.261220209187368, -7.335744422117603},
    {-7.881342688922825, -8.05203473388688, -8.026845814753116, -8.29793148437584, -8.224263335344657, -8.028026929470467, -8.527095203585464, -7.6228301438247215, -8.315781866040497, -8.223474906008972, -7.8305786547162075, -7.615166312334379, 8.409759002687249, -7.468474332667924, -8.267433393139159, -7.598939742716066},
    {-7.656852826135211, -7.704398313666471, -7.305230700512831, -7.928126886868426, -7.50001379757279, -7.559091474140126, -7.951113426800758, -6.175520156539324, -7.96372106048273, -8.08789742306357, -7.752262584509915, -6.777765223143362, 8.32277953093996, -6.752113636315525, -7.2001028103139335, -6.518520598483169},
    {-7.541146562330533, -7.489100206608406, -7.033070316219448, -7.271826699646484, -7.408340148966683, -7.493434778881028, -7.667556056078721, -5.9285927192795365, -7.639747395362866, -7.534312865238296, -7.344749584647907, -6.58366254701555, 8.4151213028333, -6.583934012773198, -7.39346680808518, -6.37711358953742},
    {-7.822547111030557, -7.766996298307531, -7.531837318971914, -7.331528211701572, -7.427257731720577, -7.915349325237581, -8.223444898131458, -6.8470147124057545, -7.52529560298885, -7.310579346714257, -7.433113036909184, -7.023492768639442, 6.257145237918582, -7.038491465863416, -8.006073413086842, -7.221416670441966},
    {-7.836740275639365, -8.317815134023125, -7.893918538585232, -7.7091076964417615, -7.955003212544713, -8.190498304910147, -8.131909427664612, -7.686499400486338, -8.020085576985473, -8.061209482836073, -7.561628819960081, -7.522326927545764, 6.15149923501055, -7.358168728703612, -8.05864084653333, -7.788999861377706},
    {-7.95185881750671, -8.159425999850248, -7.776853608447358, -7.4871687543515195, -7.9909207193324026, -8.162587373591709, -8.07890112169419, -7.650266560702256, -7.962607233990264, -7.760700028608982, -7.384827914474131, -7.797981830809347, 6.85365495102821, -7.452733421698728, -8.03439384311932, -7.606052656602007},
    {-7.929513302033176, -7.935099614982933, -7.851986919357543, -7.67666498264558, -7.887456703952339, -8.24205067420352, -8.171098396594951, -7.855667592161101, -8.006385914041433, -7.737486256087486, -7.185000067596684, -7.3504381655792335, 7.475233167271998, -7.392824049649534, -8.157015374988022, -7.442859499214974},
    {-7.525022485039735, -7.503286560139357, -7.204628854704102, -7.309613297026374, -6.907192408660422, -7.885564543105672, -7.941167698639677, -7.148124095276906, -7.6886158737292085, -7.536079704570521, -6.95827145976981, -6.971907231176254, 8.530759798422208, -6.70975785759128, -7.467831530511946, -6.907302597733936},
    {-7.336899411606879, -7.623375786574624, -6.95557911922884, -7.252648770893995, -6.980024921830472, -7.305294181990091, -7.674271031821542, -6.480949756167444, -7.73738463116112, -7.536699682984317, -6.363285960323092, -6.657126086324346, 9.097322649202859, -6.402836622647306, -7.5613014351212255, -6.501064594074009},
    {-6.765830948485722, -7.164850466164923, -6.778771336288015, -6.5792101732393204, -6.566759221505573, -7.1018885162535215, -7.214873050353547, -6.090632390143009, -7.462860343455599, -7.473488328038947, -6.309551491702254, -6.406947512448741, 9.282765559079344, -5.91772322868486, -7.469988132684551, -5.884823977091843},
    {-6.235571455770945, -6.600673038443048, -5.592318589105195, -5.480827412625826, -4.918393279403767, -6.211906526236987, -6.372052418849616, -5.075206811848755, -6.594167456824039, -6.186240448164784, -5.251236170299425, -5.016903588276956, 9.738186611711953, -4.829325099592302, -6.399776466047957, -5.409538048198169},
    {-6.769706686031511, -7.2260330618995905, -6.324038902087223, -6.770627348951862, -6.527689439001042, -6.6143920909156515, -7.310015605279436, -5.489493985450123, -7.11467386591824, -7.2626385514176715, -6.119991940269555, -6.008953882218521, 9.372281018018398, -5.843752477703919, -6.988425823476359, -6.074677935845414},
    {-6.919904294546404, -7.291573062364308, -7.000880622926614, -7.000895885650499, -6.884563511822533, -7.139627217054119, -7.646936956922296, -5.681833163228576, -7.5212862449804465, -7.279291388095496, -6.608029401300066, -6.271362662803971, 9.444151185638306, -6.400814361654521, -7.3402222325351545, -6.559556691933876},
    {-7.2860247231198265, -7.749523837256592, -7.398813657488746, -6.6524471327405434, -7.170711426676951, -7.698800440647291, -7.880801685211579, -6.5900258376018295, -7.504147036295064, -7.5958494056564225, -6.715452538957851, -6.654601079087495, 9.094224430282127, -6.527679700230607, -7.493989407693192, -6.804347919050312},
    {-6.460558183665604, -6.714814330998556, -6.317419103405514, -5.312757660805929, -5.59303358093979, -6.3583949516052884, -6.671142425037796, -5.134766711764094, -6.500921372615663, -6.36415736812076, -5.69140467352399, -5.1145646335542185, 9.57645001657757, -5.355821039101722, -6.679313008601444, -5.666539184992844},
    {-5.033374909744621, -5.0045689925226275, -4.8532536347675075, -3.624999299657278, -3.2909708370887847, -4.730401843178993, -5.390600516302571, -3.459070556901603, -4.874360588010282, -4.5194938559708495, -4.643088763295767, -3.546244714920164, 9.67440013069646, -3.8436401060252456, -5.2249482263101, -4.524962784777506},
    {-5.938179183441149, -6.106835324076771, -5.6109625182186775, -4.7990913765064445, -4.420327220599287, -5.6006211370295125, -5.861422023137299, -4.2278533215238445, -5.661989061017027, -5.532026345549981, -5.115843248592698, -4.343525746330448, 9.094893030600023, -4.273079536134512, -6.12270167410567, -4.840688121495212},
    {-6.0326214440953425, -5.976059348023455, -5.961757821504837, -4.650591728284399, -5.174864300466229, -5.990088650708843, -6.0523429980477665, -4.197325222603147, -6.022829166914377, -5.621640802319907, -5.285459590905828, -4.221003684775381, 8.90685810817424, -4.546400289910495, -6.344979208404751, -4.953649300656837},
    {-6.6551066055552095, -6.7112198845687265, -6.4569939581453095, -5.881325244073927, -6.1038562937921865, -6.753277817828439, -6.828696599638427, -5.700055629032214, -6.875270696758544, -6.8515985934148596, -6.10225418826608, -5.568160287337893, 9.0734789945324, -5.6320165287907535, -6.9926141293801765, -5.90485514916796},
    {-6.347923381167159, -6.768998169716411, -6.268748040605348, -5.437884685467115, -5.475066832104091, -6.378083515850174, -6.838739330035449, -5.251672343997984, -6.472638602524781, -6.554771779350853, -5.820313925138408, -5.347486648328177, 9.459958430259844, -5.352496837806412, -6.807636961746854, -5.626472147370624},
    {-6.48178849773591, -6.7168934903022395, -6.541762506434978, -5.5660464883846315, -5.4390613032001776, -6.710769615248128, -6.737875311694322, -5.244117719883129, -6.680950300607224, -6.327055223173818, -5.893096319645267, -5.459337636690295, 9.30350549988414, -5.686427297447495, -6.974365294592649, -6.074953904074475},
    {-5.98178710077539, -5.76472913611227, -5.634524075855722, -4.5095348534052695, -4.468311466595719, -5.91166357076621, -6.132299838767425, -4.644734077726735, -5.7112793774106425, -5.596733620300488, -4.951485697850366, -3.939800978512771, 9.082659594688451, -4.695628702869051, -6.04477576244987, -5.015499585320098},
    {-4.7939390576927154, -4.561358649260989, -4.158733947017705, -2.4410529747125476, -2.749103173394175, -4.357115403447988, -5.019741727245094, -2.9065743091248994, -4.4703360164852555, -4.007108354438746, -3.972369908718465, -2.466038767729003, 9.177315966071232, -2.5862877812283633, -5.1579334031482915, -3.783752679897604},
    {-1.4337996036465428, -0.6787922507397434, -0.6567125500155586, -1.414474355314285, -2.307655387739925, -1.9714081425129681, -0.881141329388813, -0.5668406387846622, -0.5161666823907248, -1.9502296525494278, 0.045563407680637526, -0.5346006734469892, -2.3229489648828183, -1.2655587973974816, -1.6191742242311222, -0.9010593239346116},
    {-1.561016035784017, -1.8310309941340375, -2.1387163085436973, -0.9519918930017585, -0.39933021863825857, -1.2758770925116165, -2.397073836360499, -0.6917496626669951, -1.9608939095425892, 0.1229432918989981, -2.0775537803059687, -0.5834559347455021, 5.961166893353379, -1.1521247481358343, -2.2423441933600103, -1.4981511127153215},
    {-6.8069937419878395, -7.239951446325424, -6.359645927423435, -7.173812535355094, -6.853524121060949, -6.864944625809771, -6.793631269357142, -6.619775705782266, -6.89136518301792, -7.119886579284077, -5.7927682084274235, -6.813221499684006, -1.050205810603687, -6.862457457359457, -6.7229635572025215, -6.586570567955215},
    {-6.099889978750599, -6.06123597888671, -6.33124697293728, -5.4811116006947245, -5.7322350511006555, -6.063052806485792, -5.832466027716162, -6.441946874861758, -5.629479946548447, -5.646427033128355, -5.7200232940307565, -6.435402000267441, -3.2451644446259604, -6.339809970703591, -5.746697748860634, -6.552311870312381},
    {-6.523838945694388, -6.74156706004123, -6.474278014618136, -6.491100365763629, -6.606537281310981, -6.873472320609309, -6.822104872910362, -6.484484758645038, -6.399133259485124, -6.511707571188622, -6.3312869806315435, -6.494299342501294, 0.8664281724739273, -6.490529740380331, -6.778105775118216, -6.473041980313933},
    {-4.998005095500574, -5.2958899547805665, -4.7401873846345195, -5.328553235753597, -5.015491056313222, -5.082924779371264, -5.506998801400967, -4.856033722146315, -5.292714139537995, -5.247301077336386, -4.791823270905465, -4.800183750813583, 1.6328320890298988, -4.98227603135563, -5.141976099133832, -4.913989574181778},
    {-6.268651584555774, -6.388109300564644, -6.034367101142622, -6.2883988959087995, -6.111670192180165, -6.389206115039782, -6.607112596068549, -5.708119234447338, -5.861043776673591, -5.923850227835682, -5.845945429566197, -5.903292875107188, -0.02043601918185382, -6.027946000867577, -5.8761181792989134, -5.744631289627306},
    {-6.257574229297075, -5.933856154913782, -6.262364527908726, -5.128485149093458, -5.344516152261084, -6.278872105343028, -6.238361795330993, -5.360817089957787, -5.112531674159927, -4.801045768666137, -4.914704432638119, -6.364974842882432, 1.5057842959836272, -5.780403628609766, -5.608029186250175, -6.055014949135497},
    {-6.515554765139672, -6.873932162117751, -5.982465326716719, -6.204827942336203, -6.301339275463492, -6.329671181317451, -6.78379138351112, -5.3317630601267565, -6.142141049578244, -6.254248377960076, -6.357409066070742, -6.340838920787054, 1.199176900574796, -6.503033701665529, -6.19131254842881, -5.883738094862509},
    {-6.634500919873135, -6.6804722128277, -6.286581605232658, -6.395700167389069, -6.3597545659893235, -6.519348002775911, -6.994196853811633, -6.0001514079285325, -6.589507358524871, -6.702374771269516, -5.709113661741054, -6.451460057578441, 3.2525470469455033, -6.300178314930674, -6.421288315952542, -6.111405449125243},
    {-5.706212010624011, -5.873373621310329, -6.059069392284185, -5.651277242889115, -5.968419499616896, -6.213486786470079, -6.199651287671835, -5.844037082204024, -5.495154396482723, -6.000140074129097, -5.7870422800377685, -6.302931295202475, -3.837167221624428, -6.131651129514133, -5.896056649317056, -6.201158389436899},
    {-6.1999951469877415, -6.529402658326144, -6.098842280300104, -6.090503895988346, -6.5665932603099275, -6.514716540334262, -6.582355066705431, -6.01682832298583, -6.376339954985823, -6.33890139999716, -6.033122607724199, -6.325363774596761, -0.4991942309787095, -6.332948571436186, -5.906310650371848, -6.483489165360102},
    {-7.242946585517159, -7.428106261564908, -7.239950747496419, -6.962159275804966, -7.1514956549744, -7.141307971978516, -7.4194426205348485, -7.317347741484972, -7.507071853419813, -7.50836186305952, -6.688122091916284, -7.22034012374117, 0.36894236821899223, -7.292163030637241, -7.250157400237121, -7.251074524689533},
    {-6.896220569650741, -7.121425119534231, -6.818382692484256, -7.123888420787264, -7.037525774963577, -7.124120895553512, -7.3306111294978376, -7.090130041314204, -7.1621129990921855, -7.109552038973353, -6.591600275670069, -6.965909225338683, 0.6710836209226458, -6.910144159875839, -6.643965870985067, -7.145073138711947},
    {-7.1983546610134175, -7.649698489073076, -6.853838580938954, -7.694635446001257, -7.258107176601144, -7.390808448211479, -7.441271717719343, -6.743760944575034, -7.06056448938705, -7.386425221882495, -6.0819297504646395, -7.303378784021114, 1.2099193517483355, -7.321529030306212, -7.073689334451048, -6.663936009535695},
    {-6.25087416929258, -6.530194758559589, -5.893473560019375, -6.872146083716096, -6.5336768940623715, -6.38291109414538, -6.775922400574075, -5.8339470967551454, -7.082246357147389, -7.020117086116528, -6.206128247247067, -6.231503365089676, -0.058254548804321134, -6.258477496656026, -6.08747506443997, -6.119697471834917},
    {-5.856148611431615, -6.227103474685919, -5.865307251730497, -6.0430014644854015, -5.3050339224853245, -5.829147305384005, -6.505216443259339, -5.914371921291035, -6.223076452551345, -6.015057422167994, -5.6890398228888595, -6.035352977372591, 1.4315310645560502, -5.682359980265196, -6.075065333761078, -6.145798116041758},
    {-4.837519136978787, -5.23927838238761, -4.674209882699057, -5.291403126800073, -4.463797204284599, -4.5327636256733514, -4.961732469921984, -4.2460340315534495, -5.603338842670077, -5.503533063804535, -5.227936971107984, -4.759034550056227, 3.5332591517988807, -4.0923911141474205, -5.0767865445195275, -4.860309248525193},
    {-6.4159576833731276, -6.613297293172108, -6.634176646631273, -7.2515271321128925, -6.983969432508715, -6.797181206309078, -6.633509456713333, -6.960144081130818, -6.827805075521135, -6.939547926009695, -6.487712607506262, -7.099111135894973, -2.0450928985168404, -6.8319764742479165, -6.41093860745873, -6.907094308409582},
    {-6.5063724954915365, -7.184879974560021, -6.583668705397907, -6.79404909468206, -6.981971878936901, -6.88019409620078, -7.109523019215182, -6.405312482468233, -6.562135659508153, -6.970370655080853, -6.0103860133877305, -6.665109312046719, -0.5761649484566518, -6.6436103324005185, -6.702544358083804, -6.731575476192319},
    {-7.820139579433643, -8.032505537395732, -8.032297693888449, -7.8765457070613305, -7.92030994035901, -7.953547069572977, -8.248900784624698, -7.720598944229388, -7.776369257280244, -8.179202931934997, -7.426222093271863, -8.220763172232639, 0.8343677751322939, -7.904159176266484, -7.753938437363816, -7.8249716954511355},
    {-7.10410930684815, -7.748994805676103, -7.335627712619287, -7.647205954112533, -7.428172229266204, -7.432613838294182, -7.503490322210969, -6.755433746399496, -7.856739901669253, -7.597415943258126, -7.348958463535022, -7.288477238116044, 5.8786268107530475, -7.38164894374703, -7.245584518222243, -7.073970494556848},
    {-6.591789323612854, -7.259052206647698, -6.676506982105873, -7.684977988158259, -7.531859469673317, -6.644300103638415, -7.278735430789034, -6.048556157126637, -7.357751695571824, -7.778197470561541, -6.012270299308182, -6.7387594169511145, 4.5490564838454395, -7.050218378745718, -6.5386159396932735, -6.126830440360515},
    {-7.738193459085759, -8.194476260934168, -7.7250121304786905, -8.265242979303972, -8.061417742573484, -8.211711245055236, -8.048245088381105, -7.206904501768462, -8.010413070668589, -8.127509476948402, -6.746065801611083, -8.124048137209533, 1.6100296553520126, -8.012182753743163, -7.654689349996165, -7.798108302827159},
    {-7.262303366036023, -7.6167560488403465, -7.2252728964618465, -7.968456592415475, -7.784917568184617, -7.7781633764057245, -7.650778726869724, -6.846304446560038, -7.744877864131487, -7.740450764403101, -7.144839979550985, -7.392981580235002, 0.44130321460989974, -7.6963965789584154, -7.556454497529255, -7.32203736274061},
    {-6.640394712410776, -7.457953624218038, -6.814038806736816, -8.088038985497612, -7.616971941393802, -7.080852304945871, -7.196842163928849, -6.740495662608243, -7.577321386392838, -8.120570752551435, -6.919785414228817, -7.189719129933702, -0.9515195339478395, -7.40333877810705, -6.821587143852811, -6.923809346680102},
    {-7.253311768312167, -7.643863741049345, -7.165558449667348, -7.988449063110834, -7.789585309719611, -7.570850795195771, -7.844047865556152, -6.911204838762782, -7.803483906475465, -7.943025096223417, -7.045353654029636, -7.250752077482024, 1.9939612089475838, -7.562270225169814, -7.406134390353049, -7.202214677960296},
    {-7.141205488131998, -7.447537941918004, -7.45962420651328, -7.667060896902678, -7.65293310275972, -7.6207862945150655, -7.383760248199375, -6.887400226529303, -7.763647561654015, -7.542326008611004, -6.9116192687274935, -7.175100093797256, 2.8972254763268763, -7.424134227214239, -7.299082137464992, -7.210524953025911},
    {-7.083980755025162, -7.7359400940459295, -7.270398789298723, -7.937920308197611, -7.7255068541172385, -7.275665616939935, -7.546136929267232, -6.930062941536252, -7.9337381333986725, -7.684087572719667, -6.885402844843176, -7.216606054834148, 2.6745309877501824, -7.3647794178054955, -7.0988040020529874, -7.228901078126439},
    {-6.4604413401717045, -6.9926925579882235, -6.543584386521167, -7.525091921276074, -6.924540566512858, -6.469198730138537, -6.6952304965690645, -6.051655290597907, -7.036768016895265, -7.29308758346865, -6.1541101209930735, -6.090290485060945, 4.528984539697932, -6.730413410932117, -6.150471973658405, -6.0932573220555035},
    {4.6392356510698205, 4.281866624849325, 5.580048123855436, 3.0119302875205367, 4.022854239356672, 4.8962469075494806, 4.447287600799572, 5.35252508672077, 2.3221182882487215, 3.1124750011252145, -1.4574632210493699, 4.761874556488978, -3.8818845079288535, 4.5963120401948485, 4.750573198864355, 5.407872340361557},
    {4.994741168154145, 4.2647561487694325, 4.970105709547271, 2.1987066940249926, 3.3107947896036496, 4.555765344003511, 4.282689756128811, 5.159373755641584, 1.3127368729904996, 2.077120822003648, -2.9812876493966782, 4.398700982019362, -4.266783335264726, 4.430125610307693, 4.781948764863018, 5.0017742125284155},
    {6.038366097768076, 5.064038299157118, 6.229869694147413, 2.3364148373639346, 3.923500453440756, 6.069436485939356, 5.4947417801531016, 6.50800966122519, 1.4716706861421343, 2.3636010834209906, -3.874267689321072, 5.932451079413211, -5.332865925982104, 5.522974954010324, 5.851677715773623, 6.234914810805425},
    {5.963389831087019, 5.402845482116768, 6.325950417010119, 3.117954942363041, 4.883065462320122, 6.316569829782075, 5.92693775117537, 7.02646271957315, 1.791463431512655, 3.0284208759196303, -3.621965663051491, 6.3520896999165375, -4.016334036232505, 5.835734136047641, 5.901080255975511, 6.597377563673298},
    {5.221302388211056, 4.540629268368707, 5.727065100059645, 2.4465358887489677, 4.0453008175316745, 5.615414045342849, 4.829677373795257, 5.926820088615976, 1.8953033211090045, 2.565463633998951, -4.1891759603237615, 5.8633061861002895, -3.3635135549403326, 5.218933465828143, 4.529389450346031, 5.630865395780948},
    {5.440038382205089, 4.949000929474052, 5.806544465776687, 2.5523170026374684, 3.9112863276973906, 5.612447326254648, 5.091473195149936, 6.228503082798571, 1.7961818505120224, 2.4899493540643673, -3.9558629008884902, 5.849739590036562, -4.07533219728738, 5.397907118759723, 4.936959824947462, 5.81290177566611},
    {5.930606151656059, 4.80242966734435, 6.201956552036113, 1.8770720380133696, 3.4189138540465374, 6.046403384817369, 5.449635433415574, 6.791561628083313, 1.2432540469078406, 2.0671645510703525, -4.2487430625950235, 6.056815843807217, -4.4286173839292795, 5.375781958867803, 5.388719656175225, 6.082103231623693},
    {6.058094994122493, 4.956465746228769, 6.573098903705423, 2.678343800224402, 4.144532730222646, 6.181431266607931, 5.721864116951122, 6.659328253150459, 1.770365679637653, 2.6987603585039492, -4.069141425220739, 6.238934157612644, -5.529008458690384, 5.826608675784252, 5.676015268747091, 6.799348119025239},
    {6.021344886578527, 5.049335577496061, 6.612037048545852, 2.722924958166414, 4.368995419622797, 6.21778009554148, 5.740622195540293, 7.042511668824883, 1.728236825235005, 2.935620059237773, -3.671404075809549, 6.148856278148406, -5.34573702182916, 5.499747601867593, 5.652699677897282, 6.7758938575574685},
    {5.515269765445685, 4.000586547685055, 5.809030743732632, 1.5461659131722236, 3.2317413875431225, 5.459608533591025, 4.893922809612422, 6.567180375772628, 0.752492186377111, 1.7574294487761581, -4.799922348356993, 5.322629817548085, -4.75777078795235, 4.82816029959756, 5.169618103304922, 6.272195035178786},
    {4.802584077299578, 3.9469994988638324, 5.483669036964167, 1.2541536935479727, 3.3489595216902117, 5.247551048629172, 4.403429640173715, 6.316686044797101, 0.3991687445482242, 1.5665364000577977, -4.844817075049687, 4.90113657850763, -5.07708770352386, 4.611531575477508, 4.886666756614799, 5.816139550375104},
    {6.170872470507261, 5.113770519421844, 6.936421228742859, 2.43979825265956, 4.450917041301433, 6.301672310567423, 5.946292923793204, 7.038772125099221, 1.4226955535225783, 2.691496021178437, -4.876578771080061, 6.279845416376509, -4.6447039304355675, 5.95425388599925, 6.277688146013811, 6.722514674935509},
    {6.054311976137449, 5.024091597224416, 6.5364405780263075, 1.6860937611338251, 3.490819069619964, 6.385110137143567, 5.598183780322343, 7.109001241658667, 0.6838708094880888, 1.72250639892321, -5.460466254751575, 6.2719887881885645, -5.689716720121735, 5.653612604487438, 5.786402342067397, 6.841497545957059},
    {5.461704014451199, 4.240990306231289, 6.125950052135575, 1.5868237486590941, 3.3232932853719253, 5.94966330331574, 5.34265492559011, 6.575543798985138, 0.2171463156368506, 1.8595565768820124, -5.301259569582513, 5.503219062934707, -5.221239493626986, 4.889171088969533, 5.355317999814864, 6.213973395620671},
    {5.689914385884836, 4.518705556652896, 6.242219082089077, 1.7694456051980376, 3.7711968021099924, 5.858519767505216, 5.326740420242953, 6.6607547617437515, 0.41713801585503163, 1.3943455769705868, -5.148648510659001, 5.772103441853525, -5.514999951677872, 5.39864087915442, 5.391693662340159, 6.439301890128515},
    {6.206582565712653, 5.458363043254065, 6.470437603907329, 2.32276516452921, 4.371457340079455, 6.447116166035419, 5.932982096447396, 6.8469076056042155, 1.1367450221137227, 2.071647908746817, -4.531036949396989, 6.277579427136302, -5.116370031619464, 5.888174497995593, 5.888750347906065, 6.85810872618519},
    {6.301510840975477, 5.708946004887645, 6.616606959439815, 3.1836803604079233, 4.752631053675775, 6.578428708012317, 5.821749687174097, 6.97771972416503, 1.907978816130396, 2.738129744036466, -4.086878609900659, 6.6174545695074425, -4.25115174166415, 6.1799253407936625, 5.803643428303007, 6.870791940336409},
    {5.968507219396306, 5.120725237952397, 6.603745361041978, 2.2339476783942365, 4.53058985478391, 6.224328399418084, 5.785356666961091, 7.169144710500676, 1.1805751713645585, 2.3724710272919314, -4.93402506604971, 6.70587512647445, -5.602010701361875, 6.0823079436935545, 5.569529503056674, 7.018845262109701},
    {6.048001000231118, 4.377151324290303, 6.625218340802823, 1.5804739287351763, 3.775850937125286, 6.108741739380853, 5.216777446466112, 7.296824200507719, 0.23509332982680012, 1.6425831532448023, -5.424417498207533, 6.4360395568142925, -6.082943599974775, 5.766789072707227, 5.545026785882291, 7.000300371699708},
    {6.329908809769404, 5.383280892811109, 6.646721244462178, 2.3701756325028285, 4.1876529444011625, 6.442764008529617, 6.101264297027827, 6.849723379314989, 1.1617611653003777, 2.5062203648009445, -4.7361091284148875, 6.43168375954608, -6.020746792028076, 5.6345116459125055, 6.1599665589978425, 6.858417960714996},
    {6.019854520587259, 5.11782016855903, 6.403307535059504, 3.378490228520629, 4.5682508994095805, 6.2685122518570005, 5.872471464296341, 7.112212548370003, 1.6093305651281857, 3.1330471553820614, -4.390513152414903, 6.2952375081263705, -5.6216146754442935, 5.848009809340578, 5.955556450629617, 6.843167872895082},
    {6.3293617883530136, 5.4027887915587725, 6.9728324651045686, 2.7509153407171896, 4.741091664680561, 6.462899798576942, 5.848820554111258, 7.3054235696631205, 0.9976491629680567, 2.438433153505778, -4.796955365517436, 6.7791684839403095, -5.806960366107906, 6.131221802995608, 6.240799564055003, 6.984371107110145},
    {6.3057642734542165, 5.200723366401998, 6.765978121594741, 2.0951863368073727, 4.317936344588472, 6.636386162614626, 5.935902080741323, 7.233897212499134, 0.5669966823958249, 2.309345211744713, -5.740204740619169, 6.6690780136894885, -6.687742072651887, 6.167412846545797, 5.977660475817552, 7.230379091488547},
    {6.6048087849041215, 4.9390906942327515, 6.698249485673381, 2.2426970548703937, 3.791716479522083, 6.533229137865892, 5.764579912645393, 7.486898444853191, 0.015847670569456632, 1.7506482308522933, -6.1232997532694355, 6.72472969057474, -6.7373528653917845, 5.783696966701293, 6.249680682686778, 7.1749182468556985},
    {7.006789718465416, 5.7233066328897655, 7.383582072531971, 3.1264776695645664, 4.845203629470806, 6.970023190660883, 6.162347688902584, 7.589535042626493, 1.2152182320847398, 2.7275446670503563, -4.917806701376851, 7.049253061880663, -5.608674869676664, 6.593758391642429, 6.728584690372175, 7.295057452592403},
    {6.842579962787904, 5.653216055866748, 7.262598466157048, 2.1809738176022133, 4.414110040706203, 6.810667038172695, 6.487431786247064, 7.449985138734024, 0.249981697417979, 2.24264840617388, -6.320418687057017, 6.765364344880549, -6.549867912777981, 6.186824935544996, 6.581128321013545, 7.326876663452796},
    {6.7452167184129195, 5.11654254626798, 7.057036074798642, 2.5643757472281288, 4.284594928960095, 6.734468403982016, 5.999920637989173, 7.407494110657533, 0.591155563076543, 2.269740402351342, -6.2159477544384565, 6.540348322102062, -6.413491869451199, 5.925376155232927, 6.356126024673911, 7.2098976591991075},
    {6.425517408854314, 4.7631176075856025, 6.790358950692302, 1.5221074832876904, 3.3632579025247256, 6.446933931035151, 5.560181530282314, 7.283401646273123, -0.007061098819505435, 1.4969600969331374, -6.073941329522626, 6.307860710059034, -5.655013621978306, 5.415948482329552, 6.005425783894757, 6.753114960943498},
    {6.458869510082905, 4.861872155662665, 6.938207175222108, 1.4287420564821345, 3.462164771184513, 6.467189136539962, 5.746117623620194, 7.464131774996145, -0.2871762035418546, 1.6407302487952173, -6.218792637446055, 6.7724999388538425, -6.034608130897317, 5.906472258104892, 6.0673614725143885, 7.267203943501498},
    {6.6398171140041855, 5.571225296248643, 6.891684275826058, 2.648096764868737, 4.543207050895253, 6.900783866075364, 5.993586771168778, 7.403132267931652, 1.2766797655208828, 3.01469825477499, -5.4678459427584185, 6.943464603734086, -5.772057836512895, 6.358628854802942, 6.5341442820624005, 7.128883050119264},
    {-5.1073013585663665, -4.571099974348747, -5.14125114703243, -5.24917230775956, -5.256012747818258, -4.8953210436442145, -3.921248008866013, -5.239246408912569, -4.07408001210109, -5.422556520939891, -2.3164774582932255, -4.9826944391641135, -3.979314398405449, -5.51329702010999, -4.42518033160351, -4.7632228528611025},
    {-4.61521793641496, -4.646933231242203, -4.712800459865464, -4.851602241756963, -4.300397993744859, -5.061895865794936, -4.591950734217299, -6.04194890174038, -4.482176511352803, -4.2512237195137, -4.389065749518228, -5.886538748989939, -1.2078649020686434, -5.576218147549923, -4.69208903944976, -5.162173173755221},
    {-5.4321824603664295, -6.022243950473476, -5.474706964310048, -5.308066804111532, -5.851490586762085, -5.919331186045476, -6.048438620937202, -5.60625309413205, -5.2791010601507855, -5.962334987603459, -2.890767010587245, -5.6662424413649655, 1.5646767755231763, -6.010335711815689, -5.3266201469344345, -5.4617467007152625},
    {-4.821915980066433, -4.947169083841901, -5.198918199929333, -4.161151397651913, -4.82288188093802, -5.1099292050222065, -4.832455960308986, -5.2333730622867325, -4.018948213303265, -4.337640853671337, -2.916984887493908, -5.321981446490438, -0.08086664986729328, -5.156040924956786, -4.3002732198799425, -5.373325687196477},
    {-5.4221593305832485, -5.801938044038865, -5.625086251454208, -6.047901292418479, -5.659961655008489, -5.563902700802211, -5.321995386655774, -5.20455928528151, -5.694419107299195, -5.660225359737738, -5.183747817225874, -5.614989237581453, 2.5686263793255284, -5.376546800980983, -5.471178075334658, -5.144506872215584},
    {-4.418806088052277, -4.805502108025875, -4.218801127301495, -4.627316471653486, -4.496021302635682, -4.459462041291484, -4.450729665244743, -4.387535310804569, -4.319016832409178, -4.357808616988907, -3.4578089090984245, -4.9539381849545965, 2.2235237708122786, -4.51032652768083, -4.33074112496183, -4.650039464603478},
    {-5.584403038926688, -5.36992672485391, -5.4890977959586, -5.083803245840033, -5.373038822727266, -5.48005593667087, -5.4159026678211255, -4.803505214928063, -4.8270763270421, -5.105360730812509, -4.6640769204002845, -5.5492438307316165, -0.12028125844421367, -5.465628349910246, -4.917588080675068, -4.906994297614327},
    {-4.430197099856745, -4.119856713073275, -3.9944343896010066, -3.807347236938723, -3.7147166316333498, -3.9884000127228707, -4.107395036397364, -3.7930922415972996, -3.2427259418224628, -3.335152793728224, -3.2613898403692185, -4.530514512554699, 1.7909882908862673, -3.9230059639773978, -3.938448881994961, -4.194617373560107},
    {-4.871473331723062, -4.540914193844252, -4.393779625412082, -4.55490576179997, -4.570605438385321, -4.637837833990128, -4.845531942242443, -4.130242651035285, -4.01718607812147, -4.240155737365515, -3.870187747089443, -4.809060811595313, 1.7026743106702675, -4.473255293504883, -4.230179273900068, -4.216745091206712},
    {-5.548785566887093, -5.469197605426314, -5.387715724218704, -5.624811484923058, -5.358530322472172, -5.528470519413158, -5.974729225142652, -4.520612665420158, -5.251826305520257, -5.815465416658758, -3.6791287054697643, -5.0760780341696625, 3.8114966268946553, -5.123239272704285, -5.198895432597532, -4.911901232675134},
    {-5.11440066794424, -5.088658417238141, -5.272204356651063, -4.596738363321084, -5.1577307682516835, -5.170514497967423, -5.074116451756498, -5.100984811192353, -4.658711740278088, -4.857322876536971, -4.103589859941436, -5.730054468237007, -2.956726060114283, -5.455198867907795, -4.793848477435435, -5.1627057641940794},
    {-5.913038310830127, -5.898468599471874, -5.7626071732063, -5.859550092342554, -5.73540011445122, -5.708950736271077, -5.949529756609279, -5.365389249380114, -5.988386869274763, -6.0756616883286485, -5.116873403433757, -5.772000187591301, 0.4050020192088816, -5.96204100090778, -5.125516614671896, -5.508410659012603},
    {-5.984511563538406, -6.40850151924059, -6.255700366872098, -6.148568630722948, -6.150992914336564, -6.205950243156327, -5.991680606474341, -5.4962065574635295, -6.406729324888126, -6.497883140032259, -5.186439551393543, -6.14206322452267, 1.1865311930480353, -5.993688159653651, -6.019998969920239, -5.942617860618371},
    {-5.395491790090053, -5.773349094041979, -5.178360527390353, -6.209968063510025, -5.9258870788397875, -5.379009470425535, -5.782678910312444, -5.286007813465631, -6.126547719540004, -6.265529693111804, -5.0375600709422175, -5.530403902899999, 1.724052291781576, -5.5282979817073725, -5.071456468206782, -5.434384849391286},
    {-6.188283169685122, -7.1193141307532075, -6.343822113292637, -6.7997403614737655, -6.844751119465137, -6.747690068568693, -6.966030027304797, -6.051376934565194, -6.601231604368207, -7.306067821706686, -4.661057798052144, -6.24252310447122, 2.2713041364528666, -6.721630295287555, -6.3404405890955715, -6.062838283457345},
    {-5.12811336193908, -5.703057512966115, -5.2465905742628935, -6.409305577429566, -6.108786686975385, -5.320509216793844, -5.784730553320106, -4.911532577220199, -6.370828366622694, -6.513128463863118, -4.688603223364543, -5.233081771180072, 0.41430481771103134, -5.782737970877843, -4.75337539084783, -5.1511217036228745},
    {-6.402415703045354, -6.289848165761212, -6.054770872629183, -6.636936671197213, -5.986445414892256, -6.004681446379349, -6.447005801110151, -5.8843833298075, -6.148621616514825, -6.671364838848268, -5.176435941071815, -6.052781853317112, -0.13173989187265378, -6.214318927294579, -5.810042485417929, -6.035786080073993},
    {-5.8173672287754465, -6.410911464231253, -6.01989274903282, -7.321423724026121, -6.6039765194243385, -6.17838139107064, -6.192856310843839, -5.47286193650308, -6.6850757270559225, -7.247785966384498, -5.476670717769413, -6.1613084274660554, 2.3295047427196542, -6.16242590239186, -5.8161565152144785, -5.925935553550433},
    {-6.102384308508922, -6.362138223128526, -6.037168379113052, -6.888149160536593, -6.790910511365061, -6.260250139264328, -6.094309002324019, -5.923074983216433, -6.393344972178726, -6.72643289043413, -5.272481002406981, -6.199736007285188, -0.2873680699218204, -6.208212222570281, -6.102541369996725, -5.903141540998954},
    {-5.390456344165117, -5.9903958773456045, -5.671609686894982, -6.427401084753889, -6.291284567902604, -5.756800259663809, -5.754323220392113, -5.186982356801965, -5.756882450830252, -5.99122201193739, -5.242000927684198, -5.826667400689629, -0.9118714681694466, -5.8617705870904, -5.597756583798434, -5.5004333530141425},
    {-7.440812716109832, -7.636223113806286, -7.36947382592871, -7.648564443770939, -7.473508079086316, -7.279623329419992, -7.716353794145842, -7.154787145015883, -7.096890215007436, -7.504842801970879, -6.546271027975667, -7.418346427385365, 1.1722343276007858, -7.376975999225969, -7.106554470530232, -7.351481445919068},
    {-6.7195006388719865, -7.537176656387811, -6.940705227593431, -8.307293083836065, -7.831082076592447, -6.84403085770921, -7.468530823438166, -6.060440026217879, -7.532857120114196, -8.164808110089867, -5.632215829443344, -7.357497523020508, 3.4857398112469657, -7.4298977069114915, -6.7683568916591215, -6.39408923920513},
    {-6.409162822190838, -7.3550668683457525, -6.192832815064056, -8.080206207505222, -7.7301848639126485, -6.761437476982853, -6.665007002997501, -5.778080359915853, -7.4847926803688605, -8.174024169271142, -4.363181841187464, -6.948347069529634, 1.9844479965093655, -7.100091820441465, -5.752475441407728, -6.002735501058476},
    {-7.467931029533991, -8.007988621050607, -7.253590234804339, -8.324148098058155, -8.006333726884767, -7.431112764029693, -7.414511837225393, -7.0130097914379705, -7.822958466560864, -8.477479295922661, -5.605308401331444, -7.526870438245498, 0.8679956891533577, -7.598397713851076, -6.889040839045401, -6.93926447296319},
    {-7.1490532361792765, -7.5276596824641695, -7.009386158345159, -8.140818242877746, -7.907372337861125, -7.034287017269123, -7.5671103022143, -6.807800303085982, -7.514757975167444, -7.914384392792035, -6.599689598761383, -7.237302583583639, 0.10425645268891794, -7.405479252882843, -6.864483745839249, -6.817870638369796},
    {-6.441511840221107, -6.963908236338242, -6.326629149311156, -8.18974321544359, -7.558145727363169, -6.475859691495322, -6.607334284473065, -5.918698241917358, -7.350731732445859, -8.154267135963645, -6.208604301183365, -6.577748283622011, -0.654003303638526, -7.109396831118886, -6.410148259907273, -5.776272713285174},
    {-7.117858448650522, -7.6874733506865205, -6.997468682593979, -8.673462792336029, -8.038271979286353, -7.500931211626441, -7.495524876622061, -7.060800501796972, -7.87902030992668, -8.510245317123792, -5.616313617983385, -7.5681112276246765, 1.5360134063400348, -7.900202705684371, -6.8371153839778716, -7.079434216683496},
    {-7.182225950875092, -7.667483285412743, -7.239825820817495, -8.364293583385454, -8.195966620154802, -7.70243480304674, -7.382920103773354, -7.217192828501808, -7.7960871128168385, -8.136853757695542, -5.885943544047212, -7.455516773554613, 1.784337395111506, -7.978769552978205, -7.106367596278164, -7.154698403205062},
    {-7.245958677283324, -7.771310621584725, -7.178891780268986, -8.449348508097376, -8.235004461734619, -7.455206442942966, -7.436506868835451, -6.647711245597969, -7.825036282037404, -8.511337957493632, -6.181756187757077, -7.543493862097719, 1.377929780293168, -7.75616932410145, -7.087377376403822, -6.774258629984651},
    {-7.129604961553557, -7.692861742575518, -7.181631085410341, -8.311253883008568, -7.966768206410737, -7.054618755715888, -7.512470772552141, -6.718005867970581, -7.693898975121429, -8.396988156331153, -5.573832496261375, -7.411192849321164, 1.0610216815856517, -7.792498964137607, -6.48941789769296, -6.8994110104391275}
};

static const float b1[16] = {9.342842101178304, 9.328526942153307, 9.387130070497602, 9.504847132322388, 9.284185159356365, 9.404850788435267, 9.435473802645173, 9.44429337765439, 9.20978956654394, 9.308819836785942, 9.605500816620363, 9.394097956130977, 10.098542920096335, 9.394407419902898, 9.505765284143575, 9.374737185806932};

static const float w2[16][12] = {
    {-6.777597773104547, -6.1396927437640425, -6.428847767951152, -6.541092638484156, -6.433388350905548, -6.851748738717703, -6.419442751568411, -6.6078861492811045, -5.998940178419481, -6.614920256566579, -6.942329749016375, -6.0344421830474575},
    {-6.202997819812208, -6.904503452699936, -6.629595621534319, -6.132971968121768, -6.527345789820378, -6.7081035132517, -6.116982369121908, -6.463400025646498, -6.703856835455414, -6.422508225204815, -5.992233347534848, -6.062193644475393},
    {-6.569381540418438, -6.495081755991977, -6.031227214798615, -6.008658767924393, -6.748214300365408, -6.8254851482805705, -6.229582096551762, -6.523442885181424, -6.7208410465670045, -6.2819811271182635, -6.280538463714901, -6.78960203704002},
    {-6.6057988643836305, -6.715219118776712, -6.588772208637847, -6.843433354118559, -6.752175949994228, -6.955178109903935, -6.8701323172155115, -6.1738410971892455, -6.743214914072372, -6.13379250389247, -6.266247541915166, -6.803804498753473},
    {-6.528262815431346, -6.555830307332464, -6.155020716149446, -6.248386156683469, -6.7733761253523035, -6.24305864908646, -6.824144668164073, -7.133008782231481, -6.546610845065439, -6.7172257499375645, -6.886947161979591, -6.360229690970506},
    {-6.035769676811563, -6.750026040152454, -6.472007915569012, -6.807888637730683, -6.376085260008226, -6.259985943471846, -6.840871917792059, -6.456052998781963, -6.486417981967987, -6.733941135555668, -6.9353913843367065, -6.159553581869185},
    {-6.438777289794692, -6.532081739011792, -6.09158998291134, -6.655885716338564, -6.290372057352221, -6.306744564836492, -6.618665963015663, -6.193731610372846, -6.475362415192408, -6.123136193522015, -5.984073354406899, -6.6804386460401295},
    {-6.28050951733185, -7.09550191327192, -6.818413676261033, -6.445240324004164, -6.3540673052169465, -6.5669911238407845, -6.629309572783881, -7.026970263773085, -6.741885844172656, -6.290328864470524, -6.460492826687738, -6.574491801427785},
    {-6.738085711881138, -6.391146953171305, -6.701699670140595, -6.713328370235661, -6.4472389923283115, -6.0910143770437974, -6.603508855291561, -6.639825845502945, -6.041459926912448, -6.360877760230968, -6.394986012954615, -6.564847586582904},
    {-6.253430600868412, -6.41305978138109, -6.393441279267948, -6.160231804647716, -6.3123039531835845, -6.62582414635837, -5.955685402888564, -6.3453229312055255, -6.686659165969651, -6.684861007819528, -6.763323099903815, -6.038211090036647},
    {-6.75204283918636, -6.99574369293699, -6.7973690493356616, -6.731051809898684, -6.737951838306001, -6.876299169355187, -6.900480854247167, -6.960354223582256, -6.992808220274143, -6.903999924507672, -6.8812266487285685, -6.93312646944942},
    {-6.783731980538898, -6.643491307916748, -7.0874568950798835, -7.037883644118854, -6.728742175771525, -6.457972685082355, -6.372862395393384, -7.068736830888509, -6.956801861265681, -6.501276167421516, -6.543366340480798, -6.840763179186335},
    {-8.520344283757812, -8.397538299993382, -8.485513376150497, -8.532748247684003, -8.591756168803402, -8.433139289977406, -8.429771642821773, -8.40296830036434, -8.402515343297532, -8.4293419508945, -8.431527392037195, -8.410625293637588},
    {-6.824457347664531, -6.368865997355895, -6.428109018106272, -6.56942778902244, -6.175192875794407, -6.847272768865946, -6.625989572956213, -6.105400909548423, -6.240048050634534, -7.014850029316291, -6.993379832468916, -7.108200107824967},
    {-6.536357929819177, -5.911168012072624, -7.056736158524821, -6.696490497604765, -6.731611448097656, -6.11702794772683, -6.598854099313264, -6.70401720980389, -6.40337989894623, -6.729998661322067, -6.481540168230545, -7.145409000593678},
    {-7.028755820617614, -6.561373457154749, -6.680972424447726, -6.714660634607553, -6.9165483109710095, -6.621263171659017, -6.843155594571895, -6.08050170525462, -6.691868586186862, -6.841006954442644, -6.592985606211614, -6.317868380234251}
};

static const float b2[12] = {-6.462432979292009, -7.479417484413313, -5.626254776290218, -6.93404786753306, -6.717128558239927, -6.356486614309923, -6.382304790810316, -6.951090714743802, -6.548375472912273, -6.771277006502345, -6.168657339599976, -6.821813577317758};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
