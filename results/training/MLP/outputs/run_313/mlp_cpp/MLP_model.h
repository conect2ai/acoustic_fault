#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.2481923882672053, -1.622917785314951, 3.051839057086284, 4.423884254260473, -2.0362017440696762, -2.0071997263385337, 2.1783465502290267, 2.6922857836846066, 2.1985414011912683, 5.209360694663297, -0.2451407427281352, 0.13814669449656883, 0.20144247581369065, 0.5287810774066756, 4.943526420187663, -1.0528876461418881},
    {-0.7495384007461451, -3.1716153444492914, 4.085398380574782, 6.468966368131431, -3.1266803168616555, -3.0372359335643613, 4.483141848578612, 4.817468336273222, 4.7974276109740375, 6.164146525748581, -0.36984377301053384, -0.6673101262198432, 1.0255523266145492, -3.1462439273787886, 6.588400735731942, -3.7133127255870026},
    {-4.315837460060013, -6.588890530864783, 2.8597484953469303, 6.45546625506064, -6.216938391761937, -5.807769701238284, 0.8807205637106892, 3.020409902307568, 3.481231989880738, 6.283960035158171, -5.137085780132117, -5.402743278161477, -3.6918755742671485, -6.295772652409263, 6.276754512115661, -6.288512860222829},
    {-6.363140465828262, -6.856756747160981, 2.0462448467937295, 5.395973003333831, -6.708894194381922, -6.563676384773233, 1.2886135180334812, 2.296811573928981, 1.7807221130585629, 5.621150922855698, -5.65811562655458, -6.147312603215199, -5.275245169809919, -6.344721044973782, 5.225859924393628, -6.9932553362008285},
    {-6.6960786534447765, -7.064979186364675, 1.4680423491863972, 5.359988548080689, -7.146248604788832, -6.40269810874828, -0.06753634406038984, 1.7216811811024906, 1.1499454971457388, 5.563884888206981, -5.866585817510764, -6.837812312335416, -6.022208667773305, -6.751186429207224, 4.783398183745515, -7.166146168600471},
    {-6.102463667446628, -6.680440765936894, 1.1934107125098168, 4.836733843228102, -6.454711346608555, -5.54607741127849, 0.07186972777570672, 1.776737609901888, 1.1213973071095715, 5.1503957872200195, -5.295048889356867, -6.319718645264807, -5.632641817106596, -6.480864282325101, 4.468083200332196, -6.544143683671618},
    {-5.265455849918911, -5.611187058957221, 1.8808191421065135, 5.182002901375462, -5.8606807653456805, -4.7853333527656705, 0.8155509570938977, 2.362797225849581, 1.4999389978821405, 4.900670014278815, -4.064799189758227, -5.3003375641026285, -3.996006232290041, -5.688525460835766, 4.663384711474026, -5.779072153028428},
    {-6.374763153046001, -6.57904000948119, 0.9350300244064532, 3.9806888607039452, -6.7673440329568715, -6.17380581901244, -1.1788783685455375, 0.7400888545535337, -0.42043446679254787, 3.9941457137448713, -5.714272777135717, -6.218843820383829, -5.551498089076216, -6.469686720703799, 3.8700342527395417, -6.547564419196423},
    {-7.093880132886844, -6.847035245139243, 0.893918508404117, 3.90235696722732, -6.744413528978756, -6.480867970249061, -1.2366204471584845, 0.17431117262674564, -0.8695399446689052, 4.024106279819297, -6.00133643157293, -6.399758489471924, -5.848969633103779, -6.446195363469198, 3.649126361229572, -7.132629779906992},
    {-6.255900946943406, -6.600445522408488, 2.426194377747117, 5.950389309961971, -6.558882296679498, -6.2033446814309885, 2.127730804733448, 3.1383110607897073, 2.6766191962242067, 5.883246487075962, -5.458181294948365, -6.020477399982049, -4.63427443610177, -6.074590713704743, 6.122544730489001, -6.605761575533496},
    {-5.4502641375811995, -5.773959458230298, 2.4996220918576695, 6.367403301043869, -5.200912442870695, -5.287568157389368, 3.285960492820571, 3.4479258012584406, 3.6572101047802037, 6.073177262211538, -4.588344492193155, -4.972383306532154, -3.582877120351317, -5.481456348134777, 6.078562329207225, -5.589065096989188},
    {-6.8648935455976225, -6.565841875260298, -1.335609804612501, 4.218006231220908, -6.572332669973467, -6.469844922374476, -0.9685783937977888, 0.32949664821426505, -0.8082758846996844, 4.133755674418683, -6.22212846400687, -6.198346187351886, -5.835737466669783, -6.225416696588751, 3.5147204042837887, -6.644620537375876},
    {-6.9125724951727, -6.981679270706002, -1.896195468952742, 4.110448950528235, -6.775008750243623, -6.696895216081561, -2.1578219823814537, 0.014794864114778147, -1.2651916888774606, 3.651092433487864, -6.402884526275537, -6.495108429463749, -5.980787608003841, -6.752200359795253, 3.2840659085356863, -6.879224956632207},
    {-7.057981605847397, -6.863655574442799, -2.456581152697561, 3.2893359797554993, -6.925886702801955, -6.677385991295634, -2.9323399666716305, -0.37759601187576325, -1.6336860348685243, 3.2744669179089283, -6.825416399548327, -6.994319303589973, -6.717895157078869, -6.764328195711492, 2.70414721894288, -7.0638084068454186},
    {-6.723687513466499, -6.648606906799164, -0.9641064622849939, 5.0425763653610165, -6.510888387189264, -6.288317584777743, -1.5706785073251128, 1.655712236615474, 0.08818296058358376, 4.376975781851208, -6.173815976979676, -6.545622380138421, -5.842805830817217, -6.722072104838658, 4.471563977200345, -6.622179951790091},
    {-6.643928085059924, -6.749050481455367, 0.6967961425997504, 5.158251851072146, -6.659829623444294, -6.57849012698682, -0.41148126145231123, 1.8686829737215203, 1.4747341350871501, 5.1069261222283595, -6.352705211940481, -6.158617225180712, -5.316638108956563, -6.766036071654099, 5.033833288241265, -6.835345616401589},
    {-6.895406282341115, -6.659690064448035, 0.8940996462145003, 5.192624150649419, -6.825790535292395, -6.618741017086944, -0.6849286337019294, 1.9522032069099007, 1.1634039151494937, 5.571046911437896, -6.215623956836883, -6.494911757378778, -5.802770099736761, -6.634646673671291, 4.854274247116217, -7.084620815324022},
    {-6.977986539251462, -6.818055096635659, 0.07076062281741248, 5.635778272155345, -6.977933991087854, -6.418630065265715, -1.7729519506317317, 1.5472311734508102, 0.34755541795502537, 5.662422114235639, -6.676248384772903, -6.253895939012545, -5.7940541077290115, -6.532052693065869, 5.389734163380672, -6.810234330014363},
    {-6.505748181279392, -7.09320911927723, -1.2848862842155757, 5.37478533868638, -7.153644788770522, -6.317735460158771, -3.110198043959887, 0.5804199952433157, -1.0530492789099881, 5.582902335733138, -6.892579038527284, -6.663989214527226, -6.163587977810171, -6.742810456018813, 5.214947767757851, -6.905592232826237},
    {-6.634330055402115, -6.816129601836994, 0.020734008714612513, 6.3380155062311445, -6.9343026741779, -6.406392539882348, -0.4046942207144927, 1.9421578254754905, 0.977547301901919, 6.301561242936323, -6.244926309007197, -6.435811691955634, -5.8764365282379805, -6.491486799631035, 6.0480208192479665, -6.876248426522251},
    {-6.771950755915413, -6.861211748356122, -0.019764464496336648, 6.3567396159771, -6.886135167849613, -6.728021744818972, 1.0149705869508687, 2.6702531812818204, 1.9953391250531884, 6.439703854935515, -6.7573316595373125, -6.255630070586455, -5.252456419449987, -6.221333365178693, 6.099313676193673, -6.881079897621899},
    {-6.244360479394061, -6.880340082635791, 0.909836975067932, 6.601783609407672, -6.888482135771581, -6.295102262487703, 1.1455985739594967, 3.439126770406516, 2.6806033843924157, 6.595760645289479, -6.325710515580037, -6.0049005955460775, -4.848803696215681, -6.281402665903487, 6.298749850593922, -6.9542437441022},
    {-5.553516928682563, -6.868071087102783, 1.1648923106923492, 6.652192934125136, -6.324319410182955, -5.886250343902672, 0.9758773164440884, 3.1466602227263456, 2.4206425615458147, 6.8011142394190705, -5.826213516857004, -5.301824753929401, -4.579300070029678, -5.740525952512351, 6.0183016915402865, -6.44578116300482},
    {-6.473586992688301, -6.80596090239571, 0.919774875973604, 6.467171438251534, -6.813072046652196, -6.5268996871890375, 0.20319641993775647, 2.9466064361356863, 2.1356016565439044, 6.244597802592694, -6.427550596616453, -6.22083684281441, -5.307594726078084, -6.293393685718858, 6.063516658042822, -6.872695063330825},
    {-6.467072147731729, -6.920952933012067, 1.3192956243786893, 6.102260684926985, -6.457221817079674, -6.73520609416387, 1.919970745584256, 3.0753264279642867, 2.6368887205964247, 6.409338862292829, -6.2234309729758985, -6.115235259965974, -4.4110992813479495, -6.44757950993714, 6.191641055020855, -7.035605217698814},
    {-6.62742275374429, -7.03351767216808, -0.5370729822548228, 6.005575193962398, -6.225475925014268, -6.406986476307219, 0.02043625793766357, 2.2798410515227947, 1.4861642000419002, 5.920437634472552, -6.283408292291886, -6.218681068746589, -5.209043335212448, -6.356747133944999, 5.797485831203291, -6.805823742021273},
    {-6.255715125340289, -6.89667703868217, 1.2899552134320758, 6.972916475263824, -6.545519861371798, -6.521184436494396, 0.9666649019962993, 3.2249002826467015, 3.039519465056409, 6.561860540316563, -6.085971163191241, -6.0097848246860215, -5.016459167394225, -6.531297433173899, 6.103487928139566, -6.791375019272249},
    {-6.354634422687586, -7.00834622083065, 1.269807703923993, 6.69071021924241, -6.958638740511617, -6.493471663264744, 1.5332744845323119, 3.5687110597604703, 2.9235287321381405, 6.574492757257597, -6.4123397047126645, -6.228228619896365, -5.122431996414179, -6.027860199522017, 6.385017316200291, -7.062249679637974},
    {-6.2469398412018995, -6.58871273140064, 1.091917728221892, 6.704530149969591, -6.750687956920997, -6.2371198898371, 1.8242664744736812, 3.57249394653221, 3.437552479558415, 6.670717457949901, -6.519874802199182, -6.011670107860578, -4.817542143639406, -6.304553311602751, 6.834572500803169, -6.6310459446295855},
    {-5.74209739629867, -7.1714998900564, 0.30730513384923164, 6.070405944457139, -6.805274510787058, -6.691610815099008, 1.5687459072642331, 2.4524621649883365, 2.6323254975257746, 6.175199333681644, -6.430510386906495, -5.74958737344335, -3.7640333517380515, -6.579346886343733, 5.977410061312994, -7.02395600513305},
    {0.2591251327678015, -2.0177632938330454, -1.709229788778011, -1.134531436230952, -0.01732917453555353, -1.29745696195576, -1.668093525388363, -1.645210915394707, -1.1426830392789493, -1.738363587399382, -2.9764589470699456, -2.5028465296642537, -0.09196345050472661, -2.7614559625207993, -1.4166175083398467, -2.3287485448134646},
    {-1.0044256257998097, -2.0730344416820268, 2.3384940367497853, 3.441984840228058, -1.321135147735594, -1.6113356124851475, 1.8722922128027244, 2.138802772180815, 2.3163006863799502, 3.1678485996043624, 0.18502530619250596, -0.34360997499396506, -0.42587389069824005, -0.5636372013554414, 3.710241433903141, -1.2791051518429053},
    {-3.8908192994311794, -4.267255173542743, -4.319184493085961, -5.093484892656531, -4.01718664894213, -3.8497766974187466, -5.82339284874437, -4.98148481495822, -5.504216734252541, -4.379801828573271, -4.791427637412107, -4.835457345271068, -4.709883047552427, -4.0363197009228236, -5.3078492656335845, -3.6370277834830413},
    {-2.743970683153733, -1.6176045249420805, -3.7872861284744475, -3.210235295950917, -2.3632084277758074, -2.760268482018072, -4.207454682944832, -4.43829503596197, -4.383566735044144, -3.1317474214867165, -3.8495604194323416, -2.7022559233535124, -3.524056628446373, -1.8701055637894108, -4.238422204326962, -1.6973250001117908},
    {-2.7269620253611917, -3.648776138698666, -1.2623149036483576, -0.8922215682428537, -3.1804341407673222, -2.894806838119043, -3.1377757106457427, -2.9197707885062343, -2.448967537521432, -0.76512151499188, -3.269177510329171, -3.538563469616851, -3.693307647621496, -3.125640528049233, -1.6874889403820044, -3.5366515561542227},
    {-3.099797693994693, -2.740461023292612, -2.3489809667614963, -2.273781144274524, -2.552894489232836, -2.454501461312176, -3.8661232783953587, -3.2850105345699743, -3.333938214996071, -1.9334166930979686, -2.9228161247018796, -3.040400426183495, -3.7289215349320814, -2.6019126886726918, -2.6048819208154486, -2.317347268308746},
    {-1.754424987195621, -2.6062548277951167, -1.2058606547062451, -0.7197821094119813, -2.369480528528974, -2.2482405902955622, -3.135119369709028, -2.9763898958779484, -2.9283008586484636, -1.0313593138987234, -2.449730986676846, -2.582549093935244, -3.1660443774586193, -2.538441887852751, -1.8903912194022037, -2.546860941930512},
    {-3.2575898229662923, -4.7593132128242255, -2.4615205990108207, -2.06441743722297, -4.227606053785456, -4.425107269417146, -4.935554196143143, -3.7064319232202334, -4.437937588803427, -2.1603230606753763, -4.634726572255664, -4.63125721557931, -4.266978470478825, -4.19950101249609, -2.275016152937975, -4.522769769858275},
    {-3.864195613049337, -3.942245590013825, -2.3876213615294275, -1.8655954550957246, -3.7596705562200055, -3.86267730913528, -4.940555000997782, -3.697655211888389, -4.356396566252132, -1.9883097805198453, -3.788755022226948, -4.31393843060431, -5.025153865765877, -3.7014970188888268, -2.3067134165585625, -3.9934035673643247},
    {-4.064081715375762, -4.91824623929618, -3.004363221276835, -1.659940880864665, -4.553918176293422, -4.582574032383083, -4.234759384412273, -3.861718313564051, -4.220015535615347, -1.6012291530430678, -5.001178756585441, -4.924575749441572, -4.733991382240653, -4.846185542292877, -2.275297087565113, -4.7151946195467325},
    {-2.6342813019213147, -3.0160622809920756, -2.994229054051611, -1.7024506655997722, -2.662098044023903, -2.8613596156791488, -3.3280420831303514, -3.5672209437949465, -3.091344719218086, -2.0781082594178204, -3.270216270829455, -2.9590008193898094, -3.266608480700452, -3.2429803405878967, -3.3446511447425684, -3.0558850996166704},
    {-3.529595523301671, -3.850955108578601, -3.9947501393214866, -2.4848205259221428, -3.953192690001521, -3.6978713579045532, -4.5435326292475064, -4.12106524361732, -4.121575404029743, -2.268460163251329, -4.6453088175453425, -4.294898510587576, -4.184750682254689, -4.115440480746003, -3.0359782916840627, -3.8914605887849256},
    {-4.073494375874171, -5.285058656199228, -4.353016511485211, -2.05867008723037, -4.7272420865290785, -4.74736493395416, -4.154690836693996, -4.414353941250124, -4.0606162986421275, -2.3910979121450646, -5.0682658511730185, -5.044376320320601, -4.724713911152648, -4.844517372054606, -2.9710537816248443, -4.755495999808673},
    {-4.817386352775914, -4.631616717283146, -4.490464992047593, -2.8802854901036925, -4.714250573308691, -4.063080245343168, -5.04718937811626, -4.872841514637699, -4.747683476200235, -3.121232216593894, -4.8121009646704955, -5.163111462765652, -5.02004160872455, -4.267608857139335, -3.7762499362972073, -4.408157312854113},
    {-4.321579579125036, -4.9920337148732825, -3.5914733484597825, -2.9277413585135763, -4.775561261509066, -4.612051339095737, -4.897263511781963, -4.478270155546256, -4.56600505638777, -2.729686248722055, -4.850406183370737, -5.313784001324507, -4.902645679616008, -4.691148955596818, -3.580394107305256, -4.374570509989298},
    {-4.371296820442866, -4.2240591785747625, -4.348030525301661, -4.373871769029554, -3.9788081991299795, -3.5120781447101157, -5.727163926486604, -5.540472595932402, -5.839005298114777, -4.2352889732028185, -4.438296542604228, -4.816603641083334, -5.081064457031282, -3.9629931532740037, -4.7154334385788985, -3.733727366254534},
    {-4.4178782795990585, -4.195081397913035, -4.171574226919452, -4.255594054277882, -4.464615223493968, -3.294175167298362, -5.896695880519083, -5.095492331983808, -5.504434379061115, -4.125698424507956, -4.550036000238008, -4.631371153843863, -5.764232089278076, -3.6119712564695208, -4.570182037564472, -3.6143294134909114},
    {-4.52465930372542, -5.477944105925774, -4.43865428926749, -4.230775003890266, -5.438415144535493, -4.697306125727488, -5.8621769806101955, -5.076710137628181, -5.504733967194419, -3.958905490826255, -5.721927911024697, -5.323752318338869, -5.940035521608727, -5.047266777003779, -4.472201926264597, -4.743550165427445},
    {-4.409240898763235, -4.812660132658248, -5.511628810196242, -4.800980304218081, -4.77757729767585, -4.049930376770022, -6.086588594293949, -5.429675251403372, -6.014432564965613, -4.896868668635301, -5.458662486202288, -5.475659939411741, -5.823682888726164, -4.91798485815587, -5.532996977393214, -4.32037162582573},
    {-2.8255844734186093, -3.9446750449248325, -4.3494397344893265, -3.108262599741288, -3.5786270854809943, -2.9844806494514597, -5.310486576714977, -4.677144990024124, -5.142038021850769, -3.207277856165997, -4.148285965743526, -4.793184419819051, -4.821160990543923, -3.5913720180491797, -3.6970781255022147, -3.369422102477562},
    {-4.238048819218278, -4.961628763213101, -4.634630131816918, -2.056568129672462, -4.931205138513695, -4.334766179274966, -5.1034640805141, -4.3851525203314425, -4.940491444765914, -2.5355847298258687, -5.256394851169788, -5.569086568858798, -5.746398162020013, -4.915292270356275, -3.6967260944127815, -5.164480791567852},
    {-3.82552204587273, -5.122605035492573, -2.672205069041275, 0.6569887085626323, -4.710798646720247, -4.112978044340107, -3.80308751493468, -2.7335245796954353, -3.776367416409218, 1.1317916297952928, -5.001654486127664, -5.319453152698757, -5.17373867230455, -4.8791232110877205, -0.8464357966315496, -5.063531589776442},
    {-1.6748754419717526, -3.101270461986088, -2.8283145504576583, -3.126486097971208, -2.889341864288496, -2.238277206625017, -5.25039127127385, -4.3728236095948985, -5.322567057675334, -2.1847927850428728, -3.293183447519189, -4.136954712157644, -4.274702908945729, -3.0550652817341373, -3.764681170598668, -2.909758735803829},
    {-3.8783323432932537, -4.91028021210408, -4.763184425512879, -5.003075963391897, -4.772588308385021, -4.084421470937991, -6.38574277890451, -5.497425850542466, -6.3323515069633585, -4.849044215745702, -5.602652399289414, -5.537648816198395, -5.690154308405799, -4.954509345790458, -5.754421405334381, -4.327805200024366},
    {-4.759745716902546, -5.83003342075209, -4.900776322733189, -4.629918346581511, -5.398611952068226, -4.712604068664715, -6.1524832994590986, -5.297594286355804, -5.9248082071079375, -4.951955990932566, -5.784829130939039, -5.980467492050863, -6.008273897366285, -5.734857600116057, -5.072918651459086, -5.216914076729295},
    {-3.8353758062146435, -4.377577746293175, -5.179742118782227, -4.831643749822004, -3.8189688942422877, -3.6303333108579134, -6.230403582975837, -5.33890594556922, -6.2414142199770355, -4.386338373100645, -5.541817931976055, -5.416625611364972, -5.974672185984568, -4.634277373835029, -5.579151048396364, -4.136246852382831},
    {-3.2672665239579914, -5.306884408006328, -3.9270882722638505, -2.3714071722815526, -4.350320917232009, -4.470983156118996, -4.9041074857224904, -3.7252216187933596, -4.857008982457548, -2.501240002551222, -5.522668481099419, -5.641610783007836, -5.035180171725861, -5.153581936749174, -3.1794624334817874, -4.977289835363796},
    {-4.356421806615235, -5.93413999292664, -5.4641535586151875, -4.049175986504463, -4.697569043263541, -4.888369628031242, -5.8625672511936875, -5.434179125720665, -5.723478557764472, -3.9229695934327484, -6.17566398373711, -6.332571507112032, -5.743407593482976, -5.612852283442998, -4.597483895733401, -5.40486280994648},
    {-4.321050132265049, -5.628128119136272, -5.357683025034271, -4.771795244206549, -4.8891770689605565, -4.628040606475008, -6.597168711278324, -5.98061124241969, -6.430410830356917, -4.9633962688594115, -6.1142371828989805, -6.1032852382515905, -5.946252293097271, -5.48021019296924, -5.683234714068545, -5.199049200306325},
    {-2.720867986933055, -5.154734616081181, -5.01369716707032, -4.713818595995082, -4.543227419105594, -4.068540467276553, -6.271947289159826, -5.716174289707309, -6.154773635696809, -3.9610024723862485, -5.484690771207033, -5.763243796638484, -4.787590390969266, -4.62375120026557, -4.953408739305279, -5.225552307369392},
    {-1.700956270414753, 2.2142778798013434, 3.3105588939970385, -1.6471069973830477, 2.768251473849495, 3.0191268696652367, -1.456560416742144, -2.5530410570229978, -1.2467265989548222, -1.6902857256922763, 2.719915690120236, 2.051112741811016, -1.4276138447125555, 3.0044855145982523, -1.7552140164145453, 2.2176776232062894},
    {-1.7198766910073875, 2.804104156719825, 3.9414472711167505, -0.8200808556181931, 3.358886451569719, 3.326290445570969, -0.9204412849466371, -1.9047885114166874, -0.7670219297789802, -1.0994467212283199, 3.765550086260124, 3.1433138496391733, -1.7582521792125505, 3.564408551663473, -1.2924190382302154, 2.8703617050911014},
    {-2.7071708105228027, 3.354294553911632, 4.5454611515384435, -2.6041616109653734, 4.171020798074518, 4.234306535707184, -2.0895573939199217, -3.465261214509896, -1.9151245552492797, -2.7275493245046603, 4.365738452690509, 3.320196492868875, -2.4333105703682842, 4.309956943419418, -3.050664272375196, 3.7370864934853887},
    {-2.044041117848799, 3.827933222051644, 4.375537788021707, -1.9308007428627487, 4.230337403631548, 4.249372469675274, -1.1677192692278358, -2.902997801006418, -1.0708994677093369, -2.3799834303427576, 4.181404977689882, 3.5901366732809343, -1.6741987431611434, 4.366824364824798, -2.3447626697185124, 3.7806381147595998},
    {-1.313659999861242, 3.4560871790259027, 4.093600434457457, -1.2833906693759294, 3.8981645007023573, 3.7726893447122536, -1.2308099005183732, -2.4116293386449255, -1.3217350613031467, -1.700701699731541, 3.916333798917346, 3.3398937456447797, -1.5179682659828753, 4.009529769039935, -1.8951325100068523, 3.384993465560651},
    {-1.8922003255869233, 3.5853565445079236, 3.9886078217995764, -1.7183960973953367, 3.914293787137398, 3.7173798533656806, -1.7371030554814515, -2.7200205392364367, -1.8860017228455765, -1.6461494070500136, 4.150168919718864, 3.2905606833732652, -1.6805852169372424, 3.958437668275098, -1.823637188219224, 3.555038304251303},
    {-2.553651602393141, 3.521394091736447, 4.097872240391437, -1.945265577493358, 3.929829200596227, 3.725236213427313, -2.152690503490085, -2.904212140843502, -1.8924130664852528, -2.2157410550051413, 3.988561042085179, 2.649906525378969, -2.14412420791184, 4.223608190400896, -1.8813927762583134, 3.3586775300067684},
    {-3.3074687244031633, 3.5562833188418237, 3.805168553829565, -2.1307953463548652, 4.036440112305313, 3.8285231723281155, -1.8077240949545157, -2.5870278662946307, -1.9005414906365465, -2.4589581769289652, 4.208285727015138, 3.3413428586005525, -2.249099942057911, 4.0769416157017, -2.4224452427779783, 3.6728381569671615},
    {-4.092509932278477, 4.1528991051979744, 4.039518751958234, -2.8186205942964246, 4.61658261536148, 4.4737538033719, -2.3489592795563548, -3.2671954124340896, -2.446842048551877, -2.6899856232623316, 4.6102707101272875, 3.230783813741181, -2.777911137511326, 4.80778946238693, -2.9888787933602314, 4.106814497453013},
    {-4.198766225932751, 3.281550950081646, 4.110783259909954, -2.51200312622985, 4.077881972658126, 4.084618403798112, -2.4091163663200854, -3.444620401453171, -2.6160940407273454, -2.5082592142133056, 3.943131775300547, 2.7790749990837473, -2.8831070885460126, 4.225863903904188, -2.966996520104564, 3.107586273189039},
    {-3.8511630708435494, 2.4267305047011787, 3.8201983157998476, -2.255429489756166, 3.4151262226574164, 3.253096779939931, -2.4252131580976073, -3.13448213123661, -2.7331663998915072, -2.573777780406983, 3.3331305240728657, 2.1446399069742204, -2.963097652013033, 3.4326146118046528, -3.220758910449951, 2.7037050140044587},
    {-3.302686770191103, 3.426023584231515, 4.973176318825191, -2.279291438411328, 4.241942535221051, 4.027184043995788, -2.1903430842031963, -3.1084672107512032, -2.141765147351165, -2.116288990580016, 4.304747289207149, 2.9545332967563054, -2.9846625670519824, 4.39888095320686, -2.5303500841202173, 3.500502163532937},
    {-4.017843839113967, 3.2526982257468, 4.4338375568851145, -2.4821624894309693, 3.861449221290749, 3.434546973970713, -2.9268943238243224, -3.413850444688711, -2.6724749197064277, -2.7463226613136382, 3.1984165844718366, 2.3769172517483206, -3.2845625476065217, 3.8374120055180643, -3.1580528769077034, 3.136844374083859},
    {-3.5759041625602883, 3.0119802591682605, 4.187488140393342, -2.5296119979931055, 3.5595331390430056, 3.639241832561115, -2.4471285027257363, -3.128604207223823, -2.5424881105327475, -2.8250038224686267, 3.1217902889542777, 2.9915330055409517, -3.3793832132609376, 3.680873529439854, -2.634546418339159, 3.075165090335186},
    {-4.156840544332455, 2.965414470209738, 3.682215222589535, -3.2987599627744224, 3.6511679652341287, 4.004710441936101, -3.190597793308032, -4.118647798709073, -3.3656369695988, -3.4885350899066294, 3.6987600384208466, 2.544620164370661, -4.03209176355769, 3.7580668860632285, -3.8179708235697336, 3.0447337836517145},
    {-3.6581548265121966, 3.1262701402974282, 4.981923056950814, -2.5718378068431846, 4.019770778558438, 4.01458624061563, -2.6061285502122993, -3.622210548217104, -2.316483054728962, -2.5728289666949293, 4.102867135175228, 3.1012770102543206, -3.17383720158906, 4.092175158931511, -2.9574013680201356, 3.389914055280679},
    {-3.8873556270334113, 3.528648831662651, 5.10650625560087, -1.586156497223133, 4.340629542119857, 4.178294136562519, -2.5303166677876345, -3.29635359391791, -1.8732170020601495, -1.469748803441735, 4.0629736328487835, 2.7467467702191373, -3.06122665677421, 4.406322653293339, -2.354779172870784, 3.725273487498804},
    {-4.388540901325979, 2.909743752630308, 4.738518524755247, -3.019552675758446, 4.110285136200042, 4.284159204029336, -3.1439004268422317, -4.008538365230759, -3.0771273594760684, -3.0949064171016367, 4.3169595929701385, 2.800964872551006, -3.590263280704902, 4.383731644323778, -3.4243223535776774, 3.194373650766241},
    {-4.9888766096301715, 3.052040194793437, 4.5164967039009225, -3.0722854492930964, 3.9789713983602084, 4.14270074751051, -2.9642243158173347, -3.6096224391651615, -2.7810881998025394, -3.271063547273084, 4.170842361171474, 2.6365003613070326, -4.034210399056106, 4.114794608152291, -3.0389344015278743, 3.3368964650374697},
    {-3.5195257667681434, 3.697271410622271, 5.2559331450513325, -2.2573623763782362, 4.615421329654427, 4.3689477454453165, -2.3590566080896176, -3.1139090718998856, -2.0852615844990274, -2.225589422907125, 4.513870582777444, 3.4518186917338234, -2.7277173240763166, 4.644609817928675, -2.623801676076742, 3.6619930080684644},
    {-4.026116392803242, 3.2879597895007593, 4.7061434415979475, -2.1534167608483705, 3.8657916264848553, 3.8266641396020855, -2.5885813973310983, -3.3221703841049073, -2.0355208912562355, -2.222488448069412, 3.984742967638833, 2.7339351827473743, -3.1739557293606095, 4.144232204292245, -1.9462410242238948, 3.3729520871796255},
    {-4.244832139113362, 3.110319814855956, 5.257370005544036, -1.6317025228797946, 3.9766021118546373, 4.206036562383305, -2.2747381217066467, -3.1083202487346524, -1.7583054291060214, -1.7895008893599058, 4.4093870079074815, 3.1104555394183624, -3.2226322501877864, 4.237461898354975, -1.6919965618764616, 3.3483059291144417},
    {-4.222868065742963, 3.61454858449181, 5.36763711095564, -2.0623680925552614, 4.604854049309108, 4.52791525082164, -2.8382684408898937, -3.5186764841809284, -2.1813397438153985, -1.971729787736778, 4.90050087538403, 3.978549974111117, -3.273012306741928, 4.6350128785083085, -2.6682373281592153, 3.7993035154040395},
    {-4.75106536366566, 3.6422297384254687, 5.147838683287763, -2.445654993209434, 4.590615071175396, 4.861743079410932, -3.2498903897057483, -3.9260151395810805, -2.4100297609435244, -2.7295011583822215, 4.79716958503144, 3.9349678173579994, -3.39109731266669, 4.37745890607901, -2.9664734318786086, 3.670420962303903},
    {-4.23171196314702, 3.615002373621154, 5.7205110681152025, -2.8266101641290775, 4.304995358619493, 4.725232335134578, -2.4751031854398176, -3.479833201196485, -2.312297783157052, -3.0531562031039616, 4.86759501143185, 4.131339448815396, -3.07926369101216, 4.819221692099961, -2.6570946593797653, 3.862546488486301},
    {-4.753969022816872, 3.4533838523813425, 5.355613281511636, -3.2657312069885633, 4.275061386444604, 4.288772193447698, -3.688958283563839, -4.319052702910186, -3.270544235541345, -3.1533825061139527, 4.844749169878322, 3.802047057119517, -4.202689561124392, 4.566508420273595, -3.313512776889802, 3.818957248816026},
    {-4.576400446586513, 3.536558567454611, 5.883854459153918, -1.7603421468956506, 4.530262444102272, 4.753737540268023, -2.6870090863215244, -3.5889709593995893, -2.3923556215672117, -1.89932256637387, 4.804178911278512, 3.917315501590101, -3.6056823526155446, 4.8375652910156015, -2.4379370523965602, 3.7374847688822803},
    {-4.079279506931673, 3.995360669812651, 5.41157823113124, -2.3044047616965755, 4.736873134063452, 4.795617160171983, -3.179219505096222, -4.0235887781785715, -2.824272627060565, -2.595617629473684, 4.962910852529378, 3.9446296086914905, -3.2681582400793125, 5.063020795863848, -2.7992759485648833, 3.844171696068877},
    {-4.78969237672257, 3.53828066449965, 5.412949106634205, -2.5601392360688733, 4.437029126174693, 4.37906822396172, -3.89312515881064, -4.3915758096651505, -3.388624626580735, -2.8868194458665997, 4.7460075411225695, 3.264031737394921, -4.121943425465726, 4.276629797113984, -3.323432488897151, 3.5924263470505724},
    {-4.3687068263005635, 3.453913190044319, 5.4550710079438876, -2.8303868768337117, 4.124351999193393, 4.363512853710238, -3.4052993381082, -4.315557996426565, -2.960905367544921, -2.679235711849829, 4.504161075915491, 3.523789066749796, -3.5832078887888077, 4.494160274813269, -3.143594396952706, 3.520072903869451},
    {-0.23358661786866977, -0.5574562427128211, -2.994415065675727, -3.187532523755242, 0.1139749265846867, -1.6244788615412078, -3.4383773962959396, -3.3344899460365034, -3.686306569186575, -3.717448839607411, -2.82674801846724, -2.612498074713065, -1.7445278574191863, -1.6616002827896708, -3.9399959904733324, -1.3018466403928242},
    {-1.8711360390244312, -0.2679071793469384, -0.7191696173885262, -1.2440152778708482, -0.5743261860562553, -0.15507483485261947, -2.312013343125545, -0.8364614615185791, -1.5703630784000657, -0.8657364675412219, -0.15111190946227746, -0.943632995115125, -2.8280129512617433, -0.8079071051650163, -1.6583252702596798, 0.5598114952090839},
    {-1.4072130205702444, -2.058713320546623, -3.174773843475507, -3.715707245289033, -2.077431350415166, -2.164260470392036, -3.2287225687523766, -3.722298497230352, -3.8407741790770324, -3.1766749744836704, -3.4629942287836655, -3.330709018001794, -2.147963665302452, -2.812792197703422, -3.8417597596088937, -1.9631479638102494},
    {-0.5646700559251294, -0.061060637008982545, -2.851601938153407, -3.9482861749953773, -0.5585570622363916, -1.1113388884955153, -3.249502794384357, -3.703837558521371, -3.6931720573911977, -3.681021954120444, -2.3335675998330214, -1.7758433696926743, -1.537195182827845, -0.5784671309033986, -3.657168177265404, -0.1095171242614},
    {-2.2914182467749487, -2.007691035419216, -1.1808880520000151, -2.4549296659221187, -1.9530697256249863, -1.986517952051306, -3.670615809226799, -3.227014853383689, -3.407035326691406, -1.9697335132990066, -2.397595531052263, -3.0083835054178403, -3.5694699801949934, -2.3679541410131475, -2.6929810638963736, -2.0801665688619657},
    {-2.963223444659531, -2.994334981687214, -3.2022902634143176, -2.406132011866421, -3.1569196718094457, -2.7990885984671343, -3.3442280301864513, -3.0499327711692277, -2.969133107908548, -2.626245644781752, -3.2810652812191172, -3.1803426717805774, -3.651189662760898, -2.9408900145885406, -2.722511049124645, -2.749307113786646},
    {-1.1370799645191096, -1.8729382351438857, -1.573840932485778, -1.7086410070053195, -1.8661960640768522, -2.287834404673773, -3.2661055126429526, -3.117567049914769, -3.260433796310494, -1.8966952052544366, -2.732680840552195, -2.234352353350526, -2.326373058800227, -2.539942122959096, -2.7150845089347238, -2.5142489938673824},
    {-2.2496263324127663, -2.788531463086561, -2.4063666722852957, -2.0733026629142284, -2.9714554625924405, -3.1046454990610384, -4.169167203221167, -3.373279378769624, -3.8395693863915166, -2.3156273266742495, -3.889073448649565, -3.7088518612875183, -3.5834575525769536, -3.178496139558308, -2.279555604077, -2.958605704803666},
    {-2.7255586726545142, -3.2027948487508575, -2.076323263750387, -2.2146610613634024, -2.8645681760640973, -3.104915669885739, -3.8991804261603598, -3.507818363615484, -3.484703718566863, -2.176007944095997, -3.244445588498097, -3.4595564921371778, -3.7728324778214266, -3.035674544077134, -2.4606787911462513, -3.21886927734491},
    {-2.8346163870843775, -3.9332426816561408, -2.3036104626440443, -1.8010827915690188, -3.7168439235639212, -3.7751005263366677, -3.680753318326366, -3.122724488006752, -3.497585005188477, -1.856397070918253, -4.350294731454376, -4.2420219498965706, -3.6080093337410237, -4.252958285448716, -2.4349855778115774, -4.036934376393933},
    {-1.4520010164607675, -1.5364296705020744, -2.173119396524588, -1.8045860782868082, -1.4559237752040906, -1.2521062469209885, -2.450260594364449, -2.7838440455946682, -2.5414289031640585, -2.518574957013227, -2.29619551932786, -2.534598761352106, -2.371110730912632, -2.1725374250460248, -3.102493190975926, -1.8624217806364105},
    {-1.785761353302815, -2.518838005860137, -3.282797635037485, -2.608085431613398, -2.0557596295171865, -2.3348952700856063, -3.5304923388506775, -3.0229969120943583, -3.5399236526640556, -2.7920331778893477, -3.019633133286162, -3.0843611920511984, -2.7755554785098195, -2.6921538487514374, -3.1980570168959765, -2.8254890192733115},
    {-1.2857635414512834, -2.6128755919965894, -3.2493844852396507, -1.7156177732961206, -2.1868738673591364, -2.4411379151625927, -3.34241545221443, -2.9758663871728577, -2.6911532244894443, -2.1803652902172495, -2.771920788462918, -3.2364295174308704, -2.8949990579345237, -2.6366117899328336, -2.7500554938842487, -2.955086841946878},
    {-1.905333700335169, -2.4846577785721533, -3.8770075673896836, -2.9145168689009, -2.357150821099903, -2.30495821962027, -4.326394358011169, -4.044623285342459, -4.2173057868595665, -3.133303888127821, -3.1503478531792677, -3.503755624622957, -3.637798398282846, -2.1542470590670173, -3.603555487599512, -2.8260933870369627},
    {-2.0982718047355897, -3.416725267370985, -3.1931999577004486, -3.09095980130148, -3.23029107293693, -3.2151870951486057, -4.6851283302224065, -4.298070568322662, -4.592901544799755, -2.5782205611536595, -4.16879674004625, -4.401833295573501, -3.4860963406239045, -3.850689667978266, -3.6588025848006844, -3.2399055975273785},
    {-2.4762632323434133, -1.672645474726207, -2.96568401502042, -4.195642312660719, -1.2582892060177528, -1.314213003204718, -4.682246560611609, -4.621631064904372, -5.197962863067968, -3.673068842578108, -2.486601211688799, -2.8725129756729415, -3.500046252219463, -1.6115181193277266, -5.103655739819628, -1.5777878913904195},
    {-1.550989172679914, -0.9976435764342695, -2.783035522904653, -4.10985292581088, -1.3032803583907158, -0.9487927215594547, -4.147751257695152, -4.360292782142138, -4.917202381967369, -3.9571775856202986, -1.7733943659466638, -2.2871796338954176, -3.7136743529139182, -1.2247116156095912, -4.840772214518178, -1.6432495906101041},
    {-2.146598359878677, -3.2369054470937955, -4.207383928201591, -5.121980221734774, -3.2684270778627273, -3.2741349612398967, -5.775301763901626, -5.756201708814159, -6.117653262230023, -4.758069246631944, -4.482782592835824, -4.542241415707242, -4.602574329783129, -3.2752425158453726, -5.539088922093659, -3.103151902348204},
    {-2.1699520948397355, -2.8442738533281067, -3.8778035802899935, -4.823053260345171, -2.869239627375197, -2.348764488505541, -5.873510691362743, -5.550573781678239, -5.50725405710895, -4.6772738483901986, -4.367420768865677, -4.329485987843239, -4.517778392491263, -3.544665142361314, -5.502967310419369, -2.809477136472126},
    {-0.45132225074296745, -0.8478838270389722, -2.9821381019735194, -3.446320129742898, -0.5221175567768221, -0.4373175053298369, -4.596395094382106, -4.626975088165204, -4.74622031384595, -3.609060239698282, -1.951969261677415, -2.5257892337484664, -3.2034942188171405, -1.0231503705342158, -4.449562862854651, -0.9676972653550266},
    {-1.7381691006032551, -2.4628095904261373, -3.875854739153516, -4.385099942651673, -2.6628489749491044, -2.1743566043834837, -5.579979898314437, -5.188192717680521, -5.722350328414207, -4.143829446639191, -3.5188849712401766, -4.219808659545098, -4.5001350941677165, -2.5950433683916465, -5.100699533005113, -2.9819194602656074},
    {-1.3902955573270719, -2.0044786741845995, -4.2412417156559234, -5.829844524602964, -2.083619701789965, -1.5464642431072875, -5.903264114997781, -5.871998747260587, -6.429350082429651, -4.496617473029412, -3.4281625008656147, -4.299922782453625, -4.591531911736655, -2.641120670932178, -6.024987670581997, -2.396039403895262},
    {0.06784014524406852, 0.20785269511308288, -4.0535983487206, -6.078658471143832, -0.21883379748029544, -0.07343913069190662, -6.261539812112442, -6.431482477634128, -6.889973415061342, -5.468924486254217, -2.502770895141664, -3.5069196605263175, -3.4084254357958375, -1.2027487873530291, -6.535144471260757, -0.10257239582787755},
    {-1.3114937860879257, -2.003688213546675, -4.655827429669057, -6.349139403407495, -2.3404454884691654, -2.0691935161981823, -6.394007626886281, -6.282824944452474, -6.9699599527843725, -5.727095818916501, -4.37910868939508, -4.641912864232591, -4.269233514887007, -3.169317008030381, -6.630237986471875, -2.449776101581492},
    {-2.629045874250133, -3.398301202062109, -4.505500381766384, -5.790457951446713, -3.158582345196882, -2.8145518911290974, -6.089094003826298, -6.075859391409184, -6.370267799800288, -5.583267246937223, -4.54355646466593, -4.439154067967683, -5.005414834447746, -3.648336573810801, -6.26947828078482, -3.26753386618869},
    {-2.0087975372133027, -1.7538744116564944, -4.544909764672599, -5.695408682525464, -1.130653147266777, -1.4533602287116267, -6.4635555233694655, -6.105017533185361, -6.4403215146664525, -5.084992188210023, -3.458076613275366, -3.747842295476532, -4.72014119384875, -2.30125574148983, -6.126371806534088, -1.609204530431537},
    {-1.2861225022956908, -3.2734862034319514, -5.149642648489052, -5.4012975244582435, -2.6381241005796943, -2.874555722901526, -6.025619184402167, -5.649350540659596, -6.231854682874899, -5.19434923005113, -4.955704146212329, -5.319301309057336, -4.31791814766533, -4.29873732524214, -5.825067245628431, -3.5291911062163273},
    {-1.9342352852385005, -3.598862354003411, -5.450589346014932, -5.90176915634303, -2.7844044357082796, -3.174739767725923, -6.181956420939088, -6.056435182645878, -6.648982882648042, -5.1171159523983, -5.058475442939351, -5.356474463449387, -4.80077901451005, -4.30308349258168, -6.002906509731578, -4.038246655917427},
    {-1.8909164571468675, -2.7393148089480497, -5.2335929001629085, -6.484189726327421, -2.5219462493271108, -2.3550926384849085, -6.868962585504548, -6.222889540604723, -6.861861944301644, -5.772669452557254, -4.756842857022447, -4.75997957532795, -4.800079879700093, -3.9686371866491705, -6.6126946012665515, -3.347053849298986},
    {-0.5925628134591421, -1.4936738282869613, -5.558438079779314, -6.445605392643147, -1.8745752093736217, -1.3774305352202154, -6.842300319764398, -6.348656518560659, -7.037491142976483, -6.126696625667617, -4.039583211143093, -4.767521401893048, -4.150475364065755, -2.404649657510127, -6.892546523366043, -3.024325853426976}
};

static const float b1[16] = {8.50667056869609, 7.847490420853683, 7.85665521305487, 7.833344823938624, 7.819136070532381, 7.493827210190255, 8.139150672708585, 8.037455892605704, 8.011199313137336, 7.91685569540381, 7.828200657571685, 7.750761446816043, 8.435818762892923, 7.562179380861692, 7.99839764079884, 7.647616204957418};

static const float w2[16][12] = {
    {-5.240097942063637, -5.046327050889476, -5.0749034087877956, -5.057721693764355, -5.024491390310308, -5.005962269362841, -5.316488003360357, -5.449375429407152, -4.97261030344275, -5.1039582097832925, -5.102838729323968, -5.036486893077925},
    {-5.0455474844901245, -4.4544459333130755, -5.100641339118838, -4.653910419022346, -4.912994816108778, -3.925539477255837, -5.473168710493124, -3.658807288885878, -5.046166992762164, -4.68295625908412, -4.638061902773837, -4.661255091343988},
    {-5.029665342015045, -4.993404927336069, -4.797743762537616, -4.8788811541810535, -4.8444021361343665, -4.819110152643185, -4.812110498335893, -4.804902390381036, -4.833572997119404, -4.849601236573477, -4.8333990788690775, -4.786132612648048},
    {-4.845786308211771, -5.174071768190836, -5.473624243233829, -5.558729653147546, -5.406609647913606, -5.242870780577159, -5.347970460208305, -4.896216468872494, -6.117846411734391, -5.30381484679677, -4.651036310829559, -5.362292071157875},
    {-4.753944282179252, -4.822038765332871, -5.077829620176447, -4.59211741093886, -3.9658286371682987, -5.326925479475183, -5.252715882784916, -5.456138041258999, -4.974142078353649, -4.605713131038469, -4.291477600264581, -5.47533925261919},
    {-5.159802150446815, -5.047548166412331, -4.565575171875846, -4.923093324425187, -6.072863072432258, -4.662420788134113, -4.684568928998757, -4.7148802556816225, -3.885757190496858, -5.046144606559798, -4.527777558583995, -4.3840850482380915},
    {-4.841732190767886, -4.817545799524072, -5.622095461155891, -4.9399900387267355, -4.951112414305001, -4.655842587338021, -5.332612070259602, -5.125924302952377, -5.263523900771497, -4.717810286631194, -5.252309746268529, -5.005505971121036},
    {-5.04545631388964, -6.034578587368828, -4.494686452795103, -5.272759253777558, -5.259705867386467, -4.917495252976628, -5.473457684035283, -5.447019889680026, -5.3298718222546055, -5.660361410992037, -5.170454949368314, -5.176670022794069},
    {-5.45685094580934, -5.590176269278538, -4.583175240215295, -5.00108309172227, -5.091268460361877, -5.507222241960145, -5.182987410500857, -5.23273733447115, -5.204237022237803, -5.0121046351447, -5.270325193204069, -5.00877757976275},
    {-5.992533008069941, -4.743499728591677, -5.457861687338073, -5.4632978561617715, -5.619333110586662, -5.4690788602492475, -5.13190163864846, -4.984729259975262, -4.288255317413586, -4.910985392718271, -5.607019671475541, -5.209818941938911},
    {-4.91729895723075, -4.881791857191939, -5.160257621086877, -4.361454743713676, -4.3600530827592205, -4.817782845353974, -5.114128430483305, -4.645929544664937, -4.455071848450411, -5.252469497456253, -4.825589764512237, -4.353870671891698},
    {-4.941361234082508, -4.849962834855974, -4.37569287020024, -4.817808796707743, -4.398675115221946, -5.171476038306771, -4.438608705969887, -4.888781419067109, -5.246411958011003, -4.346874764211769, -5.005570589184326, -4.9346963357839115},
    {-4.946287031899395, -5.389834070265226, -5.377502955973987, -5.217688744308973, -5.259608191247424, -5.362089291197867, -4.787030852606392, -4.9799335315454485, -5.3979064272950374, -5.170503651528756, -5.082874477339127, -5.269590794723},
    {-3.762472866124631, -5.103647916889577, -4.459074967543157, -5.075458843479965, -4.9042429153274565, -4.282763459556613, -4.1401338614516, -4.895580239471687, -4.9354318862073425, -4.196537740238654, -5.174266956853749, -4.842593539979666},
    {-5.058541379317361, -4.993114229683628, -5.387668420744316, -4.915237243636032, -5.003594940687984, -5.233128509469861, -4.815336363953902, -5.444988080579677, -5.025450822588252, -5.393420969136949, -5.245617899984066, -5.262538652372565},
    {-4.694360973321067, -4.020186171361814, -4.519549097768331, -4.8806190187139435, -4.726794039672167, -5.114007213063333, -4.307116759938014, -5.012513528615979, -4.940294869579928, -5.223439269845307, -4.888810719542447, -4.702899242184124}
};

static const float b2[12] = {-5.635947864791232, -4.995829209159103, -4.8140842251304585, -4.873165759196502, -5.678834653831211, -5.269436409470118, -5.027140331017133, -5.640984486180618, -2.8058680514907093, -5.1361256569918154, -4.762032852048144, -5.396547161394476};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
