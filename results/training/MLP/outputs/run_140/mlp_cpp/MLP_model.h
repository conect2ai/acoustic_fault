#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.0715447982852775, 0.4515917754533416, 0.6541460124117039, -1.1146234167781939, 1.376136932704487, -1.465822701818611, -2.2262811289306375, -3.2445365893562794, 0.07505602511869411, -2.7180530788072508, 0.35504200000750286, 0.6344266011070424, -1.1041241607314332, -0.1329271309711661, -2.419457456063061, -1.7397305806188255, -0.5159905731357136, -3.662374475574294, -1.6536462215920678, -1.5986807533188647, 4.686442852288482, -0.7907440587638851, -0.08576527965385215, 2.5467560001038914, -0.9653471430262134, 0.9409675955815725, -1.3907691131625501, -3.2581920036372667, -0.1315225572382015, 2.6467809337316304, -1.4832343913380401, -0.6132284282078514},
    {1.8068537794121706, -2.3791698491027726, 1.4213465051442378, -2.181593092330914, 1.1544070438249678, -2.740106609234548, 0.8229730953812089, 0.05030378764310854, 1.9597599843791111, 1.2932861367631308, -2.3934268124827422, -4.553480172478077, -0.5850046387919161, 0.05146644413366525, -1.8012246380178232, 0.2879753281243365, -0.1708302215714586, -0.3830610455716403, -0.2112067349132224, -0.8652714121253368, -0.7736868452861949, -1.191667304602481, 0.26381172390109603, -3.159635545335869, -2.9958403581612676, 0.11466783024478186, 0.948305079802987, -0.9585429649595592, -3.0788548743001782, 0.20110676847454248, 0.4147038738297768, 1.2562002673089516},
    {0.3142338588849557, -0.35929357987815747, -1.2568450821494657, 1.3809267050460299, -0.14913875189923445, 1.1046312680019728, 0.9469679485432179, 0.16729106518780879, -0.7991536386841483, -1.2695058998582691, -0.4292391288260945, -1.061807627290997, 0.9918834859757673, 1.2736979335231637, 0.5111133459132253, 1.3201010953759675, 0.6934222060408557, 1.806700933171246, 1.227871326456875, -0.08236540540191992, 0.6759689047845248, -0.9553492557260126, 0.48365763258156336, 2.7704326169224838, -2.305805757678528, 1.2077933971749513, 0.23632417012803417, 1.9545946659824402, 2.0069863616967214, 1.8232765127177473, 0.20556668442900974, -0.014784415209188136},
    {-1.7049951078190935, 3.2065340341586577, -1.875582506529496, -0.47390753671603636, 0.19971262105203064, 2.8514863728115465, -2.419669098927748, 2.3165896459684836, -1.19930525743216, -2.2729828953345397, -0.14833018307495688, 0.8363089217253081, 3.6473345971072915, 1.8800483826095622, -1.676241156607134, 1.0953704306114114, 3.438441152445308, 4.533732105118796, 1.0241466953953706, 1.8882096164205882, 0.4335741486428537, 2.1130672197779607, -0.18124622249844372, 1.1371889531340165, 0.4240913910488578, -0.9349912540867261, 2.3385003069095607, 3.512208817965466, -0.09528173113929063, 2.027314718425104, 2.43734178998697, 1.6076593366902086},
    {2.508508430811892, 0.23116940001677602, -2.141497147711641, 1.2006965076493588, 2.85421804366339, 1.636440710667883, -2.6132645024934744, 2.6665265265065754, -0.3673196352432751, -2.7665939661144487, -0.2977368446972273, 0.26188466702593877, 2.516213154225363, 2.815542871599033, 0.6985388865452162, 3.596128416706126, 2.2535666462741175, 1.5990384773846273, -1.0890382494080504, 3.0653730850322387, -1.556500438037633, 0.6579778885297919, 2.5826267776745584, 2.2438221267484115, -1.1595040246205746, 0.6738239839507018, 0.09049470209468304, 3.6601800658568036, 1.444943426999569, -0.8518559332602222, 2.4072973835719806, 2.3802964723435722},
    {0.042812331493379804, -2.4684485208148876, -0.04227346450007641, 1.1750119537576753, 2.90561716380447, 2.0560079725190956, 2.960453197070672, 3.571154883837453, 1.6950161838422324, -1.758643748090472, 0.24834896276634327, 0.014009812225617164, 1.432969994224032, 3.781481248893423, 0.25843806095915695, 2.058162115085489, 4.485885660843276, 2.669124125291117, 2.0494234304023116, 4.107842677583506, -1.9203368354917085, 2.8245214968418946, -0.9092717708709995, 0.32866888531186417, -1.387195747939642, 1.048244625261971, 0.2550595285614988, 2.2878525155572285, 0.5640227981005032, 1.0493344345800657, 1.6234720950581523, 0.625303550293598},
    {0.06237702587800287, -0.5134364453398554, 0.6495160990288456, 0.39133392865200445, 1.5173924987244867, 1.277488565271056, 1.4313989466930548, 2.012856365259848, 0.9755210133728632, -0.6680785641257804, 0.6024344840865687, -0.06991262073464792, 1.7196067473336556, 1.5813586825306938, -0.9703306760482528, 4.463176290031913, 3.2649070925047754, 1.800168170188492, 0.6322778211755076, 1.905774938595163, -2.858763647016114, 2.419012106304797, -1.148023294011235, -1.8343571529127387, -0.720796726920423, 2.167750339049721, 1.262985079382599, 1.5515705798406991, 1.2611661972731958, 1.6184347959573966, 2.52866236269702, 2.888514290796083},
    {-1.5780800418180367, -1.3143850352267545, 0.6202472630584513, 0.8524203137337392, 2.6404415500698533, 2.3520024991241337, 0.36156040955455415, 1.2752232109544732, -0.5113297077940981, -1.3582403764280562, 1.5789014314804855, -0.5429164028360871, -0.18795546875263375, 1.3775143186226704, 2.1194251872198566, 1.4419467599383915, -0.8735607094575045, -1.5935397534007048, 0.6934034400188109, 1.6363803415922802, -0.9003828008057174, 0.8987294875603774, 0.05657596699269791, -1.5193548678484663, 0.9816930011980894, 1.2952405525537962, 2.5522457372590144, 1.447027534254144, 0.6868178535237199, 0.9625797355947995, -0.9411260456639815, 0.6040128036511653},
    {-2.856977629930932, -1.2561272855960528, 0.7085532982215867, -0.08461444903943223, 1.637547182653149, -0.6564688751426141, 0.38884192186848493, 1.476959576960562, 0.15938590017108856, -0.915788956336156, -1.2008215920086707, -0.7762925670276473, 1.977286941319696, 2.1733988336277634, 2.1909290663643524, 0.48436497614266605, 1.115844396371902, 0.9132097521659442, 0.30494501356201764, 1.5265922642126202, -0.7368000192425784, -0.11167817164876331, -0.6893359438840272, -0.9343658033182927, -0.9393586462387604, 0.4966395080068604, 1.5467757903444632, -1.1770339806415926, 0.4831990396755253, -2.2004408712810175, 0.6302071363814199, -1.1048251708106556},
    {-0.5405816613071661, 0.39390839436904534, -1.2565212940698982, -3.2686359402270213, -1.8724629747109969, -2.3742246168427257, 0.05256267644428353, 1.2071882799676914, -1.6845953751275848, 0.28488866599302143, 1.0547076706723773, -2.117538877132887, -1.2995200541248149, -0.8132719721630193, -2.5798891748384327, 0.3133352375679944, -2.9503962036543174, -3.774135545977259, -1.793915459526141, -1.337512696402286, -0.6737324967747672, -0.6467258482408245, 1.6863700106296222, -0.13519708125163146, 0.5790852737566408, -1.2429760651792388, 0.6111092027936186, -2.4430031240465087, -0.29790403180134684, 0.7737711771106063, -0.6172971627882011, -0.12481742006707888},
    {0.502239669697156, 2.3085506859513676, -2.205836416435201, 0.4485433932606033, -1.4720550217353825, 1.7623947367452513, -1.3441810513693084, -1.3622730435638657, 0.38353186151699287, 0.3016290793154485, -0.12772427654943228, -0.4218162642955409, 1.6597304616350068, 0.9775490399479019, -2.009517201049904, 3.02685290531979, 5.201347043677574, 0.200558451238714, 1.3931559834038016, 1.5858311912427177, -3.712449792344906, -2.0852013061466534, 1.8141620762206123, -1.3447715482827494, -2.1241337199325105, -1.0757157173602137, 1.1430382427907804, -0.7720036384115367, -0.18680589779135026, -0.09216802534414169, 0.2071981285245359, -1.6528640934539351},
    {-1.2918542529572759, 2.307190843425319, -0.5970547548951061, 0.04086513472371982, -2.9292506480308584, -0.12064213164095605, 0.3185499369673226, 0.8056875136386175, 0.5494575510171653, -1.8144953479861126, -1.0515257191295118, -0.7339719994137942, 0.7435618634052168, 0.6422702826380182, -1.6244143054995719, -1.009135479224201, -0.14544044143529852, -2.0164892572205577, -2.2814463760174357, -0.8980697631128596, 0.4202284287384544, -0.13518904046240465, 0.2980240963258139, -1.0526798017173826, 0.7281963361736488, -2.704232795092718, 2.1208988781671487, 1.251741487165483, -2.2689059346998572, 2.244467389342859, -0.4839355586413254, -3.17743244298989},
    {3.17722075766203, -1.264470754305948, 3.1154985671930993, -0.9351322117241373, -1.6336123871103265, -1.6838397635805933, 3.000810379293061, 0.084061517150877, 2.1089691081057196, 0.5410622912802958, 2.590210044454904, -0.7918678408063176, -3.379260745206945, 0.9409402903051269, -0.6223357829617633, 1.9476396407431746, -1.9263206403008137, 1.4182398686329194, -1.2940841806197674, -2.8143461144419595, -1.199300439276473, -1.3592961327844608, 0.3018943263843454, -3.314497353727189, -2.7706219956488414, -2.170144760289809, -0.8607878912430634, -1.96926481429804, -1.2662301251750492, -0.9421885364086273, 0.27400226639174335, -2.6782424630506547},
    {-1.0114875420128964, 4.018868483639214, -3.2613728103709394, -0.7350054324367148, -2.3128603645140537, 3.2266818287573784, -0.8958487377385284, 0.7669979874421694, -0.6372277637029872, -0.7053608828570298, 0.9021261328425398, 2.3751936218525467, 3.846261662156584, -0.25649745997612056, -0.7091856202661506, 3.995863696018518, 2.0010134737772907, 0.6766180381567882, 0.9608457480829001, 1.386680644285316, 2.6425262030192953, 2.1395553335943016, -1.6010259607520165, 0.037880131263535635, 0.24731530566071067, 2.2492649689070836, 1.599975061201553, 0.41749177397686915, -2.0731550405625896, 0.22782438700596008, -0.7366944984354179, 0.09208190539882198},
    {0.12655961492734627, 0.47418613172233814, -2.060624248817089, 3.3691512566703548, 0.5631208347836643, 3.6827517728512764, 1.5522654376562142, 1.588308549890311, 2.695220626673141, 0.2796579056163563, -0.3116123934938981, 4.38525311761504, 2.719767109905478, 1.8990703503415298, 2.3767672981192667, 0.9103661027516583, 3.6404585327499777, 2.074956841623331, 1.2671985661447578, 0.2851584958267314, 1.724976199388452, -1.9967431898925398, -0.39798476968192187, 3.3643831061626512, -0.291232915998161, -0.5532433172756316, -1.1472106060385392, 2.47315295913142, 0.6627935479998951, 0.4851619078632721, 0.47292753384650166, 0.11183963796683469},
    {-0.1569348132372032, 0.9829566322971512, 1.7553849718577603, 2.7221509942249082, 1.362139074933405, 0.5967045410372844, 2.0385796160082004, 0.6271171165164962, 3.583036519562844, 2.362012421043675, 3.6864825299104576, 2.471750093664711, -2.5201811572935635, 4.635289108518221, -0.03250987786697963, -0.7292886300341419, -0.8149566313577765, 1.5434529626208924, -0.6609815514155064, -0.9539854290771286, 1.2910705289428221, 1.3174117841400474, -2.1031586503924498, 0.6170272888315926, -0.22530403915990213, 2.9973294280045764, 0.6337807258984852, 0.5159629111241923, 0.3213196067811041, 0.15970652229793586, 0.6203509527694501, -2.0992897307172846},
    {-1.7443998800094673, 2.199147998975098, -1.6539906518545153, -0.4657666278631945, -0.7344421743047695, 4.567231942088746, 1.0338648392603438, 0.3079245084842801, 2.8597756096967375, 0.7109151266100087, -0.5009429110174904, 2.1656116294774703, 2.8753123240188225, -0.5942605346412094, 0.015683183654856898, 1.09832642338144, 3.9209871441218844, 1.1750689324683001, 2.4076302469505935, 0.5516650889894712, 1.388823862604892, 2.1254170621180823, -0.49183301283753134, -1.4835959421581635, 1.8956328916733898, -1.3326272868059392, 1.7993482586781875, 3.8414974119765843, -1.2879780208366458, 1.1130172240432907, -0.7343463894629312, 1.4309471818483575},
    {-0.34818771335894144, 1.6072705841420323, 0.07604354702248191, 0.28808358210721824, -1.0782750564976262, 1.464330132958653, 2.0681911725517734, 2.1361665839988153, 2.422421463693974, -1.371663723516306, -0.2642650585501212, 1.3165954525966734, 0.8885389517502412, 3.8459103225923066, 0.022861845016727767, -0.0032210056011054674, 2.9537684400877118, 2.704636495558244, 2.8174613818693888, 0.6991832382474055, 0.3315245659159313, 2.3964584303414163, -0.6365393823380407, 1.8755517313754784, 0.6145110157434016, 0.1876242156686187, 2.625357763688384, -0.3558078573655417, -4.188138880480106, 2.5942131746787234, -0.1498045457166299, -0.7032968490298578},
    {-0.1649177886873605, -0.27843809789780605, 0.5526019846698217, 0.31467290345673116, -0.4835458285843004, 3.426169977721115, -0.40428833760250266, -0.36453105396033214, -0.5554787048120158, -0.9507343091456174, -2.732843005502603, 2.8675700601744256, 0.04859361039283898, 1.0103085635677098, 0.1975073045398332, 0.283966847081987, 2.8244027487605554, 0.695077874146866, 0.3241706623497755, -2.216876746701323, -0.2496166358609832, 1.9142860227976608, 2.027436644534721, -0.6525186712023456, -0.11459992341571844, 0.8473893201174356, 0.4983194427487367, 2.210272997012866, -1.7813253606905226, 1.4403411862540523, 1.0446719448254103, -2.410247437787054},
    {-2.788207454331345, -0.6570388094281783, -2.6469087874584916, -1.0815908888581582, -1.4404930703590164, 1.3913215079807653, 1.0559536472458162, -1.8952214452357465, 0.5532555715518354, -0.695518749713358, -0.766854664322984, 0.07055085064230675, 4.007947384854193, -0.7659778479256316, -1.2957740966291307, 0.3389832138330342, -0.17539214349780816, -1.9345628520607616, 0.06307209105420493, 0.2520857504875884, 0.26620266610547466, -0.7083996516491613, -0.35148233100260495, -1.5486614236391905, -0.8429512664223283, -1.5563890027927014, 1.5616100849946135, 0.5961014536967701, 0.004309694528485932, 2.0798458896509437, -0.9743788663179231, 1.8847952041917388},
    {0.009490361968107059, 2.54532606275269, -0.17655046636450603, 2.436571815143833, 1.0372243335698896, 5.1705963896119025, 0.6460466234531899, -0.23910063132529383, -0.06539754869452098, -0.5761375262107866, 2.537345976990427, 5.409671160635457, 1.4531960909818114, -2.371842298322922, 0.9966303555283073, -0.24415037176550655, 1.5022146020925826, 0.5770417749535631, 0.8511871941385354, 2.2171254278750294, -0.33384005552648, 3.3808550030673783, -1.520336661459045, 0.011865055980603926, 0.18909295317179978, 0.3866884525538819, 1.7816335277800013, 2.5623865042383636, 1.6240864593752757, 1.1305619225839316, -2.09329532369131, 2.7010342437170873},
    {-0.7289469615155055, 0.07984330453040475, -4.575957133870432, 1.4830338378510153, 0.8846002707235497, 2.2682734986195667, -0.8257173959904397, -2.6253495037830827, 1.1899504035282151, -1.6610963734319353, 0.3908699646087235, 1.2555290402682568, 0.7437335982434706, -2.3479177571197227, -0.4259025453745683, 1.532775263304464, 3.1971452067163386, -3.2742377696202247, -0.9373789576444852, -1.826417929404208, 0.20605441424861493, 0.8710006583249001, -0.5965012212368751, 1.9749601327026176, 3.303686753570633, 0.34856790558304135, 1.3495859342173704, 1.5002201805518305, 1.2682776048642985, 0.526731001524699, -3.326462411276929, 2.89521292897289},
    {-0.45150856832371283, 3.2523894069467003, -0.7364097543846415, 0.7470365703666542, -0.7382706703378122, 3.403532953879861, -1.0096110521578683, -1.6883685576937097, 0.33725902784226275, -1.1065526795473215, -1.4858907425380188, 1.4573561652328606, 0.9549864085878226, -1.3205121717894786, 0.2717456206517939, -1.1084138779510013, -0.12056604392721314, -1.4075485606436058, 1.6688821881255032, -1.5956854230430375, 2.129339371649227, 2.924132490448867, -0.3022096627319598, 1.4080487804116806, 1.6132853069162454, -0.340415884836747, -1.0231783852831249, 2.9934499460859367, -0.6499244664005043, -0.15641873141035262, -0.5568491194141203, 1.1684868167863836},
    {-0.7956021761225535, -0.018394129393193254, 1.5593363290340079, -1.1933780229429527, 0.7924510157832223, -0.40454379576811167, -3.1145116279184633, -1.4342906752823708, -2.1182926995837046, -1.4608395034960053, -0.6144097073364212, -1.6365981345735898, -1.359555977148407, -3.324107792082267, -4.923017814510503, -2.4068232299431496, -0.5293669122550387, -2.2654140122716817, -1.5709290520899863, -0.9581499499522907, -1.6685203878790342, 0.8370923801458816, 0.30435484129751256, 0.11932789913479441, 3.2094371431950917, -1.8428362311474724, -2.721020297341734, 3.0272299412174206, -0.26694961722459926, 1.527945290923362, -3.2453276611635813, 0.9716874739666198},
    {-2.4742176008586356, 1.064553368860867, -0.018592508042540534, -0.1950636824466963, -1.2010516066091936, 1.7052421385925505, -1.2616853954778768, -0.1876748063423568, -1.278443217669499, -2.8957596268576573, -0.526578842138163, 2.4985899694286355, 4.864338003134695, -2.2059860721810973, 0.39469341358827975, -2.370383301189451, 1.8825382739423364, 0.6055224660744806, 3.0644233861518053, -2.3598763268459724, 0.08289464082762218, 2.1087055798995316, -0.5629057126384732, 3.1459768577617266, 2.8535283666853024, -1.8204572471451383, -0.1477397262824674, 4.340039549676408, -0.3931046885012527, 0.7680521607096624, -1.4229765762590603, 1.728179032564299},
    {-1.2873724786925609, 2.1834527282988705, 0.6152952479034414, 0.45672180347260855, -1.205064285339969, 1.7409566175064974, -3.7488593372816896, -0.29520379067867997, -0.5549115862949313, -1.71886190446962, 1.076339586659708, 0.9400751521474817, 2.7321695523337484, -4.835485693618259, 0.020899229850399697, -2.9563172699167364, -1.9983406710965947, 0.011247491309989898, 0.31949365209522135, -1.0766522431947192, 1.4400919729987272, -0.101848713814001, 2.155316590027638, 0.6272301836601819, 3.224147338813338, -1.2979048865268619, 0.2069589664797111, 1.826675844420603, -1.646309468079231, 1.8735247158877018, -1.5607424160450993, 0.9443576817591648},
    {-1.3275776861586337, 2.4156507958122044, -2.05624705799509, 1.3154721877828608, -0.712932329689526, 0.6646991046047661, -4.26741183282399, -3.2319449413405676, -1.0841308398341056, -0.17576106158320223, -1.4386205881123328, 2.15030063784534, -0.2944634599821916, -2.7142604068329743, -0.6410378961455538, -1.619169804501164, -0.13340656778657273, -1.7366309448498125, 0.4453559583094319, -3.355953695774173, -1.0745308396200604, -1.146641354012102, 1.9286475234743288, 2.6398836895128843, 4.126536452074114, -1.0156996819419681, 0.028954989127682573, 2.9143898910502104, -0.3762891807320772, 1.5027563482452782, -4.286456958534501, 3.1749674409734423},
    {0.7942377562361448, -2.4209586883943475, -0.36400719674013354, -2.2693783156039466, -1.2600543367023027, 1.677313101294376, -1.7272734462234702, -1.4510582953846143, -0.25251416841952673, -1.0825114897953982, -1.4329299961505908, -1.158988513395654, 2.9590030315264273, -1.314009632749083, 0.42471530223318793, 1.0367408471728314, 0.8386428336318739, -1.3819667352626002, 1.3278656209986965, -1.42504674430693, 0.881192695485979, 0.48592892688120115, 1.0976511903886905, 0.22868978317676622, 0.019269800826588062, -0.009132118649638777, -2.4188306863973836, 2.6110601464918437, -0.7042535089886051, 0.815926731675355, -0.4443149454600711, 0.8320448222020236},
    {0.595931142827148, 2.350093002652484, -2.654072672660365, -2.9750605027701718, -1.5259419343113894, 3.2888061602796155, 0.22800233985249968, -1.916594434656128, -0.3191527575599485, -3.1836508654728095, -3.339683085196414, 2.3589240857376397, 2.5484733838113303, -0.9404872219918243, -2.800154419259631, 0.4461003474764208, 0.08463058567968192, -0.7449938573279431, 0.7277501195884798, 1.1502913697474788, -0.15879493187488344, 0.36052940064757627, 1.2822357779840219, 2.1264997197075286, 1.256106840844246, -1.9907021791507118, 0.5589084489143153, 4.465760505874313, -0.8392438473622428, 0.20813879161228732, -1.7994927539098515, 3.95178936694128},
    {0.987747729765723, 2.6891070563872272, -1.618498712173616, -0.41330141263787934, -1.758694667211646, 0.5692178809674856, -1.4255875624124, -0.8742631704327418, 1.1897878310248708, -2.419544336117831, -1.8235079760246506, 1.368284343732795, 1.4262534361575363, -2.58758986338594, 1.0361972856238266, 1.8356315465940434, -0.9676130921351371, -0.9180511001184267, -0.08400777442215814, -0.12861093238051705, 1.2363360465362623, 1.300993388632588, 0.6015031266632602, 2.109280057871133, -0.7583223463957472, -0.05017555938294131, 1.504937596982617, 0.6828142894806586, 1.2038035059725147, 0.9628589666880268, -2.864824071858958, 3.749898370236444},
    {-2.6486533499316147, 2.152084087373547, -1.7052704154949918, -3.73453396664421, 1.7785600894732898, -1.0647762856554472, -2.412874320466893, -0.9717884915226618, -0.8681863046172107, -0.28882480933532517, -2.496711504846509, 0.5928001979768464, 1.2671500063656385, -1.327733211642718, -5.383328798824588, -3.595846736858688, -1.7971700379578317, -4.340471103938926, -2.570720498305812, -5.58226517862944, -1.8707669630102635, -4.276626046377792, 0.6993430937885099, 1.3875512805352046, 0.4468545049827992, -3.83752842095874, -1.0235148838964887, -0.860892211262954, 0.13078946778290665, -1.0138382521136622, -2.185006657392577, -0.7799087386680963},
    {-3.071504580257899, 0.8986358934830693, -2.579516944998609, -4.2061103640121, -0.06236214203034402, 1.0046026706184878, -1.1691398560541597, -0.4569636035467589, -0.5674454022240665, -0.44682847349792876, -2.7275241968139223, 0.8288088630231626, 0.6837959502152426, -1.337530174404803, -1.3300435377346598, -1.347930563371941, -0.3434574294577356, -2.764986238395935, -1.7410569674806053, -4.631446087008623, -0.07679634876570826, -1.8794305066859567, -0.6886317585367666, 0.5237301677448309, 0.5065427102224295, -2.177347815209039, 2.2428222442788472, -0.9654349162288308, -1.312204343382753, 2.497410197078132, -2.603696476012714, -1.1614729146470895},
    {-1.0446965793314282, 0.5779229016646165, -0.3662668743053543, -4.956077057316382, 1.7006972699987069, 1.491472366847209, -0.037852441995512257, -1.8390915725464778, -0.43254519780162065, 0.7141220152162157, -3.511691500621503, 0.4078288534596116, -2.0123835723920687, -0.47438079621746754, -2.5713150257897937, -0.6500193900852991, 0.46119529568152123, -2.79757624387661, -2.796650589683851, -2.410484957183069, -0.04188202004239875, -2.5628229710487704, -0.4526156288313803, -0.6016447793748291, -0.7368255314958817, -3.007024651529276, 0.7552186762498363, -0.5990802667765899, -0.05877099458673722, -0.5732100302137666, 1.9209584206004489, -0.24943390000731555},
    {-1.3111201757170472, -2.455341574034139, 0.1673124684280512, -1.76540156056249, 1.1836873668456303, -0.9527162284524421, -4.218441651306486, -2.968910581722767, -1.9515965780897115, -0.12517429723109882, -1.3059560236766115, -0.7156251749660505, 1.3264000906485158, -1.1845844090801116, -2.043616429758059, -1.7845271423806686, 0.6616659039783506, -0.029278428239285163, -1.093449448521586, -1.7201065407622849, -1.8745389341357284, -1.3496108708118038, 2.4124093748671918, 1.1530850445974383, 0.5466051277393273, -3.2177361126481148, 0.7393851894123482, 0.6600021974189227, 1.223073782648332, -0.9928109908220863, -1.9949862671737244, -0.9151778089418798},
    {-0.10809456787927031, 1.028297431684232, 1.2776856789191307, -3.363188566216243, -1.253249423612568, -0.7230536889665299, -1.9605527530216416, -0.6260870421123761, -2.1274210744318274, -1.1151356021167969, -1.4301533882172845, 1.8439648663651673, 0.8773840840363848, -0.8032491872672942, -2.023438915857545, 0.045281389796734746, -2.493905536937973, -1.9913216779238927, -0.4589309799889725, -2.350844763176584, -0.4153533379357983, -0.7814266791505913, -0.7409888038920696, -0.6596456771150959, -0.4903237408010607, -0.43509045306582617, -0.9227215899646608, -1.6398139572327022, -0.8855691865656702, -0.5118921621633161, -0.4722718421701594, 0.1938160286048443},
    {-1.3910148834000424, 1.192386555244549, -1.7644885699319257, -0.8151116412856799, -0.4234746872585614, 0.4745192520990196, 1.52933706559987, -0.4523097096726303, -0.507853653078321, -2.398406103571773, -2.6524551774795513, 1.3762631664546185, -1.633508686889704, -2.379216911293672, -2.2068563644168178, -0.6170754948844864, -1.0542976211725703, -0.7167985649390399, -0.4785090761711622, -3.085734520106526, -3.2916007170998403, -0.4748471119773997, -0.4202864023608536, -2.1518477367104847, 2.773259939354297, -1.8987985089717268, 0.8785600476754964, -0.28511868069094354, -0.20726566479378974, 0.620849942662862, -1.5410694076600866, -2.5563321038160964},
    {1.3662179816845692, 0.4506589053870139, 0.5079488810938857, -1.80004721591835, -0.10949357684283643, -2.2670067788610644, 0.2899320240447992, 0.7740564775060413, -0.2091952482696426, 0.5698825045999847, -1.080069596035096, -0.016622470616806585, -2.58669402908487, -1.824498514875116, -0.9570022545836129, -1.5342921472978683, -1.121127488438792, 2.1861764367201304, -0.5555535164595714, -0.38893350548601224, 1.3788899820202474, 0.9327829355216455, -1.7106727055292148, 0.9200352503783694, -0.07618273930755236, -0.5440306707174964, -2.058986350029632, -0.19178779823346775, 0.629006621299841, -0.8168156448087517, 0.9866065034193892, -2.8892356300321853},
    {0.6659986189252464, 2.699442873103081, 0.07325828881186447, -1.1601041702699846, 0.3204394563999373, 4.003120901696829, 0.27061905599199565, 2.718614547747722, -0.5154337960519187, 0.9913153690623636, 1.265219471007481, 1.6188069594097847, 0.8197685671012557, 0.5015378682391439, 1.224156263424348, 0.8238715939056642, 0.7680074425369835, 0.6012715492908869, -0.43069696486952724, -0.23512857733732867, 1.8161513546062422, -1.1146872757429744, -1.159520800711401, 0.14547537966319465, -0.5604769638485019, -0.05281279787382272, -0.5997349933379272, 0.638494423013652, -1.7478111986733482, 0.6715704569955755, 1.6752360474273442, -0.557092180258374},
    {-1.7861222616053338, -0.7120275794107007, 1.3821947576635554, -1.2221789231127782, -0.9493612190219233, -0.026362293164540723, 0.2422425860063906, 0.552908555537706, -1.3406917106510372, -1.0836987730258623, -1.2488800458868308, 0.7123131691834069, -1.825708474510723, 0.11637892039374964, -1.336992171804126, -1.6332694022554468, 1.6657002315998908, -1.1427197504253856, -2.3013883056552755, -1.212654784004085, 1.7586160277819851, -0.34351064005341636, 1.1531986984262415, 0.1975348063569468, 1.3366285560227902, -0.9327389930042965, 1.1331647627593642, 2.510679254772263, 0.5235657321646799, -0.5089017464743937, -1.9718720694386902, 1.3023739932206673},
    {-2.619066785470586, -0.7452988580619416, 0.5099993102562647, -0.6872710377520398, 0.8247814084122167, 1.011450726394641, -0.4860329048855203, -2.4795869979250016, 1.3061155630541816, -0.9362579934572537, -0.19789887649670856, -0.17457434480713752, -1.4896978004398624, -0.09012830477889587, 2.310869155858485, -0.9436113560032193, 0.5200546610987538, 1.5521454937016324, -4.088600900238397, -1.1905970079113368, 0.5687703392359256, -1.3977819512207137, 0.6838478003493597, -0.43471689254571927, 3.301100754619067, -0.27643190884203717, 2.8491353974762412, -2.0868416456926204, 1.6890028283066467, -0.04632050374297004, -1.35344473763268, -3.129107747266582},
    {-2.85540156374802, -0.4184024445503496, -0.18440157272175034, -1.1741836243723498, 0.9475116635258307, -0.8985424897034022, 1.5892435044164752, -2.8253705191902885, 1.156898628634215, -0.9042819711754152, -0.44618869617001244, -1.2974195613361719, -0.8190201333939474, 2.4078202623247096, 0.20227646008502628, 0.4440352046649767, -0.06403005226946247, 1.150030907631884, -0.8475834372471066, -4.646749997896256, 1.0989433062003027, -0.22078043927284813, 1.9783858698196854, -0.8811699028571622, -0.16748638573256264, -0.7597541226870203, -0.11687924618569523, 1.138260386772552, -0.44937357517514054, -1.5466066687712685, -0.7642327140621976, -0.6544735616237426},
    {-0.3238722335828199, 2.9230173560666697, -0.5023760494247136, -1.0616121802995213, 0.5897065530074732, 0.025961618276243156, -2.478173915814311, -0.38446517418081033, -1.2509595190347733, -2.3583991515987854, -0.7476179569406505, -2.068185460044256, -1.385688251150747, 0.5302095932124593, -3.3066001643076905, 0.7536114213634488, -2.434153086101143, -0.1890832864993411, 0.07281913471251061, 0.24877416192252205, 3.760505983588643, 1.4400502218112765, -2.703422572677768, 1.6227606074433636, 0.3230950994529323, -0.7122481999645446, -3.1771953432201085, 1.5114159924643884, -2.4535392179306115, -0.26615937837044373, -2.33535145475395, 0.8041856064816026},
    {0.976131799716058, 2.5191587393027373, 1.0706038245796587, 1.6561616602642706, -2.5975272535740097, 1.0320404933756886, 0.34968009982055775, -3.6445730376194416, -2.131330915455883, -2.7360285712658325, 1.365523048670113, -0.7153075887976483, 0.11745437423738794, -1.1573381214629352, -0.9097853896493863, 1.7729468685160206, 0.8968151571977366, 1.0064072616217465, -0.09205224004641571, -0.4883594954143599, -0.7526408504028976, 2.136090474141989, 1.4804523320791596, 0.7110401232685505, 1.1337793247598527, 0.39076493658008576, 0.6116752900865422, 0.8248619298163554, -3.2410195884473643, -0.4886770980758907, -0.08928406461587649, 1.3950656643267982},
    {-0.21591522721871217, -0.7767788391058341, 0.44940010000135844, -0.26409626952546633, -0.7559898343453467, 1.3364950232751878, -1.0918468545971187, -0.3807702955230358, -0.8960924062467792, 2.189922822276249, 0.7229719602483538, -0.007553138257188439, -0.9326070310036287, -0.5148579724768229, -0.10049862055445863, -1.2861431140585025, 0.36082919943093905, -0.26471646128713006, -0.22531799515732676, -0.9835104179107085, 0.6774985567184016, -1.5376317489112017, 0.5941512422368411, 0.9509189255803028, 1.392630305703661, 0.4784426032267288, -0.0011391083716460384, -0.016517313633082828, -0.08526849342117421, 0.7642980558623919, -2.2006825353527573, -0.5987781229434698},
    {-0.7970473911800258, -0.7486181439616576, 1.2760325486223447, 1.320586406575213, -0.29824092531978497, 0.5803025930954236, -0.6493525841941309, -1.0368410823402923, -0.8725309004951921, 0.6469255261337441, 0.73026155935214, 1.3046969705539124, -0.09397268711967202, 0.39947437274493147, 0.8842352851356474, 2.533762374370123, 0.2432270293380088, 0.5698180293616588, 2.321429351058111, -1.208637122572986, 0.1107552028500624, 1.6347259371853717, -1.6959345726034767, 2.298926478977093, 1.4556619745994879, -0.0383276785837069, -1.4699493329427082, 1.9502268257318331, 2.6513756217064004, 0.2150538275680354, -0.7209053042629598, 1.1574977657397336},
    {-1.2868258485345396, -0.38794048342579973, 1.472765961279741, 0.1800459722501527, -0.5109027327135385, 4.735741775946799, -1.9658636940572365, -0.5309671646982292, -2.287895373128716, -0.6045954576102656, 2.3002999572641527, -0.2528299562299523, 0.2823045708517342, -1.2159050817190382, -1.1532776093815005, 1.3328150194006012, 1.6418884545032042, -3.2102537632564325, -1.3122215811482352, -0.7106208352730956, 0.489520363344275, 1.0005143486301695, -0.38922835767902203, 2.4835118823774467, 0.31140711207697014, -0.2192055562638784, 0.22302252299867828, -0.7016086496971359, -3.214092544135851, 1.3568385155058358, -2.843789449338237, 0.55143811472412},
    {-0.39293455070699324, -0.8675944359569858, 0.37317504972289234, -0.15883809893329245, -2.4612293504780887, 1.1418367169580597, -2.2198866215835897, -0.8625447540561128, 0.5341426324495528, -0.8427976837442185, 0.0662410571919698, 0.04476618356686313, 1.963724772011764, -1.221215961120274, -1.8039557670844548, 1.0149811156895827, 1.1366479279272999, 0.202863140716029, -1.1290897859628914, -2.2964064879228396, 0.6974022803272522, -3.5095741402143408, -0.010177842061513034, 1.03657799672224, -0.5081240791534783, 0.8041687444043502, 1.6701788947902756, -1.4927688223919413, -0.1347396828312553, 1.946139225044896, -1.0719772848712246, -0.3797984138584235},
    {-2.0315968310940686, -1.0545346875718684, 0.9325544488305867, -2.2588437976804436, -3.531861853164256, -0.48878783116202573, -2.152243771731966, -2.067378001729799, -4.782027402722291, 1.3456134521450618, -1.5224344935931997, -0.512954458788395, 0.6788215192072706, -2.083703096529751, -3.257907381080471, -1.1626598307494391, -0.058609474886833636, -0.7781645644008477, 0.3681280869061264, -0.37749958415383883, 0.3507552475391401, -0.6308186449712765, 3.282713017676837, -3.0328172465554726, -2.554192588873707, -0.8982748554237053, -2.179684666002725, -1.367784101353928, 1.7809709993596594, 0.9467893938829047, -0.9872671746327447, -0.011127488115590684},
    {-0.586707920532412, -3.7088861824884582, -0.24404577127123447, 1.0778983391903263, -0.356831380634001, -0.37908321624876495, -0.4370561034515816, 0.636000936739379, 1.654297856637468, 0.7243514271984374, -0.5897530399864338, -0.582473323131663, 0.9363419472447154, 0.6053491969395217, 0.555794020335402, 0.9939171229283112, 0.7432731433824862, 1.411023054756722, -3.2835687562834135, -1.639134544939664, 0.8310887304034072, -0.22124725348393812, 0.7151342849423951, -0.3496818070680456, -3.152777490622747, -0.885387456438607, 0.7024698707577871, -3.930380923406302, -1.6789598440961488, 2.655545191588194, 0.0683420308755755, -3.3503200499128414},
    {-1.299346387700056, -2.8322613557391283, -0.2865299326155849, -0.560963243542802, -0.13420187579298548, -1.4994478694673774, -0.5010985640969409, -0.7025431879091889, 0.3203739816914783, -1.7197415570927133, -0.8672026984703637, -1.4956805181479098, 0.1773125887504547, -2.41273248035434, -2.2209891390623033, -1.1104929588733177, -0.8836493206638196, -1.3770136567618967, 0.41765915981142526, 0.37251101215536603, 0.9894005491845721, 0.8614495523674455, 0.5450774016012545, 0.4204621278824644, -4.386260683574065, -1.3299948978428784, 0.19295494363553523, -0.2659728584209924, -3.189480187279875, 1.9346987144427095, -0.6418226791929926, 1.6573858348082329},
    {-0.7311111914399152, -1.9359819951062838, -0.4058579376273598, -0.0773706150768023, -1.2134413846774086, -1.637146408216013, -2.2305933584559283, -2.601891851471597, -0.01832478920766774, -0.32599964507601625, -0.811299010550366, 0.7907643994252684, -1.3020235080919125, -1.7618608965387883, -1.5890127853774882, 0.8358278659190095, -0.5157094224567532, 1.4910916466041046, -0.8027668068542672, 0.2094141442612756, 1.656532847857788, -0.049028170087115984, -0.6615135415929461, 1.8204048992308641, -2.975233653421105, 0.2775149400691323, -1.7982244974066917, -1.4129252973379778, -1.6309282260832367, -0.3832137265664832, 0.275332370595816, 1.216374377952269},
    {0.5740798404629693, -1.3786819790112028, 0.28200021582701906, -0.45697976566582377, -3.288023071002206, 1.0403639438455976, -1.118930934346836, -2.8540974726367536, -0.8399370764674203, -2.196312749309036, -1.2902101949554496, -0.022093310514713527, 1.3596954604785887, -0.740412627435709, 0.7010542171794915, 0.5044313444829647, -0.4774961505577877, 0.006799517189504971, 1.1836510712884065, -1.8807609234640397, 0.5800694112054612, 2.385008060320434, 1.1908133519891368, 0.9249635885343036, -0.17691588987081072, -2.2579618262408654, -0.1152536507963538, 1.9979361584733084, -1.5722539922646859, 2.0411594030335825, -2.1067381338794857, -1.3909338228551154},
    {-1.108182391402505, 1.155162621786202, -0.7525304783186202, -1.8656883220268257, 1.7179617897915738, -0.5254226638003947, 0.42258045940694916, -1.8663129217807537, -1.3130389429016749, -2.631267093072584, -0.7159355734495233, -0.6805692304571785, 0.32435907571754014, 1.6053098748141885, -0.604327433953309, 0.9084186910061641, 1.8263379549965995, -1.0499195304803999, -0.7753189382199851, -1.6698906824554904, 2.3093841755571334, -1.7674325097824337, 1.4318064711648513, 0.8660887552311508, 0.6370344384034738, -0.47584659939467566, 1.81479389203052, 1.889353975036774, -1.6021745121060103, 0.5703965170314658, -0.6674494702970185, -1.2975838148646912},
    {-1.695824599336492, -0.22693146310423265, -1.1609468198208448, -0.24080206370310597, -1.6276909063614002, 0.08619053772614305, -0.22456393602867109, 4.826300205360771, -1.612715673717165, -1.724073310053604, -1.4261768287829795, -1.1457864279776953, 0.3908495452565806, 0.6035899455946565, -0.6597947089139595, 1.5047304188091122, -0.18093937867936508, -0.6018519169905293, -1.2338149132299194, 0.22018304288604615, -2.5365073439309946, 1.2851150005243428, -0.7663931269301474, -1.1879916211860115, -0.06987352129510446, 0.4103868357783977, 0.28131772261368004, 1.240658589602077, -2.0319089920720774, 0.2102421411616772, -0.6675624115630426, 1.1637771726342863},
    {-0.9739720505703398, 1.2776653314431599, -1.9833489242044742, 0.07846357579257704, 0.43871073790606857, -0.02210309646692186, -0.22164948628578998, 2.437432213368989, -1.6850935281964963, -0.27335291058005173, 0.6580369968693646, 2.853204679391622, 0.6439731600638038, -0.08107492224922454, -1.0408309059527872, -1.1152010760735427, -0.2357309209066506, 0.06384191714000358, -0.07188569642610826, 0.35514199004401137, 0.9457506452266116, 1.4425977176583233, 1.4549258539439482, -0.5545396552097469, 1.1853758914235257, -1.0672685946729596, 0.2818778457307807, 0.40992378942374164, -1.0448376959191361, 1.254625750932112, 2.152068478370689, 0.08809605056340843},
    {0.15092287471284177, 1.4844918528656217, 0.6178646999362944, -0.5702560777494843, 1.2608054479951347, -0.9586320992399812, -2.2922189857059183, 0.5401599834701821, -0.8597113416760216, -0.6215480922333979, -1.596528888018172, 0.34972350906774613, 1.5929761334576624, 0.4504915113049129, 0.5429847759111269, -1.0862380983918358, 1.9145502130961913, -1.8546534577020213, 0.4511593262855479, 0.6248707636024335, 2.2859022508339653, 2.9070364511198443, -1.7176123733869761, -0.019901055455144364, 0.7235302762398396, -0.7421474119283522, -3.504679521910932, 0.1489308457900096, -0.6274342074988398, 0.3195037045177575, 3.162406222845482, -2.1864160589073784},
    {0.5110911463881793, 1.4596620784059575, 2.105780850190711, 1.3024694238744121, 1.3637220203121136, 0.6559699837165942, -0.8869454821787223, -0.9385142557273197, -2.9726087946164967, -0.8241950027800368, -0.23957284129496997, 1.0244759724579426, 2.880194307761213, -0.6431924640934317, 0.1621204070027886, -0.434122191317499, 2.4154946269557875, 1.6652597225562542, -1.4407698485981004, 0.19653426347645278, -0.38192163290947745, 2.120845804264805, 1.7493765420946077, 2.516966261914706, -0.16458987174720852, 0.7469841198218928, 0.4703488189836463, -0.5982694682082956, -0.7396020603690209, -1.3018984225479127, -1.9486120637945699, -1.135894306943856},
    {-0.9491960220228743, 1.0383831891756519, -1.9014643154714168, 1.514758010494377, -3.48719913477669, -0.11311243308437961, 0.6879791344486795, 0.2047568097825876, -0.5273808069158262, 2.3984342290897813, 0.8127675425204087, 0.1841327146969818, 0.2092693178226226, -2.181151216531575, 0.36140275409734385, 0.9187338125535232, -1.4660789151432552, 2.788641805321048, 1.1203993693607395, 0.6061869087225297, -0.7072583906343307, -1.3363644745721706, 2.727443575882955, -1.8045310855967875, 0.7532608384761146, -0.7375529699320672, -0.7984826478878099, 1.174774302077559, 0.20856878934638534, 0.04833579953121299, -2.058590542324729, 2.287723858503485},
    {-1.2951136770759588, 2.161449442093268, -0.3015884152808347, 0.6239202048964075, -1.1754009955027391, -0.7342869040360822, 0.05916173515936602, 1.24270983201845, -0.8309805538244817, -2.2742929009078083, 0.61455074447461, 2.9879041146956866, 1.0074302177753007, 0.13535146694340594, 0.9094754146151449, -0.4693810647906355, 1.173361436691717, 0.7730273887325274, -1.3062506652014856, 1.2143396172791248, 3.3349542583758143, -2.5052373509336965, 0.5584504873666172, 4.08763622227697, 2.645537714647709, 0.8084234747416632, -2.0731535736956674, 1.7663351923134598, 0.4042214860236116, 0.6723736314702102, 0.9742833446345254, 1.2247936906027332},
    {1.6174676557843386, 0.32602822665747344, 1.6134785174527033, -0.9212243174789096, -0.48769092085483123, 1.1471009414312725, -0.914756603060756, 0.6684874907739621, 2.7119775657561638, 0.6596231884805346, -3.607106184998934, 0.05902616922902857, 1.6733872224835753, -0.07772935372366468, -0.41231960860483413, 1.8469261654097495, 1.1435401071749418, -1.2805990032737389, 2.656080947399005, 0.1978460749442497, 0.14530204604076016, 1.4942688201041936, 1.095840241291117, -2.6915949134001145, 0.8290199134734998, 0.18374368139204142, -1.8332829293784962, 0.09206911014184094, -1.4772797552094226, -0.009703367845577593, 0.2003588261535856, 0.4266847585391825},
    {-0.999168528796042, -0.23240390789389226, -1.6605313333792115, -0.04681852318731606, -0.8242342848485511, 0.9033394781526617, 0.8851121581191268, 0.4654812545726608, 1.9087206956945166, -2.5805208845319845, 0.40952132246008044, 0.45227453185940153, 1.7817816687290147, 1.2958486638097235, 0.1558625058818634, 1.7901335086228356, 1.5668344857162801, 0.4311030958091613, 0.5702333566365705, 1.101520202079424, -0.8630034984448012, 0.8753286223994832, 1.5135793991883597, -0.4724130954059576, 2.4415015167319427, 0.3059773104219258, -0.07810164759961502, 0.5224492161737879, -1.445864935776902, 0.4310464222349216, 1.7804563896662304, -2.3944968041618093},
    {0.478492667143696, -1.4004286498988534, -0.04816835990179229, 0.9826938251811949, -0.9275736861201872, -0.5579950227056836, 1.0524952267817052, 1.2950042722381956, 1.490643667055127, -1.7302827204452833, 0.4133888142712595, -1.8609133040861419, -1.1268991014673089, 0.3929873312515333, 2.125796504884651, 0.13743926225537678, -2.033272756768076, 0.7057442735824562, -1.4688918258251993, 0.7819765431811158, 3.5556762678019274, 1.0083344403592234, -2.2937965302378363, -3.1338894761492098, 0.4786137241002119, 1.035118365825688, -1.9370701841039535, -2.0677368159044933, 0.14547278800307686, 0.026398048729291274, 0.6577299269360658, 2.0389012790102963},
    {0.082946360427542, 0.5832388879944055, 0.20520780650433662, 1.6741677902709615, 2.148347582546298, 0.3060657032960712, -1.0997297630564176, -0.7440383309977361, 1.6210364027846085, 0.7136660985293369, 0.37848393256902974, 0.1797465414011581, -1.3876247155172778, 2.9943014978534523, -0.30615967182973153, 1.1926060009433108, -2.0167429691818595, 0.7825664534998031, 1.6774807774380884, -0.32220184301332777, 2.007231751591665, -0.2867128272323192, -0.3217232126459652, 0.8371735048748216, -0.4487636334224985, 1.4599764714309749, 1.453154651612555, 0.3289749691637229, 2.8523887713981875, -0.20724262438404403, 1.2484731325939156, 1.2594381908418497},
    {-0.27148315184799576, -0.5713713890450292, -0.16786716262652163, 1.4651774441123777, -0.7997741198761421, -0.2528055606950987, -1.803078001601226, -1.3689975246375403, -0.10565359210966227, 1.4395863692052098, -0.134069768644449, -0.23632926397790072, -0.7494732209190591, -0.8497918273872286, -0.366842341590914, 0.1206569733036681, -3.2220416199056623, -1.1846321021657769, 0.20627825841067768, 0.034685070741130954, -1.788899491760148, 0.08274779880141328, 1.336226448267498, -0.3337197588604062, 1.446621964397127, -0.6214573032764734, -0.5623034443949235, -0.06382551925962346, 2.771950008641623, 0.4078030529463278, 0.3776055131834211, -0.09391370122470352},
    {-0.7861883738575035, 0.7728031295484348, 1.409466771295957, -1.5225164893232703, -2.20286416051038, 0.4860110548865808, -1.7467970055022202, 0.19879697084824485, 0.5730842415235402, -0.6301230601680718, 2.2216028327577613, 2.6948169024658726, 1.1708402573996342, 0.33098052475381623, -1.6966298087796363, 0.781452521089452, -0.08622716572593016, -1.3493489487308288, 0.11521829497070728, -0.7584708482706178, 0.6248018180923057, -0.4805476639922505, 1.5958185277198662, -0.32050705677694064, 0.46237164072543957, -1.1403151383550196, -0.1230219118786974, 2.3553000675801674, 1.5703267535036305, -1.3497346136970436, -0.30752513791905656, 1.1271248422023052},
    {0.44697797749545704, 1.5548264807293881, -0.2866414947319071, 2.0995421051071452, -0.1957441700715894, 0.505136971765463, 0.07545824521647536, 0.3389812059183343, -2.2266843250441344, 1.342797158272634, -0.5716707466384724, -1.0855684701498896, 1.3239516341344795, -0.1804832493175976, -1.7964591305769386, 2.893959429005829, 2.1341531962330698, -2.4778548891070056, 0.6386084156319789, 0.6619087593934928, -0.9501785054566154, 1.382657365558708, -1.0945492618150343, -1.216053445672242, -1.1076557795498612, 0.96350558766656, 0.9077591577172764, 2.2803871531761626, 0.5596863029884681, -3.3491099496904404, -0.5892942168276841, -0.24828473009943902},
    {0.5860871102365849, -0.4135354928865265, 0.7666468931353336, 0.2383435508790216, 1.6164113118645105, 0.24248303688834744, 2.1860621328545857, -1.6202841722353893, 2.7817082747989397, -0.10144721041506347, -2.16380752079879, -1.3383258397473612, 0.2661706864630427, -2.6634770133709162, -0.2710503661582096, -0.11103593756402341, 2.0705876616384318, -1.4689160796498666, 1.5627960015173141, 0.031761529907674765, 1.561134788487836, 0.4101050216071114, 1.2412372803454963, 1.580612225818694, -2.031248822038054, 0.7872226779280642, -1.6128331361911354, -0.09250801433012076, 0.676082996026329, -1.6805822312617062, -1.274112482794581, 0.5234989958121241},
    {-1.8160578155715545, 1.7693181387439232, 0.4613687047750605, -0.40370234719410464, -0.25662961042923904, 1.2155159129285704, -1.3753416536965852, 1.3170203183302753, -1.936700406404731, 0.518883027953083, -0.8073875154541812, 0.5845803265146311, -0.7817310493699073, 0.6157287917072264, -0.49488527304297014, -1.3052476202774115, -0.07167646864746957, 0.06632434279126354, -1.651802855350704, 1.5547128147183291, 0.5724695742562267, -0.5102211899666691, -1.392474017128708, -2.4293284063540868, -3.285359407107986, -1.9469208774569637, 0.26609206874992547, -1.0044876723056535, 1.8181170548218946, -0.8423406913717605, 0.34811235358842607, -0.887751885623647},
    {-1.0392500667376054, 1.1564452864349195, 0.5672918612868176, -1.0986268652806939, -2.135433453695701, -0.3104192807808754, -4.038794106034651, 0.13101451203241746, 0.048008365053908, -1.297262187436039, 0.9063615941157239, 2.8937533996329172, -0.4691350799515008, -2.2215615179307826, -1.168830181052814, 1.2129167779740964, 2.310832271947908, 0.41159073215179826, 0.41207522290494564, 0.14639061970535244, -1.0496136420607287, -3.48738655113299, -0.042589554334856894, -0.8120328749230079, -2.6575653310015195, 0.3464333123124104, 1.5811255029409725, -2.8666165978660736, 1.6354769177984996, 0.14804534056891172, -0.5485720119639294, 0.3583301283633201},
    {2.5730510172262644, 1.6733597331191887, 0.6843988964559728, -0.2848642091096842, 0.09578591647372074, -1.7924727873824768, -0.2490871493316074, 0.38760206232699984, -1.140090659379133, 1.0762952552501905, -0.23065764526477933, 0.6066232547632059, -1.8759376068038767, 0.1351558112224805, 0.54350953315172, -1.5984876341907681, -0.01885921550686205, -1.0760212239139542, -0.4375030543714456, 0.19174193677636486, -3.8969754927573077, -3.7583280700629165, 0.1799122417979431, 1.4770931090018051, -0.6940008646592414, 0.6768379896611957, 3.650019245834477, -0.6670320402421813, -1.3478396267918935, -2.4979103259501367, -0.4791281352933986, -0.9449696114526748},
    {3.1077932493386995, 0.8438994048716598, -0.9081391179490179, -0.5376395663529162, -2.850066684507651, 1.330698315319709, -2.215891069730785, 0.024227713610632712, 1.007195952857717, -0.7832359481572495, -0.28096880155537807, -0.13940901968295685, 0.5208113802083926, 2.2456789881364134, 0.6156589438776622, -1.6526529196696012, 1.175835215351448, -0.7600870513745004, -0.5881660517559919, 1.3968909370499965, 1.9389489296595113, 2.1660499337239822, 1.5091103203977814, 0.2254998241648665, 1.391859006176429, 0.7185279225308888, 0.8200758597021773, 3.3059247560289267, -0.1466910566069879, -1.8277989674740416, 1.6802079249303026, 0.954852931621746},
    {0.7384167742098668, 1.179342417561938, -1.3865807559326913, -1.7353004182617606, 0.6525524003725165, 2.100158959199763, 0.9830481873145925, 2.125873335361694, 1.9082754153907426, 0.05112198865146612, 0.17177893671929084, 1.20327787996071, 0.7668986893132096, -2.1872290352983073, 1.2040617996244152, 0.563495340999526, 0.06629469151633027, 0.8835148250553806, 0.2577066772899547, 1.8604593616836191, 1.46031623916707, -0.7232132718828482, 0.9780722724299191, -1.1748359176337522, -1.0632630954311064, -0.07052852170595883, 2.0805313775776755, -1.293451915847871, 0.21072504169275802, -2.709600835393852, 0.33592962775104446, 0.7852513100547313},
    {-0.23490780382276133, -0.7503251327061989, 1.222771949091869, -0.8715509473885344, 1.7246469214047666, -0.40744904629164036, -2.038098864627169, 2.6493176410687296, -1.2716313561886867, 1.4124090127365354, 0.29089257071673136, -0.8134141743108074, 0.03634730316901777, -2.432651763846057, 3.076624091225193, -1.82165274737545, 0.533395175026057, -0.03141649909772144, -0.661714566464305, 0.35248674368340654, 0.7161543696286528, -1.0153658878675882, 0.34377128825212133, -0.8838925358264078, -1.4472593512797238, 0.16405212862288418, 1.254844789325661, -0.22063456015284647, -0.037732991837448125, -2.62213146747284, 0.2321983731790571, 0.19941772055885482},
    {0.6166057019339085, 0.5452746464277857, 1.4727797338711857, -0.7141839011496859, -0.5549234760058104, 0.1789219192371391, 1.9702978032851168, -0.6604288118231791, -0.5313328127399762, 1.8725175121356765, -2.172278140842402, -0.7641703107666618, -1.227359013430071, 1.7876785094835985, 1.8499248481966444, 2.5322458512431654, 0.29698538600034136, 0.4540508900117332, 0.6011782023245785, -1.402101738625805, 2.4697400185527316, -1.4413817236577662, 0.039567238560670334, -1.2755861322188033, -0.26212143478849886, 3.8250136655806206, 1.5702357207602444, -0.28032020274161235, 1.054650667483156, -0.6304040422697657, -1.9050886992348612, 0.15644650189654766},
    {0.5621071689412905, 0.8785350241284839, -2.397072470590234, 2.2688752627311084, -1.3900295499616464, 0.4361696232931007, -1.6004679041705645, -2.107607634959999, -1.6369527085028266, -1.9015616438050589, -0.6175762615877158, 0.5702299696592271, 3.0077148935345437, -0.5275099689407752, -1.9761241140171655, 0.6276721193185445, 0.1694784176013932, -0.6213656877710527, 1.9685984996297443, -1.0006194758429525, 2.1661496736489303, 0.40257567703442904, 2.154548733831953, -0.8268197427717806, 0.4001690106133806, -0.5133728980766037, -2.4445423666231036, 0.7130295103383031, -0.0352111969548995, 1.9193744955743302, -1.706122953686951, -1.252834463321866},
    {-0.1841451485887467, -1.7317586265150926, 1.7174810482064875, -1.0434315280487048, 0.44350140647588193, -0.8512189605718042, -2.385654454911927, -0.47174780742347017, 1.4177162776277863, -1.52278542850832, 1.8209680531660533, 1.5128711044960785, 0.014653009433311905, 1.4770886237795968, -1.6722228188035069, -1.4530464080277987, 0.09069744369319194, 2.6348517852870357, -2.1214043862083103, 0.9305445229298925, 2.236536097568038, -2.2360862056273723, 0.22034986232887432, 0.2030174210600633, -3.7329353909613, 1.3238420666783666, -2.88879826461162, -1.4508739820634287, -0.5651862033150401, 0.44545488804076017, -0.08860594459706919, 4.046266747630224},
    {-0.5461666328223704, -0.33017454365365806, 1.3846647928983133, -3.0818938908319486, -0.4101614846965906, 1.8153949443395208, 0.06093049308970276, 0.2478509712509853, 1.4382352198355048, 2.2799923469654377, -1.3797596680276432, 0.45287461556840614, -1.7769600639368213, -0.464633131263915, 1.3285672301722962, -1.320496578606873, 1.1711181105115476, 1.6854329941476458, 2.057922741784767, -0.7950941214671925, 0.3623985256271512, -1.657104753714652, -0.7658891988988137, -0.1576194744004815, -0.44733179625762665, -1.9984890250540146, -0.25628050124104057, 1.4014592230457905, 0.3315720887366954, 0.09631328644449873, -0.2543754934650919, 0.01537840084118341},
    {-1.5335896267681974, -1.7513631476199696, 1.995678301498625, 0.3173460302849058, 1.4704555737417078, -1.7685222185236542, -0.6774643176495605, 5.515837806265177, -1.3111583246019352, 0.6513043000655756, -1.8833747044685216, -0.037585621494465225, -0.02861357846509911, 0.7155271908422992, -0.5734117023611155, -0.6639126163597838, 1.0147371794838593, -0.34639051631561807, 1.3794030849362535, -1.816987986875116, 0.47749935019959316, -1.420143512524031, -1.6349896589132038, 1.7488748631841076, -0.19245011349824767, 0.9842682991601445, -0.4045101016665723, 0.6447423402518885, 1.5867337515901836, 1.4887806525558267, -0.9610742851255883, -0.6589535490333464},
    {-1.1094794549402889, 2.584035421797694, 0.6077540109701637, 1.4570763242412421, -0.4197128910408086, -0.3155670593943572, 0.6331091540457708, 0.06870232456298409, -0.36580809180994583, -0.4207911269675913, -0.4096817689622779, 0.8930601992889674, 0.8450543792731475, 0.7578644937027008, 0.14250348456748793, -0.6772078492096186, -0.0017373809839866439, 0.350897972806215, 0.18273296641555647, -0.8389812343822038, 1.494103058292942, 1.5125291435538402, 0.22932759513386744, 2.3746879127222407, 0.3362733669429257, 0.6219159737388208, 0.0762635079736345, 0.9705173657520414, 1.3065476930410196, -0.7799472037293695, -0.9665110241458644, 0.40157270740666184},
    {-0.4086669908576877, 1.5374772851337761, -0.09713457025244156, 0.04649635740949717, -2.004846151604381, -0.06416905963583391, -1.8504452975792294, 0.2662692029250452, -0.948211897878187, 0.5302843444203381, 1.7715310358065242, -1.1188407737297776, -0.9262908539673854, -3.2157887549936257, -0.7501399630283215, 1.734083664143957, -1.5484144316401305, 0.96494058833761, -2.3187841916619845, 0.21836689968243458, -2.561586397787825, -1.8077145875797753, -0.1252265325687861, 2.2935676680686936, 1.2788948582576487, 0.008283252138139054, 1.9428382835659581, 0.10633657558170327, -3.577021557381975, -1.1158693630371213, -1.1237449780218542, -0.8718500129992275},
    {-2.564978152616183, 0.5108184653133023, 0.8094077056666815, -1.0119291506421693, -1.3415137171657638, -0.41140830169323644, -2.9288807075572536, 1.6395217048751645, -0.19858844381983703, 0.5847364596531842, 1.4599208494532503, -0.3060318067362269, 0.21579186191269153, 1.1154043934682294, 0.4258264258077115, -1.2098843970158373, -0.058168620540571855, 0.945190658812856, -2.70258343746051, 0.6295701250515675, -1.39544111625932, 1.4952441886818222, -1.607869063643446, -1.5783232570759176, -0.5499024879613138, -3.3093512544248305, 0.34478487491734866, 0.5590348747444387, 1.6523339729497795, -0.10451619478339386, 1.2019344520035702, -0.9270765347853905},
    {-0.7814158378942713, 0.641546374722599, 0.2683315188999648, -0.44541834552241805, 1.2609970115903304, -0.6274244781122437, 0.7157975811642605, -3.3921444872927213, 0.06665614512369691, 0.834244088898539, 1.525877745221936, -0.31382803302068996, -0.030686710206123277, 0.3688066939385664, -2.436677610464783, 0.3519024765803872, -0.5328497261888538, -0.525387523793741, 1.4015870675230675, 0.3272105183520365, -1.5303432906106205, 0.20717113096465142, 0.464645541441412, -1.2549696736842098, -1.2212859093834438, -2.099141279235953, 0.5632795037753026, -0.6486613728571475, 0.45715725492451526, 0.5731558610286859, 1.7055998272219801, 2.199414861766882},
    {-0.0506167772172097, -2.368512792550811, 0.9532484874747642, -0.13345037232510565, -2.260807165709118, 0.9307392956833044, -0.17379668283660812, -0.7353911842924574, -1.144000811624973, -1.9061367922619277, 0.7933685066921147, 1.8177765384763602, 1.1465116079662128, -0.311928841819865, 0.2745147496095273, 2.530871981820738, 2.8166488284044946, -0.11165325770634459, 0.52750894166369, 0.8981288524032479, -0.34231441675066365, -2.705471451220865, -1.078077682427489, -0.14967410532141526, -0.47559902496825923, -0.019205853076646198, -1.2252851972591545, -1.4481660659417228, 1.8344692857055873, -0.4002129922668832, 0.008206245929773376, 0.7402670415908936},
    {1.092534165093945, -0.5301262464171199, 0.2522733137105543, -1.384189847077063, 1.2182558779940742, 0.6190556363838292, -0.04852643177277793, -2.3034245622339755, -0.0021304484648944737, 0.1425027301677632, -0.29390952634865086, -0.8238357415799061, -0.22598734797675324, -0.6443286266526671, -1.0550910868995522, -0.4506554337210079, 0.8037463829535924, 0.5606432286457274, 2.5178933432992108, -2.479804404255121, 0.1328029177384767, 1.8723866559265367, 0.45854176284463355, -0.19237194722354173, 0.11187488825567511, -0.052260970999722024, 0.24784855785544016, 3.0914712286287633, 0.08474946208647292, 0.1302496220039396, 0.1269985133023587, -1.0700210557701284},
    {0.010836202166437919, -0.1845384158333705, -1.7445904869518791, -0.00442708526909421, -0.21662505488462555, 0.42573120168216166, -0.9464155616219628, -0.5488207741164537, -0.5604362386737017, -2.042280898776847, -1.2693045133065435, -2.084196976921863, -0.9266154983922513, 0.7768033522328517, 0.6634520222113905, 1.167481865904735, -0.9173296997275154, 0.6367085073262541, 0.783313863185621, -1.807199169501395, 0.8001025089902513, 0.7653217091056852, 1.5038323887254628, 0.11743798095958499, -1.459685441367797, -2.7618486101387867, 0.092622401909991, 0.44015501339961616, -0.31308885865466135, -0.6334712067191911, -1.9450071411841745, -1.6114846403482723},
    {0.100996295539906, -1.9164710313307798, -1.386898080421811, 0.8167749085601567, 0.2170241678260745, 1.3981615204244882, 1.5749460997763598, -2.715381531099554, 1.8340824645117295, -1.4343958677854092, -1.9309228513057226, 2.6273328222886314, 0.5082743491284353, -1.640348187127538, 1.2689502642665589, -1.100404894467994, 0.8126870076954107, 0.693222981210026, 2.6006293784177394, 0.22551897449351538, -0.97621855026665, 0.19913637371545423, -1.0220222056149049, 2.062930550763504, -0.4293079791172987, -2.448310314377313, 0.7766024460334423, 0.44207659686040335, -0.1888935208380527, -1.3440434526662364, -2.058252911978089, 0.9105657841826069},
    {2.760899951273257, -0.5317617240520697, -1.6274410194268818, -0.33716280216159134, -2.509338334295974, -1.7949435719794677, 0.9520236932265392, -1.6879321806482177, -2.66976114103179, 1.410555390939754, -2.8707745819865744, 1.565928123712071, 0.689444809674564, -1.9342276332100048, -0.43582539275895227, -2.3626253491921476, -3.231346314977229, -0.5758953421444668, 0.14072977169880577, -0.6735576429909613, -2.0746811933979794, 1.260068409951735, 1.4643264092772712, -1.627652079347236, 1.5190132038979802, -0.043689703211971506, -1.3847588560775432, 1.0288302510951497, 1.2673232735641895, 0.8347018379920443, -2.6864492737586874, -0.46208946104426685},
    {0.24296450364908742, -4.077201255346888, -0.3046563396711135, 1.338662223342039, 0.3528159690914128, -0.7295780246116781, -2.631807792136088, -0.3853949967346874, -0.31664832870262666, -0.9521772890733197, 1.741958449065236, -1.594900450581124, -1.8826144846810984, -0.14569638507757457, 1.6682648885215638, -1.3825991779619358, 0.6711530971229482, 0.49234713319220313, -1.237728048354752, -2.650088880031952, -0.8153648891707065, -0.5261998514017328, -0.0012799976290000924, 0.3875409887351525, 0.5266636697859628, 0.9082093408881756, -1.8672763851595333, 0.2783104098987995, -1.8294759651208112, -0.020689100224567044, 0.054528533651009195, 0.10798807676764569},
    {-0.4407395311174311, 1.3801288181340305, 0.9607897447684075, -0.943033260299354, 2.9310852747799663, -3.8059094083578695, -1.706042465526926, 0.6397387639473071, 0.407795011522872, -1.3935867826766377, 0.4384521090372855, 0.5165516130226421, 2.293432694036829, -1.213873648828184, -0.9695236880141535, -0.8813294415153913, 0.7536222736503867, -1.9474133677416103, 0.3746391924053899, 1.5455420199106826, -0.4364839599679873, -0.5494062551134388, -2.2150938270911644, -2.6604834066253935, -0.04875296417339886, -0.7219378574003139, -1.016377207211475, 1.0483460996126195, 1.338390572848127, 0.9680242627653307, -1.6274899283146025, 0.18247275285918435},
    {1.5547552659380686, 0.32369337897313893, -0.25505008415472696, -0.4540803203518672, -0.7935210440936104, 0.4420658743236886, 1.617484807444873, -1.0608285814560776, 0.586436696952057, 2.667217979400343, -2.8162599604314966, 0.30246370900975195, 0.5477138756613018, -0.34334622393990616, 0.6487475972102315, -2.6610576332204596, 0.2159280894088703, -0.6092374926953155, -1.8087897743126273, -0.018093547204947494, 2.445004581932979, 1.9608302112073694, 2.376832461075576, 2.629546557876697, 0.9324414357123706, 1.4153022572767582, -1.2881247257843491, 0.24587194752707703, -1.180822715777938, 0.9512377164514014, -1.5444522191554664, 0.39684498136753615},
    {-3.9940515763632476, -0.43589775170267675, 0.8113335547599835, -5.249618670091482, 1.3980615051190193, -1.46556816102438, -0.48148808295123446, -1.072969938145025, -0.49188513555356905, 0.010092228384990626, -4.169583550679324, 1.275998200002996, -0.8075926601543487, -2.2788694547572192, -4.909296123122299, -0.6360382119105782, 0.5766016627331494, -4.1884010155431985, -2.9394023466245116, -3.872364276775436, -0.2204374051122162, -6.348043769366984, 0.8742948003584032, 1.4671497230654056, -0.9227075134644332, -1.8833357543482452, 0.20486878786751175, -2.1661310031157592, 0.24673881470426848, -0.05654246763531024, -0.39243050716658096, -0.0759347438003801},
    {-3.7304741966674753, -1.0684696438746963, -0.9685725091225037, -3.4494965597653287, -2.5231577332108013, -0.2999769798341032, -0.43669735404542204, 0.23421813112916712, -1.887253783759494, -1.7911093480588556, -3.6838132595394817, 1.1893631958816013, 0.5865333332555629, -4.101658336979259, -2.839119563710646, -1.4702440126187095, 0.2850701614311497, -4.971735348271117, -2.4731225307732623, -2.710401146255081, -1.6983334024309225, -2.225524315876681, 0.6527183023573234, 1.5850615248412667, -0.4947965885431046, -2.524194004063315, 0.4522499951963715, -0.45709960062026883, -2.188524736991307, -0.7514838630523362, -3.977300248834549, 0.525224774395012},
    {-0.3073041016204252, -0.15744944033877925, 1.9681708192003897, -2.914100693994287, 0.40603254136850314, 1.2635063982096628, -3.00695979031895, 0.37519531897134395, 1.050972389981387, 1.8572813355585114, 0.6439043195436157, -0.13934817235222305, -0.7204061200912188, 0.7317503247136281, -3.5633001001371167, -3.552652006477657, -0.044802468435600276, -1.7844358815597057, -1.5912684190780406, -3.4321938238399716, 1.1511978116415114, -1.771610053593378, -0.6727171983362144, 0.909029399820468, -0.20458621869654497, -0.29005538161477934, 1.2179241258096352, -0.8518284237762931, 1.640409754230262, -0.42075156054339813, 0.4832724022071269, -2.3000009499830503},
    {-1.2335684766416408, -0.1674029108899151, 1.4070063758523443, -2.0822378019668304, 0.6673054712883528, -0.3458399109619991, -4.578003101192378, -1.9964316498165198, -2.6318796627517362, 0.1630032715230403, 0.9254198242966695, 0.6734793972891698, -0.9927937443879314, 0.043075669047366455, -0.05741348786135645, 0.6314165791530519, -1.7971493729442487, 1.503015676226651, -1.0152813753236014, -1.4589622451238553, 1.1253042835546567, -0.7739629638065132, -0.3071531920472388, -1.0360216213501503, -0.10941569642413494, -2.3986204444637784, 0.8917328212606703, 0.32846073131136183, -0.6005660575044836, 0.15372626592733488, 0.5075255444611383, 1.0558006281646213},
    {0.15714242173600507, -0.1971648993271787, -0.0847621190054321, -1.1758871644789126, -0.32217718466294976, 2.212481380980635, -1.9523730820246032, -1.2181355658896575, -3.276691510389515, -1.296951888886301, -0.5561499640061235, 1.4785626831438807, 1.960833015952747, -0.09177083426943107, -0.981470498149688, -0.7688553759258908, -2.003480719110295, -0.13400981680084845, -1.0562359642231938, -1.8716311256812166, 1.718519704229173, 0.35411196618604573, 0.5636135559898569, -3.9243162121409823, 0.5529377260064675, -2.7601134876331, -0.8047223543816169, 0.4670912272372121, -1.4765757314815873, 1.395745287918863, -0.14336664521337097, 0.2550698817801383},
    {-0.7263122510256937, 1.2031192463280385, -1.645025005822892, -1.0689651038117867, -0.45076512297440896, -2.795213126073787, -3.217033438775653, -0.3982008352357912, -0.042235238121520885, -1.8680673749977026, -4.006342189845912, -0.40041503322999183, -0.6767020282428935, -3.730817709221314, -1.9717945633558844, -1.0606367936541266, -0.7556166348440674, -1.9290605782999408, -0.5276584800282716, -4.504197344003738, -1.720020912807733, 0.577965731745652, 1.0087766437596595, -0.6159938092435997, 0.7555388193840253, -4.17981001656107, 1.234162510591612, -0.7545126823710632, 1.079654617770378, -1.3229313304212484, -1.4893510774683762, -0.43554065945039355},
    {0.25165121798952117, -1.7334874971538752, -1.9216643201873735, -1.2433218596277749, -0.6305622278565328, 1.6516785059816466, -0.5235592101211063, 2.6886997111158775, 3.0796081028633915, 1.56609337165732, -2.372660555917289, -0.17621850581797469, -1.250372219530666, -1.735968684541705, 0.6619017454522321, -1.3979260830860127, -0.6825767082676948, -0.2097324199677319, 0.793747102559388, -0.062061021950191475, 0.7173546887898002, -0.2509960330845839, -1.884488803670566, 1.3144692367915944, 0.502881420325107, -1.831207326288856, 0.011519194943550621, 1.1750489020912764, 0.3518721802093131, 0.3692282716512547, 1.5839126684863203, -0.9682756815412982},
    {-2.24149752660174, -0.9452153896602304, 0.5621802586721729, 0.5105777679388285, 0.34358181107125574, 0.9897325061003354, 0.7220475009376922, 0.21622261033912044, -3.696220226340841, 1.0505329652609243, 1.154022440487971, 1.7555571264638692, 0.9180003256902902, 1.1493539511969273, 1.6139686406230878, 1.1078226475091837, 2.0857616618375427, 1.6724835993987637, 0.5533815151352701, 1.7699950025245745, 1.568305963856287, -2.1643091718947236, 1.388240561247681, -0.13752862900642604, 0.0799296587678406, 1.6825347046362495, -0.7286354398996197, 1.758028384411957, -0.6390241273420156, 2.7571910536341973, 0.47680544510237344, 1.3717001527116204},
    {-0.7014501621599075, -1.4390761515149244, 0.10653818709207614, -4.283805247803462, -1.1705502200635889, -1.687450290163578, -1.73127349304187, -0.2967071424751359, -1.064055078906377, 0.1636101898728824, -2.9923002003750963, -1.2525502864698768, -0.1380898144845996, -0.10461960794496156, -1.6472719502284867, -1.650348990267376, 1.177670051381409, -2.609481431248871, -0.08005894159151179, -1.679997625993003, 1.1271691932284371, -0.3881367384533632, 4.215762303991695, -0.1426639185492305, 1.0140730338685535, -0.7806569354772147, 1.9729343762495801, 0.09517394709042502, -0.5008806891704688, -0.30354616072946344, -2.60318104833719, -0.3782284124102354},
    {-4.02744831845938, -1.7232292328299625, -0.515158804867808, -0.6302314568722678, 1.0790363649909913, -1.7478126819438782, 0.7694625670400066, -0.4285532006991185, 1.4674528518712573, -2.7589500356539376, -1.2274014385029925, -0.7879454399509884, 1.6954145404405918, -1.872991515977714, -1.6680475332720168, -0.2631685938539751, -0.07775344683335166, -1.1329811594890538, 1.3788224087732925, -0.7326527248450186, -0.3279484023759991, -0.8336438659428338, -0.5404316128188105, 2.0185266959506962, -0.19512662573307007, -0.8005181831684816, 2.363398224066166, -1.9920767362876537, 1.072463228001848, 0.3395671337298877, 0.027037833933850418, -2.1817559231466466},
    {-0.7153077720716643, 2.3010299396182687, 0.4663671290207941, -1.2317400817617012, 1.0159025359599774, -0.32318253448539935, 3.615433258488009, -2.533381392997604, -1.1235204162127512, 1.0907186632458454, -0.6958105197114599, -2.5723086679938247, -1.839258907833696, 0.42034586744263636, -0.2794642778249398, 0.8168223993454585, -1.0621088295437873, 1.4433443156792924, 0.35344040933364734, -0.0652307382441109, 0.1152600105047751, -0.9220738009298198, 1.0571722235233316, -0.8672266467774771, -0.5121046431889765, -2.895796532250051, 0.056384914730233486, 0.2953616929676768, 0.31923608268525105, -0.784860754798107, -1.2015379260194254, -0.6249704411729933},
    {-1.7506902360368761, 1.6271039398038862, 0.9450167831445064, 0.1780421954937613, 1.7032387039358412, 1.7377475309794035, -1.75651136283596, -0.6246342683786154, -0.4360680890313374, -2.8359952696652546, -0.7154775965495469, 0.9035159978330204, -2.2152745540902807, 3.146268906959647, 1.7745050966240832, -0.7561745749484096, -2.2892477024691416, -1.8344417798069574, 0.6694805353453048, -1.0257079388244006, 2.2157746875613658, 0.22169043139693564, -2.31887516956237, 2.561324031506276, 1.9132570038631358, 1.3359622576646175, -1.153927238629253, -0.24728918867397603, -0.2523541576446175, -0.04144058856791432, 0.058512726276654554, 0.2731987781013192},
    {2.0837958584799674, 2.6446967971684674, -1.0118174300009135, -1.3622021598739684, -0.8124828633804039, -0.9342323250723114, 0.8007708228549831, 0.3725453527151887, -2.1684187218787665, 0.18485187176344914, 1.3788442156043739, -1.2276233822806801, 0.07051751769328703, -0.1973635827031844, 0.2667870149591878, 2.0318256774349726, 1.6258453835789015, 0.6595012828851966, 1.040389718714561, -1.2308253273202505, -2.4208005566388553, 1.6426872249858677, 1.5226521162247424, 2.0847093727462296, 0.10442644059392044, -1.5993108837962988, 0.22653873969672428, 1.1692069180734264, 0.46848425345671696, 0.04188882828421173, -1.402118732188607, 1.2040752358081728},
    {-0.9765206231720632, -2.4003819374631203, 1.322121138581777, -0.298369717115694, -2.6188087783809935, 0.43490403190479643, -0.7683071963421992, 0.5814212252140175, -1.1024257390995447, -1.0398199501388488, 1.4763091098777672, 1.9458256909599545, -2.403823854871913, 0.22377442080319226, 0.33976006003517933, 0.015511625428027916, 1.7126432551093258, -0.18827643908272831, -2.670545155706347, -0.16678335598435226, 2.6631530038983207, -1.9149457679019597, -0.12335641210721478, -1.6319984538938663, 0.2498456995608942, -1.0634502425048429, -0.15630860415148115, 0.38116185838621336, 0.009456756551415426, 2.8179948201342566, -1.1339611863921337, -0.5849910789256793},
    {-1.4082139852423228, 0.4072557916409648, -1.8917947468928935, -1.0861188270020286, -1.7670955812587401, -0.8379031353837019, -1.0949832959341375, -0.5908242842136326, 1.7505054952275527, -1.095062204271836, -0.2334267959577816, -0.4774590514195556, 0.15758157925443672, 1.536311264618489, -0.3562147973869577, 0.5163529765998703, 2.5121402272232993, 1.4629179643506143, 0.43328966561706206, -1.3652954917885114, -0.4923365930476434, -0.6185902389877872, -0.29842864777262434, 0.7477559515170702, -0.3130334615820642, -0.03937401649397652, -1.363645602830773, 0.329005044696593, 1.5632881700706114, 0.49800728045143133, -1.0724252993045997, -0.7597941583021798},
    {-0.9793790525674546, 0.6655213316429042, -1.8098924615842746, -0.688317349326914, 0.3288017612327528, 0.7786878017841135, 0.34000481462196214, -1.382187287394099, -1.0857122515565336, 0.8540471518342799, -0.0811372578152106, -0.5498390896971388, 0.6870949480344383, -0.4541824497973383, -3.584681174635396, 0.9546321093376293, 0.43182043891573146, -1.59584030554828, -0.6956516707894997, -1.5723606181968528, 0.5945722191575242, 0.27159042605734945, -0.715652316844223, -2.1016881935066007, 0.0857482526992526, -0.9333502341157811, -0.13983086520888813, -1.450710503042843, -0.18373072846853183, 0.38963892923395893, -2.3126392282432495, -0.7366890688577729},
    {0.4545703586446334, 1.1752924570857974, -0.9351968970654387, -5.0269959109467095, 0.11121566683674351, 0.47108244608312855, -3.657788495941779, -0.4461820949107661, 0.8456155164725299, -0.9673114468494042, -1.094725641039101, -0.8786035221977209, -0.764812937008976, -0.43070245550435676, -1.8045454002589214, -0.15622687681738331, -0.7432418064461132, -0.7043991223497412, -0.15872689934688716, 1.077547356404206, 1.9792131999422042, 0.795094829517578, -1.2436186266593332, 0.3424116953709233, -3.1042749784244257, -0.5670129056285197, 0.06999295418804671, -0.5777591976531372, 1.677211336407794, 1.6110789935639835, -0.913207081435716, -1.454726187859567},
    {-0.870813425928219, -1.3157783725642003, -1.7967282605674353, -0.6468828468087192, -2.0691408761617516, -1.7746148947584326, -2.1480825075921213, -2.1622517407704818, -2.4769022659317232, 2.7834188366917534, -2.0461961969783835, -0.09435853799707306, -0.6978531000017867, -1.4558883858226384, -3.3905339469484312, 0.8079594676664998, 2.0048368211852914, -0.1093461426819289, -2.367470488368373, -0.5003302275299043, -2.3008077425884323, 1.6537970262065416, 1.5050010896521584, -0.6409870721989571, -0.49931854121357144, -2.471865171425458, -1.024349450496526, -2.8502914825342374, 0.32343793212461447, -0.6809912589556434, -0.11253656106118874, -0.1666160065568764},
    {-1.714148167767799, -2.63756878068746, -0.4020967838217866, -0.940534392128292, -1.7576296621503744, 2.5553690754801, 1.1515652650033539, -2.145900581470278, -0.9164445442090591, 1.2893376891846478, -1.7808136161677055, -0.94645296315963, -0.3552181357764957, 0.7646398835721373, -2.820950163669238, 0.21748474013609612, -0.21042277421080377, 1.3461997692074767, -1.9824107362798797, 1.0149597816923142, 2.779543781047387, -1.9940807448282434, 1.2589083163293417, 1.5092110773311624, -1.5550863334631964, -2.985049517924305, -1.43508024534042, -1.9388483726033887, 0.61933694281689, 2.6904745240903414, -1.0526189049821608, -0.04776644056374708},
    {-0.6254087019853192, -2.0305162164242945, 1.0454439330729182, 0.19938346331831838, -2.3672765539416476, -2.6316091349238397, 0.3180014970994177, -1.3732197365515662, 0.44447303472628047, -1.4611859367630025, -3.4669131178028927, -1.84176873265948, 0.8995286837788591, -0.7483526475045376, -4.0134521997660055, -2.8072729251273896, -1.147692642940056, -3.939151580597326, -3.458700159439606, -0.33774756733870287, 0.3725883107734014, 2.0639675234608803, 1.7676547872803299, -1.4739986806332024, 1.2729633505407218, -2.35106279564805, -1.3562398054928178, -0.401600000620814, -0.6496629591880271, -0.8386539831880719, -1.0082642150632763, 1.4661020300130185},
    {1.3716388885977369, -1.2581588579218987, -0.06467781891543774, -1.4617700803773155, 0.1134948914427098, 0.521282683152628, -1.5575095149711473, -2.761508675243694, -3.418784295846662, 1.0533783015212606, -1.0527758863290535, -0.9527471646829867, -2.1658942140749553, -2.2990865400297777, -2.4701490738030256, 0.3708224934049855, -2.115220214969307, 0.23640455953435294, -1.508314999623201, 0.988204434788816, 0.941111236703854, 0.1828030934430427, -0.6886172241019316, 0.3368143190171787, -0.4247754274715021, -0.2682728249330087, -1.2094507938736085, -0.5848743748959612, -3.9784392954717087, 0.7100624901280518, 0.34239632171665263, 0.33220473559595576},
    {-0.7463950919254996, -0.8880680285649464, 0.927586659136539, -0.8079285579078286, -1.4582848706338138, -2.116234318960054, -0.058378388182720835, -1.250027832362015, 0.8520115156514876, -0.19606506670089063, 0.41757866307720415, 0.9207984422495534, 0.7733681247241453, -0.5833577206042873, -2.0970145156320306, -0.06476285021516384, 0.7653973455249706, -0.6139139944255241, 1.454938029647203, -0.25171848758984344, -0.27894562343065754, 0.1308602658651315, 0.6022825032074846, -0.0008525005616975284, 0.07893405969807585, -1.101687528617583, 0.12592312463656008, 0.31800978843239736, 0.9396351660699431, 3.4704500977671016, -2.316849117080327, 0.3822087143829691},
    {0.6886984220499006, -1.1633204471364134, 1.0273501320098946, 1.1438839301132717, -0.5302728571041414, -0.41199944308139186, 0.8681549498531898, -0.5131213945564258, -0.2949884814884821, -2.0280010998779323, 0.36570975095900626, 0.5367868571185906, 0.3856419668239826, 1.0951993592122249, 0.9040221428481257, 1.829654513346375, 1.0400207155150845, -2.172640446538342, -2.222225676531421, -0.09668203046185456, 1.444561400244392, -1.3856362143427927, 0.10718511206065214, -1.4284053507263834, -0.9221283012361313, -0.0909293277352328, 0.8270930675099233, 1.6048154853633998, 0.057654628338715014, 0.4215082638183705, 0.4605413798021881, -1.8232655469704824},
    {0.03758187104660193, 0.13811958564738344, 0.4209333127193473, 0.20029382724148098, -2.0696378145836407, 1.1731073559876326, -1.5104533296790306, 2.3705578538462793, -3.478778600554912, 0.2259616353876743, -1.2111427006212647, -0.6395205876707876, 0.2410934613299794, -1.1985552801100612, 0.11490379571216458, 2.168139746889498, -0.9836676551979936, 0.11900662529835125, -1.8520366206827668, -2.3433352900076283, -0.8209211682380376, 0.47565139655235783, 1.188548370825691, -1.2755919603858366, 2.6174113963671375, 0.7120919635002857, 1.8542202093878948, 0.2590275439677998, -3.2629956665880138, -0.7911217033035887, -0.308544600746306, -0.861248305784725},
    {0.6316091145821305, -1.90486044153286, -0.5977134339357033, -0.40710983807393036, -0.03265958557228182, 1.1054490128446581, -1.497840407154314, 3.5217127037808766, 0.49073785038511636, -1.0059270401832816, 0.5934573448063165, 1.5120235821022228, -0.23077814685612583, 0.9017571167577246, -1.340073410558436, -0.46986285752309037, -1.5219151124270738, -0.36257846987044734, -0.9415272410231242, -0.8188301238952567, -0.6699855100663503, -1.8028727218964107, -3.2954437665168084, -0.9895312842656458, 1.1926353811687764, -0.7245587975874426, -0.6919383931841856, -1.4740187280104555, -1.9979121830350315, 1.5509598044860624, -1.1481131725644989, 0.41621855158742316},
    {-0.23255828919837976, -1.213917110328977, -1.7546815347802331, 0.1903024943426357, 3.3415002238075564, -1.6400809204628275, 0.152794200144098, -1.97970287087241, -0.618605358253326, -1.460301639832256, 2.6095645749943706, 0.5258694625222545, 0.7248826158170173, 2.569127533107059, 1.563652528283286, 0.0480781441511857, -2.953024128122059, -0.954182836981539, 1.0691215889680175, 1.7492525336756817, -0.8323194711660125, 3.514457727367762, -1.5352221423669048, -0.2532001355447571, -0.10145643236865479, -1.1754720295033136, -2.2598876111388524, -1.1361138792340617, -1.2377649272570177, 0.04582434593551989, 1.1442177661525337, -0.6048748113174633},
    {-1.0692417266323857, -2.818326872411859, 1.7502458154267728, 1.2826791579155192, -0.8497084098073814, -1.1708463228468986, 0.6585392559269869, 1.2113165873522125, -1.0674244198725262, -0.5331184020932317, 0.29980136625393117, -0.34916451276455435, 1.3960279143347527, 0.44557363689506113, -2.3196846604417103, -1.0464110161715656, 1.8168400981247335, -0.053880032843803494, -0.9348753813769463, -0.5299520524398357, 0.9722455825735071, 4.064000361501081, -0.8932516761855205, 2.2794662661253344, 2.082184008428652, -1.9022588511610843, -0.7390138581606285, 0.8672199210673283, -1.5403692830007878, 0.7436114040002805, -2.9250920503140025, -0.33930040303921727},
    {0.8942922391307145, 0.8646592419184692, -0.8131887106446088, -0.2680075598018655, -2.2167630343853695, -1.783063067164221, -2.9035020264602895, -0.43121348244272967, -0.3156009732442726, -0.6856908060049595, 0.9271589486681641, -1.2270615657223494, 0.9884994862989104, -1.1605397520987204, 1.082803392042477, -1.0818731584340981, 1.0301186377685279, 1.7640043356255344, 0.16653381187513924, -0.4715689090033872, -1.4571269237654556, 0.46066046985008285, 1.8072315534848378, 0.5214979013178863, 0.4659650252479318, -3.046760171964376, 0.5454164396159532, -1.2096111266258769, 0.32564437314707895, -0.5821878676921693, 0.938367707591509, 0.7187815308587587},
    {-2.348396161983117, 0.33888231837014743, -0.848833159771223, -2.201891487674191, -0.5869135227821646, 1.1022725277039482, -1.040567952442074, -0.2680245137675591, 0.05709306321172663, 1.9428767994696226, 1.5017506908815257, 0.9228890781762431, 1.4018322641596646, 2.5703483728645553, 0.017406979317691834, 3.626878549623672, -0.04562590833636641, 1.1216439532439066, -1.0570679493035808, 0.11184320040665681, 3.1068333499972023, -3.8252585157808556, 0.8405277084281789, 1.1711380895631711, -2.1553237257382016, 2.9395059107154964, -0.9530862571971991, 1.2894150059535, 0.014302812150150158, 0.17003109426597823, -0.4012715534709541, -0.2142570590059878},
    {-2.476676912479961, -1.9763963910940632, 2.5490821216923574, 0.2573610705787599, -0.8837052338885354, 2.23208041017942, 0.3008014494453918, -0.9152928817591411, 1.4314354856862794, -0.27292335107802906, -1.0934665687295892, 1.2513715754048533, 0.2902320027842862, 1.281634416596155, 0.5518983651479037, -0.14505365164454637, 1.8686998352400817, 0.8933217262260591, -0.8836580474038337, -0.5739941280610151, -1.507368287788416, 0.6357285232469686, -0.38756860318228503, -2.7687581355198327, 0.12695034668738236, -0.7548251924589802, -0.1156126491612341, 2.425093170528514, -2.4889290629441705, -1.5287626077632954, 0.34170734897568567, -0.45707347739179954}
};

static const float b1[32] = {4.992316480979123, 6.117507250657757, 5.045788239455664, 6.7019103955243775, 5.949271279237732, 6.215424048795577, 6.59895573059903, 6.713194038601544, 6.380832708988702, 4.991671780357175, 6.304753962416346, 6.003805645047899, 6.144031513597808, 6.2927691247387285, 6.327931107424402, 6.269507650968202, 6.362775915458566, 6.176966664295514, 5.8577628809624525, 6.6220350758037485, 6.354635927581565, 6.528566139715447, 4.922733501113131, 5.937793755800712, 5.81359280440762, 5.959301846370052, 5.00005330642652, 6.420838477564418, 5.472837157701047, 5.211411797450327, 5.068838814032531, 5.7185108491111505};

static const float w2[32][16] = {
    {1.31470180138452, -2.309422217452564, 1.6514009106669363, 5.698138399102874, 6.432277034720848, 3.117251040081773, 2.2108876036392755, 4.705297991768517, -1.39467403465284, 1.3829966206356796, -0.7438495669286933, 4.99513811015758, 3.8408609080791845, 4.690785332766906, 2.961989957696341, 4.111279552181366},
    {2.4812034635140767, 0.493441194308963, -0.2765403199441255, 6.145844540795398, 3.5833718942587387, 3.7108349225486568, 5.114741638945708, 5.52952334931491, -0.9708732656287831, 1.9536194195518974, -1.9291316342115252, 2.9991184189430626, 3.633458714735469, 4.519100404163219, 4.651983712362858, 3.55574689698492},
    {2.005203759465366, -0.35764039764145256, 1.642560773914945, 4.715998475612323, 5.6080438273633435, 3.76904293220911, 1.3404513871340444, 3.8669241682580977, -1.4224250759477326, 0.5061914256809341, -0.2171689489526862, 3.5655448801399547, 3.5590514379786824, 3.416836130431985, 4.372926477755999, 3.075691113224877},
    {0.1622102744048191, -0.3140664055215726, 1.7980791325157233, 5.715529854368269, 6.814939107046288, 5.130067244737523, 6.167307920160292, 5.358268270324861, 1.0786281539664193, 0.4146319807751433, 1.0709529409499199, 3.188321094191773, 4.341857745007219, 4.632930949370588, 5.479224761922473, 4.518928338673115},
    {0.3595106745056708, -0.6646040321657423, 0.49407085210068047, 5.918418449158554, 4.001213518295015, 5.708220469815457, 5.1937733127480525, 4.697836142239942, 0.4777706592399072, 0.39772589121189683, -1.8245772430892142, 1.6884400454324842, 3.928346755900704, 6.2226669743569065, 3.910978806851804, 5.193456163697403},
    {-0.10820390818574116, 1.1182750435428812, 0.46592614007772026, 4.354269194656019, 6.206046975810668, 3.645825047111627, 3.5482106325779474, 4.868836518007548, -0.4865401951513825, 2.587949829208445, -0.9105506530101684, 3.408878846903484, 4.958764262890747, 4.995461778555096, 5.530930200422276, 2.6375660714118334},
    {1.4781784989300548, 1.7033165377696668, 0.7878531300355365, 5.950239346930635, 3.748954077903049, 4.476749097702435, 4.458579129674922, 4.394960661297527, -0.5135509985904099, 0.43033479364698435, -0.42394886552080385, 3.936019879315152, 3.808544710113976, 5.631174439512853, 7.29774096327334, 2.3073097604395327},
    {2.2039817920993943, 0.7730556147905081, -0.5158029560861022, 4.913525421071594, 6.933159442373337, 4.318849098708229, 5.061718765675683, 6.444712552450551, -0.5788413220546377, 0.48469706333005236, -1.3372618935642688, 5.630653151321173, 4.604824335990889, 4.5468276503850715, 7.2452093789343746, 1.779012661392278},
    {1.582379115416509, -0.09149785940069297, 1.3247989673033285, 6.2791561869997565, 7.087801195226785, 2.0308062878544884, 3.753578115136293, 4.974204844749383, -0.8338979992393255, 0.16352406818616624, -1.4864716673761222, 2.630516376453164, 3.9109307265063102, 4.230419548273853, 5.115364554163361, 2.8263802401498883},
    {1.1512932099452469, -0.45390976027605184, 1.2414924745985036, 4.32753356711799, 3.0735022786697095, 3.78656622201958, 5.586609260986594, 5.15179044388778, 0.41656810904780156, 1.436918563218865, 0.3126038313678316, 3.2210056500485713, 1.7403384153656087, 4.211008157899623, 4.107905688342862, 3.366995383065198},
    {2.4512818647325654, -0.8254887789439211, 0.15979633628080395, 5.315925069579524, 5.236042137071033, 4.05143938313444, 5.808392836768518, 4.176752420624453, -0.19489162772925758, 1.4315712616145397, 0.9957317779750877, 4.12285958264931, 4.351206793649617, 3.837439825554748, 4.340722835554636, 1.8472486158488375},
    {1.1289468990222773, -0.5829704773761581, 1.0689641156165264, 5.659243341374852, 3.3670344108850006, 5.173625465817144, 4.694133942966906, 4.4748342240007855, 0.6656708655075525, 0.1420070221557982, -0.9881092401683551, 3.1756074103321263, 4.48023196108653, 3.531899380792402, 4.8767005205712834, 3.61747167408594},
    {1.5648241922537798, 1.1212501734088796, 1.638763968875026, 3.6541188461444656, 5.719124825404389, 1.8824945300013831, 5.12274972265623, 5.817510224163618, -0.28454554682926264, 1.6433072114798792, 1.00018787036071, 4.315159945975287, 2.5143611267886348, 3.04573682751298, 4.922641465683629, 2.47191307575246},
    {0.0764186837180884, 0.33628124314817626, 0.8958629284886073, 5.186079214779793, 4.830580786097512, 4.3228755618766135, 4.818713311589346, 5.150416710681523, 0.9765571944727404, 1.913535034961378, 0.028695304596747823, 3.9480840553599017, 6.042662867408629, 5.746694646090194, 6.313626585646037, 3.7574566238840172},
    {2.754447177360771, -0.9007336623722739, 0.06786007220696454, 6.318312942314308, 4.436431658660672, 2.725984029806139, 3.6938322339205243, 4.628643549593385, -0.9297263992696645, 2.044322289614035, -1.076454623599392, 2.486969088809145, 4.510034439817505, 5.003766753760155, 5.335322428767109, 3.6516849043492794},
    {2.7608703906054677, -1.7765814466393626, 1.8258338026790089, 4.026146917655562, 5.28217913114556, 3.8750393125760545, 3.7873238298991616, 5.035757101465667, -1.269298927833718, 0.4238215573892609, -0.3035587417668184, 2.943557860837272, 3.486179661820474, 2.902935748652761, 6.158623032031181, 2.439035916959097},
    {3.618774332936158, 0.27804152422943634, 1.231462240706461, 4.657171422231134, 6.549526289060539, 4.077984188681625, 5.111068059667297, 4.399727841459548, -0.6269658929355996, 1.0562618751353225, -0.061960724399325845, 3.6448229708170747, 3.491995419078707, 3.8360613160482093, 5.420916372434283, 1.6603858326251706},
    {3.2421342099646897, 1.5632463678499198, 2.40367820826938, 4.555970877228007, 5.358186583101019, 1.6642307397434757, 5.35085254505536, 5.067335358505261, -0.8916497734009058, -0.15131387668416638, -1.5714278033767795, 3.415997887038757, 2.84117031265161, 5.609398460099764, 6.015262175826252, 3.301224132478035},
    {2.0265708111877254, -0.00843149415092609, 0.30136567262724334, 5.653587973758784, 4.724036207003505, 5.410092133761326, 4.892840824116017, 4.303070762670217, -0.3048008905127753, -0.4039736531160903, -1.6472705521585593, 2.99814943401285, 4.906674487018655, 4.289109091769096, 3.9302261830500864, 2.7703844599376235},
    {1.3757282005134828, -1.061872143492653, 1.0592967367563917, 5.7281447789753, 5.8291618594846755, 5.266882066349864, 6.057461097162137, 6.098501904033059, 0.014658306321271563, -0.1477177108324123, -0.5465262703041621, 1.8759635445357432, 5.386931721749342, 4.835203193854578, 4.991414085477545, 1.7601992247412115},
    {2.801641987536444, -0.7761543016043725, 1.0065423853436923, 5.80257503307571, 4.74315203890793, 5.0325498238889415, 3.681965248123238, 3.493720509427735, 1.5351883618179292, 1.1291315176751862, -1.2457143260105699, 3.724199485025304, 3.038914016746009, 4.76241041546533, 5.511976000601393, 4.2894334485391505},
    {2.01375343516968, 1.274998282383083, 0.5204272744203697, 5.873941216350021, 4.988409528293124, 4.732454533961147, 6.140225262174245, 5.466646321568939, 1.0427143109761674, 0.7022741890495496, -0.9507957028163989, 3.663617377589576, 4.734135158569306, 4.562774717126098, 5.9555874550765955, 3.887689876379305},
    {1.7133381287609208, -1.181253510581871, 0.769269484769699, 5.0794776612725645, 3.946515457999367, 3.453468077046049, 4.334029292412926, 2.6778709157347094, -0.49890904032277344, 0.08569616051168626, -0.40756562733673657, 2.8679217817262805, 5.952228061014365, 2.29132034828315, 3.3066372058930633, 3.230611231137093},
    {2.364815166764643, -2.0811541562577904, 1.1305457271277661, 4.72618247599157, 5.646064040993233, 2.9367898613015453, 5.674690307059775, 4.858690569507884, -0.7189625426117431, 0.8453901538853504, -0.04749769200602726, 2.7539080565014227, 4.225371020622774, 4.1602289052252175, 3.062947589006852, 3.3291578178117813},
    {3.4633096754219554, 0.5576338248660342, -0.06182148291872633, 4.338748611692136, 5.573271483026932, 2.3334957485897854, 2.467980884117644, 4.9106495060522395, -0.07216347199552119, 0.7903866763672284, 1.6406180087226108, 4.129151875652623, 2.860198062999657, 5.711068640857022, 5.551688684670171, 3.3273761669894837},
    {2.8837299694534573, -0.9901781599701553, 3.193997986140084, 4.098792412839386, 4.588583393681143, 3.5956118445506204, 5.230951007670025, 5.080113742849905, -1.8632640096783768, 0.3081499345528996, -0.9275016906954289, 2.4360175374496142, 4.278861541903835, 5.244270858825878, 6.8696474944893415, 4.814522511569136},
    {0.9481102821197166, 0.6804242878502067, 1.0874136970062143, 5.035612322786264, 4.01163700127395, 3.1754958856738202, 4.812823221406264, 3.3609193614848722, -1.0750914297473102, 1.601778066645276, 2.6078814979237603, 3.2389033520718638, 3.8869958833725526, 3.413044849120215, 3.1913111941179673, 4.213271308451251},
    {0.8918988627781517, -0.6176138325431547, 1.7116345559776371, 4.9374715150080455, 5.197957897351325, 2.6644440734448045, 6.2502499776608715, 4.693136942519744, 1.4105272449378825, 1.3276037087575288, -0.44834809589796065, 2.7657544598316584, 2.7122123228997124, 3.4496789447044587, 5.656877024646168, 1.6372069586494793},
    {1.5977258281897517, 0.6770026465496404, 0.9415308196131658, 5.700972255908619, 6.523859716930618, 3.519293243533201, 3.622777830552555, 4.187466407706773, -1.3488883414878403, 1.0861910509131116, 1.3710909168108694, 3.897749424525645, 4.07952731202452, 3.024460338365708, 3.7490587053817754, 4.953164547366233},
    {1.9705118982171659, 1.3537370144364618, 1.7657694835693196, 4.042921596344867, 4.682089523132482, 4.650043015140728, 4.270413315088831, 3.7013063259112595, -0.01648023209657498, 2.350129509132142, -2.5813543225021855, 5.235339993677357, 2.6999156574740613, 2.3522473572108833, 3.9166478470912267, 2.5918772294568733},
    {1.1803946393633757, 0.2510457147153173, -0.9219603043986029, 5.2863910733543635, 5.166880797663513, 4.1347227717993045, 2.6843970410656137, 4.173023753233002, 1.376423648827749, 1.543911680117565, -1.44780398553207, 3.1511331040651664, 4.1341513558200775, 3.5732723583065926, 4.016845169035685, 5.029983122772158},
    {3.2629047661103185, 1.9962930013367406, 0.8472083259910014, 3.8463103341191225, 4.4696857966476, 3.2794956917918996, 5.683684665852225, 4.787207085654348, 0.16825955768222078, 2.6769611958557693, -0.1729735504665535, 2.81066090008033, 3.785666124528123, 2.167254809054738, 5.996835899399692, 4.391460750190407}
};

static const float b2[16] = {2.1489618083810798, -0.07885699287951285, 1.1181018195038819, 6.397487470606596, 6.326848343821557, 4.723536411535262, 6.099456595644263, 5.625203773912064, -0.20861378147219703, 1.3192754962766697, -0.4935310324503548, 4.636557865308091, 4.719074675950081, 5.5570696041798575, 6.3526776858924885, 3.7352956383032594};

static const float w3[16][12] = {
    {-1.8316827157931035, -2.200002917545815, -0.9765469461301834, -2.318283536544908, -0.9366846653975517, -3.0667811291047506, -1.6016546289091187, -2.0686476621228183, -2.3321511885463706, -3.3688183895457287, -1.157510929655045, -0.11901718264668233},
    {-0.3178965328187116, -1.6116907204849982, -0.9729867024126754, -1.008996655001554, -0.4090447536228266, -1.065726875999027, -0.4351237482951214, -2.0832300779882873, -0.18301856900070637, 0.3667384629363179, 0.8792113660579707, -0.8416312755036973},
    {-1.9834028630955343, -2.1738478128788508, -1.9222032512075131, -1.484416795695548, -0.2784573344892326, -1.3473043672454814, -1.6614476932750664, -1.5145680258664245, -0.9408064726703071, 0.40085464143097016, -1.8890578363946928, -0.31365361344643605},
    {-3.9967937560419995, -4.658832912126971, -4.759516188735605, -4.21491011502144, -3.6781679422457425, -4.645977666386751, -4.3255606476938935, -3.8247413152472047, -4.422142564441014, -4.792574751477098, -4.726477732332577, -2.8494635152297785},
    {-3.6672160915615706, -3.414003374754371, -3.1238760663275036, -3.7850453666478017, -4.539080979423964, -2.9536771434199927, -3.205277344541102, -4.0875706510467, -5.342224039324614, -4.71143777331128, -4.875170758427422, -3.4573720014880185},
    {-3.8393697815756656, -3.5724597475868642, -2.8566013799661842, -2.810932234600498, -3.537964768678698, -2.9643883453778836, -2.9632747869747504, -2.5971719896308616, -4.618164935649547, -2.0642554800746433, -4.472911627937891, -2.4883914367782975},
    {-2.888907913739985, -3.140459345138817, -4.22132679961027, -3.768338341309414, -4.119576845343382, -4.160119134941537, -4.283850461390739, -3.1872735083896426, -3.503483849918017, -2.534845025672254, -2.9353273484698774, -5.732825331862915},
    {-3.724291079538331, -4.700711166452116, -4.2538116877666825, -3.238866470186925, -3.2900333150029835, -2.2232033900069643, -3.0493209506930223, -3.9987904770746816, -2.5821824353181118, -3.3395603970648198, -3.9069508273149234, -3.5581071743682786},
    {-1.336207751769594, -0.08980474945296818, -0.007517997008888088, 0.7025253432706432, -1.3628940043481528, 1.117405244147035, 0.11194539252995626, -0.35229863053558974, -0.07214525562944987, -1.0491798907693124, -0.8855309607720134, -1.4695746747079474},
    {-2.269210345234905, -0.6999372166168444, -0.6770631014158482, -2.755676736255601, -0.5008456945079857, -0.35847866861004585, -0.3823283438763284, -1.8238923502443993, -0.023593520394557112, -1.0320235160836622, -1.99731712264549, -2.8131076631120595},
    {0.28680078040558116, -2.340196990145, -2.844197872228475, 0.9771127613964463, 0.7424392630715333, -1.287053486961043, -0.04477356571466028, -0.3555734967748774, -0.6158567123591143, 1.255692806378131, 0.39519943600601654, -1.0204277010788274},
    {-2.7415440884337308, -4.053517386741655, -3.874127609493222, -1.9129470884098634, -3.6836445228958445, -3.60353930616129, -4.612986325709948, -2.220990728567937, -2.80629063127008, -3.833108612329837, -3.9239460773736665, -1.8138709686584398},
    {-6.3348468504631725, -2.323261640093341, -2.9292342210846867, -5.3862720350604985, -3.4400922326013963, -1.7388751176928035, -3.927987253687074, -4.358203868611559, -4.304156122962297, -4.5762630847222106, -1.213831529956519, -2.6191365377856592},
    {-2.277622433556897, -3.963907666116106, -2.388613200572421, -2.2766541832669196, -3.466145217389795, -3.979992401759265, -2.110638086837468, -4.5374050797446515, -3.6926605930828527, -2.5028212362541806, -3.597343746426236, -5.351565223377382},
    {-3.0246966627391845, -2.9306410883780996, -4.326948725669003, -4.3210300475878105, -3.65253884910701, -5.844515526391286, -4.645531246541597, -2.7948552773047366, -3.185413625998609, -4.1373071186794155, -3.807331729388032, -5.0643878638109046},
    {-3.1690945091931395, -2.77946795336468, -3.1221473237035116, -3.0470870558481966, -3.126213243936808, -2.935541031846154, -2.9502733245037533, -4.13511779094826, -0.8621573390752257, -2.586638139250407, -1.7585540306441874, -2.7766981739529832}
};

static const float b3[12] = {-2.6725575331192575, -2.6985637328831142, -2.6806148848878397, -2.738753268164232, -2.6252972772145964, -2.6968071193797356, -2.7444201313720296, -2.6504364937419704, -2.8376083827502514, -2.9726052859365852, -2.4918502064887127, -3.0890142423956424};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
