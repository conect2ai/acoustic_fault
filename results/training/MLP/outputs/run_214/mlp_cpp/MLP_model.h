#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.7318188015410052, -0.9129395299622105, -0.5397862325120174, 3.2293702122511316, 0.13753786471673826, -1.8261122781566594, 1.8062636719107998, 1.064932509473388, -0.41801235187695096, -1.7357411600964454, 0.658364832940939, 0.21726859241450305, 2.299082353781838, -1.817390239561822, 2.710202642531263, -0.14803185173804928, 1.1262020495180571, -1.6403066268303392, 0.46670155948581993, -0.4799354789485795, 0.46734299889765796, -0.8282844503069606, 0.6469049787207001, -0.6608925094571451, 0.49730143173642954, -0.42881600223992045, 0.7408633520058953, -0.7512782155780025, -2.319182174566118, 0.5956918448167782, -1.802370258011338, 1.1681330974634412, 1.612088723574212, 1.3359668595462584, -0.4003784411526888, -0.342276233986611, 1.4497654912273494, 0.9323610525954145, 1.0173188870781544, -1.6558888711170268, 2.227542297878818, 0.3053055113891101, 0.06538983546394192, 0.22815450842554325, 0.626929808459479, 2.370260143249309, 2.13771161591083, 0.5247555712130463, -1.7906783413155298, -0.3002363005401797, 0.17774568284870051, -0.3060512456998878, -2.535678996161582, -0.3456974810435565, 0.7145008222606845, 0.95309876424894, -1.2163844205929408, -0.026684526291232625, -0.7214930088694247, 1.3475849123986676, -0.2298980941070975, 0.6303942955015519, 1.3911495543031562, 0.7125940906894145},
    {0.9880110577985673, 0.527997296281733, -1.683871645420511, 2.1875344604540667, 2.1344316767381715, -0.3682129250429989, 0.34770226248323083, 0.2112198326437766, 0.5736064876594847, 1.4448612643375724, -1.2685859703517117, -0.781201131767742, 1.4439516577003757, -0.44999294553141717, 1.0129787197337206, -0.8904341432271351, -0.09757938166405467, -1.7652300462045472, -0.15764529410073233, 0.0440102151774982, 1.685745988693131, 1.34464738878788, 0.06568268291034732, -2.1652974929783717, -0.3087757382034221, -0.8800964869637047, -0.9875303594117045, -1.1406387900206425, 0.4850181154856259, 1.0902136888332767, 0.7960646052687491, 2.100847537979654, -0.42684821307840265, 1.6803341326277104, -1.493816063965534, 0.38313567460199927, -0.0157826967445018, 1.0201392053358427, 0.9544322792925544, -0.6974392121538913, 0.2103836392483699, -0.3591110710304318, 0.6050437031633985, 0.7507366607179443, -1.4371153982594562, -0.5016874698588302, 2.0922582095236475, -0.4254437729208273, -0.2785492160356833, 0.14195005455299603, 0.0836119283076334, 0.23230194357999046, 0.7034673440751863, 2.093421121294026, -1.8445584969021167, 1.149593786832931, 0.31706949221553654, 0.6142792645612172, -0.16830433715711046, -0.17380856157063457, -0.8844128360332518, 0.0064537082643389455, -2.8141495978509883, 2.048461268514921},
    {1.2148844123804587, -2.816010288748342, 1.9837750024355008, -0.6131058437218901, -1.7827767483368193, -1.3129694905099432, 0.9382136056902093, -0.8748863137030931, 1.5629455041239686, 1.3813343336527646, -0.8262648768810932, 0.33516593397379113, 2.8893517503277364, 1.9605622531967635, -1.3231552714582377, -1.4134238035969098, 0.9302576011660824, -1.7950994108933658, -1.8533911107192647, 1.3276417218007153, 0.9904726421036164, 0.18225144240448107, 0.4250096224341582, 1.203582929923114, 1.3154931314112979, -1.4988582134736599, -0.4317420365238834, -2.676424655726198, 2.495609626186867, -0.6947619189478951, 0.0381553748837104, 0.35921005845765563, -0.32354646647900137, 0.8038295597300728, -0.7395641288510111, 0.347637860551022, 0.10722009250187456, 2.169486672819716, 0.14465731477823981, -1.254971259244369, 2.27094504437796, -0.7009401876732084, -1.6880914477709377, -0.18952079790947726, -2.2629175136763164, -0.8719022563337954, 0.7274173008412269, -0.043088518155020586, -0.37823605207514743, 0.19128239744662476, 0.08608007404841067, 0.594011972748028, -0.4904864026993562, 2.0941255202126463, -0.4235954076242314, -1.530551708149183, -1.0963364212215625, -1.9293745291137345, 3.886146638576006, -0.4724737016520454, 0.8450316751876833, -0.8597799815509082, -0.8221646729806701, -2.427096552373255},
    {-0.38588947362440884, -0.7212144037025097, -1.7915905544750022, -0.4829337882522594, -1.959856799664847, 0.5952286386660954, 0.12400975885277413, -2.4218013529735365, 2.278999920502288, -0.5503562175274265, -3.3013472197195166, 0.030531737239009035, 0.5449891394356441, 1.3167106249949208, -0.6013576583120215, -2.2668318696356664, 1.7279107559055866, -1.674332173998578, -0.728992062659104, -0.6629693004482715, 2.296080165120767, -0.442531283892571, 0.25134437239661633, 0.7103729559304438, 0.048707575904942645, -1.5342924602073307, -0.5690792381484759, 2.178737794485995, 0.6739960929063464, 3.0509788044969985, -1.9835086975363565, -0.3372511687755862, -0.6021871758727584, 0.8265372424402933, 0.2736889753020378, 0.13004820781255627, -1.3242980926240804, 2.081279419359396, -2.619833341757229, -2.0271162402034206, -0.3286858391004715, -1.39667895758963, -1.6735116428946848, -0.26470749708544733, -1.1404769784537716, 1.682607184177253, 0.646911432380744, 2.413544524577239, 0.11463350478133075, -1.2153812436449876, -1.618983880182704, -1.0151959915002633, -0.8633218890342754, 0.9414484511878595, -0.3078226231762029, -0.6597127947983802, -0.9807859566826317, -0.7716129581212244, 0.8672794429764209, -0.17420839802096633, 0.4536195359030287, 0.7107996588271065, 0.42935450483142085, -1.6031157154936753},
    {0.12482974676171062, -3.306980058412064, -0.8968246478436827, 0.2800841701116216, -0.734285456500693, -2.3620975488180207, 0.8433056051930211, 0.2277078046549099, 2.2627458583804354, 0.06721381229922516, -1.8857940453691404, 0.09670953480298794, 0.12491075537863858, -2.2089769564407895, -0.1275494016793449, -1.362354323334087, -0.6430407809400147, -1.6356075127338043, 0.04713074618374819, -1.6659144052418784, -0.009299299917522017, 0.06630395115154662, -0.68471158630428, -1.2714410635098132, -1.3076078608189698, -2.4304641717625857, -0.39752001140190235, -0.2734061382815628, -2.9865500014289874, 0.7460520155745116, 0.5458117791178565, -0.5962606904640784, -0.3784056363013716, -0.24804981204480137, -1.3162008966230638, -0.03944483752573196, -1.4833666818133067, 0.7880602961580809, 0.4489658142011926, -3.0156762388433416, -0.9700220725238042, -0.9104666686578714, -2.9010039129191836, -0.7760445259588316, -0.6927933172604435, 0.9856851064337839, -0.976814813331081, -0.602254599453582, -1.3413197673068133, 0.38267578778000744, 1.1690881929306656, 0.460553055054717, 0.620664245114307, -1.0290175913292592, -2.3368940390634614, -2.387009423377837, -0.48537884321758396, 0.5205568143386605, 1.6880740490975, -0.5560604023139872, 0.9470616828697239, 0.10177903305027906, -0.40873429078311163, -0.5775084486351011},
    {1.1932610347278727, -2.877004558764488, 0.5191531795956708, -1.503250872738082, -0.811255421815167, -0.3794146631079875, 1.0157390187213287, 0.012758997846126118, 1.255553483610644, -1.8322272328509723, -1.385213101346779, 0.10415315575897126, 0.4846819241852005, 0.7747407025103052, -0.8709783740903572, -3.550473338200728, -0.45181920500749145, -1.8731945598693223, -1.3480657999726087, -1.5402297712948967, -0.23399750718957754, -1.6941858520651278, -0.9773949441274374, -0.9010656619714194, -0.2711407700613104, -1.6362946682548607, -1.1712680949746817, -0.6555021401576754, -0.45837668762359185, 2.1227696218033922, -0.39436929466174725, -0.9279832584157136, -0.6642321255026941, -0.3983039841524159, -0.2799124944894888, -2.373420141260111, -0.7381291179997128, 0.7679198239389954, -0.27780969664883526, -2.4955528975865935, 1.9117359678442543, -0.061036891841112814, -0.8712209456111449, -1.2684573022503014, -0.2618683348850992, -0.7152878637557935, 3.112832091288928, 0.6067346411493275, -1.1306357901145403, 0.9033115565563329, -0.168947720048229, 0.9136894436193652, 0.21801233440075618, -0.3672801351981644, -0.9998123915922542, -0.8447043671260924, -0.7755829619446851, -1.9457550847048224, 1.2209457805703088, -0.9745812633751291, 1.5868226991342869, 0.9640571925028298, -0.34865516105376504, -1.3458670530966828},
    {0.42190313160454823, -2.0340069606769178, -0.6155282922801016, 2.9724988794634055, 0.1351349288308873, -0.12220686359860641, 2.842208067098185, -0.2846958213398326, 0.24316601915208413, -1.0884479394577857, -2.0598255110437638, -0.8137337297847661, 1.5797846702204168, -0.5161085729069529, -3.140922388501596, -2.115539412576418, -0.37731337331961323, 0.7415969715055206, -1.8307309590722842, -0.09019427962473238, 1.0208868129729585, 0.10848593798356243, -1.7287872817047358, -0.08779053024929317, -0.242408538849288, 2.1458832499420892, -0.8210267504581588, -1.7835320257265959, -0.41298227180957847, -0.30468268316790725, 0.43239288195922354, -1.2487759244677261, 0.536001722386523, -0.30708387896225614, -1.5987158051951977, -0.6247998771517177, 0.350669788641469, -1.1840521191451179, -2.260701497170736, -1.9566534381773488, 0.1756862179845525, -0.7775301960066839, -0.4121536277905358, 0.07048071123679796, -2.6723384425107426, 0.9689060740535559, -0.20729558875236104, -1.3019707894272787, -1.1685238667891205, 0.37562108500773816, -0.5313354941740334, 0.9395915461874419, -1.6120363539053133, -1.274353082987034, -0.4608375183886154, -1.7197938754245354, 0.8441462185376511, -0.20414016533487564, 0.6889317007574958, 0.7491311970102448, 0.6008499311419421, -0.6747473288209651, -0.5735783823566267, -0.6188162605510396},
    {-1.3854049996722138, -3.6380579155188078, -0.2499054627244199, -0.4279097827407137, 1.5774419724026658, 1.0430620734947345, 0.7554369962583906, -1.293732173958789, 1.1293173020103238, 0.21542325670465823, -0.34340222047446783, -0.9837402036052131, 1.2802026354958542, -1.4129090893507512, -0.567764165892677, 0.2334460931748146, 0.23708349107608498, -1.7369133840543904, -1.3003600761046776, -0.42234914080063846, -0.4023421403801853, 0.36766351413045045, -0.881991618733788, -0.9776377777815526, -2.5354887028724122, 0.46936033065834293, 0.5758818805622596, -1.0732783596115794, -1.6438433654738596, 0.32229636089118796, -0.2657859103303683, -0.211425616845864, -0.6233809690410954, 0.9943355139112775, 1.0448873954954139, -1.0419646093685138, 1.5065046510917772, 0.5855812663121656, -1.603673625628102, 0.04661249985501798, 1.1898107879676953, 0.9114684829420074, -0.3777752411827747, 0.17491841158599147, -0.945125093885002, 1.0855799878224819, 1.2975237158040678, -0.37955965132695835, -0.038113311880267675, -0.5542709676323508, 0.08156459951120815, -0.7528334611885179, 0.6678933630606335, -0.8939824564627651, 1.2375241727425483, -2.165646128511873, -2.6800426572351266, -0.7386030817027052, 0.04212740483405144, -0.30177233448926294, -1.075831482973117, -1.257902298547219, -0.65485839468972, 0.23324568826331016},
    {-1.118987566725425, -1.7584776889158955, -1.1838446624004804, 1.2012120787706888, -2.038430979068136, -1.6688571382545654, 1.4434448967060687, -0.32665932716826496, -0.4519876510906747, 1.426019227252136, -1.3730997507588045, -1.2033749791080057, 0.7146221416023758, 0.13692591361238748, -0.7448638148485274, -1.0391993314349033, -0.08623562988132527, -1.263995009998984, -1.9222257094249158, -1.2586688641032528, 1.139319045082178, -1.877130881085091, -0.3202015442591688, -1.6643112358920054, -0.4150922277655734, -1.114306197304829, 0.3255060911037325, -0.3230341892092341, -0.6503376311173834, 2.65751108497367, -0.13476159665518636, -0.4767527694815425, -1.1543607742580126, 1.1201542742340118, -1.2403970776966926, 1.7311113505696671, 0.43148557815434024, -0.007800320174682135, 0.5094551606271547, -1.875163032128294, -1.1532903512272388, 0.848376519642008, -0.5563750893760006, 0.8520740065545641, 0.5174139625625092, 2.099800987164353, 0.6797715422785277, 0.5985125783066078, -1.1863223597230714, 1.284526601260492, -1.6090989364931874, 0.25931814085082106, -1.5019648114601354, 0.6990641088448454, -2.1023003567023006, -0.5337859287769959, -0.1954068269614885, -0.3798262295418606, 1.158090576437775, -1.0485713582542606, -0.28363466997314074, -0.3858158999192627, -0.22772147763237702, -1.2382648818397104},
    {-1.1248152623654002, -1.9552896285581653, 0.7059544471094611, -0.3186538287425474, -0.9914080735657772, -0.5200444558855174, 2.126707525745873, -0.27777478303572334, 1.6167771586585449, 1.3134432474845212, -2.0203791499819075, -1.3056438387547606, 1.422739371813129, -0.831870466035941, -1.6169369997535792, -0.8089588799127749, 0.6513772970960882, -1.2095362203860753, 1.2049124694212563, 0.5364674036351526, 3.341781751526364, 0.16312224549757054, 0.25814495931197395, 1.1213582755455573, -0.5327936634925825, -3.1046375914345923, -0.4311197825187483, -0.5119277100947266, -0.7201075019843246, 0.6678223835392396, -1.3956482043483953, -0.9462362935997876, -1.5458200510055702, 0.593655296358054, -0.8872374194849556, 0.24617380421795074, 0.44438078362859146, 0.6148776780710414, 0.5795548103790845, -0.40904512898314876, -0.883729172074239, -0.1571800113196838, -0.2381753930930601, 0.38745724140656396, -2.457079329272872, -1.087688513478201, 0.733049896523907, 1.745331770519712, -0.9056156033304439, 0.6362713806945139, -2.2132859282702695, 0.5613994687354448, 0.48766466691557725, -1.360704022079853, -0.34395189791827385, 0.3768663119341756, -0.9491348308401052, -0.05659404059529122, 2.2484586765953924, -4.043712902088446, 1.824500010707171, 0.10585371546468318, 0.077508016789423, 0.37806836337482264},
    {-1.7305015736893374, -2.0804403305919474, -0.4139038513330317, -0.8987603657716526, 1.634266810534292, 0.526210848705559, -0.32887154882093395, -0.9857027408614214, 1.5952837620709892, -0.7959665604095386, -2.374696280066517, -1.223685565996024, 1.1388714311531882, -1.2799238687743442, -1.7766657810725313, -1.2922360254176228, 0.6379837235955983, -2.3166537671646883, -1.7031050674580537, -0.7300168598911282, 2.029056443105567, -1.3442222970361117, 1.6214674049969764, 0.6314983980890662, -0.4973637950223366, 0.1830922703773207, -2.146324985897137, -1.1329232519158552, -1.3410945396314897, 1.1336189576523559, -1.4718309466448039, 1.2225661058171495, -3.320554170287482, 0.41809806422243345, -1.9737285092945769, 0.027319762917570756, 0.6627007459856671, 2.686794601726763, 0.0029438908021103037, -1.2269031372309962, 0.4208016660652525, 1.624822900253698, -0.7615636127777916, -0.6317224583538905, -1.8958652539121708, -0.4913773043417848, 2.0430875260837755, 0.5344804791010224, -1.4673214610812435, 0.20349503316742987, -0.2876217759870928, -1.36308396171894, -0.9461470233486483, 0.017815112854077744, -2.284732171540424, -0.1719750984306406, -1.0464886923287073, 1.5018987308797114, 1.9925123128074713, -0.06148643962376116, 0.09642983719644733, 0.2517243273288883, 0.19925620398480864, 0.9917252241223578},
    {-2.09791725896228, -1.297907908076176, 0.2511566498370189, 1.659717973955562, 0.244790558335113, -1.78810297708901, 0.7038938977921445, -2.0530465953979746, 0.2758428115353912, -2.2113181904009287, -2.945469019305853, 0.08706588136415089, 3.1059223084242893, 2.058332254609602, -2.1697428893295885, -0.0771705858170619, -0.373190126793912, -1.625648636228233, -0.21834176170344594, -0.14909492287939802, 1.2012717618305662, 0.2920405043014338, -1.010723770659042, -0.4423974787334063, -0.4522900290978512, -2.129832924475976, 1.2630709642612794, -0.645491549555758, -1.5355119147490957, -0.8362443527624903, -0.7364343369530564, -1.4945244254101935, -1.9067744771664572, 0.44162017471743525, -2.342131958674498, -0.5475795441728678, -1.161892452049855, 1.8492006407918506, -2.1290274435291723, -0.7932865397240743, -0.23629127765554206, 0.6753116124124204, 1.3985053828362732, 0.22773938922203046, -2.0500001518598205, -1.9869921306727036, 3.22992465401506, 1.4205907418773507, -0.4691946486205546, -1.0175242921211147, -1.1320585311867928, -1.706122249559246, -1.3532814771054504, 0.048624280414995634, -0.5973723255921621, -1.2416529640166536, -2.1350527929426013, 0.16529212581614935, 1.8069694905661147, -0.452260496546796, 0.7924295143206459, 0.24901705573017147, 0.16222874017542407, 0.5760277757525899},
    {1.6380318538547303, -2.2774589059572428, -1.1842832559262522, 0.7618743775491362, -0.8758427440047651, -1.441101773932346, 0.026907267912595918, 0.5573307855269359, 0.4258904743310777, 0.11526074619920422, -0.4134540602570888, -0.3317236886581581, -2.4463129944500785, 1.2730181592526766, -0.5233343177032516, 0.06045860883892945, 0.42390205892772437, -0.9646164613399661, -1.1395274702302818, 0.09016711704164954, 1.1048470590008361, 1.3520808402836832, 0.44122985351566446, -0.6737102876002076, -2.6283409944443785, -1.4244231486416763, 1.0781322697301188, -0.4932280563728449, 1.8171774430915606, 1.364969830239219, 0.014628775018107939, -0.8371720686921401, -1.7979657414174282, -0.41414014389535136, -0.8820054904148397, -0.6112042720138647, -0.46390699747872316, 0.8308978711531774, -0.5580479743986788, 0.5101268553789047, -1.3900756564045833, -0.7198389009407568, 0.3082004189761213, -0.7914853879300988, -0.9602838227748486, 0.6506709600687853, 1.7674216848576745, -0.5074552715797604, -0.9410670608959311, -0.1233079576526339, -1.3617260659023749, -0.5955340016156614, -0.7056560477531167, -1.347889298704894, -1.9046267601302889, -0.7719307813329678, -1.2426842220802352, -0.14743116084270602, -0.4114659789657772, -1.3496138209921105, -0.3532817216620385, -1.1956087958703097, -0.26315757723890515, -1.247818267403008},
    {-0.26420989396839406, -1.5071698725122564, 1.1033052873506153, -1.6010114225189451, 0.6426438150391688, -1.1880579313014508, 0.25867829388917174, -1.3209922669556688, 1.4014509821563064, 0.2617566931986619, -1.061057870018208, -0.9898658996813308, 0.20136902812050542, 0.2308289271821446, -0.10925378658458003, -2.3929305184127285, -0.8587795412112474, -1.5882927344840516, -0.1369268452298053, -1.5155384872983102, 3.127399821184916, -0.20197981883114463, -0.3031910985872787, -1.939631938584811, -1.902501524430733, -1.5439155374269358, 0.575797085503484, -1.278938939495958, -1.8467432054448651, 2.18987442317132, -0.6207159706152955, -0.9046542475636764, -1.309195319017134, -1.8459867734952207, -1.4452759895622653, 0.3450742142971133, 0.5617198940473304, 1.036273760316925, -1.440662572623583, -0.8027905766496171, -0.8025076669156141, -0.8837216985290878, 1.7802657684802645, -0.5502896146807928, 0.6808454367615623, 1.3372452447160574, 1.8544145137436399, 0.5293122743716157, -1.6981183855685835, -1.4138678297130842, -3.5482357752590414, -0.3787435718627668, 0.4768359867442527, 1.4075935156744726, -1.7799847508255005, 0.1516097519136747, -0.5245052633893588, -0.2422406490211179, 0.9229826216426802, -0.33779339782279283, 1.4714383740931936, 1.5890350242697517, 0.7177836488295843, 0.6451495066166258},
    {0.25445885757223047, 0.0162349140724948, 1.2994609886515907, -1.5646351489759918, 0.27861515113622876, -1.358758061095643, 0.09925312245397153, 1.2355298839210775, 1.7024219185179188, 0.11597022834148239, -2.376566194048057, -2.307824793823644, 0.7373329891881802, 0.06130297830072934, -0.061496015401441714, 0.08770712087254591, 0.911430390598978, 1.7397534639056884, -0.37937051896699764, -0.5780367892879019, 0.8125362298909136, 1.0190109052575496, -0.3754892962471619, -0.57890969453591, -0.7054369037934376, -2.2066250781125687, 1.9281885267886039, -2.801040204188157, 0.8689741629502625, 1.1726064186353882, -0.3841827116448143, -0.40500135081359145, 0.7718936261170147, -1.592138118364824, -1.30672766565718, -0.3682878059196699, 0.280577637739119, -0.25500179069058443, -2.4658393533181506, -1.0854326087271355, -1.1684346105179688, 0.3438488710444061, 0.07328079409739813, 2.041814373966926, -0.35988882785376997, 0.19817015810768449, 0.4560015561104609, 0.6498864664565086, -0.5800986821413282, -0.617057477946283, -1.1308457446918034, -2.4112536551490553, 0.273796769119062, -0.7545596729059979, -3.6312895661256426, 0.1758528974646598, -1.7631011830413814, -1.0534959867866185, -0.11924674714076486, -2.0222424907755694, 0.6818404913887172, -0.47391211353372475, 1.5787933362966218, -0.5463599535711509},
    {2.0314938771612456, -0.7170447015163395, 0.5232096410144607, -2.0151016365678456, 0.1270914119230319, -2.462361005249281, 0.2630240732675453, -0.3386416014848635, 0.033046319628673396, 0.9306703481445261, -3.6222186671207663, -1.4529093273405038, 0.8081152396423132, 0.3824026093119446, 0.22054506539014007, -3.6876314875657945, 0.4243139007244812, -0.9504912484583967, -1.505056544105466, -1.2893491698025228, 0.5389937753909867, -0.8763100090466894, -1.3257959314766818, 0.2822476018132643, -1.1756617601177608, -3.9543682104935898, -2.09992477976218, -2.5890327811860194, -0.7792544351778431, -2.1521489653837156, -0.8234384354216281, 0.31448450908789577, 1.5071342908044267, -2.1526208041499983, -0.0913542515942013, -1.2894236494127709, 0.12559797190903293, 2.6115311229002125, 0.993538218090366, -1.5213436212414984, 1.159703338374517, -0.7795454718435342, 0.42099606213513163, -0.6806399877016451, -0.2087880176254028, -0.4948240907229557, 0.7424123648478579, 0.4362632050915469, -1.8715811563322529, -0.4726191795750085, 0.37524128128833517, 0.19390349403832818, 0.27683964026713853, 0.6870537383411504, -2.6338134686989743, -0.31130323893506096, -1.2465759874361253, -0.6591245497554024, -0.040577885400656315, -0.7707677375456828, 0.15699744792754952, 1.1275077473089286, 0.14028726390457588, -1.8684687825871202},
    {3.4703084478112136, -0.3177268476602979, -0.036743883463757954, -1.898454876951167, -0.1451247524694026, 0.7789775630942312, -0.060049788278428995, 1.0774388069642706, 0.5555587065990009, 0.04849844208114385, -1.0617339883865387, -2.5450337921735495, 3.3238837483699384, -0.00022923864208447046, -0.221040996541739, -1.6296947516586555, 0.22355195278946433, -0.9226503086106591, -1.1636952501135323, 0.5310112927550171, 1.3487200067301823, 0.937371438269472, 2.7372991921234107, -1.2830040801422187, 0.99695187148416, -1.5750177429325531, 1.083144624202599, -1.4622688384914913, -1.141100175835273, 0.9893977331656688, -2.1491315998249103, -0.46848835678559, -2.595518084059787, -1.951597142795918, 0.4838333978109177, -0.8742749941076847, 0.4358610473840902, 2.7203847282074842, -0.10480869184856567, -2.459243988161504, 2.920559037360661, -1.2563962910429964, -0.2581100711824569, -0.06290935983987934, -2.700317728354059, 0.7856723907939072, 0.11674488032453426, 2.344056051151957, 0.3347692832212385, 0.7364624192371009, -2.07332087463779, -1.2091241465974707, 1.0724948069966411, 0.9128497588663411, -1.7452895701857414, -0.9214688803617984, -1.225465988163899, -0.47968565329744833, -1.9948377800657047, -0.7777109506243128, -0.3307493025150783, 0.8428992651290494, -1.5064403229535703, -2.3465682746316183},
    {1.6176847395954626, -2.609448943473387, 0.22554676884055913, 1.59827631237856, -1.2302643027841418, -0.1454891120514389, 0.9244331267923488, 0.5583430778391305, 0.9648271658873219, -0.4768002893464525, -1.019035235221484, -2.436581151738647, 0.8204371413007008, 0.23146041634283035, 0.8682903275701492, 0.10551816778687792, -0.7471048966730434, 0.2794692203164562, 0.012977118283761541, -1.8915939096133543, 2.5415268654021217, -0.42597594650474224, 0.3740457939472585, -0.9078504364248177, 0.1467587012577699, -1.1791946435886065, -1.6124289753301022, 0.7174188310482538, 0.24902467809463838, 3.7887799240854134, -2.613251602770646, -0.0634548062511681, -0.8829805594275716, -0.005136970507255328, -0.6185456238166607, -0.5893263720665203, -1.2586057188558493, 1.3529671207938536, -1.138578918060556, -1.155141054313793, 0.4467033380564828, 1.4408633443323051, 0.5567703767575235, -1.875993675894098, -1.6115971861313276, 1.830008617339127, 0.12243310273091296, 1.1730705789050557, -1.1261599861983174, -0.2555566722149663, -1.1489938352429605, -1.8624869020825998, -1.1603328224408869, 2.2359713261378324, -0.7311475871377907, -0.04229236102420748, -0.08267743417340531, -0.004436233871921069, 0.14201871169697414, -2.1579671891343626, -0.10513554377174325, 0.46201756688794676, -0.551705315551542, 1.6534038527339678},
    {1.929668643800457, -0.5990479398518261, 2.2936129568695236, -1.3267234616299188, 0.02123917180678825, -0.38496221097461936, 2.071365854084728, 0.3154738528344715, 1.0481519738493084, -0.7440538337004023, 0.2583541004176251, -1.1307972946780986, 0.8414098358268421, -0.883696424429071, -0.5854192125747876, 0.7050408519333996, 0.285606259307518, -0.9194510820121377, 0.2231783339823364, 0.9759165528238182, 1.7116927202661025, -0.25092527819978866, 0.36265128125611074, -0.6157818749036775, -0.7767117138495012, -0.3429466818908127, -1.1953990902455514, -1.3319797940916356, -2.129880441799198, -1.4257480951673183, -0.33630408330246647, -1.578398331765673, -0.18905374918632165, -1.0482507047431118, -0.6435923804381093, -0.6310326383651194, 2.284039042653118, 0.535885253671835, -0.556214247659705, -2.491446820384359, 1.4612568352701172, -0.965527427875152, 0.5811208301181973, -2.7182296692703987, -2.4556070753822565, 1.651458148228993, 0.5503212282443091, 0.6483362755005279, -2.2283960906988796, 0.12008276886175683, -0.6677695042168071, -0.1738904087379863, -0.7720020638742016, 0.6395024873305369, -2.4254916699493956, -1.0970250601930833, -1.6499476507091535, -2.13611316547317, 0.3926877247310251, -0.9829770991676091, -2.435509664880598, -0.46814352595783637, 1.2657316074440035, -0.9883428512045446},
    {-0.1926117375315672, -2.6296914846005097, -0.20430648392426703, 1.2975467858574032, -1.2258012166487238, -0.6046411444510992, 1.5222529892284782, 1.6752033184243413, 0.6363416110416021, -0.12726652558756155, -1.1870301387036917, -1.3112441758450468, 0.928503221769167, 1.7155127147305471, -0.770974209724482, -2.36737138005421, 0.15879870453346123, -0.6132113561667435, -1.5793476106711577, -1.09928358819125, 2.709363843048324, -0.45577054707086473, 1.998814541175808, -1.0819217306046105, -1.9528247875747307, -2.274186754132461, -0.2607739140130337, -0.20663996720930203, -1.6295635364173853, 0.28869468580650726, -1.6560598516054617, -0.3224507632210151, -0.9677482121245009, 1.5593443463997585, -0.9458482181218788, -1.8119083072418185, -0.5623644679100133, -0.9926832551544912, -2.4683503878297612, -1.9137703570707707, 0.48376541410179524, 0.7446098417359511, -1.4319644895268375, 1.2057213105827491, -1.6828785497243677, 0.172456731688399, 0.9702281126622009, 0.9584512027914313, -1.0474745312453386, 0.9625249385428772, -0.3924761215838037, -1.058739249369617, -1.8561952382659135, 1.7429730764924871, -2.134648994496391, 1.3204072205280675, -1.8787051550401177, -1.1298166177149858, 0.7648918282916236, -1.8331590152466997, 0.05172992727618173, 1.5552173496005306, -0.3668669524674779, 0.1792663735943513},
    {1.2060341243824304, -1.5794076463538502, -0.6595173122912057, -0.23681399080907542, 0.10501609709352205, -2.340316508675603, -0.19377066815280203, 0.9970112471881191, 0.48698400843284995, 0.2808567420091901, -4.921077017902823, -0.9940972374978567, 2.426672648411606, -0.894940070423203, 0.6424630960466671, -0.05622425711055152, -1.486360083914599, -0.6680471305190127, -2.0584237303695563, -1.5621104171540583, 1.1760943175449026, -0.20778857812263302, 1.3051222747117692, -3.1651746584508134, 0.6345337910876532, -1.3832527407580435, 1.4195587225289175, -1.1975409628423832, -1.9876254318655138, 1.1918315639351367, -1.1184240952321713, 0.5613346867486996, 0.9149652474271204, -0.3157144877504423, -0.8705964929096435, 0.9224127475311594, 1.3545335883453324, 0.755525815799006, -0.987436495107737, -2.437495682931572, 0.3006039438196511, -0.009514650387531019, -0.2087148047857319, -0.9028470765775254, -1.0285489673798065, 1.6049356661193548, 1.006770340408702, 1.2101260801988754, -1.6666579060018816, 0.6293018623160551, -1.3917842342755724, -0.5275684628244837, -2.6925343047779644, 0.3847367200656891, -1.4100503001095681, 0.7644057886288254, -0.2396507190324239, 0.3837488906546228, -0.9254788071265962, -1.427267305387304, 1.2684131887480885, -1.0985588043394412, 0.3417044219220389, 0.4512063235608304},
    {-0.0945785689428772, -1.8157600616722103, 0.9068893816497219, 0.5177098101646397, -1.3134029745272553, -1.210889129341271, -0.7316860303219765, -0.20468233434434432, 0.7788962189255024, 1.0607609534389348, -2.576211827487218, 0.7455896891359608, 1.41847395442067, 0.6582758915042582, -0.38766737362116366, -0.6576725808629147, 0.27963692187946637, -1.530284042813806, -1.0782412807842374, -1.3100520669348963, 1.5421121164189961, -1.6865107458867687, 0.6158452201183304, 0.5562826472968835, -1.1724885049162401, 0.061370628456221245, 1.2273331368449565, -2.233972937884106, -1.3836314084556949, 0.8799980694338366, -0.5918199762915491, -1.2945788732801564, 0.30590769751621516, -1.3255765999002944, -1.022785240808104, 0.016056377246202447, -0.49497897571981353, 1.9043453846734808, 0.11219660863575931, -2.3584257334231404, 2.3583203155603485, -1.2119806974658291, 0.5739953662950749, -1.367760028919931, -1.549464505827692, 2.5927656178189937, 2.162926187652612, -0.24023088135063847, -2.151703657460873, 0.730995947000517, -0.7850268297647244, 0.5929226411241313, 1.015794105232628, -0.2425690843073192, -1.1425743965543422, 0.30525080182063996, 0.8506288177313975, -0.7256532158588456, 4.113143931388255, -1.7476070037809144, -0.7205845833238897, -0.669900639198265, 1.1057399047135616, 1.0892404903335382},
    {1.2888544945763252, -3.0217421494601715, 0.5403409701346411, -0.0018258115360324395, 0.09042728372303702, 0.2541483189435357, 1.3609426251786443, -1.4803938783546198, -0.16456989795972715, -0.3341277422283394, -1.3330772511518996, -0.23188763016764694, 2.5347782344873515, 0.8383014987812324, 0.24067315205181974, -1.3273484099508184, -1.1868481993091877, 0.446432474043241, 0.012617267010445781, -0.17413597020948568, 3.587089522189364, -0.671457031043358, 0.21068886041496504, 0.7015956708053511, -1.2308902801695278, -0.9659754881896924, -0.40650560855710444, -1.978243207696371, 0.9515842194390087, 0.9855154741917888, 0.2314337722948133, -1.1824074537999314, 0.3397766971346222, -0.5821254603999394, 1.9445938304994803, 0.39626335926565054, 0.1219037305937825, 1.6740679381129477, -0.7529926670571736, -1.3116212877641111, -1.1329457844001212, 0.30651235312845526, 1.4145787381477077, -0.6712189350296521, -0.7583910040950537, 3.1786418766786726, 0.05779777312865928, 0.8664706788596611, -0.12010782451298514, 0.25914708858862967, 0.5360579052647728, 0.9951153973333632, -0.3032626168108849, -0.16780960881623552, -1.6838495705414602, 1.6126629094143703, -1.8374728037173391, -1.5670634367260183, -0.3643797337673261, 1.0196768507017195, 1.7770015106290984, 1.5886996951673984, 0.6740548543912444, 1.4361273405824395},
    {1.217366131297332, -1.7993490698926962, -0.39585303912469355, -2.207944196846744, -0.19652401225703853, -1.7114705424159793, 0.8208945360610339, 1.2250788760801483, 0.08294653565888443, -1.492894861097373, -2.5766753990268985, -0.7375856546577086, 1.3198924526379432, 1.0200056849206542, -0.02059067451975367, -1.3571727431699998, -1.080731098186292, -3.20278433089893, -0.5853871760846567, -0.9256356760567686, 1.4423111394533423, -0.5461012673939848, 1.0979483774800314, -1.6788899628458795, -0.48176841946928894, -1.7921627595240845, -0.6458426721711311, -2.046794601936794, 0.18371183958369217, 2.354142415788243, -0.3141613173418944, -1.0185649769351652, -0.5705627579629697, -1.8821507785176603, 0.8299184578318799, -0.49707608746902815, -0.1530366393636557, 2.4428442331087727, -0.3068893987334882, -1.9971109117437473, 0.4238424148167339, -0.49056543701092215, -0.7764117013429513, 0.2622477637361811, -1.8922740175442772, 1.071980022789528, -0.16662138493331083, 0.9825213200539602, -1.2555760304982881, 0.7441452358465208, -1.626324389362329, -0.4486056981907648, -0.5821404862540374, -0.7258200566011734, -1.0578979512014306, 0.1590317009231629, -0.759019646622973, -1.3870295013056968, 0.4139013708369531, -0.10327083058683001, 1.1330504058093902, -0.972388141886221, -1.732507014538667, -0.11951410817842545},
    {0.6045275953705618, -0.2910435113450757, -0.8299317128951702, -1.3868351590934762, -0.3088566383787498, -1.6193834401097849, 0.14474062014322833, -0.19174467907686477, 0.07375891839015855, -0.40603405616537597, -2.384803593747465, -1.6934374132593069, 1.7682634149340881, 1.3602172365931706, 0.5940764530168213, -0.21796168095667945, -1.3266028954696605, -1.9085315172412425, -0.9079315368044322, 0.9191371520946998, 0.8524947648975378, -0.5593266190722865, 1.9343221191745754, -1.5688076105237707, 1.2280191064037542, 0.9136659007032222, 1.072646621210541, 0.3202006546926348, -3.1159240723585353, 0.0017534551492617335, -1.5793810503615067, 1.9941221290586073, 0.2592238523660024, -1.2519400773768365, -1.1383605250634574, -0.1528940759527792, 0.7962091931178015, 1.4816335428914553, -2.4569178500295976, -2.428481945781724, -0.7432350736854635, -0.2287046998578322, 1.1853918105673709, -0.44047249021282564, -0.5842614994556725, 0.12463414044613921, 0.5995164085742075, 2.077991544624035, -1.071728251278168, 0.3568022013228766, -0.3133849732658062, -1.3849437987915927, -0.27121821718783035, 1.4629515282072303, -1.4701347038183052, -0.5159034289217441, -0.5417477634822311, -0.14973163571473516, 1.5492795469227703, -0.2531306506669416, 1.225854038876375, 0.2471457505947366, 1.1024296056320904, 1.2999974500687212},
    {1.7646036124809212, 0.1585769658950901, 1.973020718777109, -1.8727338520460413, -0.700300119124169, -0.12544882708215466, 0.5282745996077808, 0.35293367682287174, 0.7564612605038143, -0.734982363482133, -1.0074826736404137, -0.4973131062987739, 1.3540582877182454, -1.0706155379357771, -0.4961772878127806, -2.2987383336933553, 0.41075867807565203, -2.7901012741146793, -0.3063136098068697, -0.5200564577728292, 1.123279927371968, 0.91038299289344, -0.9146202797495114, -2.600753053197713, 0.5432269918591489, -1.6136057197193172, 2.2408186590174193, -0.3223182626754363, -1.4634892234485546, 0.632921921690389, -1.3855000471618129, 0.45597882483952057, -0.31299142804441227, -1.0251986078019177, 0.7743603915006069, 0.13672244740159553, 2.647543699247873, 2.1388892429926716, 1.2943550597665185, -1.375388481773346, -0.10892005349985381, 0.5090804614373674, 1.0967534969568364, -0.1439524675100625, -1.0383799825568123, 2.616204622453499, 1.569207643835471, 0.6065052872367247, 0.053855300131785376, 0.944276948100274, -2.5202181629689604, -1.9685814027070967, -0.25336491574260556, 0.3818233737635462, 1.1561999529316251, 1.2005767561154017, -0.5050592273832045, -0.2626975338329093, -0.5017186457596785, -1.1115113268210284, 0.5952643494993264, 0.558301131620186, -0.2348387648572546, 0.24664495523762325},
    {0.136492903534074, -0.8185760733062091, -0.21764375305437342, 0.6168724522325617, -1.751891526811711, -1.6958778022340075, 1.9821750439782795, 0.18907212001933815, 0.16950532456896894, -0.6545463023929633, -0.18841469273797196, -0.5877933014920529, 0.5027770449653057, 1.0760324486645099, -0.5718990520367024, 0.2814272045028317, 0.30903028952868605, -1.5568101055439663, -0.7139120799948698, 0.8750155936524316, 2.267000729325503, 0.07501933040584814, 0.5743120833682138, -0.5818017142660281, -1.3191043673267642, -0.9224355157507936, 1.6008865750213308, -0.0992480803924506, -1.4436436369116852, 0.8544035374288055, -0.012746971402654574, 0.7058941112784008, -0.6687865021895569, 0.9720898936521493, 2.034083279954074, 0.5912779173099203, 2.5402267744250047, 0.9846582435449841, 0.7911163437663218, -2.7186586016853083, 0.49918236385197207, 0.059507343327746286, 0.4256860595418313, 1.0094980515557046, -0.6506075322470836, 2.3421230327207314, 1.699759571450449, 1.2517330044253523, 0.0310723966372902, 0.1322413352091275, -0.04189538526969852, -1.2923178423468127, 0.12883138378160353, -0.2940434143034181, -0.18522540373240007, 1.3629511546555815, -2.651687175434856, 0.6027514382107805, 0.5143081600037843, -1.743965856715764, -1.2641041849065455, -2.065610254053166, -1.1082626573351777, 1.1800945992064884},
    {0.065071132695084, -1.5534386713117607, -0.1216974485424103, -0.34577187513044383, -0.383247868453181, -0.5817695368309157, 1.4131537996651413, -0.553963686191919, 0.4991993653582001, -2.2468527271957917, -1.5780363385432887, -1.5012803895886588, 2.4964718688557803, 0.7241324519332434, -0.2560389268482508, -0.13685422574496844, 0.4890938063540328, -0.802551997833587, 1.2164311459079107, -0.14699417508136894, 0.6039339898965328, 0.2603069606220959, 0.22172967758746273, -0.5775042458365476, -1.3659182516652126, -0.45704445343035216, 0.5980084371817475, -2.126585060232652, -1.099859991211898, 1.5150033210902385, -0.8156258613251645, -0.04113898789751432, -1.1739715525990184, -1.7692673771402485, -2.1188724345825056, 0.5203400521869961, 1.5121708810338372, 1.19408721096427, -1.774165784633228, -1.7332536206743312, 1.6416258466698406, -0.8342837486644972, -0.8637806280309617, 1.9479690040376285, -0.8962892247530164, -0.3230968896599554, 2.209798161524263, 0.5165776990578683, -0.7982632432545075, 0.24333100622232925, -1.3075207324857672, 0.34318471996999256, -0.7396153405013279, 0.71994566667632, -0.8084693064196351, 1.4806428049946072, 0.1354550886299812, 1.6913997322013758, -0.1352246825648841, -0.7059041977857401, 0.10569379907875383, -0.41747451430568827, -1.754982635048734, -0.3788658046707431},
    {1.3316026347295031, -2.670987826568927, 1.0580224378937506, -0.7834551962483103, -1.6730940391583018, -1.0227578846717194, -0.3117571439606037, -0.4379262828350653, 0.8579250425327153, -1.4133833100413318, -2.538899152602646, -1.176576909625866, 0.6338586233981006, 0.8181098670017611, 0.39511130228700997, 0.4812622168943701, -0.5155213583196915, 0.07314053518482493, -2.1259042676562023, 2.5868489766801113, -1.2102690485350875, -0.1036406409856083, 1.5095840649829115, 0.6548126783531635, 0.7352356592510448, -1.0801296385146526, 1.0135350192857, -1.1422027917528423, 0.01737506703133638, 0.4457750319110148, -0.6946761390878173, 1.0904476392229785, 1.4581238465492228, -1.0662410504458075, -0.5187892664817928, 0.18342867304867147, -0.6663914059808662, 2.4722962727152873, 0.053786199243333846, -3.535200926095989, 1.4501166723700405, 0.8658652530215134, 0.01580892250991334, -0.8478046659352718, -0.4218144844494309, 0.5431399144030641, 1.0356556345420298, 0.5563482573507625, -0.4059251998837356, -1.1560306250315744, 0.17600728740896307, -0.28813143484523673, 1.525971586913707, 1.0977976073658728, -1.8663971287365781, -0.1607236392263287, -0.9240178406062551, 0.23633718567839407, 1.3225839054903519, -0.25326970816307537, -1.1255468601054275, -1.9427344719027013, 0.7418409635289333, 2.0627379201218314},
    {0.4578006145448588, -1.443646832005169, -1.026997735340008, -1.0127009190309788, -0.20571235703486043, -0.47449760590054774, 1.738083953042535, 0.04251958128859199, 0.7871169387975403, 0.1838173070253224, -0.15659071922843107, -1.4763956130447613, 0.4101516447993065, 1.55048786682791, 0.5065488757568912, 1.1675174146630911, -1.0338298458994253, -1.4133008820405948, -0.9164833407797672, 1.6322351309241807, 0.9830292421816333, 0.2761428120862728, 1.8171757431206113, 0.25831973344154385, 1.465804142178724, -2.4052079343984483, 1.1360368630857416, -0.7355171965788138, -2.545874475732641, -0.24632209251727666, -0.3789176777832066, -1.0198037556340767, 1.376956348022492, -0.45379244410909564, -0.45886515529473926, -0.5893724126043096, 1.4029979383943696, 1.536834893926152, -0.10868078760346254, -3.7025792124217873, 0.2615800861594295, 0.14293579958401267, 0.5603390583563519, -0.6561926246422713, -1.0409184025699423, 1.0644809486177438, 1.2564708552114328, -1.0022480308532773, 0.053883783105598236, 1.3590252831857181, -0.5540746010754559, 0.25288466601028825, 1.4738913651485304, -0.8562946358147072, -0.8637454591295844, 0.6683059393300588, -2.3649273623194444, 0.7844132449904869, 1.4565391118058193, -1.414477596706994, 0.2708865772742086, 0.919277579409021, -1.1941213682244851, -0.5731017245844701},
    {0.6917568375707054, -0.16022389861871933, 0.158958355390121, 0.5476828349751082, 0.9407990764821367, 0.10574678499783124, -0.5134360923853142, 0.36205623307572604, -0.03652438197842314, 0.16448093679650805, -0.3102284443069185, -0.49774300107765557, -0.13397413088203183, -0.7085259755588381, -2.8888405063138873, -0.8533668191125945, -0.784777016898175, 1.1338753394184247, 0.5093041383823745, -1.7220519039209023, 2.00697691848863, -1.6796212966398472, 0.45924476703145495, 0.5382119692751126, -0.8902585408380788, -0.16752926348479813, 3.100556119661539, 0.12246287002142998, 0.915153610509458, 0.4460623778243849, -0.505587723541585, 0.050465619048316895, -1.8572758649827354, 0.5102009718317795, 1.7979079357417282, 0.3365693194353287, -0.9704513560856594, -0.025524178208946553, -0.5389666371509052, 2.401131102333631, -0.8025881333073828, -1.3194398974755253, 1.5624241944019521, 0.18058695110179598, 1.01350224439936, -3.2095855101013533, -0.04148389005278198, 1.328037135697835, 0.7502120979557793, 2.2389872048590105, -1.5357872327155238, -1.6553820899933498, 0.4481924664278646, 0.7838352482171713, -1.2574474199107524, -0.0898923959798737, 0.05359677951739785, -0.3057328774972438, 1.4936552917586192, -1.9338817174354317, 0.546636922864264, -0.21300619036236892, 0.3594206206108515, -0.6543402449539923},
    {1.9585879426751924, -1.0305942558992915, -1.5262403187367453, -0.7253831055702206, 0.07437372735276138, -1.4106330652095065, 0.1397261053530818, 0.20859871867064428, -0.29217443398921444, -1.3627825242165106, -0.9394824105297114, -1.2461627152106944, 0.9151076545689539, -0.189072429491079, -0.4358441728412599, 1.2775487623839867, 1.7567329266038993, -0.5641116985187752, -0.204829676826134, 1.1571704868643033, 0.7536079239912256, 1.0016132798165158, -0.9600051582420613, 1.9089236265450646, -1.6552171756768648, -1.9959939719767414, 0.21259843676537965, -2.322936011075171, -2.3840894497754226, -1.8905625817456237, 1.469810093055482, 1.5691373792671681, 1.1915769137899974, 1.3277225541892255, 0.7858214701402645, -1.6553629066283422, 0.23640920605683904, 0.9735309586768361, -0.6836926904337102, -2.314093836711795, 0.8114400814793425, 1.5206000586739832, -0.9999823590800603, 1.3886448214926892, 0.6084560270077795, 2.24122021260316, 1.3101751548598495, 0.5381175001986511, -2.7523812023555587, 0.5477967967302484, 1.553357962069818, -0.5950027906549258, -0.36469665185195976, 0.5156667718460006, -2.195110530893802, 0.9516188588688196, -1.753979839264665, -0.31147535916821945, -0.004379377173574678, 1.1496703354690458, -1.5796816911184812, 1.3615584050753444, -0.7141305921744501, 0.14188770570630108},
    {1.1648783540110044, -0.08553759067607884, 1.0409916944274957, -0.9866583259638657, -0.8763321338429504, -2.1523862298591654, 1.2676235754294474, -1.844389397386362, 1.2826130263883895, -0.5539264066133173, -1.5499636067666747, -0.3654767127345902, 0.035710944306326826, 0.7478671049001505, -1.575238528367695, -1.7089331568366088, -0.2119009633730593, -0.10822820333113578, 0.39012550085920855, -0.8446591708066926, 0.8446347692065626, -0.6176544157420684, -0.34250052053441066, -0.43878485949960006, -1.2923540268374833, -1.5228004604314263, -1.3619335596458821, 1.0412068136845596, -0.9098682286446077, -1.0528729159121308, -1.8186901184074822, -1.5481697186587875, -0.38938333474146275, -1.0137608439005956, 1.8130397678937815, -0.3156561817265416, -0.3675777955640382, -1.452814393805989, -1.1563714637296625, -1.3426665914537201, 0.8744891243067628, 0.7728712064528681, -1.394362226263134, -0.6474960046197595, -1.714828426004326, 0.7290954846682669, 0.8303297032459565, 0.15621175737486637, -2.5515920804365777, -0.27385230672518945, -0.3406656689177176, -1.5429112615171836, -0.5223270941199314, -2.0317967114417, 0.10534935752341462, -0.3295780660786196, -0.5598611975838318, -0.6015453989505822, -1.0113227256334099, -1.6241520317492215, 1.8565326564248075, 0.5683106773776855, 0.5995222038349787, -3.1282831242342515},
    {-0.10660803268549508, -0.7146943211063387, -0.7201856374295577, -0.39898469875197934, -0.8778309937739618, -1.638605111913261, -0.276186324203704, -2.098924742580959, -0.25182316442874997, -0.5491112291634774, 2.347090708384659, -1.024891953805857, 0.8184808329973388, -3.072249097313502, -0.054711763274421725, -0.027142466669897038, -0.698424368493862, -1.511917114511211, 0.9583679988615001, -0.7089829689550832, -1.6993923184292998, -0.46544219631628614, 1.4992876867582214, -0.4206827858462698, -0.8400871480631652, 0.5767095261237849, -0.6067415609673513, -0.6525356368297608, 0.19554846849564717, -0.8058508851056357, -2.808231671401218, -2.0733980674815724, -0.2628993614476633, 0.0032849160196379307, 2.622503859118472, -0.29006574900012594, 1.2236050490455777, -0.9041787677817809, 2.642607012244989, -0.7440642118193245, -1.1330981166652505, 0.8520450629746785, 0.1811624872213049, 0.8155865808213153, 1.14341939619143, -1.7828100729357537, -0.3348889588843069, 0.16587581416566116, -0.903601641349598, 1.1710887479098666, -3.190439516073951, -0.17503167095977534, -1.769418286594405, 0.15955168600700095, 0.9489372657962195, 0.28410397070784504, -0.2515926261517552, -2.354904247872963, -0.28488930064759843, -0.33278557542333553, -0.8312913759341778, -1.3994599301528685, 1.124410055242608, -1.3524518298183053},
    {-0.500347904167714, 1.0350492384300636, 0.02025751573794867, 0.25141823924933365, -0.49407804634433683, 1.4796492230458758, 0.24525355293964576, -1.2489462169140466, -0.370478687232318, -1.321080336559335, 0.4243065380648859, -2.8329093778554104, 0.8682905566728418, -1.166964389792405, 0.19259012627902503, 0.8868960632955447, -2.1339084847836225, -1.3827805110711853, 0.7907842687854597, -0.79828362150204, -0.10519824402745055, -0.5104854775116334, -1.3394789907872704, 0.5862914988173443, -1.7087014497066526, 1.4804769705966627, -0.4305552530841073, -0.10030936882396599, -1.12989348577093, -0.04398600579385497, 1.864097133764836, 0.13038686310894934, -0.2938757725582463, -0.768475060993371, -1.3861455602596044, 0.6070148127105917, -2.328560765209921, 0.4468249624274979, 0.398044528856878, -0.457784275638778, -1.8723426520520154, 0.35273370114145214, -0.5252297377035939, 0.7717960100523762, -1.9215724473712095, 0.22467207260072705, -1.79543422251153, -0.6844260165522246, -0.8722797369945914, -0.16455255163417196, -2.654454300511198, -0.37829002385827787, -0.35824735950195163, 2.3053776193302684, -2.3324593402625213, 0.4969418382357378, 1.094880891623598, 0.9348147688219659, -1.1802122255693772, -1.383401489496198, -0.33999536311243866, -1.8450213337867305, -0.15241356165833259, 0.14014556731525032},
    {-0.33066449691108823, 1.9213690629142826, -1.1658581881750893, -0.6113590663889287, 0.2152643558403996, 0.4796032780113818, 0.3703398508165251, -0.0701758642156354, 2.8017655789533116, -2.0450898076787563, -0.06065367842156902, -0.7522533546134549, 0.02233284665883809, 0.8177580123915453, -0.4556436109017733, -0.850520623581486, -1.283732432272093, -1.2197897101193056, 0.054545089852160916, -1.1578308877572097, 0.14996145493910926, -1.993237497442272, -0.9231659174564916, -1.7171746139721005, -2.4887482727237833, -0.7277173051255019, 0.011751223785899418, -0.9395159773011784, -0.2218802354687511, -0.2043265057897973, -1.3333502360254499, -1.6095985196626819, 0.2630834246085453, -0.6612310040805572, -1.97748616761887, 0.20016576410365547, 2.175207659436921, -1.1041893079797964, 0.18854701166379992, -1.2679026028086235, 0.4811966999168132, 1.5036292461531962, -1.6382197758192614, 1.1020697806259367, -0.7419241351696654, -0.1852045346454979, 0.27381303954839714, -1.903775558437128, -0.264422126408526, 0.24933520608789303, 0.6964523594915999, -1.6060817126366642, -1.6309020239082401, -0.1352246381275332, -0.40520482865183916, 0.08043374938816472, -1.3658438606511718, 0.9832589826807494, -2.7724503076470315, 0.17633413322576186, 0.9236386754309706, -1.8140835856660582, 1.2907043795991677, -0.8660647190966267},
    {-0.34614631845749455, 0.40530871817959574, -0.9713044268666579, 0.5590597647512958, 0.3088492003030006, -1.6418901829994068, -0.8664821009079072, 1.774404312172768, -0.8008231791500262, -1.2781679465053002, -1.4592161582725858, -1.2157960922177218, -0.821084580031457, 0.7336396467831134, -2.158841694331086, -0.6376581219497548, -0.1256042375010685, -2.1667405485408544, -1.601916134645315, -0.8940659472298713, -0.7657215915746921, -0.19631348403719262, 1.416073502082071, 0.3483755698305862, -1.0731980714074838, -2.2401719237331483, 0.024909780165185382, -1.6586776198880318, -1.303293592339172, -0.6263440205973182, -0.6015994510510895, -1.2843942395044605, 0.3508657187443434, 0.3590033019940432, -0.13881349014287978, 1.4605214511755458, 1.2219078214653465, -0.8735720040310222, -1.0052247864118977, -0.818570906968377, -0.05825295757215958, 0.2704043468702843, -1.3087007287937502, 1.0789011038659482, -1.017448635034454, -1.5886372892099851, 0.13082147544442965, -0.14337871112765785, -1.4506572966026325, -0.10466993293475854, 2.8194463724950567, 0.28800232900765393, -0.3338194609817883, -0.45993879834152485, -1.064994170482012, 1.6573442514877843, -0.3744319900371191, -0.17884502204954625, 0.6870598877975588, -2.3425161294775227, 2.5032367457372935, 1.0272046035195652, -1.2171282551706581, 2.2584192652878468},
    {1.7934567037694622, 0.3239250996202097, -2.5270267020267, -0.6767892176746451, -2.8961871811094984, -1.6405971527224887, -0.7213729263686018, 0.19993925804487414, 0.5576362552839137, -0.3794826307564925, 1.9812242845862962, -1.5761341217222191, 0.24850324313152797, 1.545020092404056, 1.3618548686064138, 0.06816660249461186, 0.8233614243745518, 2.4957197220094365, 0.9022993397839475, -1.9224523145623842, -2.1789204878909385, -1.1550541029867527, 0.8871830795506341, -0.8007973139671509, -2.8032116490519794, -1.5935156208699768, 1.0157373993661658, -0.9832481579436757, -0.5925539717351215, -1.0584309355146662, -2.3724193032550835, -2.0432464333818015, -0.04431401991564096, -1.6881126156811435, -0.40127517280714153, -1.2128282531033572, 1.6623823656779573, -0.5328239445265898, 0.4537262392621253, 0.21222549856152403, 0.45958282984253435, -0.8995538470146933, -1.3459562857867717, 0.7945712930325404, -1.8119520877608735, -0.4280297133040667, 0.10750110935597386, -0.8195732411938506, -1.310176050775789, -0.3835236911619245, -2.683940943662929, -1.3702064987192588, 0.7727746973744198, 0.1610552307728593, 0.25542394189816886, -1.0752562281742368, -1.056324089123397, 1.0240901886201268, 0.4291428482630187, -0.35919704562375443, 0.6561176757222671, 0.6510217217777704, 1.178237779597859, -1.1884431540027047},
    {-3.017175693384561, -0.7985691397688536, -2.9130338042252433, -0.17044655419449695, 0.49153019545548426, -1.474683657350843, 0.5088758716649565, 0.4527534845335178, 1.4775015596935526, -0.8842993871534407, 0.5793496182521984, -2.105609140566793, -0.5314308633581666, 0.3704253993429236, 2.762997592692046, -1.2085555591083001, 0.4749584851900532, 0.4148785009295966, 0.18175626999079, -0.22231941134415037, -1.5146295544187742, -3.244761527770078, -1.630726617256546, 0.5052110280310228, -0.36884075632796354, -0.3707549555678933, -1.0216427481285004, -0.023492447606447645, 0.4591900058716955, -0.5305822593779244, -2.9665231985917178, -0.38572200103115306, -1.1823652933451019, -1.72368049707231, 0.9621440833572068, 0.128852039086248, -0.06395059702663114, 0.08350144632187066, -0.4947797645123609, 0.4591876282922341, -0.15894688625406833, -0.21742570659105812, -1.1460991227017228, -0.04090463862552493, -1.0327950926035072, -0.728736403905557, 1.1852882975045353, -2.107569959727752, -0.8897971844172228, -0.43485351553066104, -1.665918016724996, 0.25623510856589826, -1.7949194800574937, 0.581151120469929, -0.5886140177578116, 0.5614013672982888, 0.7860303718723356, 1.1033456755094875, 0.45177474341423013, 0.40335082771678427, -0.6785546696310264, -2.4252988711111807, 1.2838536336657937, -1.9014486294237662},
    {-1.285905830574773, -0.025108820651671294, -2.4113404384240167, -0.22254495992081977, 1.8812419880541877, 0.3613886151045627, -0.9166877278797337, -0.007269017631677734, 0.2863253149758475, 0.8017661202353805, -0.2702844824281515, 1.190892060833389, -1.1473937748610892, -0.8231003164075551, 0.9957643465531314, -0.24798408914676728, -0.11099667858127017, -1.2131038908350933, -0.744827743620205, 0.3521402015947872, -0.8717396567448854, -1.3298416902402161, 0.14683027385817524, -0.45867480318399106, 0.7511314155141843, 0.19414922638969861, 0.06661804781025425, -1.1405873292331046, -0.5372843564294881, -0.6281335761443448, -3.1166741522700994, -0.590683383900493, 0.1935802163922219, -0.5136685166198911, -1.8721860159973436, 0.3329081274851452, 0.004917806083805671, -0.8387614373051107, 0.6191324886503529, 0.5447763862105772, 0.16274895646874335, 0.49808784001246237, -0.907364245899033, 1.890947603272044, -1.1090705881130105, -0.49040077807842974, -2.8923335999082096, 1.3881657128904075, 0.40438992022949766, -0.7889627533028352, 0.2583866957242052, -0.6470208268295681, -1.026027902539128, -0.8775147615442306, 0.14208686688924763, -1.7036085748009238, 1.1709111341809402, 0.057580343055108875, -0.24876919693757957, -0.8556152429609208, 0.714341576409861, -0.8387269763351796, -0.09977224383087853, -1.8674081904511723},
    {-0.17496015339502025, 1.7592198740699272, -1.3687701806448918, -0.5506626730584304, 0.7621194457451759, -0.20790446174506935, 0.5456005489636059, -1.2433127696261264, 0.7336564551031635, -0.7695434109294415, 0.5344616947171656, -1.438221995041887, 0.011291013167592796, -0.6073398381986193, -0.728579873455655, -1.5559468960660487, -1.8447795902336361, 1.4852539385828822, -0.9828048943071928, -0.9263292122337179, 0.5810405609655053, -2.373491771649814, 0.6738743185761142, -1.7048989773068615, -0.3045034173481596, -0.8886184994443185, -1.3520936703177013, 1.1617630695922507, 0.21021536824105413, -0.4590069589247456, -0.8814147252108172, 0.34008191819908296, 0.5239156732564965, -2.568134816296051, -0.8351470843047534, -0.24407807404956694, -0.4821742530947202, 0.08293370399674539, 1.7655846239039426, 0.9970101904468802, -0.9624351886637075, 0.7072659318983371, -0.047979945767370136, -1.0163151312864451, -1.1090370604742832, -1.9101276177663944, 0.05010812943778314, -0.8612432313016777, -0.2163902328291584, 1.2931792009249035, 0.026391609641029337, -0.9542078823353451, 0.9357617925083388, 1.316893979004889, -1.3133618369753708, 0.3337073294572804, -0.7340127821028328, -0.9636532693891131, 0.7217760350686204, 0.5813006733424281, -0.7236745430630145, -2.9255282241382963, -2.464738728205547, 0.7526351765591466},
    {1.2708858807218169, 1.9311213356158432, 0.8046891447090847, -0.816117537937815, 0.6641952352031602, 0.31062999761876775, 0.6896623682069075, 0.5373401393010445, -0.4359852990351365, 0.5004749925666967, -1.9062467710776974, 0.9497970832982936, 1.7622823175831497, -1.6519225096422983, 0.6165551296335906, 0.8831818950713756, -1.3474979467230714, -1.2826180365343842, 1.7730099115124582, -0.4553425738443387, -0.8795433109435586, -1.3706842563631523, -1.2248146018794406, 0.8271206357402342, -1.878696236090298, -0.29592626453012366, -0.5924938280851231, -0.8594906499526493, -0.8274982722740827, 1.719638466730917, -3.4734813465836973, 0.9202825787621504, -0.06305848868641037, -1.7825788664008386, 2.12537623741054, 2.812232118926642, -0.42465308941247876, -0.4365893293755338, -0.004189342526333523, -1.400779578431255, 0.5497364341877339, -0.4227550479063784, -0.7993016233343192, 1.0013190566843946, -1.0495799808552833, -0.8285802040112947, -0.5218701777257161, -0.31616919920259473, 0.43370515181544517, -1.7307110972683046, 1.0337613393164877, -1.0562118306221053, -0.8127216231622312, 0.0817228286327531, -0.3914895660180806, -1.1031329563485834, 0.41828187995694255, -0.31844884091977027, -1.2839206996820827, 1.3325777494372963, -1.2690227358882804, -0.07529467616297555, 0.11522343493676335, -1.1312214099976414},
    {0.09277654691357094, 1.480067890178577, -0.29854044034722127, 1.8609544003312064, -0.6170077231873325, -0.307034859775792, 0.6654064881985493, -1.1575086034871624, -0.20655059619184699, 0.5291129125878241, 0.12933049266625088, 0.8507773980720897, -0.8347802975099412, 0.4363238791220497, -0.9417062956040295, 1.4718904234677834, 0.0649520608708324, 0.46561629671702204, -0.08695238024246708, -1.4102329404962257, 0.6710801173861057, -0.1757990182138006, 1.249683771835651, -2.3024328523241677, -0.6007106031086172, -1.2035470802068906, -0.8352981493266266, 0.335410698682609, -2.4861228941025337, 0.102318020359081, -1.7378481793381324, 0.7033588398198927, 0.4106504768318885, -1.8598171362491045, 0.24099316958763106, 1.8717457447532837, 0.6144805632581442, 1.1086642912941922, -1.018765963670932, -1.3935278915411478, 2.037211500475323, 0.848857416983299, -0.6528781919794205, 2.015920881752065, -0.261920417107137, -0.8040275838293593, 2.2652922876198716, 1.788258362267159, -0.29973705508805637, 0.4586215522156836, 1.3691052869529525, -0.18186840464914042, 0.1407757417383553, -0.8487225632134072, -1.1999788014567496, 0.4471843973345135, -0.245874390091795, -1.1840041054037829, 0.23629116316497464, 0.885366237331752, -0.676334410013845, -0.6410226046530666, -1.0176657539412604, 0.013162538567777804},
    {-1.599402419258873, -0.5640370487825916, 0.43689979570718246, -0.7899208988418177, -0.5289412344336811, 1.240029786682761, 0.04835339528374083, -0.9406573358991286, -0.9701374045439367, -0.6319156481907068, -2.18250540139941, -1.2775749949727642, 0.2755904719197612, 0.5956113950331449, -2.633226502815676, -0.9550751730591364, -0.16824680524871088, -0.6197656774729409, -1.4254965380648026, -0.4564291486282359, -1.0255618474674737, 0.3750802860642163, -1.080202283424304, -1.105466918836534, -2.8331656243267065, 0.8975612390069586, -0.5076581587882949, 0.5597280997605616, 0.20269639336634349, -0.2617316737374239, -3.1637737919042386, 1.0475161593765872, -0.1206227132935401, -0.3406764984979283, 0.5352682799492803, 0.4057169422572485, 0.0022554084381881216, -1.7625043374833274, -0.7608849235101616, -0.9570769993662097, 1.0224552005114937, 0.07082496511004008, -1.3927077609445209, 0.6513648586743157, 0.787233160659468, 0.15071243554158623, -2.064627885055665, -1.4843534671754912, 1.2463466495523323, 1.0292278012039682, -2.281326191258589, -3.230823754102932, -1.9428420013415393, 0.4687441956704609, -0.2895444295514116, -0.9041548581785596, -1.6833247089129808, 1.0410181551686613, 0.2341862293422882, -0.5748777064250649, 1.1112417913962027, -2.2094733665595396, 0.661184916004003, -0.9115947359568818},
    {1.392240041645465, -0.7693421650205468, 0.10287769223686778, 0.35576145019932554, -0.25648877159018846, 0.1394780129531111, 1.7071943408644266, 0.3615931575278779, -1.8219200250735574, 0.3665578839513246, 0.5094272713983157, -1.439026218498913, -0.813863635699282, -0.320918568351179, -3.0309866390162736, -0.957392464931267, 0.8280800588644772, -2.9470754680694413, -1.8838944911372846, -1.7216299357705998, -0.960281771997767, -0.948397301572207, 1.2231161952348664, -0.05383368979662668, -0.42862664484364604, -0.8733652135724831, 0.4859095494992691, -1.816136797050076, 0.8809417032264965, 0.8178946491119623, 1.2428425244459738, 0.48593587595788, 0.032392889839565925, -1.5047602347830837, -1.2734512238684044, -1.5558026391738977, 1.1137217583287282, -0.4512633668292192, -3.6326155226916086, 0.07621799477747966, -0.9651879704162767, 0.6807772127302502, -1.5572043541397023, -0.512498955441186, 0.9766770830515639, -0.4635449651542025, -1.675203600891139, 1.5069177372758962, -1.1503864252236677, -0.5545228248624233, 2.244111060018504, 0.042151583520671033, 0.07412541981174332, -0.8908113355515873, -0.6871200574311493, -1.3483194668072898, 0.9261964394373093, 3.076597004671599, 0.5402796532633473, -0.7294405593744281, 0.44760317446866166, -2.0799502844231337, 0.7550712297182809, -0.11004270976919818},
    {1.875103171121132, -0.4862430071358802, -1.9948384742336758, -0.32336031371172336, -2.283577146694476, 1.9091725534196065, 1.4913889587345337, -3.0498340090637734, 0.25826714456239036, -1.246102312973404, -0.8766130858099268, 0.1441806518773664, 0.5139104363070065, 0.09115204583271554, 0.9767225015823302, -0.576813348823767, -0.4761327856043194, -0.07322609493964889, 0.48170908104201615, 0.728433331856658, 0.050041921982411544, -0.7863454691161151, -1.5950684871243994, -1.3131841101234614, -0.3680691072718986, -0.573088712508633, 0.30619046978411685, 1.4653140519273202, 1.6398251490644364, -1.1576373303630123, 0.17566005715584715, 0.7215417928854163, -0.08453963125919546, -2.7990212693118437, -1.0619619320082785, -0.15525044037606103, 0.9603302739219873, -0.21914449952604262, 0.11694180988136528, -0.3787338318506331, 1.193589814517548, 0.4566923462326682, 0.04795954827338708, 1.3611820453801116, 0.31599754640432, -0.8604583858449865, -1.9598196095136948, -0.7107634047816973, -0.06983687296554561, 0.44687601999367826, -1.6639968637461118, 2.21496072038229, -1.0109902961938007, 2.3282095830262755, -0.623661023098093, -0.29860384002788337, -0.0668596353786452, -0.4010882071111134, 0.5989708688131932, -1.629887086603118, -0.11020158998198241, -1.2118007962587645, -1.131571662629088, -0.20409516177291975},
    {0.022235823155510055, -0.7090484472406691, -0.24907333705481327, -0.781239973090065, -1.9492929759790505, -0.7963277835256128, -0.8297006090481873, -0.8997692606124876, 0.4226008197726643, -0.2685384816650194, 0.2209585450992879, -1.6016584708228974, 0.19448374122883283, -0.5389704876920984, -1.5548398770807776, 0.14215027024563628, 0.04230637859753888, -0.6562184626618195, 0.6937588569820199, -0.6851130926556978, 0.5195008000717121, -0.5949863559277926, -0.038084374454818784, 0.1689880373149485, -0.6705829476609395, 2.069612953658621, -1.1416484072561228, -0.8703173773752133, -2.8857923903002245, -1.3237482481791683, -0.2164829772648969, 0.4258196936674642, 2.408895757483032, -1.1818089295096612, 1.306861720392342, -1.481524596173588, 1.7309160345259567, -0.43729054308552845, 0.6005424496836612, 0.4259414846388256, 0.1726687088238059, 0.2945345243425071, -0.759968354529643, -0.6951040707421462, -0.05314911087651848, -0.0029378413676977486, -0.9553372760339732, -0.8981678287353044, 1.314949556270438, 0.812753938674488, 0.6042240257730201, 0.056112192375536385, -1.204139470708115, -0.41740462093973185, -0.29179551303536466, -0.004762713382253083, 0.982801506229694, -1.123339856375742, -1.221936794031757, -0.5211264213515053, -1.2579022368635078, -1.045725383230056, 0.18318611653984873, -0.3634664112999899},
    {-0.67263871451425, -0.9275264794856984, 0.488164265789946, 0.14295692322694595, -0.9647644821377257, 1.3320646166283094, 2.607086075937793, 0.18179912055490316, -0.09554497099339637, -0.46874970969718754, -1.6374734735000798, -1.2809734031410975, -1.8009733016883838, -1.7692872629563035, -0.603687664874651, -0.10968013128734441, 2.421761459571723, -0.8109864862360323, -1.2018315917201623, -0.4411574627876124, -0.24804934279088833, -0.06546144619289358, 1.5229070794359252, 0.05879413131923281, -0.6853249692399994, -1.9600993581617967, -0.5349933547207865, -0.025957178454435962, 1.374760858946636, -0.13128765725966812, -0.2771102021341949, -0.5083269761586575, 0.8631510221546103, 0.15123766341317688, -0.22755887905857403, -0.9405729388857892, -1.1047723382105832, -1.4154937673257768, 0.09837982678099426, -1.0433486227933624, -0.2457384287535286, -0.7133702009583216, 0.5141395024754297, -1.2175464781675889, -0.9168975866649078, 0.3617384349462576, -0.0709497289533392, -2.0466190874407904, -0.9722339452004936, -1.417282763984449, 0.24591286700011716, 1.8308146334776294, -0.29378653940142174, 1.1895341499499081, 1.3800585727906634, -0.44570855584708763, 0.810883531062216, -1.1803632016532377, 0.5522676489240171, -0.21097779400989328, 0.7610544132143571, -1.4574231059894731, -1.338755109869756, -0.164794562034041},
    {1.1122094018314694, -0.2655955282667524, -0.19406540083687931, -2.2065498161420436, -2.4107792281521627, -1.967614023127864, -0.2828918368011583, 1.0263299435580475, 0.9139784473669873, -1.5688056203263012, -1.2746522003700624, -1.9247672746910693, -0.26582793704682856, -1.039404269656542, -2.0496442746587897, -1.4861447091667639, -1.040539378408411, 0.2478759916093307, -0.6768063225183564, -2.4082577925527535, -1.5772287317057925, -1.4265429546337998, -0.40895595842681787, -1.6546429206040156, -0.16452982325896195, -0.9818837684653721, 0.3136328411912231, 0.2439547667070759, -0.38592273920632647, -0.8813750060115917, 0.23845857272104362, -1.1629936139648849, -0.36335392777743425, -1.6957668975532991, -2.156050340154197, 0.6236137953337147, 0.6185551669390312, -1.1983376599115991, -2.570900072482904, -0.9361064500935464, -0.07493891715508848, -0.12297003495039509, 0.15112110740720297, 0.14708324075387566, -0.7333399402072313, -0.6702184204860326, -2.5205757359933614, -0.8437639130260853, -0.3388712123496993, -1.4351017911723427, -0.6565801495884506, -0.6786603791480401, -1.9476807658556574, -0.8469217692353299, 0.1380841631923475, 0.26662560081675524, -0.5541891863782206, -0.5533225345421302, -2.318167806064042, 0.716317213505785, -0.8454505512643966, 0.8198950524674796, 0.21586307969221166, -1.3484440222828658},
    {-0.3449157882121789, -0.535709807029748, -0.9691956635923403, 1.8540748730983636, 1.125354502646214, -2.285657790471302, 0.7090532406577209, -0.20659990939576905, -0.5044459475989425, 1.595649910645239, 0.0987110328377172, -1.4966599365473412, -0.9191700674299565, 0.4418048923231714, 0.7782677033892216, 1.0811275067310564, 0.24568517480384014, -1.7932191896492355, -0.3917935467100394, -2.9351802770522424, -0.6887181188959569, -0.09605781300907316, -0.8513948660240622, -2.653551550056873, -1.7810880544449508, -0.9224708521984729, -0.1510951853780009, 0.4412389857783044, 0.9549172538252593, -1.669158081096161, -0.39900123280583794, -0.9389044278674527, 1.0001487330057854, -0.6355047244619859, 0.40221153550364636, -2.072048657983919, 0.4293467854496497, -1.2457120005587352, -0.26847637577149297, -1.1111024325952172, -0.9725127019738741, 0.8819549613816896, -2.7703919884056893, 0.7082791485998202, -0.7297631387929904, -1.8965558881700153, -0.5931988487621582, -1.0658013571784661, -0.6453311758198956, -0.7207373087085749, -1.157243929630841, -0.34747675578209813, -1.854107337257965, -0.14801531303143997, -1.362434577539694, -0.2742423564133543, 1.2019457040001216, -0.45218453044744206, -0.9831581330079905, 0.31057647613737344, -0.8525658165700323, -2.314755787760762, -0.3430852742090652, 1.6627433207718838},
    {-1.5465639927357473, -1.716017148774238, -0.1869421469581893, -0.9197974912066244, -1.2789925689010762, 0.6812415170664388, -0.5849047143322466, -3.431361090273802, -0.7054112945287296, -1.0739808871734224, -1.7528164632222631, -1.0416712425936872, -0.6804116357419828, -1.6247866807813, 0.14533560856185426, -0.28899025256504496, -0.3098070621425761, -1.5109022091746078, -0.2237207850139344, -2.062716614484744, -0.9036116797475662, -0.34060232357282216, -1.247454490885553, -1.6687735889740924, 0.81718112052022, -3.906750507174225, 0.263340948503422, -0.6752226093638063, 1.2707214354887628, 0.7545036603057703, -1.6861193426424934, -2.09041129818715, -2.5605038696611837, -1.82845116467226, -2.5566691007362445, -0.23247989308010356, -1.1646213875188098, -0.7164501906748222, -3.6904102762131687, 1.0019904204935735, 0.2506222696347777, 1.7871383415374604, -0.6808567843939534, -0.17588906490582168, -1.0500355567485837, -1.7862862878680703, 0.20119541898600954, 0.14479808497835278, 0.7946460321490839, 1.9460770204379356, 1.7674520833640937, -0.3116346814620813, -0.28270764444674884, 1.0674208342755662, -0.14360953488534706, -0.7103521483661557, -1.5642403004857495, 0.11781572608085471, -0.8773657019036035, 1.1169088691198596, 0.32293351310742646, 0.9578486705139297, -0.4337897628053619, -1.7828392185734572},
    {1.8265061018670663, 0.12561859560631805, -0.8822928883460756, -0.10744622718454686, -0.9188349660694095, -0.6700989775136604, 1.2369744058498897, -1.3160093562764241, -1.2127124595036236, -1.526676130776103, -0.3567622767321906, 0.1484284020786504, 1.7602757688451427, 0.08054020232990114, -1.65096436162838, -0.12285975193063499, 0.10070796581829053, -0.3851029730450114, -1.9172890651801933, -0.4819412516871443, 0.4541307549372187, -0.7102312314898532, -0.14189580062784327, -0.6742097903713176, -0.8876199819143376, 0.2804209814105242, 0.335062750107771, -0.14154874695907627, -2.0326411481640747, 0.16004640915187235, -1.0331099295187456, -1.3641024266901318, 0.6312280697773969, 0.7696641140839743, -1.1023288708292691, -2.1820960976223107, -0.44661020639454985, 0.6219032731115439, 0.5027148377272099, -1.501558497133636, 1.880157820721782, 0.9245223295550916, -0.32065814137184423, -0.7285159671189239, 0.024074528898838543, -1.6550335210426028, 0.029729472045225764, -0.040670483789782524, -0.840150970946734, 1.8056802480493948, -1.2275030262439848, -0.13404439851639735, 0.10687688758929277, -1.600698365536859, 0.6905380042594946, 0.5784604783808975, -1.2118708654892802, -0.27545734451530823, 2.5088780070688843, 0.15387035086018908, 2.3934764039586414, 1.8821356053950307, -2.1037655015130015, 0.5182390155459844},
    {1.7608816664009976, -0.8739903182743264, -0.02535859578605834, -0.9331028057522904, -1.4841306334858164, 0.4747314537616883, 0.642618178653803, -0.4702239017036469, 0.6823183198930592, -0.6627694403714482, -0.8688465190402233, -1.378519237542346, 0.7879248476981758, 1.57780712250459, -0.9123184676474273, -0.6708420194562228, -0.4117613731393259, -0.3191105214874318, 0.5368039806516384, -2.6258637305728523, -0.5733043306289238, -0.3225838544568415, 0.33010951458209903, -0.4900965815376569, -2.347543530471911, 0.10421285312488698, 1.0420656422712844, -0.03350396596195817, 0.507690478808853, 1.50158538733874, 0.7568252163314674, -0.28975662803532204, -0.19872884427246512, -1.2802464499199564, 0.3356526763796078, 0.1789609962984505, 1.3664809301231624, -0.9133144264158588, 0.08389059966187862, -2.0952860017029282, 2.0955201726331425, 1.3966122824158649, -0.527380467275745, 0.6497598703285765, -0.5072409706093992, 0.008143271710727177, -0.6980609627406755, -0.5387780755267337, 0.25484771866757333, 0.05541651378089919, -0.47244889187505384, 1.1999150625955075, 0.6286586585214934, -0.2548842962501769, -0.034594794911999745, -0.47888790971402334, 0.547452791577989, 0.8486831925226715, 1.1255006776578615, 1.0783363630807121, -0.689275440837621, -1.3849663641398111, 0.9310848374366972, 0.8938297319476445},
    {0.7630999981871939, 0.8647488679809111, 1.0795363312728161, 1.0184242542101225, -2.7398114836146505, -0.2984079108581863, -0.4996880240514504, -0.7353019166505718, -1.1107987943789834, 0.224400846635664, -0.8578888357622851, -1.1260122250205788, 1.4827883113946263, -0.4345696422675584, -1.5166655738150605, 0.754209716451571, -0.25187336134183985, 1.317383517004432, 0.0020174450689704015, -0.5993739034104661, 1.593675946893754, -0.5945671135508063, -0.058656728873661405, 0.011752882555825251, -2.2940758966807215, -2.398288266498861, -1.2773058542266702, 0.04715629891222295, 0.1609545876754465, -0.26079735365336554, -1.1962651606852202, 0.5260507689605377, 0.13120529903923198, -0.5247887515236129, -2.1190757724389546, -0.012689688832595518, -0.6266387259221523, -1.1336939162560982, -1.3165856961929032, -0.04939777561103469, -0.7282702590889908, 2.4154488712868853, -0.7279555657918726, -0.45548583701550976, -0.2746293126436902, -1.082690065589865, -3.5643953932286117, -1.0603098379651326, 0.2569361037837435, -0.2636454011176881, -1.18353872675704, 1.3801793606960648, -1.4622535399502017, 0.8093548605114581, -1.8591768741682766, 1.0846309734468478, -0.9759264778556529, -0.22717973839601616, -1.5307602470807289, 0.0294398693069342, 0.7513721146931983, -0.5873566419918161, 0.2848922467941787, -3.9005557850218295},
    {-0.4470741029891662, -0.38173977738013454, 0.43784245375428377, -0.25625711934440026, -0.8932487794595348, -0.07061468292170621, -0.3437795133119317, -1.6196263171016512, -1.410539294730715, -1.0132415536374824, -1.5341648379660489, 0.26585550459886054, 1.1838521883053794, -0.8076898520109292, -0.9366147784207696, -0.20516540333384786, -0.5931940862167643, 3.1631391532950848, -0.06809091645395547, -0.03439704676009343, -1.2850864875368642, -0.8574301917315171, 0.04675847674913288, -1.6039456654531195, -0.3689130144109509, -0.8733161552288, 0.24158064966534487, 0.935344549629818, -1.2984531580847292, -1.8224503590603995, -0.07486585815576084, -2.6765436176249304, 1.879947507330269, 0.24918338701483833, -1.100511596564116, -0.7640778948580104, -0.6864050845198889, -0.9801908408770832, -0.9846339001031365, -0.7865508096981504, -0.7807066227393348, 1.1867957998038754, -3.5932480622187795, -0.845754431781644, -1.0707155047509411, 0.8570311686392056, -1.0958374244994613, -1.0486348183306262, 0.6999523745941039, 0.3384291362943687, -1.0378905508674656, 0.8837236437694794, 0.47854104444460227, -0.9033089913350378, 0.8917951696906852, -1.4848020376666153, -1.1019197566333097, 0.47727146095371575, 1.5919722271410504, -2.0033268309804364, -0.36712847365192225, -1.5652938697829055, 1.1423265978593358, 0.5053521863556071},
    {1.2292149119826061, -0.2830918142886829, 0.06051022864114946, -1.178377698272671, -1.04987902047377, -0.068586038343282, -0.060003124561782174, 0.544237728055777, 1.5277314103595552, 1.0025515929602409, -0.5258468450785877, -0.42562919565177143, -0.7542517090080636, -2.0435162433341927, 0.8224497061422642, -0.7776312612982279, 0.6347530157522622, 0.7232211245857796, 0.551434000732543, 0.06513712938240947, 0.6802900635088204, 0.4845064460961999, -0.9927011777341246, -1.8456750793981538, -1.963149334698011, 0.03364877038946674, -0.7695004198120291, -1.4431618988050254, -0.07334953694815828, 0.4569181541026442, -1.3653695352048365, -0.39449670826456146, 0.6004138931980338, -2.8160647592648, -0.46527559572119026, 0.2684665379885096, 0.17316970996310352, -0.5924926456948338, -1.0377097615342343, -0.3335101313706775, -1.302224865039427, 1.670015009575101, 0.829795280155283, -1.0327078312838296, -0.4795926740176854, -1.2240151762822287, -0.351544604195169, -0.7182481838631647, -0.29133763146696895, 1.8473569110659316, -1.2539862227855827, -1.0719639902828522, -0.3533142785406584, 1.0155789872642655, -1.1015627948559539, 0.12175376944501014, -1.9370228659248538, 0.6021917070088076, 2.2113211399383133, -1.0888029099436372, -0.5763566510310603, -1.1748482941342364, -0.17661534187094305, -0.2994601958335808},
    {-0.20897481667016468, -0.9313758010212924, -0.4681589398807527, -0.3275115134223758, -1.3298652134023101, 0.6673204022768074, -0.22141351777570317, -0.753960145444144, -0.06457676547632862, 2.1687894541281243, -0.5517332374059847, 2.3162911856963073, 0.21694085259023294, -2.9196406648037185, -1.8695035138998388, -0.8699737791096942, 2.159829052054659, -0.7541761955720938, -1.4575384885878597, -1.4313033163736246, -0.9385424202152229, -0.03544117044958845, 1.4062906849192918, -1.210884685265319, -1.6043217927569113, -1.7043952812785743, -0.8687507382603008, -0.5063143556089057, 0.0179435422447368, 0.19503001320207972, -0.25395816800144233, -2.7884563327807697, 1.3990444740291514, -1.553793207454009, 0.8887164022936642, -0.18498525908657373, 0.578286339225292, -1.7534982514298592, -1.7419244166019585, -2.544994037773033, 0.10822762592780974, -0.5525125593312487, -0.6198318784933001, 0.999632446814552, -1.0417748421806405, 0.44952135250174513, 0.1004307210481151, -0.1640190362702731, 0.9759245096719799, 1.4830862421200137, -0.9873099682674509, 1.4485160393985803, -0.7211961244586813, -0.9545312321943682, -0.4410383195143175, 2.072514963058375, -0.465051252916885, 1.9159534356118497, 0.40687102150508075, 1.2773891560137485, -0.5106127456378563, -0.6524545128873502, 0.8813043200985217, -0.4562099425126003},
    {1.5083045964980502, -2.5041311776188535, 0.803424089968424, 0.1831250347147506, 0.9535828269391794, 0.22476807333562782, 0.8723309305513208, 0.212211748087442, 1.5715258006066286, 1.7578115370264948, -1.7174392297465841, -0.04706415851017651, -0.7143859512784512, -2.5481595195471494, -1.3547982422099702, -1.3836650561027408, 1.5100780690884634, 1.0465321452495269, -0.9319907582161074, -2.32644957883321, -1.1437472558217254, -0.6108379499031019, 1.2111515369397996, -0.967745363699754, 0.27357558724682596, -0.4891978305961411, -0.03704524539178376, 0.7378117352368819, -1.8973655566643017, -0.48769797484725314, 1.2136451369179233, -1.8218440538577132, -1.1872999804278543, -1.8215791389979894, 0.14514938720592543, 0.256567823877875, 0.09080036677386975, 0.27383382723007055, -0.8299605845059745, 0.36736339359047765, 0.15316500613091727, -1.6880868555538848, -2.4725392566507347, -0.11072796497471998, 0.029862959752673227, -0.8073578866213702, -0.7195595202748278, -0.5372557774681426, -2.471816812993549, -0.246769657819762, -0.906162546178698, 1.0198335225835988, -0.420239833181742, 1.7641781866831412, -1.5628897515373212, -0.5806214744813458, -3.1013422255174317, -3.7501152066315258, -0.5001876183913367, -0.9360104263171017, 0.6445466939494436, -2.213170004819648, -1.1065969291226414, -2.1365320774587118},
    {0.5837489238124723, -1.0030010889523058, -0.5769898574819782, -1.218196579527486, 0.1601024775943014, 0.561205938145893, -2.1890016981144194, -0.322877486940044, 0.7079617470595831, -1.7191202034294586, -0.46640265370698897, 0.2448973986578872, -0.30564348508999833, 0.2706223752191716, 0.03821537188185756, -2.5272357740154545, -0.21735652954598278, -3.0485225145174653, -0.31741939991981855, -1.3497259772630779, 0.6665997431819041, 0.050591945357529235, 0.22630168129891867, -0.7966243876649846, -0.9050253928002188, -0.16670929212864427, 0.9488636752499172, 0.5499066984818488, -1.5719840350028944, -1.3302320971415342, 0.14569591330383752, -1.6886707779436412, 2.0490156620764646, -1.500133019327715, 1.3982580720293454, -2.0889276047648146, 0.202724438914915, -1.4453370628214925, -1.0865124391125658, -0.768605381462616, 0.6122139747652067, 0.458359199243409, -1.0407916849380003, -0.06487893384364678, -0.9723543317859825, -0.4097231159870238, -0.659296240707188, -0.7110994471842681, 0.13158216473546014, 0.8979255980644376, 0.17188340875085031, -0.2733634440494395, 0.7456209151983626, 1.2130231952423105, -1.281233598201209, -0.4948953447969773, -1.930683032442104, -0.01823951922992373, 2.6465014510899074, -1.0231571047932473, 0.4528233634773727, -0.9688966728717969, -0.4568640496061732, -0.5260328671974343},
    {1.6185613579848532, -0.43225380231810456, -1.4134647127287066, 0.5266942773376827, 0.17516597978131868, -0.051679756381868336, 1.4416006868452353, 0.9532650096130195, 0.6027047385071668, 1.0123049203363106, 0.9895646146957331, 0.27310677681882495, -0.6087413626727527, -1.357460624712102, -0.7091078281793678, -1.0247869697711625, -0.13572429295548497, -2.4041739351769547, -0.3552856162725543, 1.0168277498110856, 0.5618045525344055, -1.4631127953639058, 2.250565331791439, 1.9549812469534167, -0.34938367089740363, -1.6407412198161686, -2.3931683511897246, -0.07874283265401981, 0.5881823396632887, -0.352840803607593, -0.08920504586867437, -2.0497982442816483, 0.9729819566068273, 0.07659415692304139, 0.7706137130974648, 2.378010623930262, 0.18458029030209017, -1.4920621679623427, -1.5544381063918102, -1.0324610201818025, 0.9146715557809102, 1.473279103412044, -0.8095002824017982, -0.8519442110124402, 0.09393002257790654, 1.1405458900290686, 0.002660425983760167, -0.8881502808609536, -0.002487086564891715, 0.27899032551721425, -0.6257810696448453, 1.4535176238165282, -1.499964421949997, 1.0902919083086555, 0.9616179069683606, -1.5037591033289774, -2.116164222421442, -0.2795608971855857, 1.872448263169517, 0.06870760793459069, 1.6418800833901384, -1.6753050916782475, 1.2855752951559227, 0.40582390035370636},
    {0.0266858509184597, 0.05632119034780289, 0.32825279562685583, -1.0853163629675822, -0.09334568809644826, -0.20919597555160088, 1.5423031402297196, 0.4263172564167372, -2.134350129725234, 1.3022134266164496, 0.4426136969625291, 0.7902856084714587, 1.0342080378501657, -0.5640363830945601, -0.7178901376646079, 0.7037374274406498, -1.3039860262801293, -1.4157523625444246, 1.310745328222339, 2.0672987983462483, -0.3940113728822883, -0.6781481793542032, -0.10696648652977193, 1.856739362601311, -0.822334390111688, 0.8691023506266982, -0.3915693932552273, 0.09950732086774462, 0.6081158908500146, -0.8898434989616887, -0.5373056630853845, 0.9324781062071459, -1.347161153994393, 0.7508453669870945, 2.425239643661716, -2.060133046875698, 1.9928225750609883, 0.6025165429949944, 1.4669513147511455, 0.7717134069384778, -1.5630142269563974, 0.5865139307838448, -0.3595175443663134, -0.8204693322102841, -1.3867266988402291, 1.0399804044878185, 1.4907402890691988, 0.33891794087107413, -0.058451467395546006, -0.6525531553498091, -0.7162794324693835, 1.3145960319460674, 0.061529773152793545, -1.4112983124813216, 0.2978624071364094, -0.2957913999893194, 0.3519586895425393, 1.9336042522684567, 1.1641452348876293, 2.58745893218636, 1.164235028654043, -2.2956124850259667, -0.41280335387130623, 0.9066520748792416},
    {-0.9968823841636774, 1.5475471656861, -1.5242044865285218, -0.8938095092191591, -0.7552807208138587, 1.2544424001995453, 0.67179105257739, -1.7482022609717744, 0.5550996670156296, 1.5701042402986416, 0.15486428568886262, -0.6260588307062781, 0.6989664135260838, -1.232206139527341, 0.5076132434205856, -0.5842103010404381, 1.539645379964232, 0.24229988924435683, 1.6423683127206719, 0.07081091430676692, 0.44295881768701895, 2.0855365082125132, 0.08209256356988147, 1.6956226994044952, -0.7729340053002067, -0.47360520564077274, 1.8302607390833603, -0.8837149710631274, -1.5767126012483088, -1.1171752019972634, 0.8722079106412913, -0.6898772046618236, 0.7658099476835456, 1.5782995881976607, -2.186509511464383, -1.805115754862714, -1.0648377113824297, 0.7989918553923031, 0.23278976480936742, 0.30400764754118026, 1.7010387297815395, -0.3942497877999011, -0.6128480136159499, -0.0021743472398814924, -0.05080023053616984, -0.35332365896244683, 0.21199446250712092, -0.1998025570879898, -1.305785157430405, 0.34617426436770804, 1.9503334290972465, 0.41244665531428953, 1.2892543135411874, 0.6704092843404788, -0.09873813485315235, 0.644487357454307, -0.7440492942590029, -1.0193068392204356, 0.39667024747304397, -1.8068320400349884, 0.4022577047904176, -1.7508415040468563, -2.0221684636302637, 1.1396724539217284},
    {-0.12684420642872854, -0.028142843422565542, -0.6287917576426887, 1.8739373704340339, 2.3412248601748065, -0.939741774018993, -1.4546824278290815, -0.8081824118983607, 0.921405187166494, 2.727268950968492, 1.599658287849866, -1.2750296295848507, 2.598080521281139, -1.7226507346150235, 1.645779553213223, -0.6453391869037758, -0.4591430059996367, 0.8671668033431683, -1.0285310166400845, -1.4866580895072292, -1.222130689313985, -1.0359278105243601, 0.14175284214364456, 0.056041123169547125, -0.8498210850009661, 0.8557860945722531, -0.5342853747801434, -2.5917366221436646, 0.8656620700543756, 0.37942886985914265, 0.8162387145943876, -0.6517590234502728, 1.2671228525328355, -0.2571090821015563, 0.7664549952135316, -0.39246283224876904, -0.4661425138297261, 0.31037009789900266, -1.1386160882462175, -0.13849683488496675, 0.007463771198171183, -0.19917603141742293, 0.4817492345191058, -1.1849377953539113, -0.195942021409733, -1.2825543289699084, -1.076665284428456, 0.10112969936699638, -1.6969159041586899, 0.15220010305039247, 0.9073443239032459, -1.4102971645121538, 1.3720756926287634, 0.7856448823778802, -0.15720699719882128, -0.4273885851217438, 0.1526550487466468, -0.5004086943853626, -1.9826988986023784, -1.8699337092249806, 3.2755820217798335, -1.9173124147103542, -0.8014993670177045, -0.26657480906178577},
    {-1.4853902984229008, 1.191703004559559, -0.568511480526402, 0.6901614698789049, 2.199973417524724, -1.683954990549469, -0.5864168735173932, -2.3256201918011694, 1.1940277948837745, 1.8375366137792335, -0.4056377194194856, 1.4770086099896838, -0.6945928017509406, -1.9006423615562162, 0.49770820836465657, 0.7172806779193452, 0.39434126152939647, -0.39198014248039337, -0.7788300393285019, -0.12670390584021274, 2.689955242968665, -0.14434827205242567, 1.8368407462990681, -0.40303044850214714, 2.764657842027197, 0.9899397279470683, -0.5559003171211374, -0.6292867341391086, 0.6674632424226437, 2.451583658442894, -1.2361708839941783, -2.000511155316473, -0.25641410603474496, -0.07644438890738288, 1.3079445234144969, 0.7589609580577175, -0.6873169496851341, 2.3186835383100517, 0.5799724918041561, 0.6567662708443252, 1.715492850508335, -1.49787202145003, 1.7380240871643882, 2.0534339648974025, 1.5465094661271488, -0.437930076460389, -3.191651460390626, 2.3504377044802833, 0.1415758950653347, 0.4513258883745833, 0.3333873881650157, -1.5095040595974833, 1.444697740672943, -1.8022811129201182, 0.03829972004895956, 1.4666648184617264, -0.6333298770366642, -0.641069253206734, -3.9097163838584703, 1.0884505461312814, -0.8974061053570063, 0.9360845512193396, 0.9536124999052176, -1.8553594565861409},
    {-0.16008052279204646, -0.651719810962807, 0.409849858699443, 1.8128373269133318, -0.30409623513237066, 0.5371413579471199, 0.07891316351573552, -2.313940032140643, 0.1438713752543379, 0.49306889201521154, -0.11643607957111497, 0.8417454918832102, -1.3000682728618407, 0.9099899756815226, 0.8109580879046965, -1.0946903364340723, 1.9476242472578535, 0.4652223962682965, -0.9418220368676892, -0.2688295505874334, 1.083368096246921, -1.189655911658099, 1.094814719669476, 0.49852583960029434, 1.00055960641777, 2.5387643556105006, -0.229298607429835, 0.4977371339786663, -0.5694069084170017, 2.3002973580577146, -1.0285311203894496, -1.103649205557995, -0.7937912431131724, -0.2743314492767025, 0.06819848025984034, 1.7800914924876605, -1.1523230806636804, -0.9157135371292209, -0.0014823551937112607, 0.07275266632772574, 0.5102925772968174, 0.26553806914901334, 1.107277596119196, -0.038601164394998756, -0.19101145128739025, -0.12403877083046642, -0.11100835489869261, 1.6741616770837155, -1.7152751649788365, -0.11732481512190598, -0.8543262995800769, -1.6719302274801293, 2.193505303605731, -1.3436458140458487, 0.6131526827709173, 1.730273214955221, 1.44890210002707, 0.35537592782573313, -2.627513330132408, 1.483992117613052, 0.458636971961389, -1.8081046218067294, -1.0725142571205504, -1.1086697097555664},
    {-0.13715780723231524, 1.5115865850873387, 1.392347615743144, 0.3026378036697226, 1.6022345822824435, -0.26442317455672526, -2.126853832213438, -1.0739497573258934, -1.6853493550781407, 0.49252662838668615, 0.9585569773283252, -0.386721291023758, 0.04763107221432656, 2.1809581857676013, 1.906199355253498, -0.23223590251179074, -0.9987120880694135, -0.4396136711954333, -3.197367033607639, -0.06521299077213884, 0.7539942325552217, -1.6809137499273454, 1.2156724607671539, -0.3033512986482457, 1.2018870278962936, -0.948106190514187, 1.0681280614313409, -0.7390719925951298, -0.9863334191325096, 1.2217537695283702, -0.2529673596993942, 0.30510886586156416, -0.5650384301308532, 0.9965291329985922, -0.728586595992567, -0.8582289604428186, 0.2757732203359218, 0.48744346611223466, -2.0125933239263643, 1.8614021669537875, -0.5110763451648747, 0.768659994268254, -0.4126796402834024, -0.12282205971694261, 1.5783838898828755, -2.3978688711833125, -0.5799992377644317, 1.4313946458559563, -1.2278245883464083, -1.0512788592091882, -1.8327925986246385, -0.4160650380501744, 0.5765263287479928, 0.5381650229962285, -0.7855392030401108, 1.1042059023851478, -0.8905065666106984, 0.8403209175437076, -1.435894236113732, 1.6344388150925258, 0.7833977510202329, 0.04613195851225752, 1.2809829770165038, -1.1513393927881503},
    {-0.7597118571933074, 1.3838743704187662, -1.2270464519071236, 0.7475760964334479, 0.03387780331965233, -2.2466883145971215, -0.085456896426142, 0.3721960818557351, 0.5718384660006055, 0.9471767774411901, -0.06407348092258912, -0.6246791611182718, -2.4905868532213966, -0.008133566564461264, -0.3986587549337304, -0.694159088531701, -1.2090801492159104, 0.00845091920060296, -0.7308205715064771, 0.8729661756311101, -1.0780934956552342, -2.2301131534884022, 1.3744870208138795, -0.0389849604170791, 0.2162150972977039, 0.30936323153258155, -0.34499394745385425, 0.6640458553036986, 0.05938767713207747, 0.12450566076780066, -0.5349048880331969, 0.47012999618169854, 2.0678537350126214, -0.1335766103470986, -1.8493563572279357, -0.4794496204407535, -0.2600744013790967, -1.033188712373719, -0.24928598435203386, 1.398941922264974, -1.512512219992409, -0.17908719141709595, 0.0865679183553278, -1.102290630308737, -0.12618285265265888, -0.21166978295892716, 0.26518534167809377, -0.6181916713772398, -0.0829407076572641, 0.3128120147864912, -0.3571840868325635, -0.8024028197080457, 1.9971121738457125, -2.9578626072695906, -0.7555163702056161, 2.883340216701324, -1.3324268242146093, 0.373024659636173, 1.1672875527971855, 0.09927625892205778, 0.7017888658108223, -2.3563261598150538, 0.43458173613775036, -2.302617924370711},
    {0.0016798725769165222, 1.182142790641788, 1.0459959399369354, 0.2736386079946704, 1.749126982098503, -1.2334851714624844, -1.3465538433798308, 0.8995502787256695, 0.662660986408783, 0.9488056607017891, 1.2399085278067716, 0.683373052760874, 0.14272618435949241, 0.6395412482173806, 0.45025566407431195, 0.5207176116113825, -2.5094380692238114, 0.5280148666147553, -1.9105833695749435, -2.179757103222043, 0.743452944351041, -2.1496583087910555, -0.03377016244992409, 1.9094502301783791, 1.0300162054487425, 1.0161215692439838, 0.135917931392614, -0.6780158210722997, -0.13920988126285047, 1.0967260796209888, -0.4961217059720446, -1.3198112448998323, 1.1346091328411747, -1.5071352662901427, -0.21669824864731113, -1.4931022083942498, -2.527018275367415, -1.7806599189603192, 0.42496854945590684, 0.9279216877892337, -0.9258627822071185, -0.34058523840463023, 0.4617138204534714, -1.91874499774921, -0.8918522071094016, 0.04928482675449655, -2.7756130248035453, 1.1992711990406137, -0.1432530789780533, 0.07531870055669258, 0.06295301832887311, 1.1135374939382994, 1.5059030560297664, 0.5014743765799957, -0.12409918515622019, 2.58974429310043, 0.7938390653746114, 2.036212871617257, 0.4117422537257593, -0.7204149359633671, -0.5566823087074548, 1.6209376518402145, -0.842444447046402, 1.6553495651854522},
    {1.0103205549759868, -0.3106416499728802, 0.6028566278465759, -1.1916739641927216, -1.4903629682363442, -0.4295348657932673, 0.13184694859372884, -1.372433400729108, -0.0643698080313334, 1.8311630080445935, 3.314785173154248, -1.9093091967230915, -1.6538857176327273, 0.1518600559477315, -0.14771848939927718, -0.11074371584335195, -1.1794002768627063, 1.112418174895684, -0.2699604013920737, -0.031132466752406888, -0.17767787976146102, -2.21538077923341, 0.4312265526270556, 2.140218454404611, -0.4060464568229135, -0.20654507130840086, -1.130088654699269, 1.4092424420282663, -2.0207717706874484, -0.45369884190532966, 1.5848859088771243, 0.8222333465038145, -0.9489832533603181, -0.09143314620223614, -1.3764934558277446, -1.516134033864803, 0.2043381396943737, -1.5300945188970523, 1.230371017082927, 1.2319010531464574, -1.2604267656057924, -0.23174224034340832, 1.4953641129425472, 0.9664596799438515, -0.6768181347488756, 0.33584779708472623, 0.8323673174661114, 0.540704274048139, 0.19534355649917037, -0.7078997309782424, 0.5015121228556764, 0.033347407317180784, 1.7609824901590942, -1.7129595647801572, 0.6651391046236316, 1.8671363787378634, 0.6937671368854411, 1.0626556402941403, -0.8773148464235447, -0.37529164058349024, 0.9493610869257445, 0.18319113142268048, -0.7217522676351177, -0.8691123003466604},
    {-0.19053222853155433, -0.13834341002001452, -0.9747436779739129, -0.007131202310314992, 1.1917784002336176, 0.35835557996867623, -0.3743647332342659, 0.12998274272546265, -1.6426713111034015, 0.13433855075038373, 1.059119467821867, -0.058923696508596676, 1.0233220355397619, -0.04019741505341818, 0.8772297469214648, -0.23941143466619988, 1.5724793721788253, 3.259684876430998, 0.6024927663347972, -0.840664679778317, 0.8878348799552852, -1.991044610549363, 0.6711517570944823, 1.7343942985662786, 0.8569399327827935, 1.634585364991401, -0.8407662864666726, 0.1575116693641316, -3.108611335683363, 0.2643548052396245, 1.355943961368955, -0.20435890416239189, 0.49463491830849854, 1.9891651113166668, -0.5682366039342653, -1.409823946199103, 0.5086112683389359, -0.056605381780934806, 2.2696398133213966, 0.6639497194837708, -0.5161701377039702, 0.7130597927783254, 0.1235814502018726, -0.5860109246384202, -3.486156735287335, 2.13864300041012, -0.13283337506666476, 2.8425021725312143, 0.06353732596247726, -0.5250932395875534, 0.6579717070564608, -0.5237945226713681, -0.5601456891055324, 0.15229470619244848, 1.4951810713973102, -0.3096763465600092, -0.5265694344446423, 0.769011831251669, -0.7473611420779684, 1.5053502185552494, -0.734712962396127, 0.714730134487334, -0.3826349749145089, -0.809505324694593},
    {1.7734878472519162, 1.0041589162392839, -1.6846431019312027, 0.26780301588253747, 0.8517377366332116, 0.6806883877925366, 0.6562058567164483, -2.3317555767646483, 0.39218980572670914, 0.9020679219386387, -0.1426874013908249, -0.29758263955307335, 1.593023979426067, 0.5157561349185276, -0.3085571180828855, 0.20726133461701504, -0.961855887049821, 1.014159367923284, 1.1777045466244285, -0.2337696395571293, -1.426654718631633, -2.785300428698219, 1.3141718936417095, 0.11847502700157518, -1.1000729126728523, -0.4105923172409962, 0.34127744329952353, 2.031399211957041, 0.09359153991678429, 0.8075273294493717, 1.856005594735757, 1.5830083124995769, -1.320146367772689, 0.3639034910221762, -1.1831761519008948, -1.234000718053988, -1.0925514551068967, 0.13877475439133544, -0.721389746017329, 1.0534452816269302, 0.3278783984400418, 2.217603472612328, 0.10948850746216371, 0.8498083035451884, -0.7091202148308207, 1.491841095095599, -0.6894819594863524, 0.4297791950177962, 1.9839767773017905, -0.8789799392469867, 0.8636613051679782, 0.10714246121093945, 1.2688846672245173, -0.4610142802604477, -1.2745566372733828, -0.007966889636106115, -1.2520645821086405, -1.062331526788109, -1.062234882349745, 0.40120430686066144, -0.12481766522564859, 0.484661013120918, 0.9437304074702404, 0.035341129836155685},
    {-0.16395745366269113, 0.5108802787593633, -0.8971851216975949, -1.346087064398547, -0.4260458991516965, 0.44923131956638757, 0.3646048647956862, -0.5876509348306245, -0.9030097700543991, 1.3233823244083125, 1.8859386834077105, -0.3632151636097257, 0.06666975611648877, 1.1531299637132766, -0.487431373677961, -1.0637097124358579, -0.8652697544620753, -0.5849228279777321, 0.05957696602503514, -1.0085826939614666, -2.06884984238801, -1.538023091480205, 0.7785048298656192, -0.21196990741377325, -0.5282990126250126, -0.7182780192578103, -0.9696956457225147, 1.5390739040791541, 0.7953772512864659, -1.1829554591884495, 0.13827784549704794, 0.42480527653347566, -1.250841483635254, -1.8360553903508845, -2.272709794299612, -0.5820974865192763, 0.5786537080713675, 1.2374632396900656, 2.694245543069133, 0.6011605721381628, -0.7553461944087915, -0.6443316462743759, -0.0357436812740641, 0.6887627507108023, 0.0442641975572955, 0.02714369534677461, -0.3521226500119092, 0.23976995344617932, -0.036377990682499466, 0.793143369354314, -1.7645560593906138, 1.2000770214024097, -0.4831512909218907, -0.1653472681451822, -0.1887409318835925, 3.0584235685980916, -1.0097908903522663, -0.9208210506361271, 0.6414702569826094, 1.1281450772535138, -0.8092185529367013, -0.017441491911741207, 0.5383583341744117, 1.877180693896004},
    {1.8453007407694997, -1.4248042690872416, -0.13965036588450913, -0.5761957143917289, -0.589090042302192, -1.2147224092089184, 0.9218028586529968, -1.1562315327823312, -0.9900663447126066, -0.044699242376474525, -1.2231472720270515, -0.13248864107435177, 0.158468285524275, 1.2864071631842504, -0.4670677703526184, 0.2284712056665686, 0.3448119041066993, -1.7787252084405663, -1.259265869074333, -0.8559639447095664, -1.9323602643996969, 0.8070171617980564, 1.9369220904108775, 0.9080715342875831, -0.6430549132636535, -0.5257696916441801, 0.5724863151831368, 0.9197055912953913, -2.0458083144109, 0.9942167068388541, -0.03179109680130395, 0.05828754291853317, 1.3916811202087178, -1.5838850557886788, -0.2980452884048984, -0.10999810511634978, -0.00694400583429051, 0.38642624376504103, 1.7094430210077634, -1.3311778462124728, 0.2480833436568723, -0.42009866342051333, 0.3808842405874326, -0.2691095250949002, -0.52654954454958, 1.0919711106228878, -1.820470151035985, -0.7736385168047476, -0.28006427975188986, -0.9433971361453771, -0.9167592264353994, 0.6899577915377618, -1.3621967632336376, 1.4989470194193506, -0.18413391811567872, 1.0376218393015662, -0.5141749913980779, -0.6745124178014356, -1.8864069746710588, 1.156896761899252, 0.32921627454813585, -0.1884489386518288, -1.9010232312740971, 0.9020339519921172},
    {-0.9706043843941135, 0.5816935959343948, -2.07862516967899, -1.1741775974800943, 1.1109677206504673, -1.2671101226631072, -1.2605181048850083, 1.242419125844479, -0.7145133726250859, 2.225860966668112, -0.4634984514674156, -1.7949496665130225, -1.9123553417091277, -1.3678909483983037, 1.955197232816929, -0.6269501716457507, 0.08519803987007309, 0.6189916863322059, -0.4024404778305607, -0.3063847641516221, 1.9105312601938274, -0.7341790924619983, -0.8661212546904943, 0.3964947857415379, 0.5953278111524111, 0.1824621426812211, -0.4029982596625869, -0.8355446777301778, -1.3838765550718775, 0.29420874747159576, -0.5977175553648788, -1.841015655758347, 0.6557311844053026, -0.2937601683672087, 0.3780693386516588, 0.2681960311706823, 0.134429742065898, 0.3308852181335781, -1.4350184419013026, -0.5745284384976503, -0.052278717107441613, -1.068045696928012, -0.3071736325782529, 1.8886467786932783, 0.03417910710258323, 0.6836811343966647, -1.17312743421783, 1.1298602379716896, -1.0195212604467565, 1.1442567486881452, -0.029296591518632783, 0.33284282502827767, -0.05552299433574352, -0.36466797446583893, 1.5682604928507842, 0.20083475002812537, 1.4631469144369529, 0.36847678115659294, 1.745662133555558, 1.6852805165832103, -0.6389308921474515, -2.358119793668766, -2.6836479320999005, -0.6253163068309783},
    {-0.21425942759777855, -1.4094950453947923, -0.8502819684158835, 1.8458440223723245, -0.011160764343790026, -1.5471975724045781, 0.9827356650566494, -0.4891771602608806, 2.185546271586766, 0.7076624189466264, 0.0729100074712224, -1.1329767188195468, -0.4482645535492943, -0.7512547134095753, 2.299693511847992, 0.8639793131074663, -0.5246148429543374, -1.320665556149636, 0.42135828527755625, -0.41232672097073464, 1.4126639335041735, -1.2170565692563842, 0.92436598227033, 1.184482396650187, -1.7631247952494613, -0.24972409524962805, -0.7646265063736863, 0.04969709137652265, -0.2663966882198997, 2.94779784118712, 0.4524439101661085, -0.31424907311322364, -2.59253551125779, 0.06404309761101486, -1.8730065343280786, 0.4027151143936602, 1.2521448326122893, 0.8703656422463897, -0.2814669017011247, 0.31778761992417087, -0.6274510693152184, 0.4520057337122719, 1.0988229409978398, 0.9757216686026592, -1.4085726183791678, 0.3940857595265386, -2.3994087658960717, 1.9530678370331387, -0.47817611187354214, -0.9223316699377477, -0.8521691553597291, -1.209641649911568, 0.3122672406590902, -0.020906085737736915, 0.8489341218270408, 0.8556579114158013, 1.7144137476155867, -1.2902793410020352, -0.845129007779872, 1.5359427236276963, 0.9958336739095398, -0.8065886625094959, -2.077921245149859, 1.3142774439665759},
    {2.379566539765718, -0.012040202030095476, 1.1790508842418417, 1.0790437392783963, -0.1968263636171381, -2.7690229221450684, -0.6880040938474872, 0.5990532016411334, -1.1541931428100833, 1.3154205924741442, 0.7429847966809918, -1.8332101105335326, 0.010643611062999091, 0.9535675673231307, 2.7042252960708066, 0.6555181287518179, -1.0226822425202629, 1.3034187427729376, 0.4997795524240786, 0.6144124395476904, 1.464960061945598, 0.08247949809882225, 0.8738570453900962, 1.9447892339182267, 0.537912936824601, -0.1727376671934859, -0.635728024935363, 0.9058573831144253, -1.953528134343803, 1.0016290989974628, 0.2517816273508509, -0.48025222928839356, -1.3225342656068293, -0.17272753770335253, -0.3381565481337567, -1.9990099953154814, -0.7684311822821049, -0.062342400303968294, -0.6167703743913433, -0.3630524525962033, -0.4616979761884153, -0.4570745128609353, -0.5593913537503157, 0.6299533487184333, -0.5021339341803209, 0.13275110819438302, 0.44086087597087675, 0.5016069307146053, 0.5467791593651559, 1.2264595827751201, -1.2640045619479092, -0.2627939458310756, -0.25983059918560925, -2.1613555308929184, 0.20521916056116585, 1.024907753886035, 0.4419838514973582, 0.7177565601582911, 0.4402990432244956, 0.7993122291146955, 1.8461301654539812, -2.294124103127231, -0.9961827216017569, -2.0791147916033883},
    {-2.007697211475159, -0.6091365354935829, 1.3448030071281056, -1.5899033203972355, 1.9332997229434212, -3.761696286698623, -2.2220102679598157, -1.3244289564489327, -0.5234742656245593, -0.6983018924067762, 0.904980177748352, -0.33067127833762977, -0.5830320285938001, 4.120441579053069, 0.20580287812282624, -0.18138204945715083, 0.9263877475905183, -0.5267467927472463, 0.4254688999955832, 2.278407660339954, 2.2289701278111136, -2.39349904184318, 1.0228600834614299, 0.8954502885453449, -1.3922630045174522, -2.2356975347779002, -0.9138990973829548, -0.6996068149443228, -2.1267547298046674, 1.6821777240520777, -0.027705139509331813, -0.6059912004453628, 0.11436085682060129, 0.01606607582190886, -0.7583427170293628, -0.4005844883509983, -0.5090883590612861, 0.026243374783499415, -1.4532545081511596, -0.08230476514961428, 1.1209676798414063, 0.019144244104341634, 2.3030642683059597, -0.0977895582337819, 0.13587839520957035, 1.4827827477537634, -1.3453778845032505, 0.5377046118159018, 0.9811152515099504, -1.0545585796356074, -0.9506736609280604, -0.3571937568121171, -0.2868167061480173, -1.1137368371208372, -0.1208499488476912, -0.5335577800723729, -1.6561979952846333, -1.6323995234092958, 0.8528274626536048, 1.2732306772049615, 1.4490489798257264, -0.850406481669891, -0.11047890102943221, -0.8440875742405192},
    {1.166148470702412, 0.5181269122679417, -0.6852634844474402, -1.9894610434397504, 1.8080009897993936, 0.36079444965696245, 1.1089526485901784, -0.20181017108285798, -0.02983352047767868, 0.9501081089752362, -1.6056963941212512, -0.8779414057019027, 0.4954496463634772, 0.8762936345483381, -0.9236747590345158, 0.19356449417435825, -1.6918260716155473, -0.7810720528876763, -1.364504772798869, 2.088583268748483, 0.9873008916896567, -3.1479526629478074, 0.38995965292043067, -0.6117684892832123, 0.6255793623790382, -0.8338435792145542, -1.4281853082186167, -1.8054369229089227, -1.6914402612836603, 0.16655901955201122, 0.586841920257825, 1.9751516540231586, -0.3223361148152614, 0.041158312867058504, -0.7668980007123398, -0.9683204379061878, -1.3216282727530149, -0.7045298807439543, 0.7100369808534791, 0.4089918096832968, -0.44144875671066747, -0.7555972053573896, 0.4490783022298154, -0.3663805117503456, -0.2232355058704095, 1.2559122570990298, -0.9419232299946214, 0.1389310932800588, -1.2506368935754917, 0.2780492435364367, -0.8067887634938726, -1.792451479872263, -0.1688398215561041, -0.045952738978963924, -0.7370587557499334, 1.1458140183384267, 0.9051536093445448, 1.9884210256638368, -0.9815599617587379, 0.36683467667629394, -0.6312903485858452, -2.5555868984889236, -1.072844013166553, 1.9167237503398102},
    {0.7216579029261303, 0.07830429903685258, -1.8230028189503196, 0.8792791060620041, -0.4372107795106982, -1.7167523856852278, -0.15764156711492727, -0.24766360309435242, -0.30284421045240895, 0.7002570983201138, 0.43867594779690694, -0.9904269328956997, -0.5413032721798622, 0.5529986824453118, -0.7127667067895725, 1.1271266072517612, -1.6416889280909812, -1.7556331178631537, -1.902835362000449, -0.14689671179924707, -0.24523756046433812, -0.799257235315759, 1.7133879913142909, 1.6153962325643672, 0.4794211896735187, 2.3152090054727466, 1.0908978778978047, -0.09181515916008043, -1.852447478445505, 0.7393488334564163, 0.7461273232338754, -0.9776691489532666, 0.9218041948405814, 0.8879485920431117, -1.2371210417196734, -1.6573391462406686, -3.5303897518168688, 0.05997224541264731, 0.6965509171122373, -0.39802809864261224, -0.8893735659450934, -1.9449553761385066, 0.737311555525749, 0.6450792659439153, -0.053769741634763356, -0.8185800420374831, -0.43944020668005535, 0.39003094978381686, -2.7387359535322533, -0.6427567598360123, -0.8461508633749282, -0.19427377849658092, -0.4125131179411345, 0.7016454734661829, -0.35791073509519694, 1.222887205328106, -1.2150217030533235, 1.5740779842082446, -0.029763620134835387, -3.3768031124348066, 0.17609927874636608, -1.1029609426502534, -1.6261120779341176, 1.5335753308676259},
    {-1.6939377574978214, -1.3524049277559158, -0.6012680184477991, -0.6085878481260847, 0.572456424585654, -1.6904859537508032, 1.700894067099139, 0.27002663110541636, -0.026031605680844012, -0.5469445796425354, -0.3197484597939934, -1.5974886154076287, -0.8821621098053395, -0.11396114655051738, 0.5673899329679226, 0.6025018302786642, 0.017208985874799663, 0.05483405927978086, 0.6500747685073257, -0.8227949491010087, -0.476794346275415, 0.24334855250952614, -0.26584477353930913, 2.2521626291351113, -1.96966857854953, -0.8804239523914965, 1.224218205695136, -0.12620310020216816, -2.563657368331865, 2.4014188140865578, 2.370898560307776, -1.795637242178616, -0.8700145859688222, -0.7825421673878992, 0.7777433363669207, 0.6444817311449199, 0.18045716859540542, 0.5287923644477466, 0.49374238116123853, -0.36551606906145545, -1.072169705478851, -0.436174453840695, 1.4556610746624552, -0.9364715169784863, -0.1646729948845081, -0.47720147107291677, 0.396487885350442, 2.5250563945929807, -1.9889578226955602, 0.8495340666985661, -0.7104927297626507, -0.8958201698172954, 0.17050151412440454, -2.4068289742297884, 0.23036079354616454, 0.7192491440645887, -1.0296902798171976, -1.6153222322549647, 1.935014305773358, 1.5751841244432965, 2.29387363034026, 0.510964571907462, -0.9885177173460743, 1.0008217685164325},
    {1.234311478999779, 1.19057177222233, 0.42401686976716024, -0.16996538258418853, -1.177132394971925, -2.0005646706089673, -1.237400382948128, -0.8066995652018911, 1.1474577734334739, 2.246302700263764, 0.027940127347132453, -1.1369040504768892, 0.14630581709269463, 1.0879418401253567, 0.46961625266721924, 1.0177950462583802, -0.2929025833819509, -1.0884604724534022, -0.8271842218001989, 1.8616765477862172, 0.014445419901519123, -0.9205131406377517, 0.2584289522729103, 1.6907706390207022, -0.6717759211018681, 0.8877751434376662, 0.5876327296149363, 0.490694978666322, 0.9341245726904279, 2.883299674293912, -1.8254286299852238, -0.12085850388585152, -0.2862037803771365, -1.472931756205773, -1.054435531481067, -1.1099358121353213, -1.1557495791016545, 1.0310718790890574, 2.0277482870808528, -1.7052118452388727, -2.6470116680852622, -1.046165760628864, 1.283403687412884, -0.6024599862321535, -1.2873746200730602, -3.157400721689672, 1.30592258342741, 1.9700937559913303, 0.061313402527082984, -0.2459280363192931, 0.2407714156833143, 1.3579811156918007, -0.3729424588875187, -0.29103811840603855, -1.15603288433796, 2.4176531894709896, -0.020601185303054236, 0.63723453559892, 0.5836548740204721, 0.7120187919244989, 1.2425247532670844, 0.22769723078216747, 0.19101440560427307, -0.9331259580782236},
    {0.4662935558353775, 0.9031989508592856, 0.29165976307784125, -1.682965264958861, 1.0931284746928769, -1.2416369768753825, 0.9614158844295826, 0.30878128383333703, 0.7611664591652412, 1.9777921478948672, 2.4082088860391555, -0.3612379687489006, -2.134656282849586, -0.03693876694930759, 0.8173059205678904, -0.44186837234416676, -0.006729965406423308, 1.217312034119462, -1.4114078055585668, 0.9930405636099306, 0.2833922777452578, -0.15591511411214576, 2.794448306592172, 0.9805167209942786, -1.1796197646597288, 0.320227267295338, -0.4727356063049415, -0.9449969039041253, 0.9012971218798059, 2.558084860328921, -1.0258183596695893, 0.3445800925095914, 1.7335209861891692, -0.6887395309840945, -1.3980401197912813, -0.38122366845134664, 0.26745112966591034, 1.5726918727706145, -1.397847954576621, -1.3350681775788271, -0.8116418624281967, -1.2515328272484225, 1.920304501631251, 0.13762504861679542, -0.6280447143024291, -0.912763235558536, 0.3843419669939558, 0.1501415042978747, 0.6954368584319316, -1.1987564640489803, 0.1797489793126935, -1.108023023588482, 0.8722403790930308, -1.2514507966665258, -0.02052430820197342, 0.7367858850899417, -0.10722794428362335, 1.6122299357314647, 0.3065909615223538, -1.0955540945112212, -1.099799255668452, -0.5448277605268553, 0.1766013194935993, 0.30991155050564667},
    {-1.6189921586934335, 0.5724781997784287, -0.7479202692754109, -1.0071282659519807, 2.031438608211203, -0.46639297984073186, 0.061755937393746865, -0.4393376592933207, 0.9508260624801026, 0.020865005774800514, 0.0036343884478098744, 0.03827668357719143, -0.7072778555403995, 1.0118722562279592, -1.7626949092056334, -1.2563504879017775, -0.46451521020129116, -0.18449429601175985, 0.19918149596392276, 0.8341783591099259, -0.03643128920346245, 0.20702574500242402, 0.4012098622608101, 2.153572207861848, -0.5023421669777178, -0.153811595475763, -1.0918760977093336, 0.003623782801627361, 0.9528756231936709, -0.5250335822621657, 1.165653186349775, -1.3798656041872563, 1.833284168376169, -1.0749433281360026, -0.5145132039856458, 1.1538037934118983, -0.42579618529572827, 0.4867897552077771, -0.8383432938486324, -2.141494411013547, 1.4247292349422909, -0.5401311179334551, -0.22028088061983833, 0.4391345870279234, -1.3036709253301695, -1.7781711416595318, 0.25062311419960487, 1.7786000747413964, 1.9937553968372916, -2.3101161959254277, -0.10036688052087249, -0.27759396247749374, -1.4601799319390956, -0.9523798333332845, 0.7763619491884005, 0.41477288690559283, 0.22721865983147327, 1.382986867283508, 1.0336530362272383, 0.7355398925063932, -0.4545238966504674, 0.3509447383970306, -0.5388666271247274, 0.33633329741387186},
    {0.7814648921795516, 0.37622261705159876, 0.3800807817037737, -3.7299893742873063, 1.822439122667283, -1.4535703850473816, 0.3442519508047897, 0.12938421149524829, -1.8628968288528858, 0.5432032156606491, 3.653452899968255, 0.12129826396582762, 0.480941299184008, 0.33017423397792434, 0.32974730501851574, -0.9251472542075342, 0.4123253149416238, 0.21687337185195457, -0.9289874231145194, 0.03446498341664894, -0.29490075881809164, -2.221933490233479, 2.7656076595385337, 0.06352898611158084, -0.7375537976288845, 0.4689740637848196, -0.10683421575791384, 0.9549881115322527, -0.6104985872232375, 0.7658760885684665, 0.1780118922725372, -0.2824599980340722, 1.06333041023132, -1.3466946876599353, -0.5192847802441252, -0.9039664894018381, -0.0657987152843719, -0.6002310607539306, 0.6273623548176637, -0.006609832181892666, 0.9554464560987559, 0.952857272180735, 2.7039405136675603, 1.7021863795508627, 0.7003805789561751, -0.6505435022019546, 1.240362337997273, 0.8296892871477777, 1.646679386524061, -0.16897500038423977, -1.009948447699669, 0.37222337056510546, -0.47145193203790375, 0.825316165346049, 0.7262443371232276, 0.6258416755769771, -0.15564579323733446, -0.21639108500189586, 0.5705728101079501, -2.228306981145185, -0.894819920174936, 0.6354694267146156, 1.2167739682801963, 1.6511211826374765},
    {1.320255313865377, 0.09544840005593491, -1.2668848211796484, 0.052031777361481575, 0.9176125718028002, -0.8359387033855478, 1.1635282655579842, -0.48061949510240454, -0.510811318447301, -0.03651815300872091, 0.5051706901447018, 0.34153872033235194, 0.578499831068625, 0.9323241226342626, 0.718094014901051, 0.7647703549674509, -0.09802682223817999, -0.5889510873820213, -0.5309861393686889, -0.9729349746593916, -0.18092777661632503, -2.7012049275372263, 1.0215843543498349, 0.3869733003091173, 0.4474232892807324, 1.7583659137029566, 1.3403513491400565, 1.9829060060545314, -1.1943538004516714, 0.9573622540392662, 1.576232692970474, -1.1011365046743662, 2.0903839308931795, 1.1885175985130487, -1.9154607868303353, -2.8248896848597447, -0.7583149322624126, -0.12103404609033165, -0.02095769976070177, 0.809543728083778, -0.8084799803004912, 0.01775758526272372, 1.8025802926586993, 0.2562425412074617, 0.26318096716525624, 1.3671704882782874, 1.5479199752065784, 0.9710082392989949, 0.03951480116712344, -0.2992762723667918, 0.4204224126033016, -1.9272491970687358, -0.5877532171225515, -1.3645212044758557, -0.39964909162840956, 1.402237102949296, -0.06419185446705304, -0.4790338082528268, 0.304240300255051, -1.104398184230708, 0.7292190706322403, 0.09375381256879792, 0.8776064664065014, 2.1583413898181543},
    {-0.05235781280929871, -2.610637280222298, -1.4598737412814584, -1.5000013609214473, 0.09203289160902314, -1.381342025716262, 0.7249213231136891, 0.07425723424330742, -1.0892920052095656, 1.0652068650707927, 1.0773005030710854, -1.1681715045125831, -1.2164178754710553, 0.6295668826500223, 0.17319430094946095, -0.16963255373387037, -1.7500109260826902, -1.12083729615691, 1.4879919597716456, -0.4218620130955778, 0.8312094202716165, -1.0415676663686608, 0.6782816204245348, 1.4018659832631746, 1.673666784656828, -1.00186655129832, 2.3798333394196862, 0.22346712156361045, -1.1160825317364673, 1.4910719940776362, 2.3393343548908687, -0.17648084219739585, 0.5236398737390967, -0.24834923011594712, -1.6503943860804506, -1.2314298069818461, 0.16254399020459412, 0.03413822061556095, 0.01764858410576241, -0.27830843014983614, 0.47851618230058507, -1.8965732026169169, 0.8093231532363088, -0.2868697032000964, -0.32037979823211205, -0.8770894686712793, -2.6956704665648785, -0.43950984562068923, 0.21208692130010126, -0.9368639521035159, -0.5458479502356426, -2.9227174695214013, 0.7782859599830901, 0.695118729660575, -0.4990790496248271, 0.4621114579488321, -0.8743741515370635, 0.6679590648741477, 0.2561748241694457, -0.5884865342333341, 0.4913232369022658, -0.9401034391262973, -2.3156630233483857, 1.047269704028382},
    {-1.804811943822809, -0.6438512934650743, 0.5422212019613707, 0.5154126084874467, -0.6344447691033802, -1.2597147940666116, -1.1549991440895173, -1.8254880036673933, -0.18395954941239717, -0.3945175205916974, -0.9395083022221403, -1.244357409286669, -0.7408157501315056, 0.18839494298525594, 3.2928777538054317, 0.2087829822461291, -1.4958462045850431, 0.596816594475701, -0.6219437241575007, -0.29883444529664, 1.0284403638686035, 0.5312073939791454, 1.4958159976337206, 0.6447676610139503, -1.1842547644830765, 0.17025036797209367, 1.4042793508719535, -0.15105057207340356, 0.7626289716205251, -0.032735846791233064, 0.827741016601295, -0.2497194915892269, 0.5758227364618158, -0.012157965900530457, 0.8107358330266461, -1.7151741622383296, 0.796567424099722, 1.1647941732937575, 0.7826718416852669, -0.3290829127215068, 1.4183430098748888, -1.0972786877791658, 0.8751382290076292, 2.3720596048214966, -1.3961743148649821, -1.419815157745279, 0.3106064763269915, 0.1262300707665842, 1.0547195278971249, -2.1060807771427403, -0.8616802850935006, -1.8267528410920215, -0.059313239766217225, 0.4296317514272967, 0.6208982473186815, 2.279846589582263, 0.5310683119144319, 0.545627216737086, 0.27586426824667737, 1.831101336462711, 0.7000799304074964, -1.2123670106053483, -0.6832021722797095, 1.7934481239526119},
    {-3.460790577886351, 0.24900876385630946, -0.13160448353216245, -1.9677315151962955, -0.5328628107562667, 0.8394612260207641, 0.020027347341698667, -1.6418412553618036, -0.22697798327729893, -0.5684625737856112, 0.08137408912426694, -1.1246323612404094, 1.1735164002601106, 0.939869027619117, -1.5990305323825524, 0.8707968343957893, -1.2184050790523924, 1.379205087662669, -0.36114319547244483, -1.7075854683246423, -0.8140088666848382, -0.7879959722223357, 1.176808723289652, -1.590247775661891, -0.28725032751206403, -1.5746783796659145, 0.7448218485930849, -0.2665970610828501, 0.5971338381366093, -1.3188910920947665, 1.8965341799711315, -0.04694363514807358, -0.4610605441652423, 1.3627675524076364, 1.8881028553870536, -1.2106080365482894, -2.292515690279676, 1.7965452094447312, 0.3759084313849736, -0.3167652254101557, -0.3419885476517534, -1.8064212134672752, 0.9101058759222163, 0.005760140258765529, -1.5573056425602392, -0.06429201441777545, -1.2208191570844342, 1.787807139574241, -0.10234980415463332, 0.16633146082830627, -0.37222248602647445, 0.05379534308304249, -1.6470922431251889, 1.632205463578542, 0.20205014496109533, -0.5855492818113806, 1.910926994061426, 0.9683637568828036, -0.6738946245020279, -0.1642923698980646, -0.14793348627340183, 0.9148418781380848, -0.7148285786389322, -0.6725311000815583},
    {0.7354751542885666, -0.007322925329584954, 1.1341062338671537, -0.38681309418552934, 1.2229757448634135, 0.4259299905186741, -0.4558982111573025, 0.9578736771739125, -1.6469921143049384, 1.4625178280444222, -0.028438232507443467, 1.1170939295154942, 0.9351026682268376, 0.29598862295260175, 1.278695998845862, 0.8696336255323177, -3.4526077461056137, -2.494107627948537, 1.3335969823173857, -0.8084897742541146, -1.1077453966218187, -1.5229885919150639, 0.8401282618977504, 1.3056760601320214, -1.796723448349611, -0.24022519445163545, -0.8141331671971116, 0.6303382817332827, -2.281379064490829, 0.19899260250548817, -1.4847425720864798, 0.02827981193793553, -1.1993159649873961, -0.7218641517751401, 0.48680143735494547, -1.5694769980112198, 1.1910008668748602, 1.640186115832214, -0.03126227841786151, -1.0560031708226212, -1.896672509308925, -1.1008151632967957, 0.3537665747808724, 0.16902485237637888, -1.053460085096383, -1.257940704993934, 0.2558842631579408, 0.39447671772350046, 0.8852211789203654, 0.016691255487622757, 0.1054189005248494, -0.22179558789249293, 0.19229331603424268, -0.7823447569580674, 0.3879143468199353, 3.360469307461645, 1.7906149527234485, 2.718042357746498, 0.4396027022847239, -1.0421768560629132, -0.3556528736813411, -0.0875418628108226, -0.04233585628393023, -1.3646136698538391},
    {0.6014215510328703, -0.285985757006525, -0.6570179910392041, -1.5167764328994884, 2.267359045069379, -0.5070454960958033, -1.1098921403704727, 0.21610528991101993, -1.71076976241921, -1.24663397144481, 1.5911097536125158, 0.44857579022764266, 1.7823440992840387, 2.1671133494486376, -2.2020673633432764, 0.32407985656073623, -1.0149562862152577, -0.05632230066505638, -0.5140227209673158, 1.0046180815973929, -2.113633573569094, -1.2039750477247249, 0.2955865979022794, 2.464068808020361, -1.1313179501754111, -1.48780970884683, 2.907629298796237, 3.364980256262338, 0.5078347985202788, 1.3106794708516456, 1.4123394189121803, -0.622985547181771, 2.0118156511801164, -0.5729335862218734, 0.047720619375681936, 0.3475967971335157, -0.5891583287939129, 0.7295698438238366, 1.0144091320637756, 1.0882791543524188, -1.3187345962601098, -0.8447968788681074, 1.218749613909163, 0.8433347910860576, -1.074440153698643, 0.05114515257233872, 0.7453679560721869, 0.4830337991707663, -0.701984990870325, -1.630895483665579, -0.6649276035979234, 1.8880675818045218, 1.6758771922219708, -0.6228379989464946, 0.9183594666074948, 0.9977440907062894, -1.117547283253375, -1.2890220630271276, -0.6592256659625512, -1.8613729381729778, -0.9170002930171898, 1.2299169379540322, 2.4781964471718774, -1.838583072973818},
    {1.5360987011593974, 0.8668218346170404, 0.3585893111185015, -1.8551650761712455, 0.5975453019101379, 0.14925851125583947, -0.845669473943807, -1.31277206383104, -0.5494258323744083, 0.48740097064518806, 2.5681087508109304, 1.5994221997271276, -0.5847654943211156, 1.195294502889142, -0.42112567191890415, 0.06252175984375956, -0.34856671235089565, 0.5489135681682765, 0.536995082862371, 0.11574874839759353, 0.5469133060531728, -1.2297689559387122, 1.0000165953377076, -0.2838212304634579, 0.060215343942885496, -0.1070603217374783, 1.1345973062365342, -0.1410129625710759, -0.08839465123196369, 1.3158789121256373, 0.15887003740873215, -1.4031231309710113, -1.6911938014428223, -0.7966265054526551, 0.2957096101244765, -1.3280274672134564, 0.8131022048094099, -1.2588296820360507, -2.043284145908965, 0.4344065929272269, -0.019303783617799046, 0.7292938861179206, -0.563365966161246, -0.26136955164685793, 0.6383530186534891, 0.12503415971699078, -0.5136093359130529, 0.47154544783744, 0.21872945454368994, 1.6662333160790104, -0.8657872285507026, -0.9957132659954708, 1.5152627601830135, 0.9899693953325424, -0.5033158480521018, 1.2440460773969588, -0.8847187806059955, 1.8821104177606232, 0.8062235965963276, -1.5127732121203115, -0.5771663565204093, -1.6460495310094154, 1.1569313708615938, 1.0677680095192645},
    {-0.6636598873809911, -0.41091605905119283, 1.4116037070310112, -2.6370564601868782, 0.25565431716050835, -1.56098859952318, 0.9526079264790125, 0.3955329543104577, 0.3203607208619602, 0.22830107125649743, 0.6506431567050767, 0.51917982562867, 0.06176143913469435, -0.24370937407029186, -0.24517305985810722, -0.5218715198754843, 0.7400749809333276, 0.45908516051786247, -1.2462720515012593, -1.4038862377974313, 0.5095697758103885, -0.16891338403052805, -0.7114593224475734, -0.6193665283161663, -2.7566396988353996, 0.5444837490299076, 1.993452020101218, -0.6262236665809052, -2.148120493158026, -0.736488150808843, 0.0007835772969324241, 0.26130390602623166, 0.43713690495905605, 0.15995698384994014, -0.6698458992860685, -1.0928198551192283, 0.009500935770674224, 0.19720285219597236, -0.8918403156959333, -1.5730040572836064, 0.16959685291975915, 0.688707898609122, 0.6623399869320495, -0.5297221716783098, -2.1410421949873935, -1.1347741981090376, -0.38533589409180846, -1.3720701399693864, -0.9636926620033832, 0.01378357432707821, 1.4278291002513246, -0.2849366589810017, -0.7564911512709677, 1.5465171102831987, 0.9149195129225677, -1.7599766000454027, -3.336052105791688, -0.9536050194871099, -0.7579136174404062, -1.5114462100820938, 0.19119509437806206, -1.0435124226223855, -0.10376188207953586, -0.9701907352461034},
    {0.5117428524476444, -0.2980830223602894, -1.931740817361533, -0.30443374400627793, -1.2781209404493372, -1.8340799265749022, -0.019318001244685076, 0.9436714923587335, -1.3621972273069736, -0.47416582469253393, 0.9646296823996969, -0.81775976367879, 0.5210824801044789, -0.32708156043936254, 1.1600988769596527, -1.8562003250582089, -0.7022438318619875, 0.5657252249373795, 1.2313399524171382, -0.2415244083669446, 0.0865068049296745, 1.4111895564968135, -1.6239417600159547, 1.143810852528764, 0.5885988435907894, 0.056553228895402555, 0.16657943844419026, 1.9672034917619958, -1.136649067992831, -1.1403414586954033, -2.5226027264690822, -1.393413537047106, -1.2656499713976888, -0.913420725270429, 0.28105909363123915, -1.282760579157798, 0.4125997785790231, -1.096939242223965, 0.45034692228225953, 1.6286197308250603, 0.4452860854302763, 0.21914798539238103, -1.0121315557721378, -0.33472873449910573, -1.0330335435735063, -1.8549534341029839, -2.1840934494511757, -0.5130218211535404, 0.8050158779237445, 1.7560754826300629, -0.4710059749608451, -0.14162786779057107, -0.5289405428617789, 1.3313272921155321, 0.48399410044095725, -0.28969830049497214, -3.3144902355605845, -0.6155677521819382, -0.43772563991280744, -0.6450995820636379, -1.5956603771568887, -1.8675677322639344, 1.0049969662302498, -1.6939096553019228},
    {1.53746449765485, -0.4851177257910583, 0.9044195856380098, -0.1510226858540728, -0.15478337019547034, -1.769636516666388, 0.2450971060665011, -1.0239070822791947, 0.176696278272142, 0.8517222725023857, 0.2741715933274744, 0.6539937133577776, -2.2061693674290894, -0.9398974934230442, -0.15073955511186435, -0.16443051335786713, -1.0628928970546927, 1.121738610623102, -0.5811849683175087, -0.7088483013592364, -0.46652790858915244, 1.0864906944311437, -1.9819804269884838, -2.794495066262831, 0.6012527588163958, -1.4778284091966785, -1.2123472829484565, -0.8162216082897626, -1.1153058671377665, -1.181980531975345, -2.1021461644020407, -0.7690008850909326, -0.1560410191313645, -1.1145307630489032, 1.2363033537226977, 0.14533379454459966, -1.0207630561398386, 2.1783539334185464, 1.4506074044864607, -0.7715464903249184, -1.0619180466369968, 1.1409463257927799, 0.6455741571010596, -0.6008744014335424, -1.5195974333470448, -0.4750931802753091, 0.18434046335779794, -0.2367751111044095, 0.38908373243545014, 1.1119116722800235, -0.6160737944472738, 0.7626476442971307, -0.1027836256771274, -1.1254407362274375, 0.5307680914788797, -1.8362178589085023, -0.15813148569588656, -0.5888945005821952, -0.22891596601807607, -0.5758252812273216, 0.07695571784622499, 1.0200531936266188, 0.03850583820077151, 0.4144604445349436},
    {1.2013267626922775, 0.44249599879503776, -2.4511674333520506, -0.40226561868722777, 1.2913482619124528, -2.6171609222274475, 0.6205731434392563, -0.9854488348138524, 1.0271027124429741, 1.528684535747312, 0.8143641499868416, -0.39048676039238855, -1.4969553127327868, -2.6384229138603765, -0.2990520980142864, 0.31801493722915697, -1.4279808955642481, -0.9464713861253475, -1.2236316241449767, -1.0439078745288413, -1.005398230543984, 0.1549112577932454, -0.3071590071059512, -0.8258483284371361, -0.5347384299670023, -1.6002874396903854, 0.04205559434194682, -0.5443297680167359, -0.6857427998331154, -1.4697885271874562, 2.1360009952956367, -0.06871291909235785, -0.1783579532488767, -0.8602860802151298, -2.314779469743186, -2.5723612634675077, -0.3288130824102963, -0.38436512049435223, 0.6976415421651391, -1.4685643640491484, 0.07657484531773882, -0.6106320373946983, 0.24029520907528565, -0.7212996968528566, 0.47760950750341963, -0.43584851864783963, -0.44150780125585193, -0.03584501372194875, 0.7069966213988018, 0.22527088595217012, 0.12496404476524316, 1.206059623548602, -0.4747697178965391, -1.1049702526604557, 1.8401246011386148, -1.76551823676422, -0.045974728294840034, -0.9397144720626356, -0.12035135597451424, -0.19105659151524818, 1.007034175071908, 0.3452100442694196, 0.6173692752484902, 0.01831778099334005},
    {-0.9139380513622638, 1.2766811700955711, 0.7855662280739664, -1.572608248258536, -0.8805329066617115, 0.17969665269794813, -0.29837306957767384, -0.40787602422404123, 1.0138902360526012, 0.16494997273923998, 0.7386055729719152, -0.05041665798612863, 0.8535908716319609, 1.1558447566116061, -1.213361647558634, -1.2022516809611385, 0.7464310448134887, -0.8883366200132046, -0.4281743006844098, -0.47851066259736247, 1.603209370859876, -0.6476053823323599, -0.15830317374306346, -0.30456745495103715, -2.501014330156661, 0.4451693993899577, -0.3672069316093005, -0.8601191976265795, -1.5775683171438137, -0.5543510141645206, -0.42223725860397077, 0.17443989337179028, 1.0582887272748178, -1.0890730439073524, -1.1956839288343137, -1.0245296575069602, 1.4901960443823254, -0.7423280391856261, 0.23588494450552697, 0.21696111697510984, -0.11532264159812712, 0.14927982120831296, 0.9733924482074022, -0.029811905487606656, -2.442126021666135, -1.7412190618856378, 0.5206445575957348, -2.265993300393908, 0.5745216049326839, 0.6748937169621263, 1.8400712699915676, 0.5011286128705088, -1.0372754472600265, 1.357841245804569, -0.9907759602339007, -2.5517466666731274, 0.8485555589225463, -0.6221772219809224, -1.0208085611875364, -0.560236940286459, -0.1955446842702816, -0.4850493502903277, 1.4755118918837344, -0.9931721133587675},
    {-1.2226876856065794, 0.5709875678010118, 1.6958279413088018, 1.4132116964140613, -0.8718641851081927, 0.08192223737865453, -0.39957883731942206, 0.5123576963895132, 1.5637851228649997, -1.4762731727300673, -0.7319066324500733, -0.4829439342782513, -0.027565194533649976, 0.6082558401098545, -0.04284519929397131, -0.3209416714215427, -1.0414419571025728, 0.9525457377816106, 0.03007935830606755, -0.7862816026925602, -0.5661968481457552, -0.6258930760070761, -0.4503906349733889, 0.6064641461161925, 0.35187574557374346, -2.1106508428778623, -1.0387878503730361, -1.1133745145106302, -0.615685657546652, -0.5586361287970839, -1.2639461904539284, 0.02479628269489754, 0.19648747290074167, -1.3687976762459126, -0.09993914253472008, 1.022702268461653, -0.8744938627709828, -0.24325364221395906, 0.0105379067678329, 0.29892940187706235, 2.082891170983227, 0.16222245718377135, -0.864085031414664, -0.36199601741757415, -1.2266062179252488, 0.08530776057556987, 0.14711007142079913, 1.0843830694693424, 0.002300088688553847, 1.7733632483645145, -0.5486230115212096, -1.485130170294136, 1.3914175594291156, -0.742583749466874, -1.0038083565519231, -0.18000704205650592, -0.1804052859566785, 1.0036441381645997, -0.6302763829612363, 0.09794320872050458, 1.7078057299473706, -1.072365264998566, 0.6465101152913508, -0.4739660401540133},
    {-0.21393602078342583, 2.6184306080330906, -1.355799922418808, 0.3220289548654926, -0.6523376547028897, -2.1754823869740663, 1.7166821288255742, 0.7442981433442402, -1.0469774059825923, -1.435258236391592, -0.18628216254045477, -2.155338388994811, 0.31424912948423284, 0.7997109577718776, -0.18040718740838504, -2.0256780157727228, -0.3383300196755926, 1.9824154624808072, -0.9330145788782628, 0.10008622990735178, -0.13236989066771326, -1.0868696011523553, 0.6093351451583782, -1.2551488923920673, 0.5520653253202484, -3.2344420132246183, 2.03201048184391, 1.4615443584774204, -1.6890645458509048, 3.338549076569751, -1.5595911769006332, -2.3566573743886936, 0.024446013625855044, -1.1938798721226356, 0.5341940938795905, 0.3334004891415108, 0.7249872830508991, 0.8464248130794224, -0.9534983165591266, -1.6560185295860501, -0.16513599292293527, 0.20361564579764968, 0.23727385022041872, 0.287916611892022, -0.6034171947926862, -0.14543932914087673, -0.0027618888010011687, -0.7313553630562454, -0.6455766595756351, -0.40784322239956683, -0.5870656167666823, -0.6677279523579266, -1.446853268926002, 0.3835185341885944, -1.2746299229756495, -0.29942830563463013, -0.8598850882647976, 0.27817146957149275, 0.13935779620163694, 2.1683356804393648, 0.5453420558792498, -0.0391639791192763, 1.3075512722119138, -1.0423669972496932},
    {-1.4158957041934286, -0.32474027191700167, -2.3072526622262086, 0.14074874746755855, -0.15885626672508857, -2.3664669294408154, -1.067942315956327, 1.6167195645566013, -0.9043589040535466, -0.8634820234620524, -3.044094102925756, -1.82842272678326, -2.2513042874347313, 1.7132465008115145, 0.01481564013521897, -0.8279312885099843, 0.3333796855967582, 0.08261563371573377, 0.12478762467831066, -0.8089704870050634, -0.33914994749961885, -0.8130415924521148, 0.9146141777480441, -0.6456349172535543, -0.1498518466277398, -0.3404344799284945, 0.6330019871980005, -1.4745147430626648, -1.0211486082758956, -0.9036529023269818, -0.3482635844636369, -1.1578658322514386, 1.1914856870206454, -0.019235528198662397, -0.6196693665609949, -0.9861923701438435, 0.39208236528219936, -0.648729873248734, 1.3120625590497383, -0.9329135027661463, -1.111347242365674, -0.33989654370458616, -1.3379976781604919, -2.2968876481267237, -1.0974324067722951, -1.847639868182577, -0.7598393441921392, 0.5591575860770651, -0.5833451291761144, -0.6929983435100611, -1.577546635518341, 0.34169746118767275, -1.549985744571409, 0.0806561632017558, -0.6653489150721082, -0.23917897001008875, -0.5581347761731543, -1.512850408406934, -1.7845205953396879, -1.0294058682894505, 0.4270319084164436, -0.09453163492153176, 0.5414165265456489, 0.9824871963373136},
    {-0.059318015312393994, -0.5602806577845759, -0.5658782936722926, 0.04885848102492547, -0.9906280974007088, 1.4683368552558578, 0.10163570355058638, 0.20664979592632712, -1.1436306556718474, -0.3692851490534558, -1.7240907958676035, -1.0562716752661847, -1.6985132918025316, 0.4949138407181616, -0.7328180939750439, -1.5638670591283386, 0.1452472205596261, -1.5219658233234665, -0.8487951709088442, -0.11557674923015375, -1.4603483048392938, 0.2146503656836251, 0.9689471045781337, -0.4169525688041268, 0.10282624906497131, -0.7931562666433469, 0.3054963007501228, 0.617198374866014, -2.1370932722804783, 0.5257840926360003, -0.5416900216307222, -1.5354521190029198, 0.46954537872708235, -1.6267911716416519, 1.5728199995847805, 1.168321759787201, -0.3586721543662166, -0.4607599718955488, 1.030393626485401, 0.43586348937695485, 0.8150340973210004, -0.9818512389503029, 1.0880710871385615, 0.9921313017791772, -0.34257495326832793, -1.1474597239354472, -2.615972334817388, -0.09142149531440881, 0.33759115049571287, 0.031124787282185318, -1.5220970312708408, -0.3397435575781089, -0.797807356397417, -0.44209469768672677, -1.042163338375721, -1.7761038381992853, 0.9832572882269117, 0.2085351855162412, -0.783681031753879, -1.5132893117376367, -0.4319477287981456, 1.19840241621796, 1.3467634605915166, -1.5027821025456423},
    {-0.08172066979427026, 1.901255457032325, 0.18021007626597063, 0.3549760426434667, 1.103739512180419, -0.8964601854850995, 1.3079877359810321, 0.06336500546758836, 0.10682194189887968, -1.8949427803058037, -0.2614583487193615, 1.0015175264075267, -0.43582801309768465, -1.2405004526561774, -1.5012155898861586, -0.8740979668015215, -0.5492231892820185, -2.044156163694223, -1.176661821714056, -1.9308528747326676, 1.0080497805790882, -1.7848704819307724, -1.0545045715753476, -0.3653711809401673, 0.2693401320060394, -0.2645937472176465, -0.1718405704398201, -2.1663286767397856, 0.8595374779337088, 0.24975747871816964, -0.1626746183562528, -0.23248888794939188, -0.7811734546532927, -0.4080792443650511, 1.352833335219804, -1.8365305497811872, 0.09087158575727165, -0.08683665029480335, 0.8144391190025471, -0.15914790754991343, -0.3486058365681561, -1.4246782461591954, -1.1163624054256127, -1.037779997630649, 0.11318365686845806, -1.5037126837835575, -0.8878912767365842, 1.0983556621491668, -1.3525975047731786, 1.353156649493751, -1.241178419466471, -1.7651325877211022, -0.21156440684154504, 0.7462278726265071, -0.9563390421015479, -0.1530460835778832, -1.2064027279760576, -0.3414898243638611, 0.6948759503829502, 0.9264182704789089, 1.177753712437744, 0.12282145157156368, 0.2541265118325823, -1.6793850125290486},
    {0.39061995824900125, -0.020353475981242136, -0.8718670347608014, -0.14893217048102028, -0.5161086034773761, 0.432783876692406, 1.8388072963701698, 1.178428469460745, -0.5334064214057801, -0.96167511983631, 1.2659920527877877, 1.5508488351934142, -1.43278300952903, -1.3151385727245721, -0.7653629616253544, -0.16220974814313932, 0.9149667386832875, -0.6955234388465222, -1.0102116782779726, 0.6755426979988964, -0.15421103437590325, -0.9257218442792964, 0.06581192403843639, 0.9618764352417709, -0.022541672549086608, 0.5731746539593253, -0.9370850560775152, 0.6264511009087411, 0.6200388999547884, 0.27615335583157563, -2.128849357012823, -0.4160495492618702, 1.8870996680121943, -0.8646093071724278, 1.1360163778652599, -0.18574182256839003, 0.7603317654636186, -1.421683380276552, -1.5052519248355185, 0.08434955903683873, 0.7945538618250909, -0.4934371381406771, -0.38265840160147924, -0.6500518916764573, 0.1273434179438353, -0.43065229645222747, -1.6433706568845348, -1.1707499025051769, 0.8007990131566253, -0.6482940081481268, 0.3503933136599931, 0.3372409141499436, -0.8702404323622338, 2.2184836637428464, -2.935718876345733, -0.5592034973974669, -2.812252520569869, -0.956972463740227, -1.0423723747392843, -0.415652583909737, 0.35498719208660895, -0.33076801911193554, 1.320483712389723, 0.6614803315127017},
    {-0.14415669513585289, 0.94448264199375, 1.1029163747042505, 1.1923613027256232, 0.5383775303663713, -0.26744676066734613, -0.07430609716898139, 0.12135650429761481, 1.166476706443002, 0.05988699692783986, -2.3563223147241605, 1.808645142436148, -0.03265316496816183, -0.008522005187339489, -1.0322522417414162, 1.1621420656346229, 0.7079650896059594, -0.20392001740268223, 0.28146610790892934, -0.34733305531454567, 0.3297893647438937, -1.4304393194678002, -1.0662052709996646, 0.07647859705324916, -0.22622493102949148, 0.21402351870494787, -2.255782044493738, -1.11736278893087, -1.3496366485356779, -0.6244535347209236, -1.169537844157348, -0.43441610436268, -1.0572194018484202, 0.00095721842471815, -0.5104869015181273, -0.16257388589312297, -0.05238587339985926, -0.7511993796881431, 0.5868914560647359, 1.1617984697174324, 1.5211835607384285, -0.4818545038463121, 0.21254458392983788, -0.20198662244420792, 0.524705224473505, 2.080384024684327, -0.5718566974372724, -2.291952604453333, 0.6390566430929627, 1.171614915145716, 1.6957944333435975, -1.2508611593306675, 1.4505785692683062, 0.9370541347201925, -0.5815121114967822, -2.4752731676373303, 0.7522540126897406, 2.6223705921412432, 0.5294333133076794, -0.13118684524820967, -0.09208483698980058, 0.4295164308391388, 0.05147674993043641, -0.06743793358728858},
    {0.6941671205889779, -0.00081486748162355, -0.5546929537881318, -0.11379496786945165, 0.3813110177807961, -0.5930129792137909, 0.039320934050792705, 1.2190190110682744, 1.10007521349001, 1.3740075384600388, -2.9290817724100733, 0.3224714573786729, 0.1170961272779562, -0.2837376670141832, -0.727194064173558, -0.4131523342989262, 0.6690896943249947, 0.3071275340454119, -0.7644975539564057, -2.2220645918339788, -0.04795685477316423, -0.38139585298062434, -1.1476359806255727, -0.735072631482584, -0.33865510282977634, -1.7284429162759116, 0.662189259667516, 1.2810493364883868, -0.9532900232237271, -1.716808345036096, -2.271226980076667, 1.2931464479167956, -1.3672096630139103, -1.8355366193664973, 1.7917107826079175, 0.6577124403730303, -0.7625817522909173, 0.4400695198682566, 0.07780398398490537, -1.6471866458914646, 0.3656815597992461, -0.37703786698956904, -0.892517842735839, -0.9845226885619108, 0.6477358750896635, -2.1161909827129555, 0.6491930059264347, 0.015076647046004777, 0.751096719039409, -0.5509772052030508, -1.969208868254498, 0.26696704025431806, -1.2751689766344505, -0.5417430510528747, 0.033379950821709505, 0.3482294887182479, -0.5215497168818641, -1.9194117733246543, -0.6222384279284113, 1.301550127569214, 0.5962704315037265, -0.4769536158194702, 1.3884847720654496, 2.7700304414138275},
    {0.188865150830981, -0.4562477954426936, 1.118391825432883, -0.9296815925774776, 0.9156088578439229, 0.7448185612422591, -0.13125545179889062, 1.2656256536125552, -0.9092999716499727, 0.5561108342158922, 0.36143618462095983, 0.3961421165115555, -0.7597455333871973, 0.07994665502710539, -1.260356847776348, -0.20100658746719738, 1.662778655310599, 0.518767232306715, -0.5575688019567592, -1.8644366042880935, -0.034922842018181056, -1.4876039523947713, -0.7273097535059385, 0.5393383430975498, 0.8740948353309963, -0.5518322602161629, -0.49302494709070427, 0.3942557560424119, 0.008789387809314564, 0.845765905449405, 1.6604017861309865, 2.3799134366658685, 0.8927929784555657, 0.36416634379458657, 1.825279384783823, -0.5666134246628053, -0.2178200336773892, -1.2199102348790423, 0.8272889151105088, -0.46167979396541237, 0.023305341430897967, -0.5020131433767885, 0.10952097537813389, -1.0572914260478643, 0.23742361428847195, -0.32547433526944614, -0.8325856219407981, -1.2239363307553321, 1.7646090394928857, 1.5829742542308896, -1.9406504373801825, 0.3757742646530216, -0.4659743578366778, -0.8307762071514708, 1.2831614968525995, 1.348292854788454, -0.37821264317679665, 1.2510823704158813, -0.1271513602901139, -1.3305821896911019, -0.16557350409835458, -1.5085555139895408, -0.7298217652757333, 0.5322684946006405},
    {0.6640162229559553, 0.17777330168170097, -0.016025449016351456, 2.5510270394771655, -0.614273204135841, 1.4697723363714876, -0.9030440129614166, -1.0681955249021662, 0.8859945066392365, -0.22459400715218178, 1.143993510068632, 0.7621876586589357, -0.882364477026637, -0.31585684677615367, -1.259251800977526, -1.0520480401797407, 1.0653776969633408, -0.41274617793449686, -1.0950115907118483, -0.0750330965259074, -0.7276642149842659, -0.9799466943182416, -1.4400646445743108, 0.3075762416119783, -1.4057655784593224, -2.3294619750347434, -2.277961769273292, 0.4266822881354841, 0.14712639381410794, -0.9858783632187983, -1.8437281684803841, -1.896205268824984, -0.2950273576384922, -0.5501126281537568, -1.8403719930696039, -0.9300386153747536, 1.4150823766490754, -2.38631424506743, 2.37392530697181, 0.40677606751890893, 1.0820908651878416, -0.852390458145137, -2.1975245788450377, 0.35010290051221643, -0.2522648422730543, 0.9219001273969787, 0.0839942241323566, -0.7335107281335768, 0.34772079613658136, -1.0082616985820145, 1.9464376032219999, 1.764854181335589, -2.933168637401382, 2.1841660270016314, 0.3715719130768347, 0.7424026681830833, -0.8378128297229851, 0.07508072776987058, 0.3431544783779436, 1.5798592357112193, -0.31403806399726303, -1.2227653671844765, 1.0584873069745013, 1.073600560927046},
    {0.35359515139247794, -0.03968321948365214, -2.352005169600307, -0.43377784389611695, 0.021702161537906453, 0.4080942750341273, 0.6601249895828813, -0.9440067867468285, -1.664637539611453, -0.5710839678533003, -1.2896099890548804, 0.029433635149024657, -0.11792473544120197, -2.1295725373849543, -0.33018834710387795, 0.8450290545501394, -0.888488955483384, 0.4988522910268605, -1.6197738081441684, -2.9877718016875128, -2.9425828302767596, 0.4911222976501126, 0.6511648698522479, -1.372399959714785, -0.2881577734483891, -0.6251375864747033, -0.6914454131738551, 0.7229790021065109, -3.3694709236278735, -0.6049537934003462, -1.147584780483374, -2.1973302080469974, 0.9217018069682198, 0.20929419238844726, -1.4454674258583657, -1.4634496969610469, 1.1563983772189983, 2.6186772576274264, -2.2868396141391045, -1.1249586082323222, 0.8638758822776234, 2.044949401667495, 0.28970899778120285, -0.6536270391642711, -2.785094302158006, -0.27977672175188606, -0.18274482997795985, -0.18648715575645874, -2.1910419913465926, -0.15215377646718498, 0.32446658390106603, -1.279252435047192, -1.493619211293453, -0.15139797635915925, -0.36761998310594457, -0.6273362410113306, -1.0144243093549108, 1.600378440814292, 0.6471473338774899, -0.0667323971286159, 1.108168185290621, -0.6171996771304805, 2.7850272774178464, 0.7097377183749513},
    {-1.8939575712469952, -1.239539365386701, 0.17210642107324892, 1.001794761423147, -1.5018816680722238, -0.9247670894270237, 0.6785633433361058, 1.6303607858807716, -1.6223772402654464, -0.8187468094824301, -0.3400174329954351, -2.5951396801513877, 0.6104799932769732, -1.7794513707022626, -0.02769829125605846, 0.06908806236376167, 2.6990156108968395, 0.8263089870703461, 0.6388389175136379, -0.46343725389731305, 0.3617162515169222, 0.7001107131277247, -1.5328383679237694, -0.2556885977665518, -0.5663679117521839, -1.8824431223112668, 1.090615283878662, -0.20003336907315084, -0.475851463038132, 0.19215583345253476, -1.9825571882081818, -1.1619337019715525, 1.0647717404147652, 0.4023187123817595, -1.9778072660419161, 0.6743358778752775, 0.8138633818729911, -1.310184440699376, 0.8074113154863327, -1.4772523983118961, 1.1046844850521274, 1.6541959071101064, -0.3319620655244456, -0.6150757457588982, -1.8213003587787004, -1.224551477620298, -3.744171092002861, 1.9020819289957964, -3.1001848714831137, -1.6740667048250972, -0.6738323069410631, 3.148664201813069, -0.7633913850283626, 0.27682827690014933, 1.3314601694179207, 0.6152768340832234, 0.5158659805692287, -2.8833254800153507, -0.6112197485052766, 0.5309395548089861, -0.6179421163858045, 0.6910938021472612, 0.8736964932029525, -0.5643130564651251},
    {1.858552459747393, -0.31730172635443554, 1.4858026498390933, -1.2126989595670559, -2.5712860709825, -1.7157935267733537, 0.43164717559826854, -3.067307201073943, -0.713387551655347, 0.49074969395451346, 0.34123801261629905, -0.5577803978285057, -0.5024275912124228, 1.2516660360058174, -2.3717808332987764, -2.137062949579919, 0.9013795720672025, -1.163742640272273, 0.7456163094030219, -2.6267020997164865, -0.43040924755404475, 0.04426945235167495, 0.9316270914640423, 2.1445677262336043, 0.9772222114461496, -1.959673714161063, 1.3640900009690333, 0.26173754381595943, 1.456309429261903, -0.43775251075086147, -1.5254921216633615, -1.474121356739003, 3.23968605586371, -0.9695434114715397, 0.014428446931131577, -0.6844137058960237, -0.32400140158367113, -0.37016410961202634, -1.4915050231050746, 0.7968093343701973, 0.451366962484406, 2.1706336770270034, -0.005027268082609075, 1.5868274345973412, -0.18068386299386827, -2.567033963343365, 0.48365923628859103, -2.142456653230361, 0.40474288183709084, 1.1078662995568174, -1.7709278252650478, 0.7730010457264668, 0.5947504509116248, 0.9767936159226561, -0.6241560256598191, -0.1530057048539954, 0.92546549189934, 0.19992005089726414, 0.2296519962707809, 0.21022097691133365, 1.5056774989589137, -0.5349439256841578, 0.6926236919913265, -0.35847072508570843},
    {-3.7465184105695344, 0.9849080922774182, -1.384792301837688, -1.3951338645134281, -1.3706277293703517, -0.3479968633143903, -0.888934118588415, 0.9221947348591437, 1.3174281286189784, -0.07787231132356671, -1.8410987529967588, -0.5879787711730208, -3.342132735731869, -1.1831854426492059, -0.7644214794651002, -0.8709020701968333, -0.29549686662254004, -1.793196028540589, -0.18328012977722205, -0.07280784487375305, -2.282885962205146, -1.0537060446140623, -2.2690320392326773, -1.6500388622309585, -0.04062303124834276, -1.326388764196929, 0.023376529748526022, 0.739637849644815, 0.40323011366244416, -0.029531207561511324, -0.561179321341016, -1.1523814215271972, -0.7055125913070013, 0.13958951445004192, -0.4783085544257952, -0.6638816770302332, -0.7585384627898166, 0.47969408929462204, 1.5657740521117478, -0.6545367165600294, -0.8503714869987201, 0.30486310151016044, 2.1913576417881107, 1.4891251447434097, 1.530627023364366, -1.377226268218032, -1.3053984527067142, 1.030138068595559, 1.0492654581971288, 1.2002314052898153, -0.5645441928677329, -1.0413102526370706, -2.1374442735415267, -0.5726752658605049, -1.13387759355835, -1.895020447644295, 0.27540535960123436, 0.5419364788152448, -0.7352390722684515, -2.0380592689547563, -0.5996177667144693, -2.797159639831543, -0.29424451567936566, -0.46407381170052575},
    {1.5412847532245366, 0.07687698508587046, -0.08529224374237598, -0.41101986254877526, -1.8202384596323564, 1.3487490632172983, -0.9797577130657669, -0.14290459483242202, 0.0023641992275858434, -0.5770193576577589, 0.18572170842759553, 2.140327574135411, -0.09579273659521659, -1.8816950142495634, -1.9035642577003706, -1.2832205201225308, 0.5717160865096029, 0.14323259013420198, 1.0782114775472083, -1.471548818997188, -0.26172141995361364, -0.48810977592211346, -0.5124885809346168, -0.9124640448932483, -0.5334524228312397, -0.16361319394375134, 0.3828995962258248, -0.15249160071008347, 0.16037224622722368, 0.10809605190295357, 0.9579069767120898, -1.3269986270048668, 0.0441463668929716, -3.254504475852269, 0.1583309500550518, -0.986334915020734, -0.6090541788016594, -0.5408680478497686, -0.7391374180105632, 0.7484792481239204, -0.8749329666779998, -0.5683309941618544, -2.006921075685275, 0.5001509738644453, -0.07138598318850532, -1.5031420058769207, -1.7531316806419515, -1.0837259328968487, -0.3834774390038449, 1.6087461040516096, 0.5525885222644044, -0.2988781221542797, 0.11818594598562969, -0.37594583981044793, -0.27397008701395026, -0.9564146808558842, -0.4004722033227241, 0.7788378500187279, 1.0415828997313508, -0.4774421049099334, -0.5858493776759448, -0.43457967348198995, 2.0546387598317084, -0.8510060107362892},
    {-1.0490270592736917, 0.06437419922907202, -0.5530813338624597, -0.192072105536733, -0.8427467215272105, 1.3721117761234811, -0.7879158338119854, 0.45049632545129836, 1.3886045680632464, -0.33122110794696413, -1.2231019808424914, 0.79400147631927, 1.0826233350520185, -1.177940810095578, 0.927998918109155, -1.399656713582547, 1.8214582567485398, 1.9071766834735608, -0.21478735231094062, -1.4827893367324463, 1.5608435118986357, -0.10835825733042773, -0.689171824071821, -0.39425768166157427, 0.6982141413204677, 0.2061578981256923, 0.7472922481848012, 1.2134269441384544, -1.240177675156859, 1.2288925248682516, -1.1585443586509823, 0.08401806711212721, 1.0412843676864023, -0.48334474911076736, 0.9764510594011359, -0.09621325728591032, 0.09364512490386273, -0.2771126749226583, -1.9700387765603364, 0.7099731418137535, 1.9156403663685198, 0.5878471507168611, -1.8970307795974848, 0.3896468652620504, 2.4810541446866226, -0.9251805714399901, -1.9243210369475932, -2.4747729706502457, -0.08061359259013637, -2.002508012781572, -2.28599548289893, 0.30507551296048857, 1.3549539537376272, 0.7218708894279956, -1.6421523297446692, -1.5066302466675727, -0.000470711432990362, 0.30501025777592955, 0.9133370619484549, 0.08711133573066335, -0.8748127064015788, -0.7638514268758158, 4.773085650596559, -1.3870573340623986},
    {0.619967668966741, 0.5156526549352456, 0.8666321755116746, -0.1611598793750081, -0.43827489455231344, 0.4991096599643098, -0.10631139110373342, 0.4523821373000474, 1.3851464606128512, -0.3499557399511846, -2.335011497083872, 1.4520541614613436, -0.23116955239641093, 1.9720821912733197, 0.9135174050350079, -1.5262841310362631, 0.1863865213066013, -1.0024130051129407, 2.232074644927967, -1.0884339247816786, 0.05587377481475442, 1.7691488433173916, -1.7250729818272346, -0.608312311803163, 0.6054744649953862, -2.217027216505285, -0.9118448362981575, 0.2959134771480845, -1.6785099847963327, 1.063642238384094, 0.49215617237298176, -1.563440316049113, 1.8110600280183493, 0.6376336668410236, 0.7582319476101769, 0.9840798848378257, 0.8057060420118696, -0.059048450992304644, -1.3773889968364819, -1.2001635106954498, -0.6748102165103887, -0.24585428701049972, -0.648406892138731, 1.4269210837144375, 1.456030780222561, -1.0816927425287695, -1.5694193144313826, -1.954165263264215, 0.2694585732191776, 1.4114316532204292, -0.4372705085986958, 1.9958598175441085, -0.5093535137338403, 1.268217934869968, 1.3626103669745535, -1.3218971120454275, -0.6148679010676223, 0.3351841679894792, 0.6276278757588605, 0.0806492106279693, 0.9360128546593944, -0.46845911733515466, 1.2997037986852986, 0.30807552933055543},
    {1.753604560114714, -0.06042832190713273, -0.27289549408341884, -0.33639720949406027, -0.6897752185128583, 1.8032700999665405, -0.039595709567972176, -2.1433249609219454, -0.3407479393627697, 0.43312116778836907, 0.6459198681065451, -0.6441972396372984, -0.5586406324807097, -1.1657686848502973, -1.4116149507463824, -1.6517783465807225, -0.021054644364194373, 1.7242945671764591, 0.8449359725376068, -2.977554561339676, -1.2686382395210252, -0.8168929203915847, -1.1331480178517277, -2.028606665948413, -0.16882954701331188, -0.2419630798481286, -1.5103382399651726, 0.08057771175553109, 0.32945572970210785, 0.8358076532264856, 0.6490513316897436, -0.11576530343361317, 0.37160624874695025, 1.9727821255728022, 1.4316920081297233, -0.47160272579249657, 1.0945049661757613, -1.1150782897860099, 1.3049363226922208, 1.4786380805285035, 0.9709625250437491, 0.6704566287779288, -0.4630709688046679, 1.5200732023834451, 0.851761233070554, -2.4239040244979995, -0.5298373749675538, 0.5676760036959883, -0.345255466426452, 0.9748004329447562, -1.745171558985715, 1.557330092011993, 0.7846521485996559, 0.9100350633175958, 0.4276242484968619, -1.992300767852311, -0.5175831843213343, 1.0041101322242623, 2.1845573414419124, -1.1385830779704864, 0.6850699676176455, -0.8666467027488578, -1.488917511350386, -1.8061791783234709},
    {1.823513787879955, 0.11376298051914217, 0.056714866753696046, -0.6113860668084683, -0.9707415184521346, -0.6947917833035768, -1.014342828957826, 0.2834563283824835, 0.5322252009747742, -1.1099363085933367, 0.20735257023735718, -0.007948269608309667, -0.8785766229365989, -0.7202743816858492, -0.4717662734021138, 0.308333343212532, -0.1509057942234226, 1.3774144371374488, -0.7905108570584811, -1.8170891937152798, 1.90231381700127, -0.28963523720946477, -0.4949982413590002, -1.3609280272443487, -0.18365699407889882, 0.18112664053307534, 0.1858444691310014, 0.5001145345736002, 1.7375982803798693, -2.1957601285498707, -0.045697224737539295, -2.3195671012002355, -0.2917563713894077, -3.665014256569231, 1.931680628889415, -0.9012929013682239, 1.7325305548539123, -1.8607507429755767, 1.4879428232291931, 0.24993522870365842, 0.7427602766078193, 1.0939913921623858, 0.7758089925300197, -0.48635123723764145, -0.07571636343903364, -1.094578056653038, -1.2923889047945367, -0.9771746480161814, 0.2592618809661522, -1.4480293708295529, -1.7751856551736949, 0.23399587501330213, -0.5320972357910378, -0.16175247565756476, -0.6503732241261996, -1.1031472432922569, -2.103260205602215, -0.30975687850971373, -2.197452060188666, 0.5881635629480094, 1.0845211869223093, 0.08889895010896817, 0.9535779125671227, -1.1835672219952824},
    {2.7798574271214016, -1.4429010731825778, -0.2802859790226795, -0.4214083508187335, -0.8317962895746894, 1.2120650349134447, -0.3123679620706278, -1.2255081818204938, 0.276002872545755, 0.5233492575422344, 0.5232079332385902, 2.3416361690370913, 0.12281664079456708, -1.3404174535526117, -0.4845768114936267, -1.4693111672218906, 1.3526023824425628, 0.1798486186668112, -1.4717372769914057, -0.24905611167140848, -1.5248724177542385, 2.3134608741960023, 0.018275984380797153, 0.06680574523687456, 0.01902851052941355, -0.22498354013568087, -0.11885371913379768, -0.4144756569312222, -0.9489286479488174, -0.4310808092209935, -0.21433976201513572, -1.4230624209185854, 1.3148430882763416, -3.1729539043539883, 0.2092525149046411, -0.7975076596547561, 1.1126946504555733, -0.8158341525046533, -0.47713820575537313, -1.5718528431708214, -0.857571849928411, -0.3775945746827432, -0.4624134610910338, 0.6294729251043999, -1.690390430123256, -1.7757983592616766, -2.4379775925169596, -2.129038017119154, 0.9312292709978532, -0.3012241549394637, -1.2750622983827484, -0.2878140704134139, -0.024567999898775113, 2.6925672766193083, 1.0452432790650892, -0.18839908610070333, -2.104798298756776, -0.9797002775002122, -0.10100587527270972, 2.194387719520935, 0.10221501808296327, -0.21133133805692236, 2.4466455602130677, -0.15997935587572448},
    {1.3137539408767263, 0.11217385169115711, -0.2946417948264533, -0.37534662234880195, -1.7956426744457314, 2.4078806080779986, -0.31560206391133894, -0.44825337221784906, -0.5279269815465685, 2.5972198454230138, -0.015396585075897836, 0.7605468175233601, 0.12880113444127533, -1.388762075170587, -1.5136997259248113, -1.6558379140149309, -0.441162435214594, 0.8346414049453937, -1.5669712020066615, -0.7409127499146858, -1.3470385653794998, -0.3188410063312921, -0.6125934860670175, -0.9382314741230027, -1.6472232196747443, 0.2860620817456272, 0.4825234862517487, 1.1559939045495455, -1.4156180098456166, -0.10914925581639165, 1.0010803117384692, 0.4788026086557975, -0.44419799175863295, -0.9742671579002401, 0.29232807068563743, -2.234797927570622, 1.7289273090173978, -1.0134125870706194, -1.3030723460967923, 0.02952055890264505, -1.0820180593553894, -0.7450061167961426, -3.4312861523936276, 1.0645054937205811, 0.4377139607626954, -0.6496599254227641, 0.2665173531639457, -2.1286848854801352, -0.17661737025371183, -0.2650113389253778, -2.5534454279420493, 3.05497077920212, -0.7826148802452774, 1.3464141579703308, -0.943183073260939, 1.924933753953928, -2.5654651710183125, 0.9735759014250834, 0.4955991525223416, 0.571362716838592, -1.7504150205367157, -0.6720382542204135, 1.3192743052625189, -0.5995507145771131},
    {1.1708528223200367, 2.826853219871956, 0.8084983458892717, -0.5747464848618565, -0.7275668098332871, -0.08257626013043864, 0.9903158535326754, 0.15472811520990165, -0.3757274229501481, 0.5318405253106819, -0.7709647571184152, 2.2193748291915214, -1.5429121833901152, -0.7021918023504808, -1.6964895459244014, -0.5698399694872717, -0.6009124202368138, 1.8041604474225081, -1.6305102327939054, -3.470741064497338, -1.511351260917235, 1.2444750394335362, 0.7982766766135523, -0.7673778560269946, -0.5796767686705321, 0.6177711843552358, -0.7625951756352942, 0.06386871696914079, -0.08022689326246905, -0.36046432860934813, -0.5583673388461795, -1.7668946523314015, 1.11371008865903, -0.9757742538278936, -1.2193338105626534, 0.3055345179661429, -2.244345577977503, -0.2514798304796434, -1.6221861768348218, 0.28258593697931855, 0.3625457750920122, 0.7906558977066463, -1.5358714677804333, 0.8177542324532526, 0.2250155251575931, -0.7092401308065666, -0.11021369422244427, -1.4630583144241467, -0.04681970623336497, -0.2129454458891124, -2.276977370216118, 1.104447435472854, 0.25085249511187524, -1.0017379829324067, -1.169741204807488, -1.1495271027410074, -1.8070096294861424, -1.6685141958824006, 0.09134429813425314, -1.4572939591936003, 0.7016062540446483, 0.06481149960561326, -0.04006150363694718, -0.32569254888769467},
    {0.03648119176398566, -0.9204908027015287, -1.2523077427990457, 1.4092689959329896, 1.3168672727736146, -0.12430363818585427, 0.3445490238249383, -0.7696540958184663, 0.07138999820659339, -0.4005202355479879, -1.4328134848872869, 1.7402165135968604, -0.4492779444798276, -1.9540876184015434, 0.4307649818219557, -2.494983564532601, 0.8660048717923416, -0.26226417570301425, 1.8281108193270463, -1.894824955085586, -0.861673954945046, 0.4011504419252189, -0.06537926909203405, -0.24328656734803722, 1.2418161175700784, -2.4402578080829507, 1.5008418525954814, -0.540701852559442, -2.316329177404458, 0.8434988669691329, 1.391059832006714, -0.12960688938337084, -0.9348716863522804, -0.6110278182435596, -0.3678958322630142, -2.0737399149648614, -0.1928073180811037, -0.4862997957684641, -0.3095260028075899, 0.2659881736086823, -0.050050943038329646, -0.78204200991719, -0.947791866918014, -0.14308198979815545, -1.4003717160023983, -0.7353291248207741, -1.370214395110371, 1.011976767363234, -0.214262275079643, 1.0998420966251348, -0.06211695889247902, 1.1649140365062294, 1.371692255392945, 1.8061785993767325, 0.9271141307868147, -0.6345980635382596, -1.1568128019413384, 0.666162441093632, -0.4759641160329722, 0.3417730539397718, 0.0558174283108428, -1.9753870483015006, 2.2837141122571976, -1.5405926093500044},
    {1.2343527275830743, -1.0941093453594875, -1.7533427310618273, 0.8990622828696384, -1.1569449838436858, 0.3415612901941507, -0.811134757057658, 0.13322755601090674, 0.14566696666225068, 1.5048987529813298, -0.07332503882794535, 1.485618341165227, 0.6803714259065343, -1.6919013757346166, 0.06648800338378731, -1.242575735058116, -0.31199258822056525, 1.1979320536028486, 0.1884562732268857, -0.5598557138276622, -2.257595338565055, -0.23499591609230328, -0.6450223414399388, -0.13766633609389767, 0.6291935874609851, -1.2079115820573898, 2.2961162101717045, 0.6538016690019035, -1.6339847582424032, 1.572097565462635, 0.24559316833780917, -0.9144398050316312, -0.7331080803951047, -1.1641613191116567, 0.9314875468539537, -0.7523475991531869, 0.41155434352439707, -1.6819484115902519, -0.9448759952282072, -0.28816342828216157, 1.7505052074037928, -0.8885995644134991, -0.639455508940441, -1.02593186707202, 0.06189880463616707, -2.2621513397933573, -2.3530591353182477, -0.05905448703108209, -0.9110189788560854, 0.5726459477930748, -0.5027939798448122, 1.6680291123219895, -0.3669277915473135, 0.22762651385960433, 0.9656186431152207, -0.474989481361463, 0.5454517641206015, 1.507808630557622, 0.9902003837990514, -3.208689960285942, -0.04703242358531265, -1.1801334944528674, 2.1661906955175643, 1.193302100030846}
};

static const float b1[64] = {1.1839247542106, 2.0356133942041503, 1.931947404823316, 2.177662038679329, 2.133881300360453, 2.063399840966964, 0.8156839825625464, 1.2851781730070082, 1.0046403496638556, 1.866513690025823, 2.2933277548757816, 1.952318299239294, 1.6012132442576734, 2.230299143946924, 2.189765650599757, 2.2234640528737004, 1.3688683134410993, 1.9792021710027798, 1.944748165070413, 2.1807020113727993, 2.1180804390473242, 2.206409412298299, 1.5021512848848946, 2.4418163485078925, 1.935427815858973, 2.18788297550145, 0.9323982589716155, 1.4817869745074987, 2.235666718712582, 2.2314586593575685, 2.4038428976781456, 2.1698901051878723, 1.9386068273388783, 2.416999171708177, 1.7122360407927475, 2.0440074807452233, 1.2408712008150498, 2.0122668030366206, 2.1493882051060385, 2.074686097426061, 1.4736934357520075, 0.8826717204424828, 1.8317520984272844, 0.25331451294278345, 2.296202193409115, 2.2740816474598096, 2.163162599079143, 2.1404207087346867, 1.7948542213233554, 1.057681915269404, 2.050450785504866, 2.2924061563763054, 1.9703548513508033, 1.7594782592222478, 1.8224357654168721, 2.2861133933401687, 2.0887933397496687, 1.355281790772625, 1.7311322057925038, 2.2690074736351296, 0.2217595550228569, 2.222163764913065, 1.8578849357030722, 1.7556027736491837};

static const float w2[64][32] = {
    {0.5520558483663448, 1.1154435791697677, -2.136435577896336, -0.5375946438068859, 1.421994535889351, 0.23650505357323437, -0.4959372300845697, -0.014628391386938538, -0.0764305588918547, 1.868805170828804, 0.4175207911286612, 0.6342158809982222, 2.2717176064363693, 2.1472551858335387, 0.1955376541578121, 1.5593998124468995, 2.5589001454995444, 0.9748117816205134, 0.2469044699209896, 0.15283328881627634, 1.7740352040391731, 0.7603396832056881, 1.0218899328456887, 0.48941240455494744, 0.8585514041160613, 0.5185843025609409, 2.911950462413902, 1.813986482325109, 0.5690880646076302, 2.397500862374025, -0.48777029978911396, 0.36375644413498526},
    {2.375723050654296, 0.8361374933599696, -0.1197755669042477, -0.09776515080716278, -0.8648513050590976, 1.3254939439616773, 1.40308538442728, -1.1854025505591075, 0.8990778404517675, 0.934209058672735, 2.2363173986439553, 1.3693000036688514, 2.3608293467650148, 1.5572849085313623, 0.7435344882939496, 1.2969471762905227, 1.5448653291134098, 2.50016506332777, 0.5912953429410099, 0.9565460518415783, 1.3247836090909968, -0.06825986873210668, 0.42548399722267405, -0.9432061330139982, -0.513057469128995, 1.6070847702759072, 1.7877123375870552, 2.3768771473217245, 0.6620097924554563, 1.4603809879318281, -1.4265661374802179, 2.957612956387099},
    {1.592744621810991, 2.6374453324178098, 2.050454389329833, 2.0054789374181503, 0.42400299257463536, -1.0807892743855976, 1.0169901514359523, 1.4244091451649314, 1.167657467642296, 1.704750170784386, 3.0052296051747507, 0.9209860049271629, 1.0598495322559307, 1.5112871208712115, 2.614132998102667, 0.5548128238136417, 3.130468806634525, 1.027738899863599, 0.21267266024660572, 0.7453475160078148, -0.02834072081843064, -1.2312641294484115, 0.53407077950759, -0.7403551081155573, 0.49152032309673177, 1.6167952435836328, 0.899476847076457, 0.35048386612361654, -1.0929201891983134, 0.7920466108433557, 0.1638094952781673, 3.0442631561202553},
    {-0.10789668721083208, 1.6528147369534925, 0.7862277679403968, 0.2744415381570292, 1.6127136085261424, 2.2340840321838167, 0.9286932262684894, -0.5674414645734194, 2.6255384374617647, 2.3089910479581888, 2.1360145500785133, 0.6273134849258419, 1.3719904044511089, 1.5557171891750807, 1.6276195839217253, 0.31753630106280895, 1.000780770808807, 1.336894425900287, 2.662976559751156, -0.397591806552577, 0.11926781553886498, -1.6363755220036684, 1.7914945005408052, 0.6363530280416551, -0.8644511083434763, 0.35331509008108547, -0.1575329419000968, 0.6680446381967432, 1.6180231365308932, 0.8246628751236078, -1.2149464220249628, 1.6432797853874714},
    {0.3501989551918439, 1.1656683781060082, -1.8560563237395846, 1.3254180691771236, 0.10679313910227536, 1.9341961137463797, -0.5729798551007691, 0.7573989546478982, 3.9980384791165418, 3.019379716353023, 1.6561344819778023, 2.0284174781035067, 0.4825890210071528, 2.3567476116251167, 2.037885786239307, 1.581449853378172, 1.3967282005273978, 2.8236753668783736, -0.07501473094750245, -0.05415000606337865, 0.9926979528048322, 1.1353433729133384, 2.199920378089763, -1.288393200163957, 1.9923083186181307, 2.538814186277741, 1.7521095332800507, 2.413885992583466, -1.5680792157207764, 1.2474319917848506, 0.6630868050395479, 0.9878190245388965},
    {2.1391298657140094, 3.6219454606646266, 0.2651817274130052, 0.17823345843545327, 0.19860709381224523, 0.6242869746558306, 0.42642363884373297, 0.2487079990373868, 2.8628652298456574, 3.4694980056559217, 1.8255752782870152, 2.770861342124673, 2.995237292461863, 2.8863832401309755, 2.0337423632958544, 0.9788366234137815, 0.49835125073820385, 1.8435645467158148, 0.9833014416635643, -0.6996381174053454, 1.783602332134282, -0.8305615297066427, 0.2836541245467761, 1.1097909038567366, 1.8223199601594204, 0.21245174132492442, 1.5187901688484056, -0.8154980911249538, 0.4006827277638389, 1.2877581624789876, 1.0935479432776014, 1.8837738838190219},
    {0.3738741479414582, 0.5768153375099733, 0.9847017959272863, 2.042142776244965, -0.6275339164452656, 0.7562437008234644, 0.0636995404172058, 0.8720601311858128, 1.0612626013931274, 1.3930184788183282, 1.599233211644599, -0.3790988589218307, 1.0344670046176467, 0.8587257392456312, 0.7966820856117969, 0.902951840960617, 0.6299397702644596, 0.39808137629231294, 0.20291072981805716, 0.02499441723648566, 1.7531184453918331, -1.5746838440405624, 2.8765735417652114, -0.13069761782622388, 1.5088878773006165, 1.3304926401934225, 2.4843390926483573, 2.590530832835253, -0.9448448632452345, 1.2940693175801723, 1.6069118730442975, 1.0401384587432756},
    {0.9488402530371532, 0.38713004513330146, -0.9294802302282921, -0.571138265748882, 1.7833686709310583, 1.1947739926082133, -0.22012925827567348, 0.44631206429666787, 2.049932888613281, -0.5599050771483713, 2.324886410463223, 0.8737579258901209, 0.1663907497561939, 2.379113594763376, 1.1330253529101797, 1.4116191377523561, 2.5767019480875306, 1.564291572314772, 0.8589079578438978, -1.813286496379618, 0.2692656939834755, 0.18688760225652773, -0.5706696624075451, -1.3100824774086794, 1.035869578183285, 0.3164199692824374, 2.2894640472541243, 1.9204326017617082, -1.392554001684883, 1.9439028579890505, -0.6048596314691735, 1.7807649840414481},
    {1.7163817574751756, 2.1301961050270823, 1.1025659911729293, 1.0392093289072015, 0.045278982459967615, 1.831038877784038, 1.3804986461051685, 0.08536568549457525, 0.30119687198961403, 0.11812534907013601, -0.1447222241100814, 1.4336052425640973, 1.1290041004104703, -0.47227300614991286, 2.42841018752832, 0.0290414469263811, 1.9559696105738196, 0.4877529476273053, 1.5236243924020578, -2.003906148546373, -0.5916186819635306, 0.6047871538307956, 0.3411997127337286, -0.8923280808278811, -0.2188262853048286, 1.5963542394840478, 1.361837754924863, 0.2634222814382948, 1.639560073443338, 2.400155835337547, -0.26978850896194706, -0.6344153909415449},
    {-0.06040485752651309, 3.0239974802548013, 1.4879063008149798, 0.48635245322300413, 2.0695513916579844, 0.6997569042151158, 1.0717003360764759, -1.0712007353356197, 2.528689696521232, 1.3687424796758625, 1.1969309881610026, 1.5378998799335148, 0.7234286514818865, 1.3203218856373125, 1.639062009876362, 1.1977898555049094, 0.5897694295545046, 1.022024903232561, 1.8788212421050405, 1.5631338661148104, -0.0633767425562752, -0.7841733245484293, 0.6653127498615199, -0.673490899293102, 1.5201138725761216, 0.35071810690084904, 2.3635967801463575, 1.876591236454278, -0.9493447736938664, -0.37608897628814125, 0.6750530045092814, 2.705130685896139},
    {1.1274544530525572, 1.234174092482358, 0.6786313364033981, 0.556554508409921, -0.19787003000546172, 1.376454559505438, -0.05015480234702875, -0.5741828726727867, 3.9071338907295585, 3.832796238394772, 1.413969274938106, 2.990082374746378, 1.3320388308411562, 1.9233086589109214, 1.5860786211971445, 0.9363628320788182, -0.0777792269685632, 2.0496304931586913, 0.643175509218979, 0.2298787057095702, 0.14246640819611664, 0.08064435575436092, 1.6312324862004157, -1.2910921923105934, 0.20812008929470255, 1.9340763677249113, -0.4602622123838103, 1.601405496786588, -0.9481076770785332, 1.542240161261117, -0.13254964369588026, 1.1795975539235366},
    {-0.25925972065592495, 0.48408161122068455, 1.2445777836913063, 0.7508905047689739, 0.9339193033960831, 1.7765737757260056, 1.0733833873613317, 0.8497327470552788, 0.2816507652276563, 2.7158626905218726, 1.9427884141096934, 2.6475545616920084, 2.804012151817496, 2.1614885716343344, 1.9081006284607644, 1.2208404708226641, 1.7942550661583085, 2.243605890912498, -0.35423862431967806, -0.6091145206206866, -1.9338700126303663, -0.5456918926789972, 2.652636868312668, 1.2826728154948404, 1.4888143608281583, 2.621634108304736, 1.1766098164952488, 1.635632793386676, 1.1381188791338586, 1.9118892601774404, 0.20908436645827114, 0.45111576109325596},
    {0.9262382880705373, 1.0282148666576085, -0.049212273950466054, -0.17478425968091063, 0.5722114050925886, 1.2819811008722866, 0.35332686052438284, -0.13698760945442665, 0.6273055549303412, 1.1347478889200322, 1.8800349627899176, 0.5213366675235389, 2.209129985465025, 2.8072504456311775, 2.0814480779142523, 1.44906743991503, 1.4905812618975152, 1.2017514994671012, 0.18105570920104988, 1.1724175915403152, 0.5324597996740634, 0.12837096269411444, 2.3037110439742228, 0.29853941797760253, 1.6686581034556303, -0.16714737654882408, 0.5716722157919859, -0.4352757902068528, 0.8566997410438456, 3.0832915822946427, -0.8125456470104654, 1.9176228154131592},
    {-0.2618514121396473, 3.9312784080891303, -0.8273688915590115, 0.1307660331668746, 1.1559961831770418, 1.460276695410079, 0.6516956393872864, -0.8119559889353135, 1.627381872211315, 1.8510291674918737, 1.705585822708371, 0.8230073056360664, 3.0925299032759606, 0.7823888286269007, 2.653003507476068, 0.37878912270735304, 0.21305123239633997, 3.3992220251753027, -0.18177084614757746, -0.3304668748148776, 0.33041321684558694, -0.11948224269366949, 0.8779235683348172, -0.33466024724484333, 0.4029470059906802, 1.5625435239077305, 0.820739360225774, 0.7876014508151131, -0.390613931306934, 0.7213468990377094, 1.779898367687682, 0.5415486405883656},
    {0.03349565499433426, 2.815522065796833, 1.857574866670526, 1.1773384418608817, 0.19893560604455132, 1.8896389945117726, 2.441725048984327, 0.10958040796495089, 0.4149668871147249, 3.092035378159213, 3.319375032433474, 2.6609385187843997, 2.362113485645107, -0.38642368323515347, 0.09560594018642948, 0.7557608782612789, 1.0857096726652706, 2.2990698392130393, 2.2930027488209683, 0.5806795209678746, 1.136352693630569, 0.04116915248405869, 2.1773186934180413, -0.9106575654094542, 1.0402964446127598, 0.1690376045003225, -0.36532129685984926, 3.0466605636113493, 0.8669283203476139, 0.5770204862559318, 1.6112028314651763, 1.4273846675536006},
    {0.7069030334954877, 2.6242829605124878, 1.25279452396845, 0.18313732936361202, 1.628430493978505, 0.7253204416316034, -0.9593787091155804, -1.131436164185365, 3.119969679530174, 2.192547423708709, -0.4428715183833073, 1.6516749662747785, 1.652157430448855, 2.0000450936046694, 1.7589470648445635, 1.5175259773246865, 0.14496126225141287, 2.606690802694311, 1.730460252963634, -0.39297651015437063, 0.8477544204323659, 0.3321830676288354, 1.7669135279911448, -1.374772792829117, 1.3057760470730564, 2.166491468639092, -0.25557705528022145, 0.963550713790686, -0.21738762694597838, 0.11906499865845034, 0.3565526089899673, 2.443140007937356},
    {0.8396736785947819, 1.1806387999020203, 1.4661975546304071, 0.20585443400556355, -1.019391803107396, 1.5960792454757626, 0.3224741409636093, 2.2386573770717817, 1.133887419817045, 0.7307853449201385, 1.0156970111142007, 0.7996313475104782, 2.04654773977553, 0.5464305530853797, 2.6950713651502554, 1.6875629513507868, 0.22202685347500323, -0.42966544582682037, 0.9806656737203363, 1.2273134053259265, 2.080358779058696, -1.5430282142594354, 2.0410062573615337, 0.050888936320877785, -0.48075028519802565, -0.08563387022681786, 0.1641085936932966, 0.10519637719444885, -0.3025371719924251, 0.5870486551590652, -0.12798888723503257, 2.2559917339817726},
    {1.5277191057659885, 3.3804243024368428, 0.1586807493054778, -1.3033495655691527, 0.8114215432171973, 1.0223644015935522, 1.7072584687347945, -0.2500874395195115, 1.0173137718257128, 3.483737671536043, 1.1439289052005992, 0.6618208577610037, 3.1013881556840586, 2.087361441187546, 2.2709731305426084, 1.1987742519981, 0.8657043157433376, 0.44322000990517757, 1.2718272621157263, -0.4766872158285562, 0.35616432225984523, 0.1489871947360135, 1.841989867404867, 1.8642361472384352, 1.0374276027295954, 0.642032452232733, 2.9072553324450197, 1.533367302378101, -0.2917329132855208, -0.00872055570365921, -0.3351178548345052, 3.438853981976579},
    {0.9887687240703809, 1.4179492862282532, -0.01832681275586236, 1.764225384737846, 0.4318500358021451, 1.0795456006620927, -0.2786777657845786, -0.3545604146043632, 3.0486073012242807, 2.015863019768851, 0.5264964597928516, 0.7168695003318691, 0.745446583606064, 0.5429628330300482, 2.8120546338610706, 1.8497632083514988, 1.9983039696434983, 1.9311057094340367, -0.6364639433400082, -1.5479306518963596, 0.722455163026378, -0.1472249446666333, -0.4693313503318439, -0.457220305600518, 2.01487224878082, 0.8520998007242407, 0.9133841254284821, 1.2738550715799626, 0.8039245405349339, 0.5233226042517839, -1.7433225024581755, 1.4782627273988231},
    {1.2856167841765445, 2.276404844950811, -1.8683073393957441, 0.3327507989683577, 0.7486159574358393, 0.019476942178819186, 0.5397489441479985, 0.7258592623255338, 2.6240467415482835, 1.2544102169087779, 2.9211484606055653, 2.3997652471546798, 2.435565347442472, 1.7348210638167951, 2.0879219097845176, 0.9184441731967126, 1.4458930629798012, 1.5541407407335597, 0.9410642161144682, 0.389366187860604, 1.254765337246222, -0.1995382508634052, 2.4839259756538326, -1.056918918801794, 1.9410663483408306, -0.8302406129377998, 1.724732886128571, 3.713338120573518, 0.6365725878700621, 1.5515281543576425, 0.560044749372937, 0.9227936245509321},
    {-0.27985163842831007, 3.7117651259653193, 1.6745673742498457, 1.2727443414544317, 1.8253191183208406, 2.4095134902402773, 2.4000288359518978, -0.7957320070342959, 2.9522292132900865, 0.8689281758955949, 0.8557249208271168, 2.1022336383460156, 1.937348993719119, 0.022526167061134528, 2.19761199495953, 1.9175798067964502, 0.2890741478126319, 2.10463649116463, 1.1062729881190614, -1.1588056052308766, 0.0020248795709576057, 0.1909885673946363, 0.830580566907459, -0.8781955899361962, 1.2247009796817971, -0.05502522625027469, 1.564488567627835, 1.2307644367737547, -0.5621588911104498, 1.5911865965521146, 0.07874317966206147, 0.7672590251972705},
    {1.1016651136432136, 0.8927941832336552, -0.8544342982116562, -0.3971122603596473, -0.09030138411666097, 2.6873931840557534, 0.9383479320426249, -0.045395417288129666, 1.3973519633914644, 1.998951274111699, 1.304719860556549, 0.21030167467346308, 2.3425400399523437, 1.5376050469281342, 2.479730900301598, 1.306199253156023, -0.4788742377349588, 2.8450630308494453, 1.0226577745357148, -0.6019493634069008, 0.5794663164508239, 0.4962713476177047, 1.3762309393773444, 0.0943622110820016, 1.2898333949422605, 0.20536698177239648, 0.1944864450935309, 1.1024571020645229, -1.5119520195112273, 1.0630558557818468, 0.21583384395686353, 1.1103079495553847},
    {1.443585947594188, 2.085878779879796, 0.17279946049476014, 0.09525875800862113, 1.103090654224401, 1.2540943903394994, 0.6187559440323843, -1.6051620773905872, 1.1494810014669417, 0.5892419953388179, 1.9058199041827282, 1.4613305068612055, 0.9771175297395773, 1.0205628400852809, 1.9944828105352028, 1.9565891516611327, 1.7682769633778224, 2.5214280756668765, 1.632016383738186, -1.0255974037299223, 2.2231793568028486, 0.21075705669388847, -0.017271126864849433, 1.5121390456893027, 0.4193352410951264, 0.5834075355533308, -0.18982906142757835, -0.49387423891659404, 0.8555850043891269, 2.82132473050655, -0.09988683776292792, -0.03190567468604658},
    {0.9144562433052966, 2.39529455934635, 1.1307584889870474, 1.5400811530388634, -0.4698523754666687, 1.7661166743335412, 1.399470724048293, 1.0596436275896677, 1.628201682297165, 0.8336115891295365, 4.16269733089558, 2.773083587875504, 3.509413032072697, 0.008972599285353027, 2.371032231162435, 1.0010149117168974, 1.8215764659812352, 1.9628721593429486, -1.3372519893342882, -1.1120669596044788, 1.3851127312666938, -0.4400938340200918, 1.9084635342947551, 1.395218053100151, 1.4377617251686414, 0.6457734696839948, 1.2701543877688635, 2.3798997446893946, -1.7342429408144455, 0.8802748594478018, -1.3572579236534625, 1.394246016943909},
    {2.024754589604267, 3.220239967589544, -0.00978662868379162, 0.2785082909440721, -0.2660816367305752, 2.6699240043470254, 2.6986532440446016, -0.7593599877632413, 2.3704870523179618, 0.863191241495724, 1.061100747503362, 1.4518288275648492, 1.8533375239281311, 0.2879854937270342, 0.7152039903471475, 0.8990735211726102, 1.5851841522421597, 3.015859042918029, 0.6960845361037663, -0.6344686373006164, 2.0935532259258856, -0.8250335927798433, 0.9693309956843849, -0.7771897765632602, 2.745894112646742, 0.15511881118209855, 0.09680085348688676, -0.6624831520103596, 0.25563045960116265, 2.7187095000247297, -0.812219589383625, 0.2905044243921673},
    {2.0997961047825213, 2.8470686989294394, -1.5184145346813809, 0.6501466966588515, 0.5410320343706227, 2.1624398956577155, 0.5303544327110201, 0.4378192176477208, 1.0382242696562751, 3.2672281637340133, 1.0075058455960795, 1.4417205853969466, 2.665501577887911, 1.6679331963199127, 2.6042689681876197, 2.634700216227229, 1.83943808980739, 0.9523795212200887, 0.4415201897856977, -0.9451288012045495, 0.45808767443795667, 0.1456775819290349, 2.3400628103543024, -0.5679738601077029, 1.823979738840825, 1.70408669948813, 0.061419129698708205, 1.004794001126898, -0.9162917820754685, 1.319745157595923, 1.91967567662945, 1.6084878878672972},
    {0.5594005637657263, 0.22071431481857728, -0.29584338819074146, 0.7169363999999555, 1.7045758654257621, 1.068005601377154, 0.7413882680834856, 2.4755905236127975, 0.16582697438898678, 0.8428174923409333, 1.3319403697473542, 2.1388736824706647, -0.1011700854722703, 2.187295703147942, 0.9157699321230276, 0.6761561014575459, 0.13610087101946533, 1.2271899880026362, -0.3226227174854329, -0.9987714463833122, 0.9622481922282952, 0.6330052584231417, 0.16009280355853542, -1.0891406183069785, 1.90029102620132, 0.1313237919145169, 0.13163124554500305, 1.9547308520148177, -0.2918707101382133, 0.3058435958747212, -0.4738824856912958, 0.7096238545317883},
    {0.7843841359592046, 0.03163793956207693, -1.6391544098405655, 1.3013469617028277, 0.7164781860386478, 1.9852911465076046, 0.654479467932139, 1.7744839309027538, 2.1398333648602117, 1.8141070022047943, 1.923956267924505, 1.7530315622632837, 0.7132426163737143, 1.9497083469307153, 0.3101821573003353, 2.8209066012763735, 1.789393357771354, 1.6534416118781656, 0.39443528673019906, -2.124844247518627, 1.51783283498567, 0.7504333992316553, 3.98757317508645, -0.3622135677980612, 1.5617884403549078, 1.9928516151812579, 0.19492741866393237, 1.7844143704421647, -0.41739539870446385, 0.859247488435893, 0.31598040404815153, 0.3373442920286137},
    {0.571143094080078, 1.8178443245820028, 0.7376486335640802, 0.6954965221518241, 0.9086766380698569, 2.8084901779119464, -0.37219475441447936, -1.0493530026599924, 2.721387333320944, 1.9725214541728873, 2.0707157296870045, 0.9775665567374565, 2.0900075010393055, 0.7775615257668841, 2.890717847940835, 0.7972105517729489, 0.8766306381876321, 3.9448515967742854, 0.6918884477962672, 0.7588996463037854, -2.0647870695827044, -1.158735206326653, 0.7560607958749606, -0.26254733805429054, 2.231360758813133, 1.7880289101045523, 1.6575239176056857, 1.8719159612753942, 0.9598763452209967, 1.9612227684245178, 0.302173239847442, 1.1193477809594257},
    {2.045474330446094, 1.0096620842441306, -2.225352437221618, 1.4497189689411034, -0.7933990816727633, 2.647339242943357, 1.1893434749115712, -1.3010952249618677, 1.7762499444309108, 3.089403235674001, 2.1755105277481777, 0.8923078627330768, 1.5708612741485453, 1.0551359020990096, 1.6502452432675654, 0.6389989727722682, 0.4757750638292653, 2.0519768161327017, -0.2803165967476333, 0.5903261293564865, 0.27046647168707494, -1.8595263688477777, 2.207456778394041, 0.7677972931123022, 0.022837082435830276, 0.056509923933105555, 0.49097094889209597, 1.9991355899514138, -0.0504320947868931, 2.050817267572442, -1.1059326946897778, 0.3386084322062121},
    {3.309368874289271, 2.364500567618119, 0.014562553174860365, -0.291268378459686, 0.8020821213605221, 2.844418622044163, 0.7315616464971338, 0.6488359187648622, 1.3124872938234537, 0.541391127208084, 1.0051435487053173, 2.7220854449753826, 2.140669712988452, 1.7072222843474567, 3.1329645646762843, 2.523416372321315, 2.5507063063852424, 1.9097205049834833, 0.6869569065410525, -0.4127746064023884, -0.9268660808427812, -0.8553678583611777, 1.6249984956996315, -0.337302953921851, 1.0996545540275209, 1.6915300019468156, 0.19814236980077074, 1.211814704504238, 1.2996606677548042, -0.2587868005913923, -1.1213329715793248, 1.0929718384917801},
    {3.1142036194155667, 2.7555556183895398, 0.4674189886428544, 0.11885305524747618, -0.8520406881783454, 1.531336791269604, 0.9253406839438335, -0.34394806150211277, 2.51535381370864, 3.0516539698918397, 1.6895452754310922, 1.1610598932075937, 1.255645330448781, -0.6787615423700138, 1.9808766395621382, -0.18388759328538254, 1.6834978183157439, 1.677052698486251, 2.3230273570765427, -1.7406712836902227, 2.558047563102998, -0.07483442257467487, 1.1228245307520954, 0.0292830121901868, 1.8651937164209218, 2.120748034868107, -0.37088730749147897, 3.952071507878934, -1.474083367871278, 2.59528205399726, -0.6364753374657655, -0.1470013783371922},
    {2.0324026544936937, 2.1680848322959974, -0.4415685177707544, -0.07880444395989698, 1.3931679531854362, 2.0165599164318495, -1.668082461719144, -0.46635786746788105, 2.498087026524417, 1.5587302108011691, 1.8526369270368155, -0.4455776754748157, 0.495494588348969, 1.159188694181015, 2.888140429833076, 0.5293101084294163, 1.739766313640238, 1.8526644920093858, 1.4965799243488074, -1.1679678604098889, 1.0919000563153454, 0.40522094717978613, 0.45787556128264817, 0.08183271144855567, -0.32250519594274046, 1.5810944712886041, 2.7751969412368314, 2.4095656285256797, -1.0064995795872416, 2.26866134408714, -0.08987831686205396, 2.110569330087819},
    {1.0512045670757635, 3.355009398675299, 1.2735716265383854, -1.11406850319447, -0.2551968241435232, 1.7477411661992648, 2.477316440158503, -0.17448752967430153, 0.6729415120920119, 0.24794538863028953, 1.8305807124346047, 2.615304322458896, 3.461110553834086, 0.6818648737767072, 3.0678691542660297, 0.17797763958566234, 1.4890236505763368, 0.9681275447710371, 2.2262374608030306, -1.7826940504670439, 0.003628942473963236, -1.4216571354336625, -0.07367099445575703, -0.894254302919503, 0.5437638040815407, 1.3855817216852944, -0.18903658932630943, 1.4542925849729762, 1.5437433652033523, 2.8782891908843067, 1.7577816034008777, 2.729776103828164},
    {1.4144893586010368, 0.7580159835256378, -0.00940547315866464, -0.473690403353903, 0.27588136443984307, 1.335781024931678, 0.6887179526093558, -0.6791064235693558, 1.0650278443077832, 1.9713983408596278, 2.3754815628134534, 1.594352548935601, -0.40885609627411224, 1.2508046396257095, 1.8015965334052768, -0.47772296853688456, 2.7389811324761886, 1.0935714830752192, -0.18133914643226787, -1.5265302039521431, 1.2826765187056959, 1.4895599054923676, 1.5707182823585162, 0.9640072639654872, 0.6415813303876796, 1.6606710406322074, 0.30585064076657387, 0.9866442353945081, -0.5904743066995833, 0.6746022781473624, -0.3214773079084468, 2.4788204652494628},
    {1.937065205824892, 2.9708909988392262, -0.42990073715454796, 0.9887252070846868, 0.3943911155196888, 1.4026164154077596, 0.45267735458265324, -0.3161681958266672, 1.6055964478424811, 1.71865238356717, 1.9701835833814068, 1.1460626142433727, 4.274531376278433, 1.549419380288773, 2.202444002142941, -0.11612254221098822, 1.033972108700186, 0.7534415411023413, 1.7903830574488004, -0.1481629861224747, 0.03488406443100725, 1.1976176069423674, 1.6278709980758508, -0.9216416079427784, 0.7435385177701611, 1.5087455728841206, 0.9879381518873869, -1.1136285837900495, -1.721381267298793, 1.4809681360649278, -0.17074681067743638, 1.7041393388934514},
    {1.0382843362281766, 1.1487770749462582, 1.85734542074076, 1.479358994585291, 0.8209223910641034, 0.008925907921974353, 2.4997692680157826, 0.5963381899705327, 1.0498687523666432, -0.343204554208864, 0.6675055165057256, 2.579604341221332, -0.22653950485017443, 0.5702608761175259, 1.6068708335337964, 1.7878429789775836, -0.3036643650518638, 2.2645941826866007, 2.042174908487336, 0.26331787330123013, 1.4756949142982505, -0.9514299897435535, 3.3993159520616576, 0.07293415373979252, 1.3127828781920392, 0.17792295183626672, 0.07785021730139281, 0.9517666469334067, 0.15500015537037556, -0.6914214212790173, -2.5935286015880887, 0.785612279592212},
    {1.6753369479864646, 3.3983167995198533, 0.45965075896558893, 1.1493564427031349, -0.6913828804422651, 0.30689944340729747, 0.4135418020052639, 1.461981756718044, 2.6181317311382304, 0.9400380672606576, 1.2508169727744884, 4.207075815526308, 1.5458304662827607, 0.7625246190577003, 2.234823260430332, 0.8889791839974513, 0.41857932985664686, 2.1358093200223416, 0.48412273466485134, 2.068997605992942, -1.8170549305530026, 0.8563008335434321, 2.453162156834359, -0.1500947986635708, -0.29328937467690236, 1.4816801200172613, 0.8631769357971105, 0.4323645312307922, -1.6509387739369101, 2.4305514637114563, -1.3508303957282333, 2.0768664522960525},
    {0.9757576037265692, 0.7947468624267131, -0.1974879756280054, 0.6422569652009255, 1.7767395042038088, 2.5713289238650785, 1.0677727731042086, 0.8094528088378711, 1.7469542598752823, 2.886440232141674, 2.345268859391955, 0.36317291938547436, 2.5923032120108394, 1.742075477076748, 1.601306697584049, -0.7109413639386196, -0.013856759919260163, 1.7167668921210337, 0.9840797989808284, -0.433004712985665, 2.894135351418907, -0.6779573071494015, -0.2568241086560896, 0.3367459244263872, 0.6887362071820723, -0.32312464652188105, 0.04007806763387771, 0.765395565363163, 0.9087943123932836, 1.2587419282582406, -0.0017113325489089787, 1.8658316727344058},
    {1.373712834819965, 1.9294500705968798, 0.8669354540280497, 1.7996908880046487, 0.44839997495999534, 1.1695107570549064, 2.114363586585469, -0.25832876574188385, 2.4656137592704535, 2.7740914129352974, 1.3091374077488909, 1.5333349397554452, 3.5055153609054637, 1.4092739458630927, 2.0105769322985005, 2.2513994736782856, -0.2342748388770203, 1.4793637265540602, 1.0789418895614808, 0.09431616678270174, 0.5314232388269641, -0.3682045989677322, 1.40465179739967, 0.6580352216273235, 1.179832435989612, 0.7346450878678235, 1.6672077666465375, 0.7652019516089847, 0.513379217884452, 0.9404802378955163, -0.9713378443439125, 1.7168419092785914},
    {1.4500844752996043, -0.26334917895467114, 0.6458775649348518, 0.9340536816403182, -0.7263419276461723, 0.18645009562602224, 1.745217986863259, -1.027763511627639, 1.5834892594085805, 2.190986219367917, 0.4533787405943122, 2.257025223876696, 1.3676863793460379, 1.841788030815864, 1.1987601561340413, 1.598714270482671, 1.6759764438532097, 2.162112886061305, 2.3225163019642805, 0.5994353260998228, 0.7562186772613326, -1.4454257643655364, 1.4623836514050392, 0.6636959957834069, 1.9875392954534248, 0.8142560494991836, 1.0123848116144403, 0.8937365997780209, -1.1838887235948419, 0.34025027251224405, 0.36150332390625617, 0.5436514197075949},
    {-0.07977422426983909, -0.832330557563723, 0.7873218732205753, 0.9439961749774732, 1.1473550790677718, 2.258498891778796, 0.26999937517056505, -1.03118273754281, 1.7896574250756672, 1.9327407465777577, 0.35868554411958353, -0.5042550082798163, 1.651948491306024, 2.7714014057759826, 0.5004518185197117, 1.825469009981891, 1.3002307067809786, 0.430587296820468, 1.3575870378646093, 1.8717867044803587, 0.1185979553580638, -0.09217436612805736, 0.9941696478791445, -0.08029362477402975, 0.34316669841952185, 0.48877874672658006, 1.7064755523247297, 0.6358866300174936, -2.1038059401874305, 2.8134311642427954, -1.4128291586808774, 1.5344408681386148},
    {2.8050996997679793, 0.19319394015403182, 0.9904700783832734, -2.235945177567242, 1.586374524242799, -0.49335441825245396, 0.8494743545036946, 0.491729081284692, 2.01870468038702, 1.6448658664981526, 2.3164266389253654, 1.6807006752503912, 1.5973810813820488, 2.353168060222451, 3.288528779548676, 0.4439536007344848, 1.7854726720026306, 2.2018986505592446, 1.9864492405040683, -1.8775539226388378, 0.8886478022717491, 1.414386518183658, 2.6809093769705843, -0.5622708979050173, 0.5789427201871029, -1.085991677937519, 1.8604655845581954, 0.8537658216313531, -1.146980784164566, 1.624906080318746, -0.11269173636268796, 2.4884787176063483},
    {1.0056911902271881, 2.5737654679952864, -0.6651797691732759, -1.8223381848274978, 0.17754541604242388, 1.0991819825738103, -0.089546897605861, -1.8160294200587737, -0.7810394465487734, 0.946344533777513, 0.6876266947107245, 1.222799959593463, 0.06843731892716161, 1.4129870938704325, -0.3283125469750467, 0.8086432171912588, 0.3098646790147829, -0.15355270335512092, 1.3977275600184205, -1.9446345412942942, 1.5769740005366915, 0.7636380380621559, 1.3853695466145732, 2.2333749337293622, 1.7241646838902873, 1.102145505463032, 0.9223176919222926, 1.6199275854566484, -0.9108781583203696, -0.21635573602688873, -1.1627022879963989, 0.9328076443657974},
    {1.5458859586520173, 2.367047936861126, 2.4083808512638676, 1.085779631545666, 0.6779399165856961, 2.3174084445985073, 1.4563359460987633, -1.1693496604021112, 2.6660671131842375, 2.486108625772445, 1.7278243011249332, 2.1559443703160968, 1.9525329606638315, -0.2655474951567247, 0.27648327990327976, 1.1856827438391504, 1.5179298888448574, 1.6559206472484822, -1.3033125868266553, -1.3267859974501457, 1.6129267498507152, -1.229520593680469, 1.9245536929065399, -0.7293872260616339, 0.9560267424302894, 1.006032116090516, -0.4638783664914958, 2.0226288595629818, 0.2375056389824138, 1.2878518984176697, -2.4320986541466554, 1.6965534466874155},
    {0.41890971925108644, 3.3989151022756423, -0.1953164117196505, -0.03964536059733476, -1.1781615754220278, 0.8697149231919413, 0.4027916726131365, -0.02298848114311968, 1.965268705317503, 1.9789945757377732, 1.0210797594424177, 3.071150424727222, 3.494085302871903, 2.0588908912736352, 0.5182006160715001, -1.1598329559191645, 0.9569321057626673, 1.4925796788103172, -0.029053557532031874, 0.251393116101378, 1.5276171376857341, 1.172576272902655, 1.5646440933330903, 1.266978440307725, 1.190602110479446, 0.8148598110025035, 0.4035676033887705, 2.032396798851577, -0.16351742710392117, 1.865909235873629, -0.17623723537032848, 2.123358572688046},
    {0.07892490915802992, 1.7238113182291852, 0.7076043571910202, 0.38834267082494217, -0.5912463548322754, 2.114219907383319, 1.480441633504154, -1.9922996698809212, 1.4109296130971831, 1.15338679581607, 1.897888541196439, 4.0175557445271, 1.8445706194594178, 0.3495437581247281, 1.8954573467108975, -0.6887582201730944, 1.6302199353592062, 2.050472921378824, 0.7000793793198408, 0.14308734158452588, 0.28024436267154923, -1.0394312732687274, 1.0366712067304082, 0.10797693809743494, 1.887731047007858, 0.3819054637245676, 0.8525804806232599, 1.785680565146103, -0.4029235376292271, 1.3518528323212309, -0.5624884435522141, 0.8871169717163039},
    {2.209621592553283, 1.6900390820959723, -0.5358753585074716, -0.5173360728285993, 0.14498309640140847, -0.19750953370542626, -0.36149298763808263, -1.9004186252654767, 3.245569510108773, 2.0608402352668986, 2.0858338140823864, 1.460748334710264, 1.1873062330986628, 2.56406809735402, 3.3763876241802664, 2.6161602328745475, 1.8758653085466719, 0.6933880883540985, 0.4264524666847877, -2.092177259138164, -1.8100130617752919, -0.03872830619811057, 0.32314861926366056, -0.7588974887762778, 2.209677928121028, 0.25411379041589904, 1.580471206894014, 1.6569023063957748, 2.7593272646118416, 2.333851593017346, -1.2904614893631803, 2.8338650488448676},
    {1.5844135958724201, 1.9053358107070049, -0.0006660673683853391, -0.1869055515073637, 1.1791199294182921, 0.4330024065050931, 1.3431934476806535, -0.6522894708762766, 0.6501800881913141, 2.156978164963311, 1.3700128321384641, 2.0445872684590483, -0.7559882657649579, 2.434738818662212, 0.49479758787245093, 0.25520104119934384, 0.7671818524662098, 2.480995743464839, 1.3761041322663832, -0.10112631423560127, 0.13007075756682204, -1.6963084166542854, 2.3364758632619615, 0.6232350416680409, 2.9171438529095526, 1.1840712971541538, 0.5863889178677139, 2.223363006490101, -0.11476679116587826, 2.3222258107573, -1.0540438417655433, 0.8474517100858443},
    {2.1548260392076988, 0.5865818347559553, 0.8294532729913967, -1.2069239740107478, -0.417303188992288, 1.9775964042430818, 0.9999695587995098, -1.3442510540812715, 0.5275189086429112, 2.1154713622330443, 1.1527178849355924, 0.04969485280266518, 0.3198598285672178, 1.5662290670723271, 2.4087967924693876, 1.3520569263600926, 2.6193293200288976, 1.58300548313612, 0.5862894284858101, 0.9979474828023728, 0.1445086725139258, 0.5593571827584436, 1.0756214392198349, 0.5658643410392576, 0.78905489334122, 1.5948070049652348, -0.37209258009655, 0.7168335820275058, -2.2221474825444325, 1.2474204380680614, 1.7885670072684632, -0.3246508377638918},
    {1.2875543018717681, 0.29091648798683334, -0.13308930812869676, 0.2842923325042221, 0.3421311880695955, 0.17403516950497977, 0.2042263544344971, -1.9687787296490298, 1.4946387765257019, 1.9031353182936073, -0.4440605229114988, 1.7393259427407886, 1.746210511751587, 1.603991504200907, 3.2582406821399794, 2.4141275930249146, 0.7204052925650964, 2.626701603575076, 0.14848625668398488, -2.104936464593963, 1.8023562305630185, 0.5059587748252613, 2.112897605138793, -1.333015294028056, 0.25464964071100105, 1.8516127409884482, 1.4117535050179921, 0.693724732354667, -2.2752868900485663, 1.4099511303938586, -2.4209564653707765, 0.47859981320839023},
    {1.37767104272641, 1.1371259783556709, -0.27615333909060935, 0.524808979786284, 1.2629921309795682, 0.6185739219631817, 0.8763316749188937, -0.29160597057719845, 1.5588985016603107, 2.186100274218676, 0.1834333210022891, 3.2575343525106133, 0.9850344008177709, 1.3829195072508238, 2.6492519464741484, 1.277764895790464, 0.7804684564460728, 4.092875213613722, 0.8448540805345424, 0.8503733184640855, -0.09779707041400038, -1.963027812946471, 1.7361697327212364, -1.0341225646819325, 0.2360104320668938, 0.9627895056926767, 1.8032875376750628, 1.6261074024818538, 1.3705963308349287, 1.5467854305670796, -0.6396770721883711, 1.314595025648751},
    {1.3003782609915389, 1.3702867003638717, 0.9448034744908467, 0.9452805819066579, 1.005949281733339, 1.3515593521808935, -0.7763534572583298, 0.2380009836028783, 2.2656029457547247, 2.9071938489674247, 1.816171274933627, 0.5675696335006194, 0.3549128706908376, 1.9461934155717857, 1.9891936882554995, 1.1373449891565104, -0.5808361232518785, 1.8161413975342984, 2.2547916317465617, -2.0762169022742336, -1.172988530019266, -1.0794603271681131, 0.8501355869545258, -2.8510716502280915, -0.29439563207299047, -0.44702895585447483, 1.2186628401653468, 1.2925294972440808, -1.0776194551664795, -0.3874059554071113, 0.33052112742493545, 2.6433005941343475},
    {0.9542451091138953, 0.6664488086411621, 1.5935293317803443, 0.7213671109861801, 0.7913300159272555, 0.682267598646761, 1.638545546016046, 1.8717385777295077, 0.2104736776828595, 1.9949761400002868, 1.4583937112816296, 1.1066326566428775, 2.0415547239274248, 2.361228987314228, 1.0774512203218494, 1.135275210530996, 2.6308425791521626, 1.8177191221742188, 2.8944154426991884, 0.09582472205825777, 1.65261495451147, -0.5528774767026267, 0.14944959601687446, 0.2277532307006864, 2.2979119605801244, -0.6283452079146595, -0.09136518835281547, 1.9945106071066268, -2.199368394405367, 1.9470783431031584, -0.029738287827805566, 1.8243547957254664},
    {6.15014541294433e-05, 1.359544509834913, 1.287782962627539, -1.2529536586544798, 0.06422898339262453, 1.0585192896182736, -0.7202854004219824, 0.5019805600520872, 0.8170506451019888, 1.9565432785979517, 1.4376823272247887, 2.6434892399946985, -0.06412131194733826, 0.09118101377810373, 0.7508493888971203, 0.5382257528011306, 1.554968665609349, 3.7633086831376135, 0.03166918375957232, -1.8694684610800434, -0.32922420680883174, -0.26781919356776507, -0.306005999383392, -0.6277708389022325, 0.97466444493952, -1.3976438102214692, -0.7365691984458913, 0.31406059524897434, 0.6974796594374173, 1.1194734105366089, -1.7755927564606295, 2.064102706595953},
    {0.8512515981115051, 1.6845222098877688, 0.6773832772556521, -0.19031005994911812, 0.5527416409142917, 3.3881951990661556, -0.48964082062119474, -0.7430263485129907, 2.121407996556297, 2.8080876597049507, 2.869052873886385, 2.5225346714240424, 0.14051563515508095, 1.4089607682625318, 3.931465742240447, 2.7683615200483183, 0.6999508766988615, 2.751368082029247, 1.488467219977547, -0.9927515380126608, 0.4024799482742839, -1.7787993837180676, -0.43302204292092844, 0.565330757305781, 2.7817146371113255, -0.7153288275506352, 1.149252032313336, 2.120577228995015, -0.26249125541007395, 0.9516492086939604, -0.753642121050516, -0.2549840169998623},
    {1.2136865075326322, 0.4090992634903303, 0.8107644211606968, -0.16241204224602368, 0.5505057998479985, -1.064025433651036, -0.9068626064707468, 0.998629326290979, 1.8757767080190886, 1.094022363357341, 1.0245795279860341, 1.9088762370715298, 0.9050460076423382, 1.653425651393535, 2.293265779573605, 1.0970659509788219, 0.8746379929714577, 2.6782245002062313, -0.13035784801234973, 0.2587746440006158, 0.13225415741020657, -0.47249478947807555, 2.443305839737429, -0.7674558386451212, -0.30970607712729514, 1.4918876101534537, 0.33733470313079145, 2.1840729555210694, -1.071201929607068, 1.4683217735414025, -0.03072670274456939, 2.734051733887006},
    {0.32259573544316733, 1.215167331206896, 1.0418653823216462, 2.362717208121384, 0.746320933661097, 1.2613206934175232, 0.795844208439064, -0.7049700507971293, 1.6825740446614803, 2.0574877332520143, 0.9857303530057465, 2.892235751058202, 0.08315597374519068, 1.4840457820822812, 1.133128247113727, 1.3648576365460863, 1.0125088309125678, 0.304350063577004, 1.2825849615360025, 1.1325682370792884, 0.32642553717457345, 0.4658775731709732, 0.34718610122258275, 0.45124659244163506, 0.9418508993955826, 2.5403149165411016, -0.071070817026594, 1.8107777285105813, -1.9965001159510865, 1.4847955937064132, 1.0607588545968765, 0.9021894995903817},
    {3.097563453742128, 1.768602029299988, 0.03344057125523319, 0.10464112820050571, 0.33030169321343605, 0.6588337173962306, 1.2870063892918495, 1.6769821421337308, 1.6856546944436446, 3.118784855083181, 0.6691263324710206, 2.130965550324921, 2.013422274304199, 0.9826745338606716, 1.2438168690869942, 1.4273476573808153, 2.8069078979555395, 0.5381344444194641, 0.6754418744446966, 0.26392559607478233, 0.2629495476710327, -0.189035079540842, 1.3180670357239272, 1.6646022893936052, 2.2741250305297434, 0.46276353301459794, 1.0490292964783965, -0.1694771102258804, 0.030613316134158686, 3.086896057088311, 0.07741775425273195, 0.25534300478079464},
    {0.5345154972287118, 2.279343624471315, -0.8087274043232009, -0.35634704825371405, -0.8384546268030467, 2.9156802322093744, 0.6817809190870641, 1.0356335391871914, 3.264357059184663, 3.154798903890791, 0.6960211899724382, 2.217145422441428, 1.8457472263426216, 1.9049037273371743, 2.167198408470334, 1.933970357345071, 1.0129485877274944, 2.03108447189964, 2.182088308009876, -0.7968306762467645, -0.9811143655569988, 1.0515630634897286, 1.3414753354185132, -0.7408186206839456, 3.734031518992355, 1.5799753134869179, 1.340612472021529, 1.5824198909652691, -1.6321397775361177, 0.9315707974566868, -0.7077590741201869, 1.59581475932496},
    {1.1162034104312781, -0.31980766916928144, -0.9263604271342829, -0.26389814525198596, 0.49070862853589636, 0.7556181638466195, 1.1519767810475217, -1.9879819464054793, 0.5916903773883391, 1.6654084117843, -0.1624843732010546, 1.432374819036967, 1.601594649007308, 1.1101143153843072, 1.3143452792641157, 1.4006969254182025, -0.9674283914094715, 1.2934469390355205, 0.8390158633111928, -1.1454133108635602, 0.9480376489244113, 1.3562691953318016, 0.08549904625272849, 0.9967729620574697, -0.04322993045219232, -1.8818124178300164, 0.23862937812158794, -1.411334418873062, -1.27289553800984, 1.4739440940479458, 0.13270970820280198, 0.8466137330751875},
    {0.9501179600418815, 1.3852657863471052, -1.8658031605835426, 0.24489303616190375, -0.34532967260484343, 2.064112742058447, 1.9484651047835926, 0.6720860890394544, 0.8506503492919668, 3.0114400734284374, 0.9523747392126238, 1.6213766675043335, 1.7958885092361008, 0.7432410427249566, 2.4451765225322077, 2.5053074510221074, 0.863026911036011, 3.176932448454283, 1.5339895718753358, 0.0076014215549696515, 1.2755328215962174, -1.7631542853721123, 0.6195706938077312, 1.2946960195500932, 1.1213651048147637, 1.4832977766784214, 1.9534331307915107, 1.3296969499671942, 0.3504814368703719, 1.3684726429213292, -0.2572720017105334, 0.4968809522888469},
    {0.4835219622063847, 0.6602344604277992, -0.980256547061523, -0.8903720303640715, 0.33842640754749176, 3.373799828493332, 0.4202107204009443, 1.5846184457484496, 1.4082780938712542, 0.695948298607317, 1.1499982786777723, 2.5519003982139203, 0.23138213832654547, 1.9266883719352723, 2.9477663130717655, 0.9910968261414594, 2.242818725559459, 1.69288880298842, 1.378392947668118, -0.8549093405258199, 1.7521669303567824, -2.132476514658202, 1.4243964170138634, -0.27337335543962676, -0.1124954738830254, -0.7124111940650556, 1.7663267973294448, 2.310914593006165, -1.5970060973182567, 3.6491480184843414, 0.4804067712185428, 1.149643654179283},
    {-0.5875327552991697, 2.0289157316894557, -0.5788255902053786, 0.9099778377289073, 1.118876803443723, 0.0814933173778439, 0.29840525423026387, -0.235949321212462, 0.5282013817336422, 1.1738268057597527, 1.57902418021056, 1.216447698361044, 1.6864471321257204, 2.0099932825643836, 1.8114594532130273, 1.9389124622653449, 0.09357155973188008, 0.7417355050322297, 1.991936416604623, -1.4409046769837477, -0.8661494055572719, -0.20317614033521553, 2.1253112347661345, -0.23111749644494933, 1.588401846629115, -0.36297961811630397, 0.41201282670637174, 0.8747723440924806, -1.0437559497395268, 1.991681653012414, 0.17671733490612, 1.826683237261702}
};

static const float b2[32] = {1.5224398921237656, 2.4870302470268384, 0.19281940128188607, 0.7827419246855515, 0.7395200024868678, 1.8765805599177388, 0.9577833593643417, 0.00402497099000523, 2.0673800223297047, 2.562561938676524, 2.470268014976193, 2.4458871515685785, 2.3907123884183807, 2.1126239239251183, 2.593128130272545, 1.656957060008795, 1.8594995152268594, 2.49396434598984, 1.4845053363149616, -0.2674338326428733, 1.1952839307554814, -0.11630084271706817, 2.0790386785526125, -0.25221297099828305, 1.668446901374779, 0.9436410009591263, 1.0386174588938586, 1.9112469487092707, -0.26550999529642777, 2.0149034076681565, -0.7470883282906324, 2.087126353036078};

static const float w3[32][16] = {
    {0.94618712182852, 0.514292449194222, -1.6381164198080562, 0.6806908166498055, 0.5272569898887189, -0.3138796039985657, 1.2517125371825362, 2.302849386189463, -0.17688768097486315, 1.436333084505209, -0.5338153244159048, 1.2757484533268897, 0.21935059133288304, 3.632024437572356, 0.6608965894273962, -0.4382153954564975},
    {4.456516759565925, -0.8553638729352839, 1.5071980353864844, 0.05171286728441805, 1.2413189883436049, 0.2106330754515797, 2.8890682866241337, 3.0057884462596274, 0.6104348566980727, 3.040731864736538, 0.6023360344278608, -1.542459483026272, -0.09715364414102945, 2.5417281586880716, 1.0485633837160546, -0.33710455608229345},
    {0.15641501223001525, -0.6147394013358287, -0.7564857988016432, 0.2558532942543213, 0.3826855982426287, -0.15768229425572888, 0.34086398874477025, 0.4994394504902804, -1.4593578598295478, 1.4041642463098711, -0.15147524929479253, 0.9960893860035525, 0.40203127398006233, -0.5351550403052782, 0.7053693825085324, 0.5169769088224748},
    {-0.2229894541927421, 1.1206427856209824, -0.7733816513907219, -0.5470967256733561, -0.20478618581657776, -0.7681121590528679, 0.5656768812640122, 1.7036139538193875, -0.33914981944933004, 1.9686651013049723, -1.90585718924124, 1.727529858549977, 0.6168604233996442, 1.3130646496826865, -0.2719418148674613, 0.8797589306687758},
    {3.281005344751579, -0.3538122107554867, 0.08826684810088997, -0.3133317309595863, -0.031132877770169404, -0.46480824035299373, 2.1599161488754577, 0.030598067157737937, 0.16658649739218528, 0.11434927409385359, 0.7969407442977017, -0.11464361507517408, -0.33851894307724145, 0.6149718835730875, -0.5035036242157911, 0.712310083210851},
    {1.3087403346180917, 0.23106699335860664, -0.7931544457925015, 1.450803634895029, 1.3067934558746208, -0.18265308499830246, 0.5755472243201136, 1.4765727786623526, 0.014006027232212752, 3.5796404865858906, 1.3526222889088781, -0.7214987772316489, -0.4019121529485317, 1.3609407708756378, -1.0065104890697953, 0.7297659302422876},
    {1.3631945992965562, 0.7572347419388634, 0.4992830710579739, 0.7964974410543921, 1.7124877213763186, 0.8503227089579319, 1.3375487675754612, 0.7486723841111871, -2.50885599634829, 1.287061692774971, -0.9251118691210664, 0.49666107445118945, 0.4765889644450288, -0.016708943837805697, 0.7885937048393292, -1.3734880951176995},
    {0.6890514131782518, -0.262390195294867, 0.3620623760660384, -0.36183668688735615, -0.7287354981313582, -1.6169253332393083, 0.15016813494161158, 0.6124114089899754, -0.6939351547604214, -0.004566185677635831, -0.028221126975190487, 0.3070222810041694, 1.6461574100874363, 0.329535410011626, 1.0485838463766615, -0.85642876206284},
    {4.263758311485005, 1.2156964759452813, 1.3051729323969699, 0.48134456263984154, 4.072292424483525, 1.0237383063362901, 0.9210653251398511, 1.9692713524560461, 1.657321844298528, 2.9873316145477955, -1.9220635737947847, -0.22645887991158903, -0.28870936305157313, 1.793111216749852, 0.031264604095485975, -0.4363729435594495},
    {3.2422732927579103, -0.12384830680811984, -0.6477263619258545, -0.8348851352511529, 0.26917949825641396, 0.0708156451428144, 2.2452016666262415, 1.8813338719479435, -1.8582246020699724, 2.953384614160288, 0.09939405489677587, -0.7666538336699226, -1.3859887662420751, 1.7903646444734242, -0.012429230039102998, -0.3864236164066777},
    {3.6517868242544034, 2.1159283182473194, -0.518168045766672, 0.28448593788471405, 1.2397800834084856, 2.2673290710556357, 3.5520285030151855, 1.9732978540209483, -1.4863222826009161, 3.4783987530657003, -0.5661901542117981, 0.47565920036071313, -1.9978717794418086, 2.414359859079767, 0.7051700923940724, 0.24202373072026168},
    {2.121649947177734, -0.6153244409685088, -0.3352281977310371, 0.5121835501023989, 2.7833202550405787, 1.1748962187579663, 0.34782206444252933, 0.818927642304074, 0.13981636535368633, 5.045001791223523, 0.8452031401716249, -0.0938396356361436, -0.1518287570568809, 3.850087716381034, 0.32799456087036455, 0.5385610648521445},
    {5.20703378001842, 0.39493863058880696, -2.6697667673442607, -2.9353171413517223, 0.9283142103094101, 1.1050922936021936, 1.1803743220261227, 2.845432890390995, 0.6754495315959346, 2.5821351013819767, -0.07609818695424868, -0.7934399411609113, -0.17231441829594768, 2.0262755700804305, 0.8982489733030898, 0.5939507401688646},
    {2.2915158416458175, -1.3068156412007281, -0.33685396185767336, 0.33050722977467134, 1.459359001590826, 0.7005746903845324, 0.3176299150643045, 1.6127540711476966, 0.9759784494940889, 2.7670361400022694, -0.4286856424767367, 0.7270955545452924, -0.9265008279817811, 1.2808333030641725, 1.5215388681314417, 0.8467070918361705},
    {3.2048122813385604, -2.1502455965111973, -1.2188353408694692, -1.1188472677446986, 2.1559956816357606, 0.8743209395775606, 1.2537852807747685, 2.5443457390786266, -2.5813532571141593, 3.182988926978292, -2.00270079117657, 0.6248629555285024, -1.134644342855419, 1.588342031339628, -0.4317256743475341, -2.1798472639309145},
    {4.074923779138117, -1.575083392781901, -0.5537862977589141, 1.6437550269616517, 2.9407347910771113, 1.047744404431832, 1.8948142587076326, 2.361899168851477, -1.5301861535914025, 1.3603227874926918, -0.4104007571659817, 0.20707326307670168, -0.21140703740202066, -0.19135724788945627, -0.1811477612673554, -0.887562746738248},
    {2.5673685905676478, 0.03622489285920575, 0.17947544076152247, 0.15860006078330424, 3.0098557008455193, 1.9342355154280175, 2.446706472831644, 1.5543785463131075, 2.3689178070593546, 2.117689999902979, -0.5732849082191928, 0.34660161605326284, -0.36772766024336007, 2.120516181306101, 1.5470214537148435, -0.47819381808154926},
    {2.017443759237894, -0.5033832824423821, 1.3067465614105809, -1.1914814440994284, 2.502884252904947, 0.6776300490164797, 1.5887342677245717, 2.2828732345686356, 0.7232419862521298, 3.693426254096648, -0.9002041339917952, -1.2531339946912992, -1.3530828241834925, 2.6956482246883873, -1.3259144022718423, 0.5383357978351899},
    {2.039060542988921, 0.5047103767183788, -0.7139093554039698, 0.362509215237194, 1.4474360122603356, 2.220146379118243, 0.5182597468002115, 0.8698972985973173, 0.8793604697983248, 2.011301902991131, -0.4253353172664793, 0.5070175939198804, -0.5087856617578717, 1.2550740330983554, 0.6738853906790775, 0.9211945028399249},
    {2.0297736071617964, -0.6684777746282984, 0.7289818133215661, 2.5880165263087913, -0.4629513156681493, 0.8001271204737086, -0.0192399639390982, 0.2296427608458304, 0.5476550042166983, -3.4662277822468943, 1.0743454246703246, -0.7293503205462266, -2.2237973020606008, -0.21716104057569632, -0.689544537800145, -1.0258609789726418},
    {2.062517676284349, 0.3611181107799919, 0.3723869767548603, -0.6088005610597284, -0.9938961552416092, 1.4389386716788566, 0.42260912500709347, 0.9221516517785582, 1.540655961755994, 2.597630500067625, -0.5050164010789837, -0.1817370754818203, 0.5075940750303262, 1.1911347671128705, -0.3016185869162415, 1.3970647833425187},
    {-0.11434216917918177, 1.4358238065347781, 0.4489692333470408, 1.0569157059989018, -1.5554875021883483, 1.072825042006867, 1.2775318052002318, -0.07053900836254627, 0.7976861368222773, -0.8201803192903513, 0.7299598163980658, 0.06178723399311957, 0.4654179397052036, 1.1704731990234816, 1.7677131081022124, 1.4372250331690926},
    {1.1518936693207642, -0.810268233096612, 0.7038854558269769, 1.7588766564703244, 1.7882446651923747, 0.9194481044648566, 1.806937487878478, 1.5840261964377689, -0.6066186213589652, 2.7383027341104382, -0.2689873414019515, -1.3960431235628148, 0.2745170677780286, 2.310033517125429, -0.7627710739576198, -0.5814013301867995},
    {1.3095950101900005, 0.1920281383290694, 0.7167696606406023, -0.48423231106048253, 1.6730329761166793, -0.2092721667094657, -0.17852929969933484, 0.12477822151631267, -0.1714494525210161, -0.6879294252958004, -1.2623617682095847, 0.4210149114669765, 0.2535959420186322, -0.16807562561242662, -1.670508104724087, -0.9856602813398058},
    {3.1971468150637925, -0.4196332624632396, -0.45890821335147436, -0.812758782176909, 1.3831280973319187, 1.225531358946479, 0.7542832966472588, 2.1689438677816177, -0.36211234606533566, 1.4268836688590965, -1.1759378181616493, -0.0257528245326694, -1.318768985519974, 0.5930045351492282, 0.6440956167226874, -0.2574773093162157},
    {1.863830865235991, 0.013539944652436946, 0.18876200488157865, 1.6090187227614499, 1.5776455104773084, 0.14159909817689886, -1.4228480882755443, 0.3218375138290241, -0.4602900208740075, 2.6639344613273264, -1.2969731101901645, -0.44424348965722643, 0.7446318354605127, 1.0968696220733916, -1.0920041092919073, 0.46841197739464363},
    {2.1149930445159906, 1.536778032274768, 0.7131245481587062, -2.024643107778706, 3.021997236967134, 2.3481714542626566, 2.0979161749302233, -0.00239468796034763, 0.6746192004121855, 1.3431864671400646, -2.2536965615877262, 0.3567828577549829, 0.3629896110713553, 0.8988960364893901, -0.7284708213212138, -0.7170164866682689},
    {4.07309535364109, -1.6562717425896436, -0.3608038338249022, 0.6817728135175193, 0.8125878038588324, 0.003888339241634805, 0.2204069653246095, 2.7798842217228317, 0.7943131601736889, 4.634619883346722, 1.3828861653535662, -1.6748770842936047, -0.16941667421612908, 0.005179366073861149, -2.48259509927949, 0.4651050012330243},
    {-0.0396787746450953, 0.21199747453020829, 0.05850769575518244, -1.9375110558531952, 0.2498379737025623, 1.5000672275063172, -1.272730973469042, 0.07755210523535695, 0.7205347372296271, 0.019491423937049137, -1.0971023041929273, 2.028780150201607, -0.7867506953706854, -1.2420430080731386, -0.1337970318093918, 0.38171406870398883},
    {1.8355986467087493, 0.5425592536837501, 1.8474597670213095, -1.7625260954078525, 1.4688874922919173, 0.39960801260460665, 0.8203183876648777, 2.3968189917947447, -0.407784648001681, 2.0710970393329866, 0.7127049013244012, 0.615750996373553, -0.12289577329761102, 2.094360469209215, -1.4356762697566892, 1.0085378031627885},
    {-1.0947907672685095, 0.6552274951089923, -0.7708001453675943, 0.7550935223678638, -1.5832914186203693, 0.13333870784243163, -1.0597733946124013, -0.6405503698217652, -0.5811703433168024, -1.9707215941767597, -0.163922416282232, -0.4807220575831156, 0.26557199153679867, 0.2706180942439196, -0.6460500268741769, -1.1893167375306417},
    {1.973938032523785, -0.7625361112136048, -0.023471131771603024, -1.0935042757563846, 1.3335818734447447, 0.5625465994340385, 2.4980242243569224, 1.6553634877087635, -0.4880170707854032, 2.161509946820348, 2.7587586623838907, -0.17084625520240124, 1.1786397801512096, 2.658416776017154, -0.7522526514442326, -1.4071434064815465}
};

static const float b3[16] = {1.651021173681013, -0.0835219324810589, -0.1537656553169718, -0.16064558358054282, 0.8369738955693867, 0.481512832812644, 1.2179497062242484, 1.4387887065684066, -0.2041318563647868, 1.8768031505042009, 0.042150580459169744, -0.03300955981089177, -0.06564351791145308, 1.14191656071337, -0.08157355727529658, -0.1434618329742908};

static const float w4[16][12] = {
    {-0.8605985301381232, -2.788284936105875, -1.5295170934253561, -1.141534580222275, -1.7822055987028944, -1.5904180569049646, 0.036046326546716904, -0.8962747291152137, -1.7235059152665169, -3.4912797419438273, -0.056337863474208605, -2.8659184452025896},
    {0.6640704103471377, 0.9829008386050448, 0.6205595343344393, 0.7094461853002306, 0.6993075103024657, -0.6658307144642461, -1.1877173443353843, -0.1215586580884555, -1.777216307535078, -1.2654830265301737, 0.8236159267555851, -1.0772120885520868},
    {-0.8582239200367395, 0.10272784220990423, 0.43787867356153476, -0.546077862758931, 1.4327546406796194, -0.5098331528450049, 0.13139201745675752, 2.0123981707191696, 0.1869773473357253, -0.17905112904286993, 0.43107732135528726, -0.976248436803806},
    {-1.1063791856543026, 1.1516673982633054, 0.11115701268613067, 0.7714491145852661, -0.15990081645401877, -1.286940248832238, 0.8196519943444288, -0.028230900568688662, -1.3878935860469177, -1.6520996859926407, 1.1307464184536202, 1.4803368142906885},
    {-1.0493529238709836, -2.1614184011633735, -1.4575419546149262, -0.5606864328321873, -2.7205442319346687, -0.3032510513642162, -2.0833639477199863, -0.3626075770717508, -2.341153269159579, -2.4407853471998058, -1.8279927210073883, 0.34948091559250727},
    {-1.131654188281528, -1.4394101651891305, -1.7688321323964076, -0.6350535662705156, -1.4846030667906067, -0.6186991730036506, -1.2887350978299872, -1.6339700016564458, 0.8300771197472406, 0.1890684016608512, -0.2675631764819411, 0.2854719446048806},
    {-1.238410928895547, -0.22269237387278595, 0.3304398450028898, -2.579461625051796, -1.7467672686369766, -1.7086878221534159, -3.672797309621371, -1.3070929001716167, 1.151121874743252, -1.229149152998876, -2.1630595528315273, -1.3035256591286588},
    {-2.618527863805492, -0.39795466337979507, -0.3225909661132657, -0.8976201095041193, -1.273828977642065, -2.1507040805871145, -0.12952220783561047, -1.2924451165105757, -3.200691545776353, -0.38862165807295257, -3.9500845701737135, -1.1029553317557397},
    {-0.7089462683653871, 1.5488346533677777, -0.5828333640073909, 0.14019209458653278, 0.06933037640997354, 1.4890933632608192, -0.16503813511289203, -0.4824083488065388, 1.1730812424522812, 0.15810723753408557, -0.03616369608105131, 0.12493583934841018},
    {-2.097609255240786, -0.2319310111399853, -2.9726394323145717, -2.0305699445248, -0.9510611664920671, -1.3260939364410211, -0.940689076776952, -4.032574373350507, -1.4573890576602844, -0.5910798069380646, -1.3075672512522234, -1.2147777728056652},
    {0.05564493129599474, -1.2026075992497873, 0.6159915660046383, 0.471721189321066, -1.5054242799286064, -1.4568553026545519, -1.599332136311669, 1.7717484730279611, 1.8580208425343219, -0.48349780101153983, -0.7671524664158704, -0.5386037187159227},
    {-1.1334821811198854, -0.8702463095598713, -0.07691543002323921, -0.4366450505551592, -1.0251888867857395, -0.03098520131906658, 1.0687372667881159, 0.4399314623504923, 1.107740157502808, -0.9474927482254786, 0.3821431564025711, -0.7417974265284818},
    {2.0300428971276308, 0.9466340768930482, -1.2957769309188987, -0.41218392330602877, 0.6134288582248191, -1.0458985684104825, -0.6508060085227073, 0.9664997298314357, -0.7472168390817714, -0.47610947298615897, -0.1378713559976503, -1.007891151279544},
    {-0.6219954442008438, -2.182970100700566, -1.0603266573334327, -1.6034326829320822, -0.2696390837344757, -1.6201874246295977, -3.461221125728811, 0.7686458603466574, -1.1771340790832892, -0.40983331388382244, -0.6180181333959611, -2.370897189734804},
    {-0.5255205580092328, -0.9800316961950997, 0.8646268469629702, 0.23121427640674244, 0.32460102166666543, -0.03972702664869199, -0.6210157646386898, 0.06964153474169496, 0.5876567078975748, 1.1518967132403501, -0.8444888684095764, 0.447345450199285},
    {-0.09721834804790247, 0.29256845361619055, -0.1439309121926655, 0.16450660182365273, -0.12828133554296192, 0.39727624390894467, -0.2813133179507319, 0.413662360690687, -0.058208721791541775, -0.7406747060145992, -0.7140368768749406, 1.1834807265926008}
};

static const float b4[12] = {-0.9360259381963628, -0.8539545368404294, -0.7923104960384859, -1.0122382148945177, -0.6307785166277727, -0.9942456129684021, -0.6829527351634362, -0.9903569348389826, -0.6832969028840512, -0.7493914920315051, -0.57134201354779, -0.8580772243888084};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
