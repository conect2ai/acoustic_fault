#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-3.849813879415772, -0.5103658328161635, 0.9492900434527783, -0.8713885857109025, -4.232942008213167, -4.092917555894146, 1.616866410770043, -0.6821935305395485, 0.27657279243291305, 0.06562502323765701, -0.2632434210967858, -0.6294453742250132, 0.5461987558965778, -2.9717520076622654, -2.3684895538632054, -1.9593305913620114, -0.34747852270171664, -1.2581685127109519, -3.7866822092696806, -3.3047887568974286, 2.1459052092189945, -2.141621413371371, -2.9874150535491104, -3.89851745089916, -0.27039636431655745, -2.645478072067016, 0.7773476692685707, -3.9224429293052863, 1.959630259648595, 2.116496019601574, 2.0916992892946005, 0.41667783769979294},
    {2.309935210835879, -1.8140144977691413, 1.6078940164170856, 2.4340366050279862, 2.0640216379126834, 0.5899247342705327, -2.897056206561526, 1.4963130800344364, 1.0584871995794853, -0.3728367697234525, -0.056908795154452574, -0.8473387613745527, -1.1979947301732743, -0.7142245815629789, -1.8314294207011348, -1.100947974772911, -0.1176347635810007, 0.15497364204399122, 2.6640342905305285, 1.559509818201018, -1.6352882024202409, -0.25975115141260524, 0.44604176102869897, 0.40422819000295024, -2.6305046776929837, 0.0659457245620285, 2.2740548678161407, -0.39446372776307964, 2.775948853249433, 0.25246757061207187, -2.9815516724286795, -1.0333035045839827},
    {3.9456956113817516, 2.6452391977353633, -1.4477604683460776, 2.745980504956114, 2.036631809684952, -0.09880951818597178, 1.7970548568298716, 2.1665150437234755, 2.77445853112024, -1.1230600025130988, 0.6243152579422666, 2.6003243402195415, 1.8777268495018162, 3.102220799205926, 1.5523091432144367, 2.3022326278705947, 1.336505727125638, 0.13838394681817, 1.2799646241747196, 2.5059377448013107, -2.476278977735724, 1.7202601096022885, 2.6892227583836252, 3.016531735528095, -0.7547355999824376, 2.659085135613867, 0.13554076956894393, -0.6769868961655963, 2.1711806819363892, 0.7976969166474203, 1.6302180875155265, 2.631217532853627},
    {-0.056148459849835734, 3.490284147341394, -2.9672204299942764, -0.685826074206191, -0.8212072164355496, -0.8232909641314191, 2.3126459385820315, -3.5990441118834737, 0.8521927283354795, 1.1628446492472506, -2.663572506157314, 3.0719665012737356, 1.1088488656836852, 2.4637039492571957, 2.613576150322013, 4.449307189743224, -1.2894651729404945, -0.9050155864269996, -1.88967437347924, -0.41822828746124846, -0.04903056539225823, -1.4418391622662616, 3.734568976904109, 2.788703437018713, -0.8954199307468913, -1.3459319649115355, -2.163469096933109, -2.0876924625919524, -1.124182555191372, -0.7084064613372881, -0.3950959392708777, 1.2725248508432205},
    {2.8350383280814038, 1.822625953275808, -3.592736702305956, 0.5389558590308646, 1.986841593148723, 4.049440398580426, 0.27281787022826576, -1.4067332745188823, 1.2659826871741278, -0.45794970855760686, -0.6128311668035804, 4.420300638460665, 2.6076196324352963, 3.5331567562669886, 3.7571732193710625, 2.145897086539401, 2.1499054482598225, 3.1920991300857198, 1.1406360595114562, 3.99248816951707, -0.4861997509408889, 0.7667066384704884, 3.9978995345852115, 4.945956043836794, 1.8585504116977398, 1.8730243543440515, 0.07465156244695105, 0.6773502162697641, -1.7700675852038572, -0.6002469857828711, 0.3544382711973494, 1.0097182530983269},
    {4.07987284493153, 2.203566728002391, -2.992619503992326, 0.28966875122180713, 5.293828324116009, 4.662887317879974, 2.6845612503881324, -0.8179001485080563, 0.618056060783222, 1.4635230095865464, -0.3273541375827382, 4.880595124479932, 0.5451552135670473, 6.478306407527836, 2.441860363909112, 3.505563833898812, 2.540045028544592, 1.767883544749076, 4.488925290954272, 6.137070501422318, -2.032321912844126, 0.44963423226759003, 4.988610510754266, 4.357628441647188, -0.18486219237932994, 3.5583073551563085, -2.3544142852165098, 2.502729887868166, -0.6386656021407596, -1.5257355942310293, -0.9140735609531656, 1.6463007034764314},
    {1.9508333465183725, 2.030759229806194, -3.268089996846739, -1.285877846170389, 4.923131525858357, 2.6102458082216504, 1.397853248383916, -1.7210093971033293, -1.4178665591180208, -0.015762066187068623, -1.7818951664406932, 3.1896137930990407, -0.8177033792470014, 5.735912169558121, 2.266093283849096, 2.067792895305097, 2.4307067736690287, 0.7434799891318762, 3.4502093965485785, 4.745660010950114, -2.6718969063164546, -1.2003710328904693, 4.366688494414538, 3.439826986937303, 0.25489605383242553, 1.1335593565033515, -2.2460889115065674, 1.4984463270729678, -1.1003986014123792, -1.8325418649749927, -1.5397578656776636, 2.7254294155379815},
    {0.5988495393498788, 0.32622759958868924, -3.586164891189276, 0.1830860865154412, -0.6155692311562201, 2.3107724323890286, -3.208976084787395, -0.7691346595639823, -0.6384324772074792, -1.4639064628296188, -2.133839045958581, 0.6959655186082516, 0.29423688032429113, -0.3082128523592973, -2.142749557356623, 0.2331010362956046, 1.3032731184237971, 0.6723923090717259, 2.0343426383464163, 2.372341015722143, -3.061647359263377, -1.8203403299437804, -1.782310653368019, 2.141538641084665, -0.5370094593503462, 0.10928369732405037, -0.8011532335737745, -1.7366909903388492, 0.8787359927912098, -1.394143754537307, -3.115563772717411, 0.08630844571356142},
    {3.4948255215838975, -0.5627240706390128, -0.7250838683076025, 2.7141695861369675, 0.8213350433705588, 1.8285182423881463, -1.2539538256224096, -0.39942263650514387, 0.2399557694856925, 2.423950875841866, -0.3508766161128461, 1.410448510191412, 2.7831627183357597, 1.7155671689839151, -0.5481403768254827, -0.8392832913066341, 2.0329087805166735, 0.17986369018116477, 1.4424264195113878, 1.6458104001247271, -2.128052624596366, 1.8888442085077317, -1.05596821451153, 2.01359838518999, -1.9713280729955207, 2.129951865937668, 1.211673289711667, 2.080013589733968, -0.3911055423909332, 1.2794071059149918, 0.8490235856947087, 1.2547315426809142},
    {1.2410293058524497, -3.011235762041979, -0.7723667953563269, -0.6955701918833159, 0.7675281617574328, 0.7673361922566745, -3.308530218217288, 0.3710743904563967, 0.12013270387390335, 0.7853413891437586, -0.8647854839552221, -2.5839351779972444, -1.8787472136168795, -2.9896856477093827, -0.8739789678025247, -1.6088189018783778, 1.7188948897337613, 1.1223569102329984, -0.08120470822762905, 0.9398528522086805, 0.8197165765615246, -0.2018436072741003, -2.3530455044902356, -0.5887004829949867, -3.6310393887586554, 0.8337187084059211, 1.6716712992093776, 1.1273264363350999, 2.0316237490758016, -1.4715809193984402, -2.4599134121101347, -2.69524542257013},
    {1.1534723661225288, -0.298893834563721, -1.9205948049346655, 0.08115522316247667, 1.2861011331803518, 2.0853043980101496, -1.509659531342106, -2.789833045350545, -1.585509707947938, 0.6574893189200124, -0.28378443370193773, 0.38604028073463686, -0.3728248391308008, 1.5595388005964068, 1.2383432157966219, -1.3544073708066802, -0.09169727317718873, -0.1173300430911498, -0.25644495128063366, 2.7536448641723834, -0.43163460427654643, -0.9615790451720186, -0.6121982861634173, 1.9711460516932182, -2.959913398620021, -0.7670446068256873, -2.178310709597942, 2.9598095163072875, -2.008493176344167, -2.5834690845537134, -2.7384385473419046, -2.7160693516113303},
    {1.2137759620977129, 1.930277201913481, 3.0148804748762155, 0.327224834637228, -1.2679647770067122, -2.79261008745276, 2.9573370818531557, 0.8218325750244201, 1.0262851196235159, 0.8999056638515123, 0.04177981346749218, 0.04052135353448311, 0.4455903035085006, -0.08297148270813334, 0.8596416719744688, 0.9387785034925337, -1.6137836866105701, 1.7546049044829053, -1.456622305131255, -0.5677847836933818, 1.7890452388715052, 1.838563135304327, 1.7261950301974998, -0.1259103890069139, -1.3857360064059572, 0.7174933692990744, -0.4314845993747344, 0.45154963834679707, 0.768831534138994, -0.446598018020724, -0.1073087440994717, 0.7264828689650935},
    {-0.23890139471398023, -2.270913588266639, -0.8210242709752248, 1.0072070428108792, 2.3353644490645014, 1.5463235691652801, -3.4607068407851735, 3.8788472122371416, -0.8731775653055808, -2.5564946038501004, 1.0669639086000577, -2.7496993712614755, -0.8962844213237109, 0.27212881546454193, -0.9640471568895485, -2.294592912749367, 2.237827909479424, 0.6752794656891092, 2.509267397833835, 2.1247339892859505, -1.4493762353508528, 1.9618106016059473, -2.5838381083358257, -1.0327529918662177, 1.302973409184086, 0.024053403910434926, 1.2883162390985652, 0.43047145687164035, -0.04296724140715369, 2.2260897729863145, -1.6838086457684172, -0.2635594393733769},
    {-0.44963124528234205, 1.3057281400120755, 0.5767345174617892, -2.416585099507807, 1.2649629176543926, -1.7661590617983167, 2.4988400810915676, -4.410867761447103, -2.1946877867979073, 4.628777543687332, -3.4310879493329423, 1.3943414076401601, -2.9459525182091593, 1.704082431472871, 2.976944649710599, -0.11620132067294119, -1.6200540344058216, -2.10304210493939, -1.9389604678665855, 1.2009576377029658, -1.8709820486120867, 1.3875136524080722, 3.3224833779650362, -0.625078163297333, -3.1093991466631383, -1.4450375393540602, -3.5318573860929128, 0.8114108780856786, -3.142502150085976, -1.8395648882825084, -0.8678700457686915, 0.15592312676596007},
    {-2.187874892904246, -1.5991922228132676, -1.9336880550598987, -1.5953391821909422, 0.8722437904388015, 0.15574285597363668, 2.559136571889023, -3.493694234219183, -1.0050446847684604, 0.940861873327974, -1.6670424772067562, -0.853510916082119, 0.09399293552359754, 2.8929895250265636, 3.2406220744091443, -0.06157099570331903, -1.4624207415245485, -2.7133326266323583, -1.3008028199049912, 0.23810446493458945, 1.0634207801710358, 0.8458699953722657, 0.3028245022866175, -1.0580310326975826, 0.14678362062469616, -0.9843258544081382, -4.785556915904456, 2.4165313348957094, -3.2985848512668126, -0.7509629699378366, 1.3717461637564947, 3.078297429909965},
    {-0.4087834507871225, -2.8855547088763096, 1.9278339135290954, -0.20267173877940303, 2.230267433116258, 1.0046240909731776, -0.20785805799417845, 0.944738045668872, 0.810808441754918, 0.2331256641479228, -0.9410323649624853, -3.589135822788052, 1.2711556499596317, -0.3912848011708668, 0.65590680295569, -3.8007457213421403, 1.8734965675444837, -1.9350698263567545, -0.5282197885804054, 2.174613000190853, 0.9038138633067809, 1.5876288848899682, -2.048338346646052, -1.6929632642524917, 1.9072775645652518, 0.2735211472528391, -0.036201318129336614, 1.4007424200412646, -0.021182678768513635, 1.7217780531746676, 1.415018682403874, 1.5229476297017206},
    {0.1118513793062063, 0.4953164510968296, 0.18001529661691004, -3.3640856141977924, 1.7123101074123193, -0.5646731361372391, 3.3812449400924334, -3.5950505716195016, -0.894154371223156, 3.3424345191738136, -2.3095698761019876, 1.8984755455807374, -3.5446336017904927, 1.9454442157229748, 2.682695676533666, 2.3967956045607037, -2.3335775026520156, -2.6908580060596274, -0.7916199676974468, 1.0767332516785741, -0.8621543462587371, -1.716270233750391, 2.4564426830551067, -1.5027750386157173, -2.504225740697417, -0.25741353567433667, -4.530720623416926, 1.9873779351181573, -4.413261992901779, -2.651901781617424, -0.46531522953414856, 1.7036832988188102},
    {1.9176108512303214, 2.688580861478487, 0.893329109197846, 0.16412391928360495, 2.728613794188757, 0.36667873449274446, 1.7209249026945816, -2.4364923805500203, -0.8086659703390932, 2.963496581281512, 1.2249921506018704, 0.4199829272776636, -1.4835111295850774, 1.9031570099835804, 4.0466024134512475, 0.737684351748939, -0.09852616560263205, -0.2366034409258788, -1.5568585030710167, 2.0144489050988863, -0.28903192913020703, 1.894512901441498, 2.0244256419713778, 1.8042821323283276, -1.664539600720655, 0.8786755669843649, -1.5775283517664092, 3.303220281908892, -2.610418838955192, 0.08597516941270017, 1.233176429373133, 3.3181847030896847},
    {-1.5768321522236826, 1.0227372575314861, 2.4386857894772698, -2.7292071775102054, -0.02724157391082277, -2.1962066848937143, 1.9118139522520807, -0.48182947362193607, 0.8984596382751967, -1.673364693399991, -1.2044590903838628, 0.3958697630510186, 0.2693615236658881, -0.11054574883064959, 2.2343990994111813, 2.231981574936526, -2.1908192625847853, -1.457672640147535, -3.1616488147598636, 0.20984872795732262, 0.3567508983489329, -0.44658579499047873, 1.108373342815596, -1.9847734649340691, 0.3983716040669602, 0.8712176809001422, -0.41893423530069207, -1.1186844796970175, -1.3682295319781252, -0.6410880792235112, 2.161720086153709, 1.7499864153229976},
    {0.19386521529496106, -1.075293352841577, 0.9108285052396565, -1.6992438909842555, -0.20253430202225628, -1.901542517104721, 0.2151961563127144, -2.1541215565314817, -1.7773254829154155, 0.29111411061121106, -2.705113146663789, 0.33423144049058534, -2.937877325069866, -0.46306855583237033, -0.4302257028195505, -0.17497275978907803, -3.128161849398145, -2.4962257928229725, -2.1932603583474517, -1.2126625935377615, -3.175711829313647, -2.319643152745175, 1.4843832077845451, -2.814123911348094, -2.2663383602939398, -1.807395450740128, -0.1780105566940804, -1.2445124340004126, -0.4314153603327992, -3.13524218685532, -1.385158984109564, -1.5046612780106474},
    {-2.0851820406892894, -0.6427567699075792, -0.7466869782570914, -3.454050507636237, -3.416550942012127, -0.9835093102670817, 3.43758118244648, -1.4485042140900426, 0.09724176822597842, 1.8063151986416999, -2.586850015262234, -1.138269260781147, -1.607994946715206, 0.5523017910587809, 1.8491232681626864, 0.75059429317698, -3.4198274056337135, -3.8403672788260064, -1.0800436123399408, -2.339030357743121, -0.7864176764590368, -0.23498191702671176, -0.2853961644116861, -0.3543165876126933, 0.043587520141976026, -1.4197172043112765, -2.7680381053942806, -1.854375660317706, -2.1022249316094075, -2.356022541020258, -0.8892930213139495, -1.1556538766999649},
    {-3.708732126026145, -0.8862667871198858, -2.2607145169385277, -3.5953142553539816, -3.089579741199232, -2.376095400740497, 0.5493029086011391, -5.304544350518077, -1.7688747056601617, 2.0519545019772054, -3.268445329160438, -0.927361878623408, -3.0850642973713747, -0.4438437032532161, 2.41873559635391, -0.4452617185624143, -2.415189902380685, -3.0971495630424664, -1.6250091005194123, -3.1456348595487897, -2.020082067782155, -0.876928890681787, 1.7436986114636293, -2.318117624416473, -2.0230277192280113, -1.6883143681862263, -3.5290939181766956, -1.4300483413269514, -5.016638829243672, -4.965969731754846, -1.7230435037884042, -1.679594595909328},
    {-2.2186149677184432, -0.9025955308533052, 2.241224248041526, -3.260908227870424, -1.8234910799146034, -1.9874506014376345, 3.013348318388068, -2.684512678887353, -1.8400894860645267, -0.49429211753709357, -2.804804782493481, -1.7991414005295308, -2.7523303167482225, 0.07195854600061082, 0.17578740702788634, 1.4929501910770944, -3.445535966033724, -3.5147297965711934, -2.089289597013184, -3.1781026997690542, -0.8899995790490626, -1.220884893060979, 0.5780453311120618, -2.554213465088396, -0.8319012633560815, -3.490447290839481, -1.0343349248443798, -0.9070079313410779, -3.274900394429124, -1.212880144391649, 0.892762266398142, -2.7166401279647068},
    {-3.7286410982348364, -1.9479506469126489, 1.193069558373007, -1.596073177119965, -4.037100663827866, -2.237742692761362, 0.05364732515422498, -1.3888976791349503, -0.8899875151104016, -0.6651550136409149, -3.0826253206977046, -0.05552202722964152, -2.9910588282429575, -1.6135797053460095, -0.3338511778343554, 2.033582014239734, -4.027157480388892, -1.145830497603371, -0.9710325542528675, -3.5763638030730753, 0.2687157368477602, -2.799253311112693, 0.7330732291404448, -2.359308806706362, -0.5878121149761405, -3.06886686291847, 0.515961787144873, -1.6610798938620357, -0.37904951889389454, -3.689443764273446, -1.0910958050431492, -4.637998938855517},
    {-1.3872616031468783, 1.1727676853411806, 0.33465735970269156, -1.1233863354011204, -2.6868243415474047, -0.7025006930735609, 4.189267192164269, -2.9486529986271863, -0.8780072110007406, 2.9336248530325775, -1.9249009674179511, 2.9699700798659845, -0.9044801703155573, 0.7021205159943884, 0.5617965889673622, 4.140230949445031, -3.5920922719030677, -1.241855128682987, -1.7490359836262352, -1.2587821124190228, 1.41298798060434, -0.7290671666477979, 2.1319178638179626, 0.8677591136470255, -2.537194771648333, -0.9300481575704402, -2.0259534805437713, -2.200146350338042, -0.603911309879168, -3.5078825673489815, -2.046407444007781, -0.87098171252511},
    {-3.3337919353479104, 1.6747474926134607, 2.394147984408873, -2.4271760340363557, -3.4453674063562496, -2.926509574100327, 1.7020981438716596, -1.794902506586854, -0.5248375005667918, 1.8235853485491653, -2.4964046300935587, -0.3107231723188308, -2.049209888177366, -1.664225643615544, -1.6394001725163283, 3.019859065803312, -2.670835165565805, -0.7432352163511969, -3.153817384271484, -3.554657228888761, 0.974367467158142, -0.46246103523608895, 0.3164007526597822, -2.5309450598731837, -1.975079526342449, -1.6522680507958576, 1.1692455098073808, -3.290473637176306, 0.1292119121483197, -1.192983436939355, 0.2678294042785489, -3.0582779297642677},
    {-3.990407657145856, -1.95454980504563, 0.77573492442612, -4.076975374137096, -4.4483471064312985, -1.7009226666452377, 0.6341506108751731, -3.327465075494203, -1.4310822850727187, 1.006697469668627, -1.5972030749825874, -1.0201527887563873, -2.0755222373780904, -2.9463839283072284, 0.3159267030540741, -0.15530890403036207, -3.154658883809334, -1.5318275936315124, -2.229880453987075, -4.9782452029933975, 1.9219860028605409, -1.5699892580783084, -0.20408532335416477, -4.284783497667809, -2.276082732521482, -1.7047697689536574, -3.178692781061981, -1.4607423407346, -2.009707993002533, -3.4743078187521417, -1.2792816231244144, -2.6602214942923226},
    {-0.1715665801360307, 1.100318439385303, 2.009595153448951, -1.1108895716004215, -1.2266011080955632, -0.6251483725976263, -0.20659244447203215, 0.4596894530308135, -0.9964541162271099, 0.06987579224725224, -1.144108170886235, 0.8057473594852538, -1.0421015646150111, 1.371262659989846, -0.9648657143195069, 3.278691939843173, -1.582066830229698, 0.6761521624302886, 0.03184071418968685, 0.3632869408193827, 0.6074375482266433, -1.225302844617561, 0.020024034647601247, 0.6396556460076279, 1.6320051479201036, 1.0534141224239497, 0.0006912252385561791, -1.4864031488764873, -1.2211257012587657, 0.05318438603943316, -1.0429684275118898, -2.555349243446298},
    {-1.442286237115701, 2.4871182820042974, 0.39903387864210776, -2.1903325186701577, -1.4524679656137935, -2.8630171775141693, 1.2409908418046096, -3.712477803331794, -1.6600126240482098, 1.8256272711007533, -2.3911193976376084, 0.9323341044666015, -3.3198777068034033, 0.3346679034671182, 1.5198324746203293, 3.9217329387211963, -4.247340979635885, -0.22436389552870667, -2.195166617442488, -1.256272402535355, 0.6948481167078481, -0.058377358950429475, 3.1434025468801856, 0.655026146905533, -1.4735549870362277, -0.754237095596243, -3.144074154026668, -0.5512369291309825, -2.8338295569244503, -4.548753579359546, -1.350702951434055, -1.6359220983874385},
    {-0.47233318880843617, 1.0044071291994925, -0.45504629651735234, -0.8286967931640793, -1.5262685814756405, -0.3002996704204858, 3.7466631280940557, -2.392691855539476, -0.4017778342855106, 2.4923153250895, -1.1940901753339106, 2.331229465388024, -1.6061279679561296, 0.8504191300324854, 2.068208315998169, 1.9065122860394526, -2.255399850949948, 1.274862501594038, -2.924015846259626, -1.1981378631162243, 1.8945408913896096, 1.9187480703091697, 1.443369518848074, -1.0977321902166766, 0.29434830920603383, -0.2554800879560259, -3.3145417188760864, -0.45752041206618027, -4.270300025580141, -1.6906291523907444, -0.8731882367973192, -0.9885907245808575},
    {-3.662377209288618, -3.958993034296864, 0.8744977905748771, -3.959073050855152, -5.848922247333981, -4.834939534331242, 0.4791790654258253, -4.187804246257355, -2.990782637665973, -0.304523798166525, -2.5149119331867644, 0.4205013335693364, -3.8641074298942537, -4.143503284172576, -4.835364205846692, -2.8025785896137605, -0.11088326499157995, -5.73321917018608, -3.3871051580546903, -5.0858763361484955, 0.4579993926317765, -3.621622513113412, -4.217817960897925, -4.293852354740286, -3.2438904228210808, -3.190314069313699, -0.6079725430668508, -4.859316302708354, -0.3188164564536689, -2.2099399590370656, -0.5515034277546191, -5.335666742810109},
    {-1.7831083685732536, -0.4820976908530338, 0.7090900764643265, -2.6556741065250393, -3.4770928544659, -5.037403176387337, 0.32371702352484066, -4.005635803481205, -2.6376311145509215, 0.778065011031694, -2.906123341501639, -0.08725045460201424, -1.5394774796435304, -3.047907249468449, -3.294482638728161, 0.8595064057869494, -1.8909829530940447, -4.979328392274259, -2.3711335522278856, -3.6953164033156374, -1.397429391175001, -2.1003809960464443, -1.3282877221731724, -4.011659964571451, -4.132672567481226, -1.9139757469954044, -1.719494159245193, -2.5347540275602665, -1.5903392865283499, -1.0962152162015635, 0.9821664917609542, -2.192647340664173},
    {-2.1215813983059313, -0.19018695976597474, 2.1239176974387433, -0.5468845925838408, -1.622570915335152, -1.2763131312464653, 1.1087637190230712, -1.217783014138706, -0.03731264493959583, 0.5667937666748822, 0.5386031586027242, 1.1964026638157819, -1.448949621030793, -1.6814214612952592, -1.4981149436915284, 0.23316793387757792, 0.14737447218538688, -1.701228366411194, -1.707310651750996, -0.6731923326584645, 0.6412733966921726, -1.6261679793317232, -0.971620492079431, -2.7559973973231564, -1.5435774396778876, 0.47648437066744664, 1.2218316286235795, -1.4094552397624585, 2.1763732463773118, 1.6908696455677468, 1.9393438812203558, -0.4140522184613751},
    {-1.0957374858994637, -1.3627796609481846, 1.3453468486985174, -1.641783382847376, -2.9810627723936527, -1.8216373120546454, 0.8238077305655759, -1.0004449833380433, -1.7732259676594653, 0.5174665919624084, 1.0495667006939802, 0.568835682585329, -0.8197331551066362, -2.631088533918075, -0.939001845773356, -1.3879102775413297, 0.8951422643927124, -2.194887448972875, -2.5553890530709076, -0.6490027586033847, -0.1398593430078843, 0.2884745459529384, -3.0243118708621157, -2.5890832608412695, 0.8294495168611628, -1.9603147772869949, 1.1990543162207639, -2.5143715396431356, 0.8062868311215955, 2.106424387334992, 2.0861874545165655, -0.2751917671173324},
    {0.11795188142161855, -0.4731811633655036, 1.4458526893634165, -2.6847683094152273, -3.489086779058027, -2.273967683496159, 1.6496554254414522, -2.662444252706454, 0.9068833249810152, 0.30158462049749535, -1.9340972826038259, -0.21557298558083057, -0.6084634539570883, -0.6226391769887968, -0.9618547084690178, 1.0324916370617034, 1.2459770713525278, -0.2107555213691053, -1.7009873492549872, 0.0634192145666005, 1.7693868284206062, -2.4312472566221963, -2.2274165369144114, -1.9336588388488216, -0.1493020302401482, -0.5667254889846278, 1.174502068135233, -2.602442964904737, -0.2638875230194217, -0.533582242893615, 0.2616896086423572, -1.4795922758092726},
    {0.7094438350122755, -0.9080187117933902, 1.6696115469653148, -0.923127462154641, -2.286010441601011, 0.2949754981295075, -0.04438377385399902, -1.937658762350201, 0.21018638717717955, 0.17822934249834232, -0.8344208522464623, 0.5954859410680103, 0.20397956590776486, 0.2869497496557107, -2.4207477601082963, 2.117214944050078, -1.448734435415658, -1.3583428707717922, 0.9113784603752031, -1.4101288773247336, 2.2297145900898485, -0.5166837768072972, -1.2255187668234093, -1.9974311045172426, -0.8002853790271054, 0.6462004799206862, 1.1635984785011313, -0.16047764241360177, 2.085062750062433, 1.0195174848721067, -0.43979010646026967, -0.7794927610702829},
    {-0.869416618827147, -0.34625546551320435, 3.026671459532019, -1.6811547462857284, -1.315810414374515, -2.809606631355844, 0.9889361789899074, -0.24611819498827708, 0.9695166758043927, 0.3713510974672795, -2.619928728829781, 1.8788904727637816, -0.37866305657955834, 0.39192020955389784, -0.5529739004275055, -0.5869350401520301, -0.36709858443916715, 0.1976389970637663, -2.1814194341395554, -1.7587854575200774, 0.8538207289454113, -1.7690393084406504, -0.7137416162449528, -2.4107545993324506, -1.8136963135665227, -1.8123015536920528, 0.4187607883960537, -2.5299109768778636, 0.9158767031411186, -0.9498431727234476, 2.39026264331095, -0.30010088642385374},
    {-1.3176834100143833, 0.5148009824524618, 1.0359521729936456, 0.9979165507991767, -1.6181836012022162, -2.311237964716425, 1.711815510914762, -1.4324026847868572, -1.1167114430279286, -0.542205099980335, -1.6920103270523172, 2.201028100076511, 0.5424475073577986, -1.7136024791434685, 1.2738975262256131, 0.835666990553801, -1.407806670631024, -0.18360210814684552, -2.9980549536953514, -1.2254463595099605, 2.5192875567217823, -0.25050496399601885, 0.65850316945321, 1.0314814688425367, 0.4090846338493557, -0.6752223530962481, -2.4659410779000552, -0.873642695126873, -0.4999334659508383, 0.13469543734044842, 2.455599982867654, 1.0467403119018062},
    {-2.817051959439484, -0.40590310902844556, -1.074204219154834, 0.4727953215838777, -1.0753712002081957, -1.4166767348160487, 2.291255450522528, -0.7787309189773504, -2.206799877427775, 1.5114898768584715, -4.347335632361426, 0.6649960496086922, 1.6012256791424064, 0.7720576211391073, 2.0114777333394724, 0.7705118565027066, 0.6841140992726691, -0.35232685614509535, -2.1996886972151577, -0.5335332463825796, 1.5642246781836384, -0.03592929492798091, -0.6686496437141217, 1.8848733731221539, -1.428137853634697, -2.1585549109690008, -0.5861510180019521, -1.054583887049936, -1.3605851680068155, -2.81428706398896, 0.09919769513122338, -0.7829619761602931},
    {0.5719456123465423, -0.11687690192786149, -2.132147153512786, -2.239585401593711, -1.4564322630466526, -0.7173255127535783, -0.7186726087357171, -0.19429565749880937, -0.9742039142661024, -0.3272568059251861, 1.3570269232065904, -1.1138346067332763, 0.05656245242222502, 0.06843675961438417, -0.4175125358055764, -1.065157845003944, 1.1159166370902798, -1.4407847932827464, -1.4551774402688074, 1.2418554600313831, 0.6990206204609312, -1.9526403001315504, -0.9597280506603589, 1.1535155222506361, 1.1916450087019248, -0.543870434755645, 0.17523863464232353, 0.3527199023710531, 1.4406752462914392, 0.3958595275705381, -1.1880471137073163, -1.3665238702891485},
    {-0.3547022742224644, 0.6947407900484178, 2.8475170287959624, -0.5651846414788939, -1.2996661823428606, 0.12608129156197795, -0.9105215889757595, 0.4606649925965414, 1.1964546503181563, 0.06066065711398113, 1.2567321972146304, -1.3663600817900117, -0.7036266402882844, -1.5516225230911302, 1.0645435968198622, -0.11822419931725049, 0.03856343652590734, 1.6793621009109612, -1.3793106600404146, -1.282158838922571, -0.46850447076206114, 2.126028260909072, -2.7531838624816443, -0.17099698578739422, 0.9907394610841618, -1.5793506718021477, 2.0716752960761733, 0.7675332528697683, 0.4120400736490508, 1.6742542211211806, -0.8435560576537932, 1.0243481255908593},
    {0.043198495426487245, -2.929230029750969, 1.95679410771878, -2.1176611705179917, -2.1752572919155706, 1.1611855572096033, 1.684596585181951, 0.3279558698691745, 2.3718113772257734, -0.5005625882654393, 0.48483821526534554, 1.2703865061188016, -0.6604289573046827, -2.0393741605335856, -1.1140282879994245, -2.0261405962443186, 0.656304519741878, -2.7813245596115825, -0.4821492176390246, -0.36269989543871983, 2.1464610605372925, 1.3706620375607699, 0.7529940338592975, -0.09726549419753774, 0.7896901394458246, -2.0459267741388736, 2.816568391553372, 0.08397048690948267, 0.7301117328069834, -1.3916491404592208, -1.2103722536858619, -0.9585266952362759},
    {0.6814760428590038, 0.4993211879361403, -1.2703403185449882, 0.6541803431077603, -0.5263444422608184, 0.7890384189219987, 1.529904410664331, 0.7840727328407371, 2.285889985584444, 2.612328076085195, 0.5158293859442281, 2.533428729378602, -2.227639500091547, 1.505750959186869, 1.445474565105225, 0.7453596828262835, 0.19949165778633474, -1.0349961284249651, -1.20868656454285, 0.012259693434074995, -1.6385427227897043, 0.5035036403332076, -0.6611581638609685, 1.6195127374068592, -0.09015523545912545, -0.17593678903612783, 0.3933562472185264, 1.642524416919966, -3.3165077249185555, -0.3450654112444065, -2.0336909764004822, 0.7403419200786728},
    {-1.1341873287144701, 1.1060794702473116, 0.7421490805282142, -0.2632357250959727, -1.1688181289654396, 1.7757815179379213, -1.5679529992190266, -0.4501828864740949, 0.2941978144774508, -0.8372687461377626, -1.1160559762399087, 0.5122252737016193, -0.36529716940450074, -2.114627248905275, 0.21755720714764498, 0.8952898050956666, 1.034541145470534, -0.954803115462385, -0.7203330145171011, -1.292549356111237, -0.016954173654559115, -2.050293315351449, 0.6293304433031878, -0.02835859885175186, 1.4817217012013093, -0.6140504202042322, -0.2455819822077992, -1.3225770728240005, -0.9070618682586514, -0.3986429512349742, 1.3911582305460082, 0.11928455938173074},
    {-0.7036266425504359, 0.001132602254930504, -1.496788530586791, 0.4981403132021598, -0.3239113705940462, 1.1427568090363989, -1.7436636905477068, 0.5341293368414786, 0.33927806649324593, 1.7938999781067013, -0.8716823489115858, 2.120397391763074, -2.180226859486392, -0.3305342234833088, 1.7718016976259692, 0.9703940104927157, 0.5251423924491142, -1.3389439757577724, 0.370800314441796, 1.1787855321024134, -2.237053267797558, -1.0395191336431615, -0.9413169647599094, -0.8246539089069512, -0.03753617381316096, 0.7606008857392437, 3.063146977241648, 0.5781637863288992, -0.4864411576356723, -2.611341382844132, 1.71071686228992, -0.6783735120610874},
    {0.9288942074820251, 2.5221630650470037, 0.41329103024470637, -1.3437992444861757, -0.5586119141958779, -2.2376575151203024, 0.9574969003543535, -1.7388950497171103, 0.5827855227067468, 2.865203274616375, 0.7438203272037849, -1.4546206562551003, -2.1777088646956755, -0.06291649568379472, 0.7600767076492164, -0.24442467504349605, -1.1839724650654468, 1.605456396758587, 1.5407827115984876, 0.8704766032172432, -0.9659459853972207, -1.8956757741253465, 0.8368821635841804, -1.7100479639454216, 0.34494717244555645, -1.2837707630039827, 1.4444267260238755, -2.508858737873584, -0.7288617693945308, -0.22772361817550216, -0.5754727619335968, -1.8483870158368383},
    {1.5874327658794805, 1.178921655373822, -0.6915334711573796, 0.6127545286514299, -0.23528106219720143, 1.5598587458736073, -0.5954226189592903, -0.7355644573274392, -1.2683655302931762, 0.7686146860834336, -0.9519133346194325, 0.9815624259427255, 0.8909344823463747, -0.7505405870969336, -1.2915110471480467, 1.6919719964509428, 1.8979645233107414, 0.6610214309959521, 0.19868473413661736, -0.4584974327623929, -1.0241302773911234, -0.7952397007462567, 0.8290823350274824, 2.7043169454889533, 1.2092212328135479, -1.6229121631090344, 1.3185856879498095, 1.2827719883331814, 0.6055610221978305, -0.5722541631989511, 1.1315211259503257, -0.2702895947318614},
    {-0.31658765545086087, 2.6234259595135074, 0.8594493084594975, 0.7148251813702772, -0.7152093404825088, 0.11551002121980584, 1.2518271227900049, 1.6449992200000625, -0.4213509851365468, 0.5673548928556281, -0.14720842254209757, -0.23608196349692137, 1.8527007901803387, -0.648615154492706, 1.1357156440250407, -0.301605346937949, 1.3703240177025222, -1.6049034302285325, -1.1372058195696941, 1.57952639478086, -0.6866713604465501, 1.2061094674169368, 1.7197994371000418, 0.14873038902427335, -0.33209812127474336, -0.24836509770284057, 0.666913602194164, -2.4238384560830593, 1.1608273633727557, -0.6849129792667868, 0.03980557658858806, 0.8494751975362104},
    {0.04191504277003677, 1.4135838925565234, -0.6240893759671987, 1.3433085985147495, 1.0518998077205455, -0.502843113394606, 0.9436622506663177, 1.1337400291697795, 1.0847625882455623, 0.08433143767809853, -0.8775526224721875, 0.8942162582881957, 2.015155898129856, 0.6197339502064256, 0.8897917623828201, -0.5295995994045357, -0.636223810796671, -1.1443430133106982, 2.075381424212803, 0.3210664831562099, -1.5817397560882085, 2.239347810375721, -1.416412813208187, 0.39251858268611034, 0.9043126133537945, -0.4779281211879199, 1.3431673971905438, 0.04863541523987919, -0.5473677224234229, -0.10967563141283429, -1.2203715945865683, -0.1786752583919606},
    {1.03101104663166, 1.9387862717428654, 0.9515552782473637, 1.7140195564111762, -0.23311575761368603, -0.10118593125570959, -1.9342562742768055, 1.8468327592256486, 2.4907567754437494, 2.122773038688606, -1.325088420152198, 2.587555277385333, -0.24496612167627427, -1.6467499980930569, -2.643754556908702, 0.532160289622678, -0.9497659271983314, -0.20712763758349007, 1.0794314548993653, -1.254337470809363, -2.2319066941030155, -0.7809884135514973, -1.8486983850392114, 1.8413025207100995, 1.4770771746645484, 1.2446235861795527, 0.01944703276317644, -2.6707892068161434, 2.544048588743719, 0.5011554389824625, 1.6457196497735385, 0.4906305405750079},
    {-0.13247335657105, 3.056469864295059, 2.3387720945751695, 1.4134502032706746, -0.46053341029958883, -0.8926217245684027, -0.2504795591143265, 2.3797775371713796, 2.3183399763491432, -0.24820267687894323, -0.6440386919113023, 2.506413234304971, 1.5457820006378913, 1.838793699935876, 0.1370655120610939, 2.229220598146574, -0.5821712644931376, -0.9711716465735205, -0.7209126158110416, 0.6872291045518445, -1.5367275160780665, 0.49011851573286186, 0.7674491418557011, 2.808459716703697, -0.579395195837787, 0.5496194902512738, 0.2641335315709159, -2.9621603083358394, 2.37580828037369, -0.055107566947930314, -1.000110086629313, 1.062891565820127},
    {2.884378583383854, 0.41791094471704815, 2.5369868531979898, 0.5598798119072854, -0.15288060966892048, 1.0676589502226146, -0.05708426404336171, 1.1986245329446457, 1.568387047195488, 0.5991165001967965, 0.2598356995644484, 1.0443443642032357, 0.351322996886714, -1.2595337892472396, -1.0468768265317883, 0.7657555391420104, 0.3932005862450567, 1.7129360562539149, 0.9553349475312245, -0.11291733570321592, 1.411517036870358, -1.2225347161058475, 2.670605176773389, 1.764578377316704, -1.4764743979379122, 1.8195746051229837, -0.5304653174928544, 1.3522948332163633, 1.8601127145959049, 0.5439390910478342, 1.1240742404382105, -0.344934265304876},
    {1.055185518466805, 1.0128002108363998, -1.444240906975907, 2.031452377299685, -0.14526489249321023, 2.2471597073117855, -2.2357573880091746, -0.11073755780302512, -0.08321538602030598, 2.5129342927705784, 1.1666207077211466, 0.36052389382641953, -1.0546063526468563, 1.443817615700074, 1.130272344911848, 2.384914450744226, -0.6943597100770716, 1.879262238532742, 0.260680517877298, -1.198988033137342, 0.9319078505027696, -1.4711186877861735, 1.512869651441454, 1.372396379887912, -0.3257805358867731, -2.3982027031589093, 0.04644837728282939, 1.2473016094043259, 0.5364477508617471, 0.44587391463661175, -0.40560108409217693, 1.8475461509889113},
    {0.6838887994535777, -0.9083143637989521, 1.129072351352477, -1.6690356432440125, -0.8852650822332929, -2.271654856737516, 0.3090873584120365, -1.6544993878749994, 0.6377066558484812, 0.5293124562339838, -0.2794070290781799, 0.8901081210347992, -0.8325142869548705, -1.2101997158715336, -0.18782332080274855, -0.6392735956806956, 0.8964908717289878, -0.18408896088038523, -1.5067558336284483, -0.23253503487548166, 1.7818107125913292, 2.3843615123775574, -0.7585883527521757, -1.1702923005348318, 0.13043354837416601, 0.7763605752254936, 0.7379112442314671, -0.2718866978751177, -1.6470004229933284, -0.18272481834058948, 2.6873642473583486, 1.6114275810887944},
    {-1.1300225843649299, 2.2044983165822933, 0.47167970321242864, 1.6322772191316428, -1.0386687148577287, -1.1466380591269336, 2.5368628117329215, -1.6075954235456178, 0.21234132965113425, 1.1214611206639469, -0.44098105813276905, -1.2517469838832065, 1.3990668103489665, 0.31245620213132524, -0.19208570639414524, 0.6703159424199033, -1.8304629028910508, 0.4919944904460038, -0.30211475549376166, 0.5575715159996432, 1.7243732448668725, 0.47645464495731527, 0.7990265510048878, 1.7636987077300412, 1.6327245135623234, 0.934785597645272, -1.8734379185592345, -1.3386181897847242, -2.3788496936643084, -1.6432980770369934, 2.0473997032221054, 0.9055742234309405},
    {-1.2883047595632178, -0.6420656610335579, -1.1666175907846068, 1.0364282954232023, -1.517583239317275, 1.7881503461229291, -2.270055893495856, 0.5859872814183789, -1.5505855805692632, 0.8739188554562213, -0.21756622569782222, 0.555395236464075, 0.9888994414323109, 2.11637669889331, -0.08512337203171151, 0.5528455381313323, -0.004846570158673886, 1.4543411007869829, 0.07658997610420666, 1.209333547181376, -2.61435563064506, 0.9926651665665363, -0.18329160001250702, 1.185134172342006, -2.1922424530786344, -0.7922493764069577, 1.2829242263235718, 2.275957889098879, -1.0225060296076327, -2.6418978219455034, 1.336153093873212, 0.8646022222430766},
    {-1.8386894892784533, 1.8463218375703045, 1.1688108679775893, -1.0543354925205153, -1.6301467165417887, -0.3955883848575351, 0.1405273866235249, -1.1339387381372448, 0.20793472785557843, -1.1319348397611924, -0.565590149278839, -0.3825579140493877, -0.15497891657461596, -0.012523274539375417, 0.6384334005930975, 1.2365232164014042, -1.3187846950939597, -0.2589754889595054, 0.4242155050413845, -0.2298474927343702, 2.1903839503425755, -0.6540034995306292, 2.542501485250688, -0.6897082103166998, -1.6973369849121003, -1.4403717312698006, 1.3299051484636464, -0.14212899764173653, -1.3409634287093395, -0.9641789621241534, -0.9840660677834517, 1.9142310057269583},
    {2.2335432351102877, -1.0028782118438153, 0.5822571126295593, -0.9987175194589787, 0.44255938629393954, 0.4758952355034901, 1.8871379778744177, -1.0921151646103477, 1.4886115196361571, -0.9517182501479792, 1.8714596872911726, -0.13422846629179302, -0.1867254833196389, 2.39671040528436, 0.28171114825479365, 1.5510781250026797, -0.17023995602850203, 2.655396192276008, -1.2031961077277273, -1.2650864434638416, 2.0180586990885225, 0.05671352030566814, 0.6179055923085195, 2.0233897902704516, -0.04609310214800733, -1.4848051535782034, 0.7743820579876787, 2.4581246890411643, 1.2556145435550237, 0.7404617891273008, -1.1249682866076125, 0.8082891594795559},
    {0.7970207368086643, -0.5244789310475662, 2.3842918127625525, 1.24408390252354, -0.4849392104007365, -1.6621953766310686, 0.2512392236410614, -1.3776615200533868, 1.9350838603478515, 2.196446881245779, -0.4327398351615787, 0.6955146199453034, 0.8706255775902602, 1.507872894138968, 1.2329849969132138, 2.444812198721075, -2.339285490865911, -2.320029815408557, -1.7685180212812877, 0.8525010983885156, 0.3729791487464043, 1.4393425118860033, 2.429049105772514, 1.7358291940268598, -2.680174098813586, 0.42162948279068724, -1.7034381054084213, -1.5466952820981685, 0.6635797414911865, -0.16861464932783565, -0.6013569083184795, 1.0331571934793171},
    {-0.4110988140096823, -0.5199776878772722, -1.1598150291837517, 0.24083102251997826, -1.5607223242306598, 0.9679309010197399, -1.1585073796818381, -1.8158657359135422, 2.624825358712499, 0.0378164960656532, -2.991606162663687, 1.4503914920415852, -1.2701000541593224, 0.45740568362462547, 2.010805690294422, -0.8197542617111494, -0.7375697446398631, 1.5425585310740646, 0.8336874904012018, 0.9383091161008338, -1.6093810718219839, -0.822294556102325, 0.22653553680457306, 1.0758121819797877, -1.3375371509898424, 0.26598462232968184, -1.1887372927954933, 1.4245875431112245, -1.7826867431264541, -1.5873391563137813, 1.6541681392564753, 0.2513298943069403},
    {0.5455866788717315, 1.3490767948368383, 1.432532669517596, 1.894073215741513, 0.6260192406079068, 0.5270677163615701, 1.5591436962974434, -1.2533062542212148, 2.162897303864995, -1.5011040248000063, 2.044142058318626, -0.6538994016847761, 1.0359324605043079, 0.8960458031717052, 1.442674811626537, 1.9890805682752632, -0.006662312790186729, 0.357789098548596, -1.6237388575438814, 1.5471137427176327, 2.702290847189222, 1.2132189947834184, 1.2860605556473153, -1.1325247671494618, -0.3220790868121059, -0.12378982361179228, -0.0069043911994031764, 0.6961591883230323, -0.5222204579284055, 0.9280148280081187, -1.3599446977688199, 0.8545108682982157},
    {-0.3978589852230559, 2.335189140215336, -1.5445476032870435, -1.3791726292444826, -0.8520324607692998, -0.3877884339593717, -0.6048286332286223, -0.9007249129460151, -1.5291391645483472, 0.9552198661038355, -0.007936002074973685, 0.6750884915784876, 0.601248295528091, 0.2892149350686672, -1.1126152796656967, 1.1058909581229646, 0.38779552056001876, -0.7097402767639899, -0.40482097290630076, -0.9070119273488093, -1.0942130231847018, 0.6765709251757797, -1.3331904843929663, 1.1347822136218237, 0.7527015822554177, -0.654618118337392, 0.1798599546284103, -1.156317328963748, 2.1067943013892623, -1.1955027749807605, 1.3987641241876378, 1.2850449537547581},
    {1.0489498855422026, 0.045541136984654514, -0.6803124727417915, 1.3976482650434252, 1.5078215949870974, 1.249293021669388, 0.26460892869869734, 0.9165406329174159, -2.467873885894573, 0.8718718472881105, -1.39278545788082, 0.6094877197308403, 0.5931483813660343, -1.3978287597339476, 0.5139035281432125, -0.187668880875291, 1.0019447272905604, 1.0019390880102539, 1.307710724725425, 0.25144711397125713, -1.9915024377775217, -1.6933365282125663, 0.44454826910391604, 1.3801600374426375, 0.48204172484806573, -1.556033586850512, -0.24100714642656526, 1.2099176092459019, 0.6760915439524412, 0.20170364469816995, -0.837561388555161, -0.6196114569250665},
    {0.9092586660510534, -2.1331792268781182, 0.3528219039267189, -0.846347021805224, 0.43169109963430435, 0.7803579961323661, -1.48057111572416, 0.9515238462305651, 0.2581165282666159, 0.395583805744688, 1.122365052391515, -1.120569992520389, -1.0505465923881705, 0.7840903959700819, 0.7495237888188806, -0.26645279706601266, -0.013757092849331375, 1.878071886483865, 1.1151084469959256, -0.9483304371444593, -1.887329746625371, -0.9948752104343314, 0.34757960613112293, 0.9524109447171585, -0.13405413601955765, -2.1520783921443116, -0.5165178554733313, 1.9046344897622134, -0.6778541144233325, -0.8318562902061583, -1.392425518638346, -0.15132021607377427},
    {-2.1904034165693362, -1.3578058814175376, -0.35473968074766926, -2.1086155111154934, -0.9891035616154209, 0.40908129319016867, 0.8207969649235531, -0.5139494052217239, 0.8947453764727528, -0.9100537890284832, -1.313077559491135, -0.7645542446060708, -1.7979704112413633, -0.1634041508800551, -1.721935974491144, -2.2306613927980634, -1.466947422690163, -0.8138780115372884, 0.6960579858879188, -0.35631973707735803, 0.5240152833533039, -1.1848272564456033, -0.6411226929696311, -1.302149232683137, -1.7164410637189962, -0.7464101161483438, 1.0621197284402966, -0.4870957653778672, 0.8677981614376615, -1.714996504975577, 0.8658931976272429, 0.8121568951525004},
    {0.7275343061448432, -0.5852092896595505, 1.7964321106039278, -0.6796163793524046, 0.25827851249547235, -0.6180728366438725, 0.386277841634051, 1.3536671443616666, 1.90680607060044, -1.3138599115795013, -0.25358682634041885, 1.2684834362900572, -1.7688335735718252, -1.4218250154033563, -0.6318738591320349, -1.7273079343304434, 0.01261882985294282, -0.8495428728605192, 0.7844746137955935, -0.9055289348213226, -1.9037395218813318, 1.27732918612296, -1.0458468440478865, 0.01441011653418278, 0.8457704799476486, 2.3591941730162653, -0.9778096646725726, -0.39534711103460196, -0.6039158614353494, -0.4534923251396675, -0.009659466738230127, -1.6741430155706682},
    {1.3466506791270145, 0.25511917959571423, -0.9363792064980587, -0.40190414581308864, 1.4041405213043852, 0.15590340066459454, -1.0569387487117907, 0.3234525401306753, 0.6444412558101718, -0.24238826422961518, -0.9900445583889425, 1.515919505894772, -0.07257285360651111, -1.5890686775163507, -1.376164688253948, -1.2167697314686046, 1.6834977372775273, 0.5980812380494082, 0.1559181490395596, -0.6063078553442243, -0.3659876474447217, 0.02595772726703879, -0.8885023329348967, -0.34782045680587487, 1.0099117042629309, 1.65172491042427, -0.45706253419065457, -1.0376270280603428, 1.7833368149560345, 1.3418441866388435, 1.3146752982857146, -0.9898611356440752},
    {0.5822212862894157, 0.21451459238978304, -1.7710177046985367, 1.7758512344649104, -0.25955275426370394, 0.5287749963528888, 0.996006163171877, -1.5023491111065141, -1.7846232376876814, 1.4392934681218086, -1.5640302913855773, -2.23324095998073, -1.4851702268170868, -1.9831187478851564, -1.5121038747127864, 0.2533653766138237, 0.9870391291402272, 0.7406088349205617, 0.5727318905665574, -1.9667660015096153, -0.40759951155185387, -0.9972587276483338, 0.2763082611520167, 1.0072796033098375, 1.4783603746945346, 1.141879044941881, -0.2034824480777837, -1.19185866350986, 0.8501095433511523, 0.5624268273675279, -1.7854247387374473, -2.0096540119040127},
    {-1.6917036794827172, -0.7022973543569436, 0.8614120972740569, 1.0963457765930904, -1.7471292998757444, 0.7054860307331214, 0.8372513038735648, 0.9615479329740301, -2.0893322657494195, 0.780395759600023, -0.6945012849102425, -0.1485057279786871, -1.0755605350813442, 0.2632719903694946, -0.5948510719933428, -0.5587592812404276, 0.17816192949659704, 0.8857254683224048, -1.5318678143481106, -1.4572007569822631, -1.7276176641067045, -0.7048669883369271, -0.033620339987591584, -0.08843454935229256, -2.857544889230461, 1.0512959939864381, 1.4476435964390109, 0.6678747037463999, -1.937718518152749, -0.5367444933863031, 1.0951864585432984, -1.3161260840420639},
    {-1.8454988735464344, -2.427403595972277, -0.02085007855312416, -1.0191952356996141, -0.25209488443513184, 0.6306566949342491, -1.9099307671327304, 0.8799651714023021, 0.7947032713469053, 0.3050410809202398, -0.006884331284828877, 0.8732905085236442, -0.41920438837445134, -0.4749744761100196, 1.4369858366236072, -2.1847051986516304, 0.21074463088872847, 0.9184980255991949, 0.5625148387611116, -1.0162184420734053, -0.2765965904949347, 1.1565931186639666, -2.3882412675923157, 0.6477435403640597, -2.2057534235605023, 0.5185469093370599, 0.4879312332125756, 1.7632386400626923, 0.7972358749970229, 0.36567199587065435, 1.3860656279203005, 1.5384854103742802},
    {0.6255096064881517, -0.20274967162214935, -0.07145016649961342, -0.9915879598882995, 1.7337652724370185, -1.1707643105897698, -1.75820963091274, -0.6214860012664385, 2.7576844180558027, -0.7322682471008224, 0.9980329911046691, -0.09997438239730971, 2.247524639304462, 0.9996980901191125, -0.7069414904594222, -1.1526814777225498, -0.3121025411319592, -0.28175223822839174, -0.22324101359790297, -0.257062816833503, 1.5122829030672231, -1.550780083691942, -2.1314548644410247, -1.649875207075785, 0.42455151915238465, -0.8658546977423773, -0.3804446502473635, 2.279283519364068, 1.8420620055587156, 0.5574532225448939, 2.9667803732043763, 1.9895868065106201},
    {1.7864753890001799, 2.4431634782056153, 0.9244154279580694, 0.2725068936928529, 0.01201942054510009, -0.6900673534443529, -0.5248270029816245, -0.7177441504159526, -0.998199652593022, 0.4653934914504507, -0.15444366150771086, -0.1456597058906434, 0.033575391408901686, 1.2429590144009999, -2.0813319443396328, 1.6258993895721776, 0.8382551551880508, -1.1647733042584711, 1.7468519735271297, 0.6623983208428191, 0.4528754518686325, -0.9315045152815664, 1.6420292736707027, 0.34818470606492424, -1.2692970104523347, -1.8702561541170193, 1.3165463973107157, -0.3574679457107266, 0.8877653269946276, -0.0776122378435831, -0.025368886585912832, -1.3526684814204313},
    {-1.3079116775965878, -0.5978593100708037, 0.1892067615524172, -2.196457497097737, -1.6385550206477166, 0.8367914774278277, 1.2926200818289144, 0.28038688277199525, -2.30928475331535, -1.035810762381181, 0.29838903762956165, 0.3597362889642781, 1.6920532001578066, 1.1940644602699682, 0.8661448451803233, -1.0048170192581283, 0.16948361480901367, -0.35079368090398716, -0.7203368918949574, 0.708650325982433, -1.7654198119372748, -0.1272286454459198, 1.434947572111126, 0.18900955101471187, -0.5525106014336616, -0.07790434379391793, 0.9918907316312904, -1.6670259361986015, -0.059181774907443994, -2.4093168332677726, -1.071762787072089, 0.40611156210531646},
    {0.761345646326532, -0.08319669277514209, -0.3147328571750515, -1.445729090501367, -1.5485412690944718, 1.6839142295503993, 1.4999621761052448, 0.49936617022849045, -0.12800956039620934, -1.5403286062333839, -0.2770362715006412, -0.20110413436544045, -0.9019524099536455, -1.6218321987057998, 0.998893455810011, -0.9998727497825824, -0.17384695263814856, -1.2275652895349456, 1.185340734879512, -1.0116069223501103, 2.2958076715845066, 1.1375006135393575, 0.003263124298000213, 0.7632551743301816, 0.65422724256091, 2.0044717851820444, -1.1687112430843825, -1.2282413397785654, 1.4394545353628214, -1.2695194810576063, -1.0343646318728816, -0.5689471676911164},
    {0.1777661248008122, -0.28584531564534027, 0.8694555037933397, 0.8698973695755872, 1.038576749559359, -0.4593902384705221, -1.0498640788601976, 0.7038974984716556, 0.7436589727250064, 1.350513174219408, -1.1695241068547384, 0.31185810435919503, -1.4886913122077552, -0.845607900856221, -0.8043506183962955, 2.6833900192158775, -1.4138092136536835, 1.4088436870789458, 0.5454097581895828, 0.36878692666394547, 2.1299161725546023, 1.8154687395248956, -0.542712935766903, 2.086415472521613, 1.891859188080421, 0.8865165626576266, -0.8905662490243618, 0.24272727305401756, -0.2381866537469807, 0.701916298730434, 0.032955324725456765, 1.4309339900462386},
    {0.1903704857990886, 1.46102521006507, 1.6817195505017404, -0.3208247044651685, -0.46269487112712065, -0.18677399946215867, 1.281354413185153, 0.27432100614321886, 0.01771786102273425, 0.3847372638830134, 0.4060893622973271, 1.3964861330288134, -1.1635166512581805, 0.6275188435262721, -0.3791787590406117, 1.8668896762842888, 1.0810566166559217, -0.0658615776964233, 0.2805084586086714, 1.2999919341805626, -0.6666151142137584, 1.8374009046946271, 0.6028255182720754, -0.3892450093539674, 2.089982014541225, -0.7426303321775901, 0.31433966247115885, 1.062567594652568, -1.5278444639829103, 1.5684865929184135, -0.5251183175178589, 0.9326455949928523},
    {-2.039250268766987, 0.13904541570837609, 0.475767667317326, 0.24160930879403014, 1.0240970010681336, 1.2389085472261991, 0.6196403750398518, 0.10840016956444319, 0.06019284993871284, -1.3182743272830781, 1.017734543677222, 1.165703847549499, -0.47559535493894395, -0.839737615554705, 0.2849513871659574, 1.5080432061983788, -0.4311827343316403, -1.2865852044805544, -1.0698882127355491, 1.8746514935670187, 0.27972260810088456, 1.343122468501718, 1.6957032652042474, 0.5744889772871938, 0.18670483964488901, 1.703785307859306, 0.7692361326130053, -1.1445340622251203, 0.11789985971141384, -1.2513833750640453, -1.8736636723753903, 0.6532618322946687},
    {-0.2036257584882328, -2.1210650953668297, -1.9540307961585006, 0.23150102703747583, 0.8459194260803947, 1.7843613748840104, 0.08080244636304755, -1.256114328813044, -0.9308071867102983, 1.6207349924142513, -1.4181150109201737, 1.8307269658715655, -0.8579942278452232, -1.0529907958702411, -1.8691377592412068, 0.06616038949916028, 1.2992978550070284, -1.2524530497074784, -0.09853525883480273, -0.9150036718429143, 0.2651850563443284, -1.0380540202789776, 0.16544947696820925, 1.6136728992546738, -1.0854350652452514, 1.3170484334231722, 0.5997772065313145, 1.2063163227190075, 1.917636837225862, -0.4600731561997042, -1.4789900610170668, 0.6000642333709264},
    {1.6932984299599376, -1.8877510175104886, 0.993990292957471, 1.617225766167801, 0.8274013974544141, 1.544649517290891, 0.8738928512288223, 0.19753469871634674, 1.8985883440674278, 1.6810465404982602, -1.8187343433792489, 0.8657806607819389, -1.6790009729695277, 0.7315198916430583, -1.0211649805668297, -0.5720597377311485, -0.8424649279816331, -1.4679327085409353, 0.2989294835764904, 0.6635886164794246, 2.498072435770977, -0.5253499946644022, -0.6944534461614791, -0.38070160128169356, 0.5494951890066991, 1.2553032705622615, 0.8500052543207135, -0.7243360941258399, -1.3287397628896533, -0.2132980837933319, -1.8764376831094676, -0.9168740985247645},
    {-0.6213636513654732, -1.060120031481631, 1.5180381316411056, 1.3447427982381785, 0.32484066933437405, 1.0212976114381676, 2.1152245123049718, -0.7326002212219423, -0.8315877903924348, -0.4462655033657329, 0.4773974477860875, 0.4371554153580192, -0.7905656819387663, 0.889935691148724, 1.7609347852762998, -1.2097833012682029, -1.33132035762053, -0.523872795945001, -0.7005871826587056, 1.3409844784698528, 2.348332204981118, -0.6678393163318856, -1.4697499548894308, 1.2375554343184922, 1.033869891810745, -0.7573340680379756, 0.5267481320622656, -1.8859413211541736, -0.5791661400329419, 0.24973394454829081, -1.7489614180671118, -1.7931038090134797},
    {-1.7053396936461858, -2.392000284223438, -0.0018778802822220389, -0.9271047895254585, -0.5868338832506713, 0.18720152335670232, 0.7770302452811322, -0.6621244332923071, -0.9166657533536903, -0.708469328743858, -0.013683386334638788, -0.23925370013598315, 1.368504378245944, -0.0058055597096973634, -1.147910010794192, -0.8434114257401223, -0.4165015316640173, 0.6045952442622708, 1.549856519513709, -0.9106991428739347, -0.9229553385956134, -2.396933659173797, 0.31317223169985786, -0.09991823328304943, -0.8521531208067729, -1.5073058280044735, 1.6386422289982936, -0.5465011240542452, -0.7167359181201971, -1.2688051733718408, -1.9490923399960103, 0.04642649570249276},
    {0.29965386490990437, -0.5573496224399742, -0.5293497129809311, 1.2196200475957648, 0.9240237754459125, 1.0045380872869925, -1.284817404615951, 0.5909893968900738, -2.4052135580206104, -1.109673454722138, 1.8693707114697853, -1.1354592201498777, -0.6817531739691514, 1.1001403806576635, -0.714513919010763, -0.8355167922196916, -0.8607271368697321, -0.06131961343189885, 0.6220222837877454, 1.4109792563083505, 0.07003795910416935, 0.7406559035673058, -0.9689283206922352, 0.7313626893048597, 0.1306542685030759, 0.9585346345655832, 0.903244897284719, 0.484122836112273, -1.0652004723520065, 1.3806787290673923, 1.679383350924305, 1.3439663966113238},
    {1.44796126099691, 0.9654752729078292, -1.2572948633935097, -1.7073362669455643, -1.356252684350073, -0.5860465259041181, 1.0908113045908876, 0.3511504099584125, 1.816005362429883, 0.3811106826061581, 0.27932101968863476, -0.2909598513061587, -0.5142102753346451, -1.1141126790305698, 1.2983627116931145, -1.8989998425446264, -0.3555599709790531, 1.4987153047584523, 1.5568905646017042, -1.610104599806532, -0.07180388769771205, 1.101491676491389, 0.2856938480464804, -0.10978876146944756, 0.08813854426168417, -0.04933972721617299, 0.19681293763261962, -1.4091091169772798, 1.0827385386138748, -0.6943321857503274, 0.5180339184030966, -0.6263236379980835},
    {0.8601460448949554, 1.9189765605572153, -0.5564177999890272, 0.2853077915802005, -1.4996500479260813, -0.7104512097445669, -0.20724816318993217, -1.4442377161308082, 0.7066357581436639, -1.733033197005952, 0.33088704430858606, -1.6429529893222854, 1.640845773748501, 0.7610634706416302, 0.46814828848448437, -0.2886518067494348, 0.6820184462915607, 0.18457795674085134, -0.5564659163896919, -0.4773802581460835, -2.3084369222118752, -1.2874768069996472, 1.2128382979170338, -0.5099283884979384, 0.6250950115960904, 0.40913827040290834, -0.5612129004805017, 0.516259190964747, 1.1261427473560046, -2.4949850900384463, -0.7635329743914261, 0.8305069541667092},
    {-2.185670823218391, 0.9458261798378019, -0.6064023969727168, 0.16279044197382542, -0.7995893500797498, -0.6049425671369638, -1.0092560707861205, -1.1621076418608174, -0.2992337659089905, 0.19832775484375015, -2.6206562193330636, -1.3854176493655528, 1.0302673421819402, 0.7005090795727856, 0.8734783143240783, -0.5774860402173647, -2.0398022519841326, -0.5831340117343526, -0.11301561356744293, 1.0911139089325574, -0.19568522980394476, 1.3831413503980354, -1.7896165528455132, -1.5167882588384811, -0.8068748833570537, -0.9820270243816729, -0.16194651308205307, 0.19354564483317438, 0.5093531341064913, -2.3379120652617127, 1.0885940570677821, 1.8406568095072289},
    {0.33196397208037837, 1.791510912045263, -1.2443124714995684, 0.6541865964428376, 0.6950289083883224, -1.1843263619511157, 0.9787130103078489, 1.2234213013892619, 1.3570333801578727, 0.42354136764926825, -0.20240895745729542, -0.22513283311899368, -1.3332769413524488, 1.5817772226318718, 1.505346292824274, 0.3312080436647234, 0.69653580832156, -0.8364099215056905, 0.7889989364596056, 0.2515975524603398, 0.07063704324226369, 1.6912221681212476, -1.0045266663059187, -0.5200818953278297, -1.488062664453093, 1.4255559238294035, 0.2072676969904265, -0.23919928662009074, 0.841264583922718, 0.9487386555416114, 1.4536421323556346, 1.0081753181893918},
    {-1.2588367989147085, -0.8491977086448421, -1.6570151971388063, -0.6785763775230871, 1.0254120480071756, -2.1527093537211464, 1.0771960937693863, 0.7518851234027331, 1.4442293663006005, 1.5349811919592866, 1.0961137542329993, 0.0988862623920253, -0.8427451773072023, 0.9636081406437538, -0.7034115917160534, -1.2836350963652934, 0.8869741381270091, -0.284155239012136, -0.6713786742950919, -1.1467257707609082, 0.4797375039007723, -0.4998166405294588, 0.5350477042617116, 0.8811682025904437, 1.3151173487964696, 0.8369685864014439, 0.3620362830926009, -1.1159171486644752, -0.3387805462424432, 1.0080011160670979, -0.1525980920996762, -1.433889796106762},
    {0.465003888274278, 0.4992999286471612, -1.7451554073482662, 0.02452294176057667, -0.07059314818216347, -0.4467405428042835, 1.3241587375904298, 0.476836529120621, 1.0982865526304408, -0.9558321867355228, 0.9029947501812294, -0.6816843881346377, -0.26376444954572753, -0.20872372250062055, 0.4587704012449632, -0.9778160829497906, 1.3262326130980928, 0.34100212619952935, 0.09580240711364119, -0.4204209455955796, -1.4566478401767506, -1.778407355921778, -1.6531980415809409, -0.009749603004238924, 0.858435978355903, 1.7383105823947638, 1.8631524803963697, 0.9795357308278637, -0.12569225214197743, 1.3370108185662708, 0.386145719242738, 0.18127921963873683},
    {0.40462248696854847, -0.37364986746608125, 2.0901337499591603, -0.7384287864385072, -1.4322738324103659, 1.5062444206055627, 0.5395657638418927, -0.9982428517744691, -1.3687312982463584, -0.7433217824154174, 0.7986156429468056, -1.680489017723817, 1.9726148890001194, -1.310173153575798, -2.134132752111327, -1.2337099868109236, -1.0191398405023262, 0.5636968430517161, 1.6453424406199513, -1.5336204764793662, -2.0596553717337307, -1.5240924771050977, -1.447229205069904, 0.7800438473799739, -1.829424419082982, 0.3882177327898062, 0.28502924531098206, 0.12236966876690729, 2.3213782067912003, -1.2109253049384252, -0.4402140590903599, -1.406964760796032},
    {-0.43794138884427236, -0.8796116034243716, -0.42460138112372686, 1.1208349274788345, -0.7805107346180975, -0.21184791405855047, -0.3298466474282026, -0.701731185964626, -1.812289540117215, -1.2825674665121556, -1.4298926484385674, -1.6406872374037789, -1.2275058976394608, 1.075621362642687, -0.25405569915800896, 0.1259931834141485, -1.2062090654091517, -0.09728444452229133, 0.026063159280278036, 0.47448477883130113, 2.2905946694887698, 1.5874104879284923, 1.8658131593078096, 1.5941738915560622, -0.726081967437907, -1.4456604992548778, -0.04007088911774263, -1.7326043853114137, 1.6458811836404594, -0.2820945498259633, 0.2201374920025986, 1.1931705225795275},
    {-1.7774127616752362, -3.5251859911396526, -0.6762454272121607, -4.769423572023651, -5.4963051088499615, -2.774016225917634, -0.8314805059832825, -4.899639259137943, -4.018520004116554, 0.12458798278059803, -1.9383457669078015, -0.03309329862710115, -3.0236042069969518, -2.341804015373032, -4.376922868327825, -0.8752635903044309, -0.5486062045517878, -3.885441015544223, -3.2209970775011243, -3.177885434909573, -0.9014231622239122, -4.038805797208011, -3.6082137580790166, -3.7079678987787714, -4.5594787451308845, -3.004372257896915, -0.2294967747852914, -2.3084551878232196, 0.7917543275900837, -1.979282108732903, 0.15933073030287864, -5.09579339395795},
    {-1.3692818098607982, -2.822248333201437, -0.8868293313620634, -3.5820811743159764, -4.523752970201544, -4.0291781755830005, -0.14671408803605177, -6.142472694700602, -3.759311195275868, 1.5488518731414347, -4.192771549339408, -1.9578214741415203, -3.55370025272902, -3.220695672692086, -3.9735405392374163, -0.13764465472228216, -3.124783846352401, -4.723142862147662, -3.854561812465346, -3.066523626535186, -0.7664989167043204, -3.820934830340674, -2.1887414933423943, -4.3843362565311645, -5.486738215047481, -2.1904315729847226, -2.7484222292593063, -2.040966827274981, -1.3665341308892682, -1.6461458326326, 0.20513883264498464, -4.757997577587527},
    {-2.6747807226848623, 0.8723909668488639, 0.2655970643510439, 0.26685155798151544, -3.4292495910051333, -2.5500770183506494, 1.8411120857229435, -2.161782606983216, 0.5192903767243389, 0.9828461868754583, 1.0176645382521188, -0.3731698527868453, -1.8790656207525551, -2.547505613550246, -3.3323094927856687, -0.5134830372295541, -0.8826661286644961, 0.056665547573354826, -0.5201805383711133, -2.012797204307154, -0.4681359196772039, -2.0358988358622025, 0.11995237255190482, -2.8424132960378037, -0.9839561263493055, -1.248148349617854, 0.8836120032790417, -2.121412168980329, 1.5483987174293758, 0.8605008428475157, -0.2545474422217935, -1.4026185086388294},
    {0.6538370283093343, 0.2426826623142545, 2.063612878426458, 0.5987274381395815, -2.9382016940969913, -0.9108774604941685, -0.4444536910824872, -1.7282997273878147, -1.0525642545998313, 1.471520494221414, 1.0063840873624714, 1.4574345617409092, -1.5117630367613712, -2.087936333405449, -2.145760598700887, 0.10285709620997904, -0.1164972980073746, -2.6560451943224965, -1.8649773842142423, -0.990988673384951, 1.2891553273293732, -0.5046682395668841, -3.226890031524269, -0.053124571194711166, 0.7303907839405838, -1.1796844944532083, 0.7868293887798018, -1.0785270751537923, 1.2280851514843016, 1.950870162106213, 1.9696369058119172, -2.160886427712819},
    {0.023333419253233734, 0.952871555088883, 0.6658242867393539, -2.066638223077119, -3.28358637009256, -2.9021513230695355, -0.007888278104121122, -1.9558702588258776, 0.4803126056154329, 0.8483559502282054, -2.8027522981999478, 0.3262003025385987, -2.0488863037340432, -0.4544991832071709, 0.7520215935259492, -1.130552738107138, 0.6922949669825283, 0.17219232211252428, -1.4662222730598273, 0.5242420532213015, 0.058389599002201156, -2.7597899673890143, -0.7201102711644689, -1.690865362887519, 0.5846198562201591, 0.6641188505569815, 0.4549791616009189, -0.7127591348076486, -0.06678398730931852, 0.7327949195410144, 1.569486614921552, -1.298446648041781},
    {-0.7310093797983231, -1.1530843539932183, 1.5861265663357509, -0.5920844203129961, -1.6779588404472665, -0.8436706878880099, -0.7222533036165572, -2.632125371182009, -2.1505533000537183, 1.3135624079244248, 0.1350272278822649, 0.21726400416292904, -0.5153084650598689, -1.2303206904708621, -2.7227930119844257, 0.72789978368418, 0.12535387182274535, 0.13877604032007895, 0.44619117051331736, 0.4740736898221298, 2.4854247546499755, -2.0465593449142827, -2.4910313849123287, -1.0227827723336327, 0.6614131112210715, -1.7805654183083213, 1.9321438419009114, 0.18555591672274815, 0.12529727076517597, 0.8624793245343478, -0.40789656514357, -1.312776601238389},
    {-2.256744489310876, -0.6424299316077714, 2.824861462899669, -1.2627772204551346, -2.316361434656361, -1.99994481026483, -0.5991943635963615, -0.336351138685212, -0.25267829624134025, 0.7993084580763457, -3.331759740796394, 1.5287275926918682, 0.5325679378719368, -0.7172788906666414, 1.479555181940522, 0.6030182983240215, 0.2688325876140988, -0.1167899737807021, -2.492004437382583, -2.271411554117107, -0.39034610308834444, -2.188700442456856, -1.4794220971006014, -2.1328973086844596, -2.1703067131654055, -0.7387849937809654, -1.1312667432085628, -1.1653429633958763, 0.35380859966971123, -0.15028700830321842, 1.1836453484589187, -1.2517319152845032},
    {-0.529006098259321, 1.167450640439289, 1.8434280839932016, 1.484932309979588, -1.2009798579398077, -1.4287430534333216, -0.37740501160791307, -2.326772882302524, -0.21212397616691106, 0.6095483633283276, -2.142028616918006, 1.4470492147214569, 0.04507014135519579, -2.1162175534261243, 1.6782959992563509, 0.4509747693219831, -0.2710010299124756, -2.0090401990413125, -3.293712147238927, -1.7937662193287682, 0.930023756550131, 0.2683251374805508, 0.6643612171408967, -0.08621967472170526, 0.624816118982932, -0.9672115377134203, -1.900253854108831, 0.4387738320053422, 0.374082285742858, -1.5809945943810366, 1.481415428837045, -0.7332300930697048},
    {-2.211186183421037, 0.5459703348917433, -0.3557034400285841, 0.10040120296055242, -0.7610708674068886, 0.13231262149453182, 1.6631543800159807, -2.38436773960953, -1.9527118775398287, 2.088596301519351, -4.479092302043898, -0.3193675665883966, 0.5416977945054843, -0.019164582156948516, 1.0376830728008526, -0.9144259290903741, 0.523709992444313, -1.686559384486388, -0.23017368362853424, -0.37092686918831397, 0.6284877269869904, -0.4653142793755479, -1.5461793053226573, 0.846393417475803, -1.5767236763443693, -2.7517996752557217, -1.966906886757758, 0.6824833506763119, 0.21628026815407317, -2.835947104811933, -0.5216451803481933, -1.6393454911896808},
    {1.8514695292691383, 0.097408741942258, -1.591712714865283, -2.301422845595035, -0.1734588739670262, -1.8038478720907107, -0.4419369566252526, -0.776544811755539, -1.7212064885519611, 1.600612153301746, 0.16073389633429042, 0.0932349088422061, 0.37966129963876843, -1.227015530208244, -1.1142704437726392, -2.207686269800645, 0.6346623005340565, -2.3974709972501835, -0.4596026645469296, 0.5875765829602344, 1.454867321596348, -2.249002292151847, -2.022599412364954, -0.38183959414723645, 1.1310339731799857, -1.2093333044608414, -1.3371313752545575, 1.4415899103315137, 0.12199156191140952, 1.4948107008815585, -0.1291019286200333, -1.9699575030049299},
    {-1.8057611155910565, -0.8531736978900994, 2.221576559903893, -1.1893087913891782, 0.050132101019195976, -1.1535998997845835, 0.8686763758020675, -0.4283444318578409, -0.34159986812589294, 0.9033573050897169, 0.7632876166729361, 0.5453582514063876, -0.9387487074490863, -0.5735512857595049, 1.0787914365807505, -1.08407949224675, 0.018535854152631197, 1.5146842706006205, -2.1701823634982635, -1.5591174797480258, -0.06290878495175795, -0.19498993583842814, -2.734540083263034, -1.7408816082004697, 1.3003102150486217, -0.8899010231352468, 1.7893198635729568, 1.2031252842291458, 1.029044262008565, -0.46149423574047294, -0.45246648884800417, 0.13387391277361896},
    {-1.4883732755184698, -1.7200739304090658, 2.118007477318019, -0.3258797541730314, -0.186938734162568, 1.6522514517171174, 1.1664308903136698, -0.9218347476206291, 2.470076532893773, -0.39437428466973834, 0.5984451260537585, 1.4617934839900462, -1.061694987314265, -1.7122735680856536, 1.2387764610149523, -2.10691277379642, -0.010547573215049474, -1.5792079859585715, 0.9992893285251467, -0.09779822468534664, 1.6615800007921333, 1.7374653291553839, 0.705695114133359, 0.3762348372460253, 1.7593668677774539, 0.6268873209209863, 2.8335231336087277, 0.416741766562468, -0.9279603419797136, -1.5564126510996767, -0.540170502837328, -0.23069175106261522},
    {-0.14541880555948805, 1.990011651974623, 0.07800179753518387, -0.12780706483173804, 0.11387127966896583, 0.774682656657475, 1.9668633796607984, -1.0938508090775465, 1.8738665665275527, 1.7093300645773442, -1.6398257666860656, 1.888836559298107, -2.5745896912186916, -0.29453630578747797, 1.2706897789406324, 1.0252652419311563, -1.7098229063066366, -0.6937463438912195, -1.1490156004191874, -1.8670342973702283, -1.9352921308605369, -0.21068113131327226, -0.6025124664058724, 1.060315831797304, -1.4124958798444225, -1.576319482304973, 0.36001447778024215, 0.47244179751798177, -2.7712591855534847, -1.2923096069049467, -2.762512559688547, -2.004793951489117},
    {-1.1023845614082977, 1.8056664341348594, -0.7712919991448517, -0.5707134371100916, 0.34765927743831065, 0.41328118312354467, 0.28104446862409127, -0.24734939031653597, -2.0023670606932837, -0.09831616735947071, -0.16068421037891306, 0.23221730923674186, -0.5759430960980645, -1.8319640069266314, 0.9375905772872252, 0.7109762979227542, -0.5336730658513704, -1.1297886862088016, 0.6070766187092631, -1.73259713651313, 0.22676162126883861, -0.7719204459780289, 0.23385465593725183, 0.8538542071279619, 0.6099179940433856, -0.1838938131709901, -0.16148926017554074, 0.6064605779478773, -1.2202753615646051, -1.4722436309586342, -0.6927531117921417, 0.8735886791626014},
    {-1.9001959352129691, 1.340264832584542, -1.1814253080369357, 0.40109238990014934, -1.2318162052551953, 1.573420960631462, -1.6547346346843845, -0.1543650448821653, -0.6804847069559706, -0.288213660256688, -0.8456277828477606, 1.252544077619068, -2.4437545832849867, 0.09939675758164725, 1.2833065455313735, -1.554038151764087, 0.13045416523358547, -0.897621706050851, -0.38199688958449696, -0.911264375617858, -2.306517264136898, 0.20117885173549777, -1.5308509276332776, -1.0963036418886614, -0.00821677447426637, 1.729474102839877, 2.169522971510159, 0.33881382330098864, -1.1636677601652128, -3.183990127223944, -0.5410941865746095, -1.9175370330984354},
    {1.2928626663528082, 1.991176382485111, -0.9258346419829504, -2.5170311832222327, -1.7958528201795425, -2.2684216572246276, 0.4873239503342418, -0.7539227269595133, 0.302379506229128, 2.3121845242897012, -0.9440811683421706, -1.9157326771937542, -0.6755993021384293, 0.1778323021974962, 1.2367396580598087, 1.0264988514158229, -1.0537156487840207, 1.1384304038596307, 1.0386388043444235, -0.21183476870796322, 0.09093887799925626, -1.6400927281770865, 0.16522766105699485, -1.2968124793969111, 0.8122665143326447, -2.707231506314484, 0.3617320907244576, -1.6861575509917457, -0.8650580201606968, -0.6093932750871427, -2.3561674113462105, -1.7015188768126408},
    {-0.12391279846444242, 1.372995504327085, -1.4963303909873622, 0.4106888648941298, -1.1184786144379417, -0.6750492080941135, -0.5656690652470576, -1.9056615953424214, -0.5034316400714955, 1.5072858893540053, -0.8416425602581936, -1.669929821205613, -0.5838355404222223, -0.5696995852400439, -1.1174110884376853, -0.4926108158573423, -0.3563818861935756, -0.9356770435735132, -0.8334100004849404, -2.1240814916761104, -1.2287566660329847, -1.3691161099436406, 0.08223412112755758, 1.3861525947912492, -1.5373949429793394, -1.8059291317048602, 1.5571549591699156, -0.2193976493813156, 0.6830349570127431, 0.29582994457157624, 0.7045103523829173, -2.155619961763815},
    {-1.1856973043307792, 1.1988450217016036, 1.4793324761553228, 0.8778018134070243, -0.889084364225089, -1.073593506951893, -0.36065069998928034, 0.21739440407486474, 0.649502202465164, 1.7148108826495927, 0.5567317204725523, -0.24852224630707698, 0.9816376989707123, 0.15901876103671733, 0.7591662562735617, 1.2257368536051234, 1.2534330140330965, -0.9519447799871283, -2.1626921353610418, 0.18520984999159723, 0.5001626801458119, -1.2577022991210547, 0.0004825576019102057, -0.6765986136511775, 0.266245680105652, -0.871787746777891, -0.15570884060135148, -2.86686671107718, -0.7260179196304366, -1.779211297926328, -1.7621574391747499, 0.025228629260127863},
    {-1.3407090514529745, -1.5799359776698856, -2.0245923066455545, -1.6646982943935669, -1.4670963415503133, -0.6710816476673552, 0.5005068256514987, -0.013809257769465767, 0.7760377196794424, 1.284495918747842, -2.7568936721657353, -0.49820404805523794, 1.0487477291026324, -1.5941941797029315, 0.20243529245033895, 0.5876784000648766, -1.6363163793539444, -1.6141474758517396, 1.5526207218686625, -0.22543611384588896, 1.0850904580388814, 1.8013054475428474, 0.3417354981784016, -0.5029645062162624, -0.2263668509993746, 0.7714012891612947, -0.9693416213164435, -1.9819719510011924, -0.06816032783628526, -1.9965267984689652, -1.302081859715892, -2.2243138377281046},
    {-0.8602953476321064, 1.1121881035877994, 0.6718596640089002, -0.11715299357240674, 0.5645066076775301, -0.45541845608294473, -2.9397490910474673, 2.3200425583782267, 0.34469438973627237, 1.8772647479145004, -0.9415802717195549, 1.9371042303141435, 0.34757737075754014, -1.7553198413775448, -3.7412751769264774, 0.7434648614761626, -0.38650201666688977, -1.7998970687931317, 0.1837178331340285, -1.9860099113839298, 0.1833612565024476, -1.0129092743997632, -2.4274605120814563, 1.4037380174437133, -1.38220977640028, 0.24864257844641172, 1.8680134036874283, -2.099974288931096, 1.2818448060332575, 0.017338840296721027, -0.43382427926154304, -0.8977758483872903},
    {-1.3948564770654877, 2.2312110433528396, -0.2609333397715184, 2.685137330800086, 0.6877177447430959, -1.3221319217252363, -0.08528204065895409, 0.6832203309969889, 1.9354972724463981, 0.2193641060987015, -0.045977698843702244, 0.3738681601981533, 1.672987692819072, 0.10337481898009707, -0.03556960473102695, 1.9155122296854081, -1.2224120947656907, -0.11629340572748155, -1.928272946129754, 0.68335508011162, -0.9576072188377727, 0.9521082400780405, 0.7266599088603019, 2.203287268550334, -0.8990550640766607, -0.07131656356995617, 0.744918064561812, -3.509065000027851, 1.6668272434695854, -1.5303532498031567, -1.4223496350620066, 0.7404839399938746},
    {0.9988033991420672, 0.39205339720176247, 1.467141340225444, 1.2444550964764187, -0.48837962516140165, 1.6912612456012543, 0.6558196188054661, 0.7660037861246689, -0.16800106446038232, -0.2739904844509334, 1.5170236432184812, 1.9563613312059187, -1.3094626449024465, -1.6995057722190456, -1.664178071017011, 2.42407305104866, -1.3003291908424888, -1.1987583430717628, 0.15680222045447967, -1.2422468164844132, 0.3761120375576461, 0.30611294194876587, 2.2764834381185755, 0.22886353694527672, -0.36864702594765913, 0.18891796548878523, -0.7943795677917724, 2.306448888539598, 0.29945654079480116, -0.7670467626626756, 2.4244838035677767, -0.6953717021408212},
    {1.7189552366753773, 2.1221482563057283, -1.018734090874397, 1.9667414903766143, -2.094006683766488, 1.0166031124200192, -2.2303049333140574, 1.107234973150032, 1.3741659903259733, 2.070246238776973, 1.1648349325043887, -1.5164772039909409, -1.8779327076814316, 0.37834401571845916, -1.2968415766438421, 1.6294578053624198, -1.753633294911766, 1.0540997182972929, 1.435964996020245, -1.9378092240675584, -0.2043226415254248, -1.4440120192616894, -0.09662637949787756, -0.0019198994105960687, -0.07400789918197213, -3.0825427554954485, 2.250537166573887, -1.474030843566703, -0.9743601777050396, -0.03918392745365397, -1.368067997110992, -0.5666963426615419},
    {-0.8568112188465993, -0.04347634711587298, 0.9831612108028805, -1.6411743241275634, 0.10967339622500032, -1.7855065815369435, -0.3235299304817852, -0.4178043007196665, 0.8432690985591537, 1.1827509629129165, -0.16680134510160877, -1.1285243356977226, 0.1726365984798317, -0.6803870690086978, -1.489953143839387, -1.2459748978190937, -0.9989571895085334, -0.7546129857286177, -1.4631845999470934, 0.5503456460386, -0.24144870116539996, 1.6731292132952886, -0.5111249816350966, -0.937934987326569, 0.04152272867384484, -1.4997751579231542, 1.710503541753525, -1.1329004711083444, -0.977876438283305, -1.8524349774764703, 2.1276498891746103, -0.19793412282239445},
    {-1.3478479185214172, 0.17800007350803057, -0.9603293189732649, 1.6369589168242353, -1.6877155408107114, -1.3987231493991144, 1.9417063533399563, -1.2759525966990901, -0.5910771917858573, 2.0982256292774872, -1.224083625259569, 0.9735348128496822, -0.5163088379799875, 0.24046316478664514, -1.7041621152136504, 0.6560710643308848, -2.112085478628093, -0.13505813434446776, -0.11408439523260296, -0.5902530966745129, 1.0473689768719099, -0.8811102778716158, -0.7493308164853966, 0.5343217775467628, 0.27676557021726, 0.8273901534750974, 0.32176377434285464, -1.105131700040843, -2.1352321311599987, -2.3954220919506075, 0.8952069884898208, -0.4836449861388605},
    {-0.9701956502846448, -0.40034813140644326, -0.36964063779046324, 2.21822373462733, -1.267055099920448, 2.5209594026535944, -2.0507546118573474, -1.7168599953866979, -0.9586517807263573, 2.44264363918505, 0.8644455392625027, 1.1500737179620617, -0.7894504518204711, 1.6439125032882216, 1.0069320653619107, 1.8547209391086839, 1.4416259256941486, 1.525292126223089, -0.8019261321320851, -0.6189944368013527, -1.5031608667797498, 0.28460231557964266, 1.227541267086066, 0.5022637317385195, -1.7530313501648227, -0.5839540293050524, -0.9522761468170262, 2.165062242717393, -0.2183392881793614, -2.1063717151835113, -0.46010540947308604, 1.0050184828478366},
    {-0.9147480838495045, 0.31655726175495424, 2.338419981073371, -0.8468085187183801, -1.0264594795450679, -0.7581176291829844, 1.7370841045484726, -0.3117854916786771, -0.3131831992047357, -1.5537524214879395, -1.2701670765025141, 1.3333611145317528, -0.9596216257470748, -0.5960232267846486, -0.1479751719763239, 0.5196778173761794, -1.7696482899800403, -1.2316898359563793, -0.007999487435652071, 0.27045896549042103, 1.582830256605017, -1.2757633760081921, 0.8739707511859158, -0.2364232283817783, -1.7107224351125254, -2.143790006823174, 0.8031054046102424, 1.1426311265282565, 0.20528148606409283, -0.14952723935470166, -1.0684000041772945, 0.7675575700614469},
    {0.7965170176182438, -0.7910345628925627, 0.22086786569552924, -0.8839764883360511, -0.8330544527414163, -0.7771076633036508, 1.1647421272096623, -1.9000270487295525, 1.3500842995827511, -0.27792216605058534, 0.5691849211586418, -1.778026618944578, 1.685578571273272, 1.7202197431005146, 0.5419415676168662, 2.073948537094399, 0.11887053306704147, 1.3871333635798504, -0.8158339620368217, -0.35596792384737225, 1.9984503257411292, 1.3772378046866653, 0.9160055936098608, 1.1772650857042901, -2.12275047500368, -2.4168076214828886, 0.24621499997270746, -0.24963762979892215, -1.1224846299271396, 0.14776979687839653, -2.0859835281560297, 1.03034287842999},
    {1.1710235642172035, 0.671333567566755, 1.9438469530882891, 1.5257354579261218, -1.0666027359549082, -1.4600126813639598, -0.6902714399506554, -0.4645932711470701, 1.2250383044261421, 1.5913080893302531, -2.040680545211469, 1.6967860626410463, -0.8011997420926452, 0.9120590818555419, -0.14857291303095504, 0.02730123678494928, -1.5963412240837325, -2.5570176100734336, -1.3003163578130228, 0.22360902134495036, -0.0030754065912428053, 1.7918598877174468, 1.080670008437272, 1.1275977527050502, -2.253501911205223, -0.728054258566695, -0.6269808216019805, -1.2621212425241692, -1.0049178664381122, -1.0242161197711255, -1.7388416496994408, -1.3330973944065172},
    {-1.5804332116028623, -0.9057536694641632, 0.5593033731358287, 1.5743101425384352, -0.0931999832790413, -0.16285038676298588, -1.6117225258309327, -1.04647400291751, 2.2834959010711158, -0.9027098148272871, -1.9580059040583055, 0.8934359449526621, -1.6787121371123013, 0.9527073746891461, 0.49784030162833964, -0.5236398915215553, -1.9591258284830988, 0.6287952590535999, 0.9206577497748205, -0.11511648990562494, -2.2553349131193094, -0.9972148393308661, -0.5843488686702965, 0.8829364367532774, -2.508501640114977, -1.1958878744129797, -1.019915152275139, 1.6153665016120273, -2.638561121174806, -0.8261843853315278, 1.1911047654913307, -0.335171193092587}
};

static const float b1[32] = {8.132359057411627, 8.165129923927765, 7.7692678509208175, 7.760331273703283, 7.969388129305997, 7.867381476951818, 8.008586560108606, 7.992771752946296, 7.939609621811148, 7.657263522109715, 7.970595615071229, 7.880430019281021, 7.929234579911351, 7.470702039870239, 8.051264639146549, 7.9839531793032545, 7.564218048701786, 8.202147882357801, 7.785688329384386, 7.966270607932234, 8.012197352108519, 7.604800305490255, 8.154913599023308, 8.139599190633643, 7.814497540088132, 7.8551988692354, 7.767537121776054, 8.01613644242861, 8.027956609588449, 7.562455798041775, 7.683276084155039, 7.846641217923375};

static const float w2[32][16] = {
    {6.0710524545485285, 5.907041925244327, 5.764799234817121, 6.975997852149472, 7.224853329289425, 3.966072103734087, 7.582489310449126, 6.921746710105598, 6.40864863971144, 6.341415522024802, 6.9625082933002265, 6.842073042816068, 5.7874687129997495, 3.565472737929667, 6.106165614379739, 7.388489134682857},
    {6.911987114099516, 6.303545435720587, 5.583365394054062, 5.461291063672017, 6.545362471197482, 3.688436318319279, 6.10973205779923, 6.310990352760931, 6.244945382008256, 7.188753617781367, 5.849272483483913, 5.951038993099395, 7.180051323121934, 2.739928766537618, 6.1494661185574815, 6.499400787391135},
    {6.562366839769906, 6.414621786886001, 5.357568512111411, 6.948160201312227, 4.994106266022511, 3.6020861690295742, 6.802945710451416, 6.13985223332274, 7.213659093732711, 5.742060728611828, 6.721169394544068, 5.944912360974055, 6.079598481332284, 3.9575111978992816, 5.954967198606558, 5.628826969720102},
    {7.164673631792131, 7.199507950288956, 5.217129991059582, 5.719282890444465, 6.797428974726459, 4.778108783401458, 6.381372273206407, 6.886961097581751, 6.985011609553693, 5.726864765494879, 5.815416632758518, 6.314220433001852, 6.605359645537069, 2.6500381948224905, 5.50421966966102, 6.938688986967082},
    {5.763054269707064, 5.682276547667087, 6.726572655425694, 5.8066788031074985, 5.7324052957085785, 4.941145514156384, 5.748243379790149, 6.407100767959469, 6.752371922373524, 6.403541014675388, 7.091141387401828, 5.668114906684683, 6.778817460888068, 3.375629138613866, 5.709996782240935, 7.212535766865078},
    {6.584089089208798, 5.989976639092411, 6.386287746039369, 6.39424238103673, 6.201233317460512, 4.883702317206358, 6.740313457368414, 6.269880886729681, 6.491664307129959, 6.251470999051846, 6.580376235302403, 5.360229882600638, 7.212148344223804, 4.153288853415403, 7.246409354747677, 6.9677530975291155},
    {6.113781372743578, 6.559871985418295, 6.234637003736215, 5.5803411995452326, 6.120853709018058, 4.857749420680237, 6.857533223300354, 5.880797662438468, 6.772663724060016, 6.87539998595997, 6.79132765970666, 4.909940595321021, 6.992508378595859, 2.6870434673270953, 5.857740406281322, 6.910413374577363},
    {6.008879189944887, 5.338013981470528, 6.9582372837808135, 7.10555383557803, 6.245333548015609, 3.568914134994506, 6.271332200590029, 6.067212096120926, 5.477926563188151, 6.637089319914177, 7.272331116105286, 5.662706190095441, 5.68929565821814, 3.2235700182998697, 5.69547129239185, 6.863341823684103},
    {5.5133582070434395, 5.977482312912616, 7.174956641749766, 6.22855354501122, 6.954829464503224, 5.201045003967296, 6.437030574712409, 5.618275680302852, 7.57715290676316, 6.237181729840118, 6.786520105578633, 6.663548301841654, 7.2673971100003, 2.8546245595684363, 6.06679439974012, 6.751618237286544},
    {7.033065116112771, 6.314708512019421, 5.787900332190273, 7.147636919482673, 5.246568489053426, 4.554873146153124, 7.113442702617684, 5.373919721054109, 5.5963257569925755, 7.280560179670207, 6.097173951451962, 5.8108768721952515, 6.202115979955485, 3.7841783996155844, 5.606660606458687, 5.744458353617204},
    {7.128065904562243, 6.982434696146819, 6.0147628004948, 5.746619052774621, 5.811160941686396, 4.523921984071378, 6.922863061426818, 6.636919352538461, 7.16196410800795, 7.615095045008639, 6.60895205931651, 6.470581046797681, 6.838632928876987, 2.783289392216936, 6.826118913121203, 7.021674033807617},
    {5.6148819142910265, 5.885627352405217, 6.79016064325708, 6.030164759533314, 5.820664118432503, 4.1675118633613035, 7.120280974850401, 6.960280075049147, 6.537226086414793, 6.178222336693487, 5.625928507863371, 5.126394318808198, 6.5978027478167895, 4.068941344936578, 6.080557925673947, 6.328046310215685},
    {6.09898962946605, 5.558107104311128, 6.840965381804731, 6.181054490875792, 6.864037640957841, 4.6980323302118006, 7.125255638041198, 5.584662380779752, 6.452877780450121, 5.814875767774286, 6.143962080033984, 5.03795660560194, 5.722730425666003, 4.136811701051532, 5.5958279214001765, 6.745607197323203},
    {6.435668001197082, 6.6853503593220545, 6.387001302534673, 6.759569491622841, 5.976085842659209, 4.765322870795295, 5.957714537890038, 6.475157899407419, 6.117380192713286, 5.882281187604535, 6.257613582283198, 6.536704162600412, 6.287000857318351, 4.201611383629172, 6.048923150361243, 7.529252389500991},
    {5.783560992799702, 6.929079355925431, 6.2045178474729745, 6.511132347563514, 6.437575655493866, 3.9803305536794107, 7.320359008211288, 6.973613890072215, 7.405077269769466, 7.555386949615856, 7.148448776552068, 5.8932070374803125, 5.8913470637163, 3.0606548463073375, 5.994936851400819, 6.461217057247618},
    {5.343731981910063, 7.234112945443357, 5.891372403904058, 6.88210640684961, 6.132905928869808, 4.14437782668907, 7.121000112983, 6.9515692135335625, 6.518197656828317, 6.381730145897458, 7.056613028735008, 4.879519752909371, 5.76977034984133, 4.450430316392298, 5.835049647128198, 7.220280419204572},
    {6.594656135901597, 5.589744116144755, 5.867363911083136, 6.427831794932476, 6.07974055127175, 4.330505191216982, 6.242872422438151, 6.076544478739075, 6.847860489949266, 7.126454571659949, 5.747690420189173, 6.657362284565725, 5.5252325179949695, 3.9363062477073845, 5.395109952053015, 5.296967721004812},
    {6.6083981070953, 5.825856539211678, 7.0646112784519435, 6.34512743385098, 5.559354874379943, 4.187133932910924, 7.2176320008499815, 6.500325715786714, 6.938854474175682, 6.4966279469116675, 6.380275495790083, 6.188442058695053, 6.927125419349063, 3.637951428232168, 5.756473205802042, 6.763493820966239},
    {5.766878338015433, 5.811005749801661, 6.761817659910386, 6.168837817915691, 6.686445057566835, 5.048949007603433, 6.057179490900197, 6.195196698636557, 6.995085746015608, 7.361681269421062, 5.973442095135938, 6.591704824358643, 5.7952257535085305, 3.337152804014708, 5.5099314418268905, 6.6260469943606},
    {6.427942163835724, 6.760397187667451, 5.808905119026335, 6.131134234111611, 6.42543763701538, 4.234178313372443, 6.605799598230513, 7.317796903342079, 6.020041902391576, 7.189665835842656, 7.051756952678439, 6.441521892958831, 6.826879236910908, 3.9435046382083225, 6.396265802995962, 6.175873039380594},
    {6.026961947206054, 6.29150902783364, 6.3239890769857325, 6.365479245916365, 6.131311116887728, 3.8364587953111156, 5.975379377202723, 6.594582514363379, 7.072050331194143, 5.854751366925225, 7.090497030191421, 5.694984696642761, 6.624679868403773, 2.4058571657483614, 5.571337400600516, 6.5140977415318275},
    {6.376380942315264, 5.611832579506738, 5.78976845132044, 6.051613047669613, 6.262314752039199, 3.6173145196816128, 6.266426862506595, 6.19873074664964, 5.973689565901663, 6.812440777555372, 5.606322642337763, 5.6815773576081785, 5.627541148831735, 3.986473176381222, 7.147088754657846, 6.70650047017188},
    {6.214572112417078, 6.346936443666133, 5.711703301627612, 6.06807997513238, 5.506318948583301, 3.4684562449775007, 7.4345250321346406, 5.549194613669313, 7.222419806885231, 6.410017935099242, 7.0753253228100546, 6.444973598906963, 6.20224887859364, 3.7410472687033147, 5.85841778156974, 7.392133980794472},
    {5.679196877333525, 6.711658577866715, 6.973762857624435, 6.901686645381025, 5.939472082764755, 3.7378288263957558, 6.552183411352972, 5.6899502407039995, 7.001502819145194, 6.806125307290419, 7.393454255219349, 5.4406485406447915, 7.380938359586581, 2.923268909574609, 7.187185878860441, 6.12081391338696},
    {5.559591695901518, 6.275179220232753, 6.204572488231889, 5.898563895364332, 5.842275917495357, 4.250957856246078, 5.764366100365905, 5.493077679072524, 5.485443246098423, 7.304926806908534, 5.541655424779904, 6.395625706293844, 6.7589764979159845, 3.695834596777505, 6.93530133022963, 6.933379250308383},
    {6.121895080758425, 7.037886579124987, 6.948501232833703, 6.540242382084655, 6.978217406149023, 5.124842122468074, 6.037370078981614, 6.572999290365362, 6.110526256991348, 7.243759386602541, 6.503567948790707, 5.642890835929779, 7.27439339626515, 4.293767558951779, 6.548535473999591, 6.441069954563694},
    {6.888324935254376, 7.09363052707297, 6.4029863589256815, 7.0150958782994115, 6.953600051088328, 4.736549346356624, 7.25905655892053, 5.71002454676171, 6.988777193249201, 7.017705757164369, 6.127305153110966, 6.227693821120597, 5.906113611298643, 4.3016944490223485, 7.439794395750877, 6.4567699284418385},
    {6.733934360605562, 6.2896812096842005, 6.252425701244474, 6.204157365650539, 6.856580329944527, 4.236555072210656, 7.349245577508243, 6.192734845871161, 6.642748572268039, 7.588469881037995, 6.187990473111583, 5.157486551479135, 6.6867664977732755, 2.5410737533668164, 6.933320120340913, 6.707688827425055},
    {6.151032434082018, 6.092900247376495, 6.191427682547996, 6.6013833464701035, 5.500415719606375, 3.6805273550834237, 6.416565534167202, 6.809167277736787, 6.601816469857535, 7.119426440277256, 6.733632084700972, 6.1140423992762125, 6.3643753300657, 2.5934138645053335, 7.242070258723576, 6.601997024598981},
    {6.424509300342295, 6.804064339353168, 5.548028560672993, 6.707204312855352, 6.243922589836839, 3.6928037976125223, 5.73426715483305, 5.577752447149613, 6.4956695827489295, 5.952870389867364, 6.220507045786693, 4.884609294506092, 6.07913484781622, 4.245781600267359, 7.193236618185147, 5.686196611547334},
    {6.531976829572941, 6.8805270200762125, 6.522847986737723, 6.700285928000704, 6.07458543430512, 4.748955939779411, 5.59369817696042, 5.890924000021598, 6.928231828320544, 5.601536225810174, 6.5415615639730715, 5.553947388255962, 7.234560485570373, 3.684236023538105, 6.449122146548743, 7.360248595953752},
    {6.391452646621561, 5.7610623274966395, 5.915898388974279, 5.598056148943301, 6.845633396913266, 4.763975755396487, 6.086441731304705, 5.97133713427115, 7.224655049730013, 6.797368120450751, 7.578312140222446, 5.351057697177417, 6.162254919594016, 4.056092500492122, 5.9177356963497525, 5.826831897798779}
};

static const float b2[16] = {6.890522588981798, 7.179504694217234, 6.965075896824199, 7.035594584825393, 6.859442617210529, 4.804140005460641, 7.098349650047609, 6.833560367518358, 7.032458010371597, 7.115240065789153, 6.946224108233589, 6.415442459098575, 6.95160402806074, 4.1673863060073675, 7.147318464407466, 6.9155178056811595};

static const float w3[16][12] = {
    {-4.580604400322501, -3.572557275918761, -5.081962572708897, -3.742338454838039, -4.145241350863548, -5.062782966302584, -5.44365800337093, -4.249837506349888, -4.890763498592903, -4.3376347449677715, -4.602822703979593, -4.306052025931548},
    {-4.9470460498339985, -4.77066435704879, -3.7994794766757454, -5.2656541929784115, -5.045153672594072, -4.966797725899403, -3.8046113329877884, -3.7473087449644504, -3.649102557639874, -4.9802834417360815, -3.961216697047992, -4.57019389157387},
    {-4.402919888998019, -4.075199891909353, -4.137647545437948, -4.510744776056345, -5.452481731448354, -4.9441325720812594, -3.8553816661439524, -4.8755177404838905, -5.0973267650786624, -3.809697565474378, -3.6758420169992165, -4.037475104809609},
    {-5.557152832284778, -5.3194160244182624, -4.891764451169999, -3.7648882657073415, -5.491741804447052, -4.399550614646729, -5.2176701263165794, -4.827556420506142, -3.373911692758446, -4.559913111675249, -4.698300155530249, -5.144532174588028},
    {-4.835669311883098, -5.583205109078199, -4.271324679896545, -3.564630530711846, -5.129718943171033, -3.9973144053908136, -3.71688873113259, -3.9067730198741684, -5.161738765905229, -5.16899568477805, -4.255490915404827, -5.104133040172855},
    {-2.538976062095928, -3.0792925661185273, -4.334135248820752, -3.069815842312343, -2.729779130024444, -2.6148313519071347, -3.5548150216424252, -2.97508372236311, -2.4523226762563994, -3.091142876966324, -4.597856984560104, -2.7083580163604},
    {-4.743993008951383, -4.3487544711412625, -4.555378761280873, -4.569268039026977, -5.183959714349229, -4.722112502407232, -4.155788542016409, -4.745952713881758, -4.38952500614262, -5.3419684745278335, -3.9736558668296875, -5.097828662026673},
    {-3.73210209756695, -3.8144852667619347, -4.718073370272525, -3.581022288776814, -4.50907051834347, -4.6145461362667275, -4.6512065186858464, -4.9384062285779615, -5.1283303981831825, -5.170798257359962, -3.9458277237595083, -4.51601190018517},
    {-4.744455404988781, -4.7286774456617975, -3.365510160561776, -4.6759597187289526, -3.923722926446259, -4.883458517076732, -5.236960017977165, -4.940609480533687, -3.8153488793790618, -4.337032197602266, -4.000506899548817, -5.251726680751905},
    {-4.290446958611571, -4.434461347193866, -4.318198537552055, -4.569457624737987, -4.806480390844319, -4.570696247278361, -4.632202362124707, -5.065252188194244, -3.8937579164711864, -5.304384503820848, -4.903320223346872, -3.951970176514157},
    {-4.441335971819346, -4.338400520409129, -5.291991833906306, -5.269233516484665, -4.9171231199613485, -3.7861476934311695, -4.566502322686098, -4.7559341074326955, -5.266421656069441, -4.585008040269755, -5.514017086844154, -4.129670226374562},
    {-3.8780898852142616, -5.295530567738451, -4.052756338450816, -4.893527028097929, -3.38475728259312, -3.804441833416027, -4.830333037305759, -4.377367679859705, -5.175547471272849, -3.5296129277204717, -5.2429706964757035, -4.799333916271043},
    {-4.840651712329421, -3.7950663237586926, -4.236758540596745, -5.517779465601962, -4.244752309239585, -4.814959126868528, -5.42153029662311, -4.2368436283336255, -5.375883618243023, -4.693668644328667, -5.481355942863047, -5.10615857276226},
    {-3.021127769414336, -3.0903467487846834, -3.1887494758774926, -2.2631092968922255, -1.8453310868663604, -2.285192341871231, -2.075556666904222, -3.2151329243975386, -3.084144194934981, -1.8872945595353325, -2.106499319908263, -3.6255683808896446},
    {-4.323429896693102, -4.683470662095916, -5.362338801376774, -5.181128681623755, -4.192476388962618, -4.834536120145564, -3.883656205655437, -5.126803391375219, -4.855673754128376, -5.084521798146664, -4.390049661406721, -3.302811954538236},
    {-4.848058386555105, -5.154965370269045, -4.840936078848393, -5.138727010190136, -4.273270062576595, -5.1389959754945185, -4.613632685250767, -3.988832588992785, -4.358013513257838, -3.5149701011478682, -4.719405074821243, -4.472120105499998}
};

static const float b3[12] = {-2.846583921216161, -2.9983904674449113, -3.0990701357304347, -3.2335387163740252, -2.7683699100213124, -2.786316081076873, -3.072342994841424, -3.0759312060727715, -2.4741463717211407, -2.933396239415249, -2.678582561368171, -3.2441433699414843};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
