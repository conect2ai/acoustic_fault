#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.1515332126274541, -0.37930491577692, -0.3243460550951541, -0.004867260335157068, 0.511550491545246, -0.44974796413393875, -0.4547850886216156, -0.5090530819251098, 0.16857750928155923, -0.2808124169140536, -0.08287894718169961, -0.5266934034578652, -0.5869371665725907, -0.4804844560298442, -0.6007802982873656, -0.11553002440247394, -0.2552496684484791, -0.49117895085186414, 0.3856341099804164, -0.5669816931125532, -0.6529821984239027, -0.5898829288402583, -0.3969427941112154, -0.5702554589921588, -0.3925219521526343, -0.45185614483869846, 0.3919492174109464, -0.5747398890709964, -0.5354993080881865, -0.511341421615819, -0.005337648998043065, -0.19312191497778597, 0.38351750295414616, -0.11573765346166498, 0.5133923481557968, -0.28420383223023815, -0.4418632726383587, -0.3504850196242826, -0.5799658222880549, 0.42496283359549947, -0.29647031114567257, -0.544895518450497, -0.34457841926884236, -0.398987273863304, -0.5553583672111799, -0.4462026250827008, -0.482987765835563, -0.3234356589485714, -0.22711075926459368, -0.25853531550278147, -0.09802185149836297, -0.6485818578847036, 0.1812056138539813, 0.29572313804651934, -0.6688828112274441, -0.21653920654030412, -0.33455526805131625, -0.3437678484237529, -0.6043732798701129, -0.49884608102085487, -0.15852450389464823, 0.46612013020929255, -0.029849834968722753, -0.162514058159396},
    {0.27831613328076843, -0.09226589946865028, -0.3948864478773877, 0.4714136373519054, 0.7288934745421352, -0.4222915260371726, -0.5319733462039983, -0.8163938655903106, 0.6257686578009807, -0.452837530872206, 0.04657399961552374, -0.30032854188533303, -0.0519953119636428, -0.6565645387600694, -0.25676035637658895, -0.15269672517631244, -0.6759033565827082, -0.3396489606143839, 0.6606815921621362, -0.1873262864149792, -0.17980055157187164, -0.8020837378386612, -0.5652884657148205, -0.4396903499778993, 0.0366267449543974, -0.6625959425397658, 0.5423495734983339, 0.3023330460980093, -0.7524440587383672, -0.22295006482004673, 0.3712536029701678, -0.2764594874559281, 0.7477567677186332, -0.5205734292651502, 0.4048272677337924, -0.07216181377927687, -0.6170660142385387, -0.4356301913913583, -0.6803096447147823, 0.7139696143777536, 0.273911730736542, -0.856593421184761, 0.4579732843024549, -0.561510136928364, -0.8899241036313873, -0.7238657470682196, 0.03928542305544865, -0.03398977260571235, -0.09409478561537322, -0.21783138247186237, 0.02405280542446807, 0.25852801595308605, 0.7523729327045771, 0.3077705345131491, -0.6180733123266963, 0.46593630868620933, -0.40298279754659677, -0.3871122002090387, -0.12541263049942236, -0.633682422937685, -0.2868727636710243, 0.3992990893582951, 0.7392047335024144, -0.07626967611528067},
    {0.8118575488814904, -0.05498833104236774, -0.4292591532530557, 0.6503195967047194, 0.6583263961603273, -0.612864974160242, -0.5546238354492925, -0.648798711442681, 0.5717107414207013, -0.24045142227383925, 0.49516815695109867, -0.19143677119122046, 0.13936084166980164, -0.6614169809088526, -0.33367848162760955, -0.10572196461663458, -0.40494025482954665, -0.21904605062837915, 1.1377928746356007, -0.26024176482162026, 0.04723575159236756, -0.5110539501565013, -0.1036496078674803, -0.4207141102410093, 0.2119877783416444, -0.2544517383676104, 0.3859566301464503, 0.2378192892700454, -0.5113662756876022, -0.20645501460573928, 0.22324326241083894, -0.25574340545019925, 0.9694248472286855, -0.3391243515912974, 0.9208821537702097, -0.12771099832412414, -0.4372346421853716, -0.6931627317242676, -0.3629661063848319, 0.9545465205750784, 0.3779052840283503, -0.2510193780209857, 0.6043896205390105, -0.17547243512466493, -0.2859451895639759, -0.5876280201290923, -0.006024044981323884, -0.09884275166456098, 0.03276896878270254, 0.46440264616258253, 0.2715984558562752, 0.38685098312295874, 0.9977275363497475, 0.6975536042875241, -0.11116013997621307, 0.7248247767671532, -0.29312485803048965, -0.38243856481296556, 0.0595564684618465, -0.6907552536451718, -0.14761050372678278, 0.716949959390736, 0.646461817181285, 0.20332902075227471},
    {0.6282098449301167, -0.6490305377462773, -0.386541826267908, 0.4920764295250828, 0.6251354254823933, -0.9077507744494516, -0.6223116447276388, -0.839361108691616, 0.6385960063567999, -0.7391417823985706, 0.3929644932363632, -0.46184673884267136, -0.6502498343296244, -0.6897915915305011, -0.6591648390030358, -0.4628645581940452, -0.4586366619145493, -0.6974287140012031, 0.7560144401206619, -0.7685018868902386, -0.29746038251196494, -0.6267881821095853, -0.8351407440097071, -0.746745123564249, -0.15169025456525362, -0.9276040901762796, 1.0485992759401446, -0.17520753127753025, -0.6572934632679218, -0.9581572264266284, -0.18023919953029005, -0.60520933205171, 0.8367737493613306, -0.9247747986858964, 0.8352591136935748, -0.6467661074453266, -0.8165101223574573, -0.9215960787799496, -0.9522963545241306, 0.6369153022687996, 0.17011377796283716, -0.625834549734334, 0.1961417902184316, -0.6998440852077619, -0.6800085179826938, -0.7207574000915808, -0.2268996626478487, -0.5528708620392686, 0.02052308017195095, 0.2611000594586361, 0.16588532250471863, 0.6415016366438873, 0.8315270695360297, 0.7183686374430551, -0.4447806764284864, 0.43260375949542784, -0.5524460791898644, -0.6824151826761402, -0.48640512783791623, -0.7773676435927297, -0.47732657343388796, 0.8268584794694549, 0.8975282489058234, -0.0487947925605686},
    {0.9659326831654403, -0.821533878215792, -0.7033623039441732, 0.5613398561064427, 0.5418582200700257, -0.824733330822984, -0.8320268001199588, -0.8320046394833688, 0.5214203387392303, -0.7954539246459583, 0.6085627759432993, -0.4176435466720098, -0.7180444427733991, -0.7151702805787378, -0.7381977230316126, -0.6374367422002933, -0.6205489646582364, -0.8596450099978679, 0.8180344838052228, -0.869402047732364, -0.3193908742872842, -0.7909054104301161, -0.7944733453237706, -0.6670709447688196, -0.3235908340752681, -0.9008570949610757, 0.5907976461639286, -0.0794054300101896, -0.6897527037860304, -0.5353783910176314, -0.27330097563642836, -0.6087679312052487, 0.7686982161928444, -0.6739775358449962, 0.6452913855426069, -0.8006225460980736, -0.741763088917204, -0.8199229062194339, -0.8920583931811009, 0.31542021010882737, 0.35935083417266067, -0.7896704719608892, 0.4318964505931939, -0.8624770983772521, -0.7017143999710789, -0.9059219275302922, -0.06877468616549598, -0.671939001748969, -0.26790647711044463, 0.2657230153438259, 0.46518323597763683, 0.7589020768568563, 0.981784158779225, 0.5216218446147761, -0.6646617413412115, 0.835876052587152, -0.8023005541086315, -0.9298842267802118, -0.6601895933095097, -0.8767167639612415, -0.6480735485502755, 0.9717301498739159, 0.9100944929996958, 0.055241847299555814},
    {0.678819469039395, -0.743407085437607, -0.8745371355094206, 0.7136757610658709, 0.37225476581094813, -0.7407325076576724, -0.7649680321992292, -0.8175900911648335, 0.29929648623383975, -0.8056377631281861, 0.5228089631664452, -0.4947822608010656, -0.6968181909220514, -0.5025431242148446, -0.8654828743055467, -1.0490708485050255, -0.7159509652282354, -0.7383266672760932, 0.36599088783649003, -0.8321538691376831, -0.38595258904597346, -0.6467140549196679, -0.903325658687893, -0.8059962458225383, -0.16844550411777048, -0.7582293526129723, 0.3706336386060041, -0.1404446792400777, -0.6357747197723348, -0.5528006108642256, -0.13207787459556738, -0.8743586260116993, 0.4792956770520153, -0.9046495521800826, 0.43818349291723513, -0.6217358053233002, -1.0713101953607356, -0.8604529876152289, -1.0321978132710443, 0.272494122860718, 0.1963257264202596, -0.8495617762955429, 0.7779703803698298, -0.7119834273029001, -0.7153582067403864, -0.829470683004233, -0.06741505595095308, -0.5965538011712481, -0.3370169294330871, 0.4385288017337827, 0.4921665082052309, 0.8610917299287992, 0.6920705697763277, 0.5839428007920858, -0.6184393740594973, 0.6234027790340367, -0.5762670137220922, -0.9185304186029948, -0.8500164786918533, -0.7264427840791592, -0.32666051733056284, 0.4760209680654307, 0.7720536832948508, 0.1324435395342139},
    {0.9931834783199878, -0.5122889807147933, -0.6667244012516826, 0.6497425848056392, 0.5495971312801605, -0.7800346790264311, -0.5564162391979395, -0.8332447722971291, 0.3291196713554441, -0.7666305277606956, 0.41712318356162437, -0.5946609950632902, -0.7502689259278661, -0.664679327684217, -1.0046964866667367, -0.9225307704586583, -0.5818738508234386, -0.8765220496968398, 0.593493906694115, -0.7987956175714865, -0.4552929028124572, -0.7464641164127942, -0.8655936852546093, -0.7609293365140143, -0.11762235286617446, -0.9166510085348974, 0.049132012696261426, -0.1723350468981207, -0.6090048784872026, -0.8034210035740155, -0.14258164169629706, -0.4901628800301363, 0.6773518109253595, -0.7487135788707973, 0.3342994939666909, -0.6722007386760966, -0.8596833552855622, -0.7144522359209124, -0.7690581734415423, 0.27142148873964755, -0.09514463864434211, -0.7848642364641322, 0.761652523234494, -0.7070164903073519, -0.7837979567810751, -0.9062878146300507, 0.07537856520324178, -0.5122633105643403, -0.25562626591750875, 0.4881333996646806, 0.6123078689288532, 0.4974501513002891, 0.5431818344697396, 0.42485425345806777, -0.5054320529777697, 0.5916787306299576, -0.9850476423730993, -0.914667340182787, -0.542319111900609, -0.7025078696329139, -0.5442434127437917, 0.38604284959362467, 1.0138868615266063, 0.21896547955961548},
    {0.8994544925292863, -0.7799828788902033, -0.7167485850011655, 0.4603637602617119, 0.6224177040544719, -0.7885811355901862, -0.6542124528618622, -0.8885697982676707, 0.38641824283278897, -0.9986579669553455, 0.5488557499593999, -0.8955514667483788, -0.5610294569678479, -0.6521986166690011, -1.1205777274139899, -0.6765671335729571, -0.8753964914331879, -0.572318184484002, 0.5262711840282723, -0.6177066731296197, -0.5103631097500007, -0.8253482726096124, -1.0683768804146123, -0.9282922702882207, -0.22527180941064784, -0.6976387469349525, 0.3238956900085028, -0.3984052556632292, -0.9070982143866443, -0.7558378947419031, -0.24420121745272094, -0.5637395937602001, 0.5218264251265436, -0.9151135437304255, 0.40745250138040784, -0.8502696570340246, -0.7626826495537792, -0.8141326812587961, -0.8083997492111051, 0.6058577383922109, -0.18158537022002993, -1.0143370914587844, 0.6183280387779255, -0.7670065644202922, -0.9327123033132232, -0.9905399172713176, -0.34406767363589935, -0.7752153132532764, -0.3317307289772113, 0.30313118488050267, 0.4572202486533984, 0.5969011416001034, 0.6863146673578131, 0.4093486594506565, -0.5379500254610959, 0.40098330312475794, -0.4395269759505588, -0.7219693617116706, -0.7007415023394039, -0.8060079761118548, -0.5718074235658729, 0.5757552287330431, 0.7097091987064675, 0.38289523900193884},
    {0.6437262578729122, -0.6860705719696997, -0.6715637909123309, 0.6709122816068889, 0.6392327992734943, -0.6819077851027846, -0.6872086211652595, -1.0559889131392093, 0.289584553669965, -0.6354154207281772, 0.25353286210894976, -0.7465051996334848, -0.5850469557699522, -0.5550379505828721, -0.5199766247530221, -0.421089936181054, -0.7860059546077174, -0.690024471173908, 0.4742204158784772, -0.6599664818479302, -0.34319706157641044, -0.9210042665007679, -0.7138506674714661, -0.6620963672291126, -0.49919328306615735, -1.058859338186566, 0.625168860656827, -0.14538167032799393, -0.6195315139132166, -0.8759418553937481, -0.34448575892751687, -0.6212137170329799, 0.70626004990843, -0.5425593659334721, 0.3352490736676579, -0.7463223239017808, -0.8903004999039992, -0.8497077431374321, -0.6235056111726538, 0.4348349477271852, 0.12078088380169073, -0.8115467676502273, 0.3859474295987697, -0.9217750616805879, -0.896810585144733, -0.90276265313149, -0.35729974936252695, -0.6845122314872174, -0.3134203085043954, 0.2222022712909137, 0.0012262885901813592, 0.3877116095277997, 0.6154719384448737, 0.3693622816353308, -0.9201576611837055, 0.31649851310058114, -0.807894371938596, -0.6587390171316211, -0.5570162787631514, -1.0160296070569927, -0.7535138410561798, 0.4404150231219884, 0.820022225492008, -0.043793220080349235},
    {0.7481239760829451, -0.8875089802961451, -1.019533536464272, 0.623744193745995, 0.738197026061489, -0.717449021747654, -0.6381137878741968, -0.7829686554023036, 0.5816323091416069, -0.7717528829059644, 0.5414303631534277, -0.6303372486228285, -0.2713074730368218, -0.7616917741054007, -0.6287773145106873, -0.4495760967591769, -0.6915242144250434, -0.6485583970349414, 0.5396170742481905, -0.6719082927183974, -0.3076464257368948, -1.0136500939912352, -0.7881211692886899, -0.4927072042750678, -0.2541627146626279, -0.8473982161126361, 0.647720359873444, -0.03124203151577413, -0.8860742438534881, -0.6557301218805291, -0.16281422796997885, -0.7869380651982304, 0.5795846502490632, -0.8000834459099533, 0.531455898171545, -0.5525833938252015, -0.8682111779508118, -0.8839294336150092, -0.9081427638854872, 0.6056162996517277, 0.16483882399756708, -0.8837716179599449, 0.37992964509335786, -0.7338809292838088, -0.6361082567106732, -0.75899149648815, -0.13625450585429258, -0.5569855483592642, -0.15722682082344114, 0.4550019447243988, 0.19616407145783724, 0.7066868708021277, 0.8614141232934599, 0.4746391293020584, -0.8967757872149128, 0.2805923882063201, -0.7341200868295168, -0.919332886418861, -0.4170879563403669, -0.7635907245573131, -0.44422576830477406, 0.5014600366316405, 0.7993526464271925, 0.13667814124222002},
    {0.4348064030500257, -0.4009601961110676, -0.7015610206947499, 0.6619764079952064, 0.5125692459051537, -0.8472723206760907, -0.3677729802931338, -0.5926274612337287, 0.6706595286757203, -0.6146944579006451, 0.21731390598386605, -0.39603147819155776, -0.2589060682619937, -0.9212397212299903, -0.5022666434594063, -0.6543318568012945, -0.844054844978585, -0.805018044925972, 0.4740574938860401, -0.8641980902238127, -0.4704623614332125, -0.9369493280177408, -0.5988513035612497, -0.6609255081300209, -0.09025565007050076, -0.5853735842839214, 0.5959741350649725, -0.09058422175350701, -0.6805376978474544, -0.5601146011872385, -0.03839846210510538, -0.06912888287236899, 0.5510036967620524, -0.8118999896988991, 0.6619573767545471, -0.3551021558822741, -1.0304026562739463, -0.9967551536444782, -0.977830515728747, 0.7261078613327269, 0.24850865498685387, -0.7667991431501121, 0.6287534808882371, -0.5354336369212257, -0.7784177601877549, -0.636270748362808, 0.04986345368444248, -0.6079039975356536, 0.043841324824799084, 0.24757709973134218, 0.10983619398308772, 0.6485818289311309, 0.6070865386589065, 0.31272589655304744, -0.8421756069530586, 0.4854672618765057, -0.7608451502391578, -0.7918600629500782, -0.5752047174006785, -1.130052922883505, -0.09992384732559165, 0.5650469277170347, 0.9309739300024761, 0.33251202485198195},
    {0.4433752686399968, -0.6748312974245232, -0.7567811071579579, 0.7133985238572289, 0.7907330982279709, -0.7396524097604392, -0.673794281041877, -1.0934510601716518, 0.357078009629376, -0.7270079436269052, 0.4209442417955953, -0.5883761275007183, -0.23100288154420795, -0.7993880686645042, -0.46648574243053864, -0.7199033794757355, -0.8507266084978542, -0.7115999139101548, 0.6076464565749815, -0.8529131759153933, -0.21435919344520923, -0.7316493717327761, -0.8708441178112672, -0.8116222688012138, -0.33529906897302864, -0.911673558477654, 0.49301563008004745, -0.2964639833585505, -0.6456694240581294, -1.021295600196162, 0.03166007994198959, -0.651931457963538, 0.5199795886459103, -0.6679827320792147, 0.6020238918427012, -0.6673507195423262, -0.7260318754373348, -1.067263592566239, -0.9040885433873329, 0.7417178514005686, 0.135661100610582, -0.9161063099326743, 0.5767400068253511, -0.7241252331968069, -0.835158908242836, -0.22935608133833751, 0.1846493291870977, -0.5622218465453194, -0.22425607455209226, 0.497455462882806, 0.24620715682396455, 0.45476065953688577, 0.4777048822360592, 0.6644514420999499, -0.7638327591163532, 0.7462706861815223, -0.8288746034907092, -0.7605625725559934, -0.4724124800918842, -0.690786866250454, -0.32339567159997196, 0.7315753060220626, 0.7484532018799163, 0.4573912571742844},
    {0.6125761473811456, -0.456052844685154, -0.6640998878353198, 0.9705567220972526, 0.765961621810411, -0.6342060655849577, -0.42862069016493176, -0.5399787118157322, 0.5899553081439136, -0.4997592696112018, 0.5023632415805855, -0.345813744495371, -0.18003205749083367, -0.6357209696827465, -0.6734451182558203, -0.7471639760308367, -0.7626455862928548, -0.6433601278602945, 0.9356203265047403, -0.7142132273470428, 0.17670651103274823, -0.8891724837320354, -0.49019196581528285, -0.5129449645710262, -0.18351195755807767, -0.5873136578814468, 0.6609086745751781, -0.08686207644369921, -0.5828676653977801, -0.6953051869950992, -0.03885884560165204, -0.2908287108505805, 0.7118890571029125, -0.8295682386533081, 0.31448898936994246, -0.617357165588668, -0.726372784378091, -0.8283923323852462, -0.7460003419619111, 0.6737205420738296, -0.12858725409165872, -0.712367054981593, 0.464194836594122, -0.6842541483252735, -0.7188781098398072, -0.585916321182096, 0.18004907436330553, -0.5745021892933414, 0.06515905716867498, 0.7251454067254366, 0.1362677537926085, 0.542189037922104, 0.4383100467648759, 0.466653818055807, -0.8265931140463091, 0.6489803713495045, -0.6364437427715491, -0.8032331967263282, -0.19750852885677866, -0.7277290336837309, -0.272466003892999, 0.5615718658980898, 0.7288784222892454, 0.4917232726881813},
    {0.2021364852811943, -0.42968124854505446, -0.675106971474687, 0.9039838131372061, 0.2914899610934613, -0.543509138225244, -0.47228968270039495, -0.9284771718686611, 0.5436784488979393, -0.5791854883707861, 0.4033334160533883, -0.09279546803347602, -0.33123694376683155, -0.7819127846805971, -0.33259703868498514, -0.6922352034441327, -0.7061803924750529, -0.6601997976340641, 0.6183621593210559, -0.6569080184722201, -0.11137107217234488, -0.9035204767643534, -0.7582560440388605, -0.4884050886931145, -0.10104654068845913, -0.788044187755829, 0.6345092535717024, 0.21442180981846337, -0.7434454375578374, -1.1453897634666128, 0.06786951003662035, -0.5494842171029148, 0.8022848227469798, -0.5133487581641251, 0.7398296695364804, -0.7595309042679691, -0.5571244925316656, -0.7049270986162535, -0.6697449639596347, 0.7198273220292654, 0.1371480653821778, -0.6547341159490816, 0.8412700587219251, -0.8297650877686163, -0.8002732641655783, -0.48932286950744036, -0.08999421643133722, -0.6850714692373442, 0.13878368539394417, 0.6466610739425251, 0.21537231116683941, 0.5043895133646799, 0.7197088813590291, 0.5841791137988448, -0.5183257481956725, 0.4341514706448852, -0.5102131937680827, -0.83468924487498, -0.5376778858687445, -0.4862567162588596, -0.638142697911097, 0.7909860186939718, 0.3935036394643329, 0.530170146778008},
    {0.5124711939053017, -0.4585514827686535, -0.8575700931182592, 0.6956183268686371, 0.4431708167030667, -0.7795552714503234, -0.8403837101093424, -1.0800992954331556, 0.4926810612235805, -0.5812959909075893, 0.5620326965638106, -0.33875764140672443, -0.40715918624747266, -0.5653213212582195, -0.50752095785722, -0.8944948996790946, -0.4344089361737576, -0.7807564489604185, 0.7591073764306099, -0.46887066960032436, -0.20634193921743163, -0.8247478464390112, -0.7207649425130532, -0.7401580212388507, -0.3963269639313057, -0.7844154679796914, 0.7551523193189371, 0.13844465133244935, -0.8786414702131485, -0.6823232863772136, -0.031153334302103333, -0.2922797535167923, 0.6716036706643055, -0.6890830548480347, 0.8094703507935368, -0.44527257777428125, -0.5271136864027749, -0.940197963115572, -0.9168613390431898, 0.661876305157358, 0.11412067796865351, -0.9306004443180073, 0.5940371038100004, -0.6194049722774561, -0.7617821001294203, -0.6250684568311575, -0.2992093958295703, -0.23096400143316692, 0.17875051234010997, 0.7608521233043178, 0.10268444639630378, 0.7642615932475867, 0.4886808021260767, 0.6110474563652113, -0.09117236489404437, 0.5123042822016421, -0.5327145930331632, -0.6919770914889148, -0.5419987068097847, -0.7715561631005693, -0.7459299035286117, 0.4253447790673555, 0.6360246165334672, 0.4153100019899876},
    {0.5532759120133862, -0.6403739296926797, -0.8356373562180655, 0.42342435886443575, 0.7525067395499587, -0.699309249327874, -0.9154853480552262, -0.8058759464219135, 0.5194104697392812, -0.9156682804426257, 0.8410606329227842, -0.5675500357990404, -0.6886930115289227, -0.862982585985449, -0.7527532282651596, -0.6575578085762586, -0.9502609566192303, -0.9159526081194349, 0.6373110937063581, -0.6751143452618082, -0.40049478003294187, -0.7321677692418871, -0.8855719452989449, -0.7038179217721536, 0.10491663420418954, -0.683238676505635, 0.7474344170639886, 0.027931898867904165, -0.708630343146262, -0.6642147964836106, -0.009756514376565193, -0.7399112520008055, 0.6040198538848276, -0.6570078297633745, 0.7356103824136916, -0.6500315339934459, -0.9128534174743347, -0.9149927286879833, -0.6939805707725616, 0.6783793119195543, 0.3001671938648886, -1.0064636283726824, 0.7622695735722934, -0.7473239679813852, -1.0723192044344179, -0.8766800232894312, 0.1041696493522114, -0.4572855497650962, 0.2485813720009857, 0.5390213096021459, 0.332402645658847, 0.6935539322709643, 0.5560556308663376, 0.6693333801946727, -0.35344543405532464, 0.8137958278952933, -0.9113159079284, -0.8259199034164044, -0.4041028572364385, -1.0255589622290011, -0.759769833098034, 0.5020724302073748, 0.7369553682911593, 0.5008432314791063},
    {0.6454796696333366, -0.4141368250755906, -0.5989732132475457, 0.9577776479736902, 0.5537315948796001, -0.8656010887015263, -0.6580600269908151, -0.6978122825170204, 0.6026817257223912, -0.4707514379101086, 0.7137051509961794, -0.1857698437020128, -0.5046799910598584, -0.6921753724577899, -0.5349822340242685, -0.6167988585034583, -0.6924665986745638, -0.6024294614879896, 0.996171170548201, -0.9752206235679483, -0.3161412398449596, -0.9210080503136996, -0.7915094991609298, -0.8239822875002513, -0.009349574173814301, -0.6100079546938358, 0.8795926291170276, 0.18110240874546382, -0.7471078919136206, -0.5081799004954481, 0.2924289224174853, -0.6234111666851764, 0.8324579802306911, -0.644574951025507, 0.7931270773483768, -0.5970771879181934, -0.7358043450439724, -0.8811958261022486, -0.8941649993730258, 0.6725658252497148, 0.13134573268676708, -0.70295783978759, 0.6840535115295299, -0.9129255099519087, -0.8953687331497783, -0.9919546667974976, 0.09402149267904086, -0.4651911799835569, 0.09965392017368323, 0.5284276414727852, 0.34086612919561554, 0.5928951904548211, 0.4230276265616533, 0.47574439758014525, -0.16576697081820127, 0.4371610484038609, -0.6786748634481031, -0.8373635912603429, -0.3791084302634096, -0.85994883237759, -0.3745130097110849, 0.7866120451174795, 0.5415552276976962, 0.740520149342028},
    {0.8299920483643667, -0.5211646135984213, -0.4534215546536625, 0.7734590251231233, 0.864043575381915, -0.7008605239572592, -0.46325431919252497, -0.7066669786852123, 0.5682124610255237, -0.3741978879514093, 0.889956500786747, -0.29016059911064757, -0.4078979026929758, -0.9942576537252721, -0.6272020209446552, -0.44025800551549155, -0.47113104963938446, -0.4923096092773128, 0.7764261724800794, -0.6844813274210862, 0.10073846046806309, -0.8025128011186802, -0.33226568258104194, -0.21438099199802269, -0.0704158629469337, -0.4457508872936039, 0.6527529889937523, -0.10154781975378988, -0.7097652095914115, -0.45902150199691477, 0.042675908086695455, -0.5546394587505846, 0.7704991003523478, -0.3073510346580114, 1.02914973753782, -0.2670943369285571, -0.5433689523701917, -0.770139036328332, -0.6164384474504797, 1.0132918263637578, 0.23237633589809156, -0.5065318059300777, 0.6741936687339081, -0.45741016215317226, -0.5307633911279034, -0.4474761340902752, -0.18211679936102654, -0.34388117892226183, 0.467029636369715, 0.7266427222894632, 0.17302987798520586, 0.6488653847183348, 0.8051412949910877, 0.6134932601537885, -0.00433207975422676, 0.7013224712160663, -0.5313346649490746, -0.3412093318985301, -0.17148315608234918, -0.5603753557272038, -0.3895754942643522, 1.0340851904151565, 0.5341046362988668, 0.6678651602570678},
    {0.6977478704090301, -0.2823521863810494, -0.3257508443123923, 0.7943214239393462, 0.7322676088965836, -0.638844684363135, -0.38310951086551315, -0.657259037717055, 0.6594223943958426, -0.5663627417132415, 0.7016026024480616, -0.4638777306704754, -0.4759425974250454, -0.6232004915983081, -0.595103302920965, -0.32501809855863345, -0.40155877662720657, -0.26376839349255227, 0.9626231566975688, -0.7730837251203172, -0.2476360593704552, -0.6769770277099243, -0.503456668889287, -0.1978639649186454, 0.060608541820223585, -0.43397625699479464, 0.6919995453777891, 0.030539625781344264, -0.5775084192530558, -0.37990171612480544, 0.07661634351494614, -0.3786732550096398, 0.7402801356153395, -0.46998797061672043, 0.7921666878738908, -0.7857992561387227, -0.5813604180221634, -0.8987698804148995, -0.5824458133949021, 0.5223964609384049, -0.2783475779643267, -0.6124050030961373, 0.634779263445604, -0.6302844359755374, -0.6747164139974463, -0.3443686176419796, -0.18639251981727598, -0.12017545273916977, 0.08837750953197702, 0.9397350831936966, 0.41419478783979596, 0.7984978522252952, 0.7047969893104461, 0.6983260692717443, -0.21219528285824912, 0.6752922172392365, -0.4093929794546278, -0.7075283172783624, -0.18976048743041302, -0.6027449458276817, -0.21141442236545277, 0.7315524118152938, 0.66284118022747, 0.4977842196972892},
    {0.8565875398392434, -0.2862820248619309, -0.6768040647930773, 0.8510038824727224, 0.8484249302997373, -0.7570772251742884, -0.6244570402897224, -0.48487664418610166, 0.6909000361878401, -0.48345044170711554, 0.49739012373542163, -0.6019868930969134, -0.25344276544202327, -0.6343647190584779, -0.5776059941890462, -0.5526157403699931, -0.6832656861164935, -0.7242954155289761, 0.7629640131424399, -0.7981444788063204, -0.35542984318441867, -0.9802438672454075, -0.7145194975233439, -0.874747589869848, -0.35083663672699983, -0.577670009386322, 0.6516480965620256, 0.04395787317552174, -0.682655644113957, -0.8169941262732228, 0.02854159040157141, -0.37770552177499156, 0.5813566068390194, -0.6169466069798191, 0.7561369966955502, -0.8237581874815032, -0.6497609838115131, -0.6521940690138056, -0.6792337861643786, 0.8331328724784666, 0.050450277750273324, -0.6988675111178914, 0.7096437653014313, -0.5665892231311914, -0.7518123782425322, -0.7047754887844072, -0.13413029092466539, -0.44344848466869585, -0.005850342426237677, 0.5842504494172152, 0.6016484727373609, 0.6958930326437454, 0.821440236979029, 0.8029469184269061, -0.5270150091555492, 0.8148135776850212, -0.6396938951145484, -0.7139996545517264, -0.5228939295798566, -0.9554321471349618, -0.5459455843330036, 0.5147138768496526, 0.7076434271703289, 0.2767011087263433},
    {0.6992172435185925, -0.49347800239925477, -0.774011526911687, 0.7300189768182381, 0.8161102220338653, -0.4131541081534609, -0.8905615662956229, -0.4419493342953843, 0.5746007867881455, -0.3500882008950838, 0.44325179368253675, -0.41123649787719324, -0.1597858821900325, -0.35853647675527356, -0.5226324891002688, -0.5609357606653343, -0.5340616966176468, -0.45808539799110753, 0.7819314196500217, -0.706664437408827, -0.2093964016089805, -0.8297466196534693, -0.6841096512372897, -0.7151601907619443, -0.24635570699213807, -0.5808783316215759, 0.45711624351920344, -0.07370587303838429, -0.7000307811222478, -0.6456198660335628, -0.01409985220599529, -0.5440533985664742, 0.6635207012424877, -0.5320713793372758, 0.8113140888721758, -0.9175148381247581, -0.43596127061681605, -1.067706265459648, -0.7030678363818562, 0.9776779778887769, 0.06408945345216001, -1.0024657728605069, 0.6834344691770973, -0.8465198813970632, -0.5900763173440438, -0.5912625241786625, -0.21473741891189843, -0.5324966987808161, 0.2377556481717707, 0.37200468128572084, 0.5853112644005986, 0.4966685231327209, 0.5584824759456464, 0.390586408759552, -0.3488973290750758, 0.9518490222382768, -0.6317231901671857, -0.612155550333146, -0.35915578559244193, -0.7453348486149856, -0.4730790724803076, 0.5884271530860878, 0.7238318738491399, 0.21829866952386884},
    {0.584672704059041, -0.3667725527660664, -0.31329249660476005, 0.8168750965471011, 0.6721460279446689, -0.579022914278964, -0.41371332325863847, -0.40086581829182427, 0.5043468249926891, -0.5277146224427663, 0.6419755609577767, -0.358553411655247, -0.09407861513086539, -0.5302671906176813, -0.49240828615610566, -0.46692323696895405, -0.6299354753910433, -0.3893285640089458, 0.9356139834997931, -0.4726845700575305, -0.048574937808039155, -0.4656108647740089, -0.6090570927580984, -0.5559363059769113, -0.16769644143225687, -0.46753962737164495, 0.8013141408794583, 0.18425943869037137, -0.7073273205843874, -0.5820091036316606, -0.1253624198555725, -0.42015921539524864, 0.8509822498764485, -0.5903519477745433, 1.0411082221797503, -0.24784316282598004, -0.6969411453442902, -0.7126642918875883, -0.7633982383903286, 0.6679067841376755, 0.2620977415179606, -0.7133998016664604, 0.3413584015604773, -0.4633074670766831, -0.6481069163917333, -0.4461375440404081, -0.17425211931572612, -0.44114676348517684, 0.2390772590265084, 0.19874458290817693, 0.43073970646289284, 0.43817415240974206, 0.7381960390595187, 0.6253566657592162, -0.31097116646473033, 0.6961560500786392, -0.6646087538407192, -0.14152762691223417, -0.2620809241014336, -0.5673419931919905, -0.16260918325362353, 0.710920988709579, 0.719125088806731, 0.48197273624169706},
    {0.8993496491793984, -0.3046568158433604, -0.3008091681219145, 0.4674237547101587, 0.7805543520237078, -0.7402566873557088, -0.44430119761306414, -0.45506495295115845, 0.7282275845759543, -0.5133499961816915, 0.5515579998901058, -0.10404800564485621, -0.1998241650080907, -0.8285082259855595, -0.4221827721894842, -0.2859073250847999, -0.25691561670859614, -0.28193791258928835, 0.9243474324422349, -0.59964615855432, -0.11863833342103781, -0.44028633133973194, -0.40198320039083957, -0.15235685353001227, -0.2824783383619305, -0.5436624939109869, 0.987223290172331, 0.17145650559455428, -0.3851503240585544, -0.5358871457477117, 0.29161908662997116, -0.11916490433121435, 0.8332215574331996, -0.6148354189498274, 1.0218086946000506, -0.368159549713994, -0.5394221104767322, -0.6591487841784557, -0.5672082234771663, 0.812206701621337, 0.17116260091121938, -0.3780402288644455, 0.4453933687116514, -0.5064292895594512, -0.09260449613783653, -0.5629803557168706, -0.12633242985382104, -0.2296446974204531, -0.0527617215758984, 0.6797688193935063, 0.2358313877230707, 0.5752146619458982, 0.5721582301483079, 0.8290177064767769, -0.3778048851020385, 0.8297562073131401, -0.10349793556810265, -0.26243538444064607, -0.3726783608115519, -0.8168499228806144, -0.33880254331234944, 0.9219302818689824, 0.712633689870343, 0.5848180659344406},
    {0.5981285153211571, -0.3810328943193229, -0.41301087414291676, 0.5374843329733897, 0.9217046302900507, -0.7298150618661465, -0.5021713874925959, -0.5896875687561222, 0.6337031357016981, -0.4972711249310154, 0.7664437969087918, -0.1505992759797487, -0.15158980874139705, -0.7296166564044768, -0.42494931856864415, -0.42932882448114673, -0.5084434308983351, -0.7624130364187224, 1.0402440922774854, -0.7483360902806585, 0.051926324535643255, -0.8928804594246453, -0.656097587291426, -0.4246045237956061, 0.033192404151870726, -0.43303349127492363, 0.8302690330584644, -0.054109785692518134, -0.5147117921986519, -0.35833114141035544, 0.16900158793863487, -0.21243875065618864, 0.563635052571482, -0.7345275363346266, 0.6404931178577046, -0.059769371510338384, -0.4868393897506259, -0.5261417909208274, -0.8080345399543482, 0.8732527820540472, 0.12767349516315596, -0.25469549493228544, 0.4882303190894158, -0.903251893743852, -0.5975732027222392, -0.4766558154945628, -0.026643659328239363, -0.4529746460139822, 0.052785626755470196, 0.40601991929846737, 0.41972179852167246, 0.40506313481220024, 0.41724028701419064, 0.5247842505399526, -0.4862508889644211, 0.6277452198084942, -0.4876251368488659, -0.48061381202065095, -0.42566741506689326, -0.6370845313617314, -0.2746487316178234, 0.7390834293373074, 0.6465481597877244, 0.21405216183671816},
    {0.44745153874766513, -0.5363051239801953, -0.6299835089583677, 0.6246808028515082, 0.694450073278246, -0.5530566499207062, -0.7884765477991598, -0.6760067180768073, 0.5818113573882828, -0.5310928940797413, 0.4397878691153485, -0.2777603787856847, -0.12748425178048992, -0.6828023679680069, -0.26434643174742317, -0.42579850566910593, -0.334082378764499, -0.6103996457679544, 1.0754012642760258, -0.7227257910512036, -0.08689319179114922, -0.5435635986783132, -0.45839633790562984, -0.4595175820545912, -0.14474114845854855, -0.509386900992074, 0.5899299558958293, 0.17317784173408393, -0.6850835204852161, -0.5368393074333208, 0.03884259104407954, -0.3060214560615161, 0.5601190667128841, -0.3490680304848911, 1.0703711014191408, -0.5430667669041513, -0.715415230892358, -0.7912757325793615, -0.7209709920641901, 1.0497863927224325, 0.21423136769248255, -0.826185118497735, 0.49085165365282746, -0.5660367847610266, -0.6431312335833512, -0.6557432379869116, 0.21626363410657587, -0.29588344361051916, 0.09838469647423712, 0.4234298750708482, 0.23649477694977533, 0.5759119915580176, 0.6693348937311029, 0.6022346055038978, -0.46626406621220534, 0.7678798325990617, -0.49931384970778436, -0.5380848987564141, -0.4499154295325985, -0.8016332059515947, -0.38086896044193524, 0.6104465904471752, 0.8043846438867364, 0.20807311302102555},
    {0.5784954970578362, -0.370987804174334, -0.4345588174658271, 0.6417466270050691, 0.6292746221311649, -0.699178950615849, -0.7920500129714471, -0.6827509594003044, 0.5447607127530922, -0.2602229738459347, 0.5964870375583738, -0.49412334265501123, -0.24903854095738956, -0.6848024479577552, -0.14119475790318403, -0.6087721171640473, -0.27682735293310945, -0.2316178174804894, 0.8623709205208562, -0.7240668221517979, -0.31578475904492953, -0.8402627081363385, -0.6272202948758876, -0.22588542672385437, -0.32170383177972084, -0.374677252684775, 0.7819042986518976, -0.08098639051917422, -0.5769587785820697, -0.6263597634831154, 0.15813264307876998, -0.16872711205586205, 0.8368460058820326, -0.5931493454038322, 0.7221444602609921, -0.6538699643546508, -0.6882274463152159, -0.7849359896176008, -0.6366468631177066, 0.8135628441565621, 0.3089794618650281, -0.5727819989553807, 1.0549322194889534, -0.5437607489408995, -0.36096447863812037, -0.3927945405535663, -0.020734384946662413, -0.3532093678232875, 0.08510220415434992, 0.7203206549956792, 0.3728956344074747, 0.621286820226717, 0.6258737683187752, 0.8005349610482516, -0.08230367222773546, 0.6750418032554759, -0.6828290633040963, -0.36389382429490663, -0.30684487546145256, -0.4744164049101393, -0.4162546849602246, 0.8113863011897913, 0.9529374734646481, 0.7109606610798722},
    {0.7442755162487826, -0.30845222314814946, -0.5574048406639664, 0.8009944575974581, 0.9286718591093374, -0.6760550806894412, -0.4912092978452581, -0.6552804726381145, 0.5099080155158049, -0.29741583267735927, 0.6280878613663579, -0.16279812746894137, -0.20813142551906838, -0.6206204269436715, -0.21050025331205358, -0.4085912423325639, -0.6387053000018698, -0.47567918570726875, 0.8924989945700091, -0.4319654987784344, -0.288315189618378, -0.8189623181538416, -0.46950901552725477, -0.6910144725297492, 0.054953858119285305, -0.43602899218505226, 0.8717203225784584, 0.33976260121072915, -0.5666503736104591, -0.6293730776147379, 0.16715644835245744, -0.2463940857126083, 0.6594222711921794, -0.4302715917363454, 1.0929423416745625, -0.27553698788262376, -0.657702061006396, -0.626213677420295, -0.6825871106647845, 0.9233091021028493, 0.36291119491667945, -0.5110179411526845, 0.6375018926431583, -0.6428686481330262, -0.6843397607339478, -0.5109934623531559, -0.031244842938376743, -0.22621499322170618, 0.004261132739387291, 0.5244430690181228, 0.5267405615282037, 0.5589553383583189, 0.8850803546902348, 0.8552038542007319, -0.06731193950821086, 0.8179789358934745, -0.369068577367037, -0.28598146593019685, -0.1958156443538902, -0.5077247822087362, -0.2138971190441608, 0.74196282466749, 0.6417504893506047, 0.5735107575295901},
    {0.8161324763754462, -0.3387133266670883, -0.5225323906532559, 0.5890221927150773, 1.0701769583741767, -0.501058962053882, -0.9413754661047299, -0.6046714066581944, 0.6935113709024076, -0.5299744541430604, 0.7669661771636931, -0.3652055478742207, -0.27710400339675884, -0.774993097425438, -0.29631330507813575, -0.40435012438581147, -0.5238858764767058, -0.34428992555233146, 1.01255680845491, -0.7039076294616274, -0.18850533560200847, -0.626075793223183, -0.7824536231680316, -0.4236484919678273, 0.07744725251379986, -0.5934896879372626, 0.855116099532676, 0.011421482102207255, -0.4225895491077248, -0.46879818085233815, 0.1183264676047552, -0.5057491155985198, 0.7637220691035043, -0.4142101798588551, 0.9935598546636116, -0.4438877861145542, -0.6570979993654434, -0.9023069726778762, -0.8227509569161486, 0.9472905490199575, 0.37966801395374633, -0.6128842323026071, 0.4917198180401912, -0.8464391242599294, -0.5038403654684077, -0.5849775624805227, 0.117523485983175, -0.4014418635796348, 0.12758494024829414, 0.3189636911840399, 0.3489827684854876, 0.5815475293198258, 0.7233429360467509, 0.7004057177078524, -0.05040293411259998, 0.7901646983891113, -0.36459617131102384, -0.6206496930814499, -0.3664659885889593, -0.6843784359451454, -0.39310900955184497, 0.764117999768093, 0.7909620835945185, 0.3397783580651894},
    {0.639881266158366, -0.24837936016916434, -0.5997776682972776, 0.9525454479672562, 0.650594943620543, -0.621383265203049, -0.6185266827968885, -0.5690383283076993, 0.7844651043568273, -0.3968730343438823, 0.8026097578227226, -0.22679199771212838, -0.2816007214988468, -0.7617154248865393, -0.24347809047717328, -0.49840405667621707, -0.5507010218532454, -0.2642504807668796, 0.8987563088453174, -0.3764407987218306, -0.29822334466095396, -0.5622957689041891, -0.5212897779298583, -0.3468859910882464, 0.019747902813888277, -0.4267027325182885, 0.9450855923731282, 0.3900390359057705, -0.5791337114549174, -0.40675669167806994, 0.3272178493453421, -0.3280641625092853, 0.83611132499453, -0.4766120989650695, 0.9152819285846688, -0.4006953388093695, -0.3526735511298587, -0.7467826686942829, -0.7233760023782604, 0.8347791639442877, 0.6745781996682381, -0.5775687624353538, 0.35484345942013906, -0.4609465784017029, -0.528371322641613, -0.49456103738223645, -0.0010236933343888896, -0.1522736892036032, 0.06986894710423587, 0.716307103329144, 0.5088671963336692, 0.5894159605857813, 0.6356955027902927, 0.6118963867848912, 0.0067582834794454654, 0.7676401800759931, -0.4635939824735581, -0.5636704020636069, -0.2117888298712991, -0.5449311190344556, -0.4461996092010357, 0.8585584688282608, 0.9446555360271641, 0.27478306006163195},
    {0.7127423997347068, -0.3611591952134078, -0.6029659221414038, 0.8458541618910952, 0.9775407577047088, -0.4101708076470662, -0.4342102605006353, -0.4950654490646994, 0.6022420711238411, -0.3740315220747371, 0.36468765920958013, -0.022053046144132553, -0.37172087508699203, -0.9227537876344142, -0.26883118207303114, -0.37257023948317686, -0.44869076837697325, -0.28418411356014645, 0.8443105632285389, -0.5854929794286744, -0.1535147338940986, -1.046402301719919, -0.6188601350163185, -0.46406892462466215, -0.031992671145399915, -0.43568205815358246, 0.6295281216337258, 0.19988398989501463, -0.5658091446044698, -0.5858489624026048, 0.13265001686575723, -0.5925382491584945, 0.8459133031106122, -0.5625823293481276, 0.8238347925956762, -0.523673675052997, -0.63394600909157, -0.8151835522441256, -0.6840484413983715, 0.7425823889644362, 0.38395596201130333, -0.6139305294271548, 0.6011286121192669, -0.5926477165115199, -0.5307957653224782, -0.675597907915901, 0.12063494321720242, -0.20896748481489316, 0.17820631935178302, 0.5751576461936294, 0.2965300064774933, 0.4857764194589108, 0.778628508402501, 0.832762949082777, -0.3729528544800565, 0.6698091221260591, -0.45404607052994567, -0.5779189118566117, -0.4006406103263038, -0.501288482854179, -0.4579812361001934, 0.7787248443606362, 0.6247819668430035, 0.264454035115407},
    {0.391130333983029, 0.5669512658244755, 0.11869806239228563, 0.41447893060910335, -0.5879849748675676, 0.4675987755644368, 0.6311877736057786, 0.670228828596359, -0.44417958745768527, 0.36611196354886905, 0.24519415012275747, -0.2990589697479502, 0.43794033383418624, 0.48840851008292063, 0.2409949332268193, -0.009558204594979408, 0.6192599154519426, 0.049716835529082314, -0.7240092018321668, 0.3902929236162403, 0.23281354068292034, 0.47166954253576815, 0.3700595314394343, 0.3837964470729996, 0.1348425322022617, 0.16300798150435797, -0.5915720993096824, 0.5380508817400007, 0.3499541122176296, 0.40339547748045573, 0.3069742045434384, 0.4464112759152609, -0.1523268316221199, 0.5198505735921921, -0.5944009903075891, 0.05656630011138755, 0.25527646046213515, 0.5111357995835569, 0.5616071453627145, -0.6065628178958616, -0.5608236576518894, 0.34707664083852924, 0.24943679557321385, 0.5550706362598022, 0.17366257973705548, 0.5134963433107502, 0.03305533154752779, 0.17351025313096755, -0.6406534608773645, 0.5992003218756315, 0.4476791304719975, 0.304524382377872, -0.34959820945285447, -0.3317186010090202, 0.12772960779876424, 0.22874280407845385, 0.15842492355919827, 0.14005342500584755, 0.15229962068147812, 0.2954443186215327, 0.31422912869226755, -0.5254467308919252, 0.08784402333583888, 0.117922882802168},
    {0.04239931203415286, -0.10197218583538244, -0.39518724241084013, 0.010091683738426437, 0.11739336200388477, -0.5143778453936153, -0.3679389420220331, -0.49553788708172675, 0.08038709553512084, -0.2929476309108323, 0.3571352200274003, -0.3738656554413696, -0.3596870984890378, -0.2711141510619836, -0.37004837329697343, 0.02867755460247152, -0.416231533859012, -0.4832719765222581, 0.03491170800235262, -0.4097218926425734, -0.464718280816629, -0.37931412667192066, -0.4030407924313621, -0.2374634836136908, -0.18394293249841356, -0.3072564834778294, -0.08473287402294752, -0.6981947124600459, -0.3622449344022884, -0.23711672054288221, -0.3835742459759971, -0.15219538147385456, 0.44576799445829207, -0.05703130697226753, 0.046415591529662854, -0.15725303040457267, -0.457909507382352, -0.4599805779801489, -0.2378958502358711, 0.42973580880896295, -0.3906598263790031, -0.5283362222374712, -0.3403076624011781, -0.5779236114902044, -0.42903569380152445, -0.30674606387749304, -0.4715733782361377, -0.19729905892299385, -0.6662068411446305, 0.004506582388470338, 0.24376832938675264, -0.4432725944539412, 0.10635319509040485, -0.0468151837051223, -0.49011892119470213, -0.1253634879576182, -0.16358266226548857, -0.10888840788238353, -0.5563867846292188, -0.4749723344003251, 0.15874194826446814, 0.4239323417636784, 0.21356266050246667, -0.12584531928847043},
    {0.2385013445986387, -0.13593305275303086, -0.47146810399849526, 0.19291165388296036, 0.05656990761034792, -0.06787724501041964, 0.2040023886240289, -0.6918476951787396, -0.30250213472897675, -0.27181319906003637, 0.14366541577353314, -0.24726446227316298, -0.6599777849968905, 0.11608883570826244, -0.22741512348281875, -0.2851753572595666, -0.4630846663240862, -0.20986557152730984, 0.06155089328008828, -0.3115251571679274, -0.9033798778192553, -0.3912041022630718, -0.3613651831194368, -0.33439892980437175, -0.5217402188449819, -0.3561849283742583, 0.06390689006666687, -0.6847369604379203, -0.10085445764967138, -0.29710831003858496, -0.5587388802691146, 0.18339925441870314, -0.04391878206723151, -0.22730962010657102, -0.26314583244983186, -0.5248476886706832, -0.2798895496890863, -0.2339930548134894, -0.3578541610806336, -0.24972489387422742, -0.7723393735973886, -0.3104135029039573, 0.3411735793925325, -0.40266268825232443, -0.03958280398444608, -0.18684731190079737, -0.4019353243763229, -0.5157917837136017, -0.28464551219408135, 0.43107639509320766, 0.20097652757471002, -0.1447067045688955, -0.46547819018866116, 0.14562337570660722, -0.1866575144946904, 0.09167022998535512, -0.3903065491135629, -0.25264212243081935, -0.6875764022513028, -0.0836019879073301, -0.16757732135775413, -0.00431341623988043, -0.0806399066543598, 0.41940087129812853},
    {-0.42794620598019006, -0.09707756306440404, -0.36473924076614384, 0.12701605114071207, 0.3572066492063872, -0.21154368865956816, 0.02623259104435838, -0.07290312863614024, -0.16424685343579817, -0.17416782232172395, -0.08176415230952845, -0.4515625602611759, -0.6018491954922303, 0.10119660822185336, -0.49021529087246063, -0.4886047507193418, -0.18526492663491292, -0.15302970221856457, -0.16545925835776043, -0.3597624101649475, -0.48641372516670256, -0.36037441422765465, 0.0038988785522813246, -0.06936441456911129, -0.31390740563473496, -0.2599479007874116, 0.20905464280454583, -0.5053792428889717, -0.39423305873195025, -0.15753811785839697, -0.5228899074005742, 0.07995245607252341, 0.033861862073343116, -0.3862202491757981, 0.035546165803463876, -0.2816694541023944, -0.07892093134276795, -0.1802037120482699, -0.5706122927840392, -0.13282084426262453, -0.38544167520472683, -0.0809205658692706, 0.07859820830206149, -0.3770457807072204, -0.24563588479728177, -0.3096140057911313, -0.4475439793964592, -0.5896533784356057, -0.3410116536796667, 0.17027404041277538, 0.23845283301592726, 0.08396789551064096, -0.0967412409429493, 0.18366470856338213, -0.9584110380636249, -0.0062710364598779315, -0.4122734080374519, -0.24977277402395429, -0.4826806944962268, -0.1022865995250838, -0.2585441181963264, 0.20154066499839204, 0.03723691505989968, 0.242621158271776},
    {0.10000528412618688, 0.21193571482442328, -0.5004642435526169, -0.2796982277315908, 0.3973428518483941, -0.32359463143971245, -0.25841321083143654, -0.5425902455448809, 0.06434538327351318, -0.5145188048335005, 0.24723529991412638, -0.22499304122955155, -0.38751059048494907, 0.023277798866439093, -0.3750569798026845, -0.5186819960057487, -0.15111204648864343, -0.16559181084299282, 0.513986927377312, -0.44787075191313375, -0.37474913047573977, -0.5966383197071352, -0.13855146473698848, -0.46880602208677047, 0.20721755267269015, -0.6983455757235146, 0.3581794630960947, -0.21931151156135173, -0.35206194805402585, -0.466787129469643, -0.2974645378533155, 0.08431090310930145, 0.489985565185526, -0.4827442085501637, 0.0995983796190439, -0.6624583132589157, -0.5671625127350738, -0.22382643386203205, -0.3187666150129544, 0.27805929977435695, -0.08559704305864464, -0.4268789663430596, 0.10186832319047523, -0.41898106362388365, -0.35343094688110605, -0.5218141784303733, -0.49590560889930624, -0.5073962335047518, -0.32342622276817146, 0.10539779336633814, 0.1301694392815966, -0.02444272957634551, 0.5470826980384554, 0.17541510274135869, -0.6892805195301143, -0.03704314101582986, -0.41557529577744234, -0.3004101464961086, -0.23861685384537232, -0.13128756501186906, -0.07306253141373058, 0.35660664586195173, 0.26711028621369687, -0.08266081359409022},
    {-0.04018233095333453, -0.14937116559959723, -0.26864243501382934, -0.03335583182431412, -0.08274220133714616, -0.4253285279524533, -0.20894580882785677, -0.5658819284833704, -0.11506824031091874, -0.303337237080897, 0.016358500479191358, -0.4498709956758485, -0.548454048997379, -0.1446678680502104, -0.596879677150221, -0.5307242927916309, -0.17127940521346371, -0.4843328200849618, -0.018177671728456964, -0.4327932032906139, -0.7088137154938221, -0.4128319920816176, -0.5648043321100461, -0.5271829140049492, -0.3676777964643786, -0.8473090550005659, 0.1620126612261325, -0.35686328476219503, -0.6982804994325109, -0.6356837744127682, -0.48925351159277786, -0.01784594808802353, 0.1857207857738224, -0.4259503673623036, -0.20468353445974802, -0.6508848602002222, -0.7406616082588031, -0.43483321096369043, -0.5578668959983589, -0.4452632858657472, -0.3256470301341663, -0.6336905278729404, 0.032219789106421995, -0.6882690596266282, -0.7318365410851725, -0.6002945122736907, -0.6715151046552028, -0.6430041553164296, -0.6257098744390304, 0.274014846806368, 0.022532023579191218, -0.3622904626336732, -0.09532255004574426, 0.28397528174226316, -0.8260585247312799, -0.47030933105549594, -0.5626015318295312, -0.4224705802150667, -0.4620460293636973, -0.40402559323005527, -0.012673188427516862, -0.011919814877441497, 0.26733140400060224, -0.022656752826581895},
    {0.017016921702435777, 0.14072880986345393, -0.7879892071081753, 0.12203116822762096, -0.07546955281030229, -0.16458431026691545, 0.03422128577353671, -0.5722061171711667, -0.3575471816896398, -0.3891460184086146, -0.049156336474065296, -0.6905710811940879, -0.5517482127590626, -0.01175264045204317, -0.5184132098156844, -0.2638276644728027, -0.433547337751806, -0.5570952741236861, -0.22224865187852286, -0.22015602678543478, -0.7576717097178833, -0.5141538772246528, -0.3760643324588553, -0.461628202962873, -0.21325988520391018, -0.6426424205729933, 0.11049431499258017, -0.1486918587490984, -0.7317068004609124, -0.6171040343002862, -0.5189404169047248, -0.0990077756501131, 0.1078548834264089, -0.4085920184252229, -0.17740607926343432, -0.5179356670435861, -0.5648266377172803, -0.33606834093069987, -0.27282779175413796, -0.13951704491347416, -0.789484292764184, -0.45660843950847735, 0.13302698874578206, -0.5366886896346104, -0.4561293519164863, -0.409441621742368, -0.5924267591511333, -0.80580010535137, -0.6654971900482666, -0.17071343929181554, 0.40385955103700805, -0.12302812294641152, -0.003382647450412541, -0.0869157776459824, -0.541342073818322, -0.13912515646817142, -0.5930919523131261, -0.6985711492900506, -0.5284970520667476, -0.8479040718971496, -0.4276421571792901, -0.10899026627890711, 0.010455369887403736, -0.10128857444271323},
    {-0.3292569525319325, -0.05235089782872114, -0.595504350687841, -0.07143658519680068, 0.14266396651731994, -0.5022995021150067, -0.10158109179860102, -0.22386896465724987, -0.24915572568403938, -0.6191266183550276, 0.12260532165602606, -0.6162212546738853, -0.5320944517009178, -0.24479720754772064, -0.4141246339717078, -0.5970687331537109, -0.37397548697289035, -0.6419778753090769, 0.032646435059430774, -0.5345807619611774, -0.3847376292916873, -0.6274997181455098, -0.33273390210114295, -0.6538519212101798, -0.40134617977848147, -0.7464656047215874, 0.015178715749719017, -0.3188311844816408, -0.6333616549619617, -0.34852377884201874, -0.48490343985306283, 0.17032160364020546, 0.07929021896005639, -0.47283748057490554, -0.3316016187950542, -0.4253018586142485, -0.5717913670953148, -0.4091089514595341, -0.5157205008464596, -0.149723754113452, -0.40800749725783464, -0.2826515881193087, -0.17663665145354396, -0.5170923646860723, -0.3150962413973925, -0.36515450336595173, -0.6104323133593965, -0.320533796600952, -0.36795108747102034, -0.09717062851960546, 0.1795610174161371, -0.16470734069712642, -0.2737514279496391, -0.22011399290629233, -0.779546053745535, -0.12399692346351822, -0.5780920404632944, -0.6442496778633191, -0.5101700722161828, -0.6180895827067416, -0.1406085187596193, 0.13635599313453392, -0.07005194056739726, -0.17391681765820205},
    {0.06654593403095282, -0.31488293851273, -0.4203450041277584, 0.3263137613070373, 0.14535649719041885, -0.3811061216833085, 0.16292649578769564, -0.6495945270100683, -0.15332766975065057, -0.5125626159700901, 0.11945779445127801, -0.5837228355407064, -0.592231960754785, -0.3778461892890526, -0.5531904787473793, -0.5905891278895778, -0.45003355869416506, -0.3945109433652706, 0.15827264961440868, -0.7512058702545144, -0.49506587600777735, -0.690442061639902, -0.2171076630912353, -0.21831604672226013, -0.7052453434462131, -0.7294569965123106, 0.1553046965917212, -0.5993408725083511, -0.553497827232581, -0.5355945835857502, -0.5494685629560352, -0.16976335607479398, 0.33904287325668325, -0.4976277736087448, -0.0531292009275072, -0.3768344778677385, -0.2267534061404847, -0.2728852454768004, -0.489987013758817, -0.07921916330373593, -0.41879063021850516, -0.5123983196365158, 0.039191322822524306, -0.39095252706521133, -0.5866225106269285, -0.5073136983507733, -0.725912414946309, -0.442598606038912, -0.3572568299115581, 0.3203113515909066, 0.20082996844380802, 0.22845119145622447, 0.18754213181762439, 0.06963288250189348, -0.5596429964518576, -0.07744605946091589, -0.40598000769825476, -0.5837080282241444, -0.4633281501593744, -0.5114289945030667, -0.41262371793475927, 0.23781852650411095, 0.08449533778700719, -0.14865744495313948},
    {0.1642228896082078, -0.04603779095437592, -0.6659059537380474, 0.14695564785611834, 0.12073467182905255, -0.2458674290317753, 0.1802373210850727, -0.3233354062834258, -0.1996116442395968, -0.5844441664072205, 0.13087038120715958, -0.6247420670828209, -0.44378598394617047, -0.4053017080949484, -0.556860029786931, -0.644156490015992, -0.26896344025287866, -0.5884429454769149, -0.08187427249743656, -0.7328329028084021, -0.5763373718450167, -0.5308128345618436, -0.4867506005045996, -0.5119071955773664, -0.5727206588606997, -0.8637096284095973, 0.10760550686802851, -0.24471728817233837, -0.7040762289665502, -0.38950592607964096, -0.6621494018219856, -0.16375341198359641, 0.09421223231919487, -0.4207083794916161, -0.04909310461774453, -0.6400768605696784, -0.4263512470436416, -0.5765143820855697, -0.8401586726189334, -0.03274456337012734, -0.5291577325456154, -0.39148896587703297, 0.003396048183534952, -0.5761863330570625, -0.48805159432840195, -0.5997789245697219, -0.7556927251064173, -0.559495450713914, -0.8387427803257657, 0.5022690906330558, 0.46127068013077477, 0.1392275653167751, 0.1639672295440124, -0.1905073440176901, -1.027220999516092, 0.07511473808718987, -0.631369435070221, -0.5815580410393888, -0.6241879084168666, -0.46316704166114536, -0.35697092211867737, 0.11989399781871148, -0.01022817480760883, 0.005052983000170085},
    {-0.0448551242914886, -0.008983277641361899, -0.3478012762287357, -0.1535326156285285, 0.06634615877245831, -0.20936759209465847, 0.19608790727445624, -0.3582280721124447, -0.11102890959985888, -0.31797024893149944, 0.25677686214437717, -0.528050679775028, -0.1710730094517565, -0.1753650159138206, -0.45063412414957366, -0.5506035947468143, -0.13091813256162277, -0.2241761327299682, -0.09567187949447402, -0.2435190077761021, -0.4762149460584524, -0.37956005188575587, -0.3939391656539369, -0.23434434112703958, -0.47622492815510653, -0.3281647880190076, -0.047036194558516306, -0.41899581159261023, -0.2880636379006496, -0.04060455383896373, -0.6862254123588247, -0.05325628298913359, 0.3988086296642914, -0.1608097368221722, -0.39843717456468797, -0.4458125495738287, -0.6616366374949019, 0.047900411732896976, -0.2906257425197449, -0.050343580905530046, -0.30706348709486125, -0.3909638290017373, -0.0729428473776867, -0.259335043732284, -0.08970747379046215, -0.33899966083732275, -0.5063094253476761, -0.44025575395134986, -0.5050742694535567, -0.15347436627781882, 0.4496660001338035, -0.283081423977133, 0.15617577174164182, 0.05097761498403731, -0.5146707065092252, -0.2049192149521579, -0.534433236830542, -0.21936376739701893, -0.7466760810710813, -0.3152033442247219, -0.03223254428221313, -0.1375549069232163, 0.04922116301546562, 0.16051455909342985},
    {0.01431733610205749, -0.4298164059318588, -0.4945103333238413, 0.33646113262629523, -0.19338472605160134, -0.5583173290865813, -0.2708086389560315, -0.4882184103667564, -0.29298017297229023, -0.6735539200035726, -0.05506568588741395, -0.940450197598202, -0.3269283498085974, -0.39929364091290814, -0.6328808144230931, -0.4567377544156206, -0.602873868804069, -0.5480970149560088, -0.1271101399175316, -0.26330538321993746, -0.5138551468230441, -0.7445333420232256, -0.4726540406182873, -0.5579265582992867, -0.42817889771039636, -0.6635624036600464, -0.03442800231690263, -0.301152418278728, -0.49745703356983695, -0.34882848867653016, -0.7092902939657556, -0.11743109483363595, 0.21960959648021305, -0.5195411249169949, -0.4288567030851105, -0.7054859416611691, -0.4229417452564406, -0.246398574859678, -0.48250270206569773, 0.010336949150586815, -0.5891389852473332, -0.4569081610129722, 0.23262214191186695, -0.5318302620282952, -0.5739722756068758, -0.15786916342738655, -0.582232251719851, -0.6223770713590109, -0.7185036129961163, 0.10499816831200129, 0.4106584337604398, 0.1911360413309441, -0.13912282476237828, -0.10971772783755732, -0.5602240869011881, 0.038266301336063686, -0.5414660195581165, -0.30734997549871973, -0.5337014822368572, -0.5447636879786838, -0.16145520346330355, 0.11080526315616014, 0.11111420602863617, 0.13884683603649825},
    {-0.0024878756897519184, -0.33682464589599503, -0.5664057395102017, 0.31492726656033365, 0.05426844829801185, -0.3829832126693668, -0.2502160443477036, -0.5964351989426647, -0.06954056871816322, -0.6233530031348818, 0.029569831873259997, -0.5299712125612958, -0.463250480268724, -0.17447912355339137, -0.42942657488998986, -0.5128381962975185, -0.28130309523472224, -0.5880090625308161, -0.0026357291876631913, -0.5706978009342785, -0.7184394279340185, -0.5022932831149879, -0.6917456136071486, -0.6906675923533176, -0.18732488013660525, -0.6835075426794275, 0.019856730038476166, -0.19320283524237986, -0.4471640999413077, -0.3703713008101141, -0.7113829110824018, -0.19692170075080334, 0.32065757852691046, -0.6422291997987748, 0.11733611474407513, -0.644679325634373, -0.4162956810086907, -0.30040821413414287, -0.8932511942943885, -0.2980897884942919, -0.6110562036523747, -0.6817973415286798, 0.1336840795652674, -0.6757194519558712, -0.5989314094560001, -0.48681016268290084, -0.5140081672390571, -0.5748591029979193, -0.5889611095839907, -0.13513133414386175, 0.2654600341346201, 0.03885788231839164, 0.0303947198899692, -0.059490880583876575, -0.4140927242054225, 0.12338132090885735, -0.2930989751295617, -0.3919072783530215, -0.5643886144164479, -0.43319676964065257, -0.41671897192308843, 0.10726422819114388, 0.052673448902805294, 0.2900482974748663},
    {-0.020384463403854015, -0.3708557029022966, -0.6016448629997349, -0.11522888040351877, -0.03473158311362697, -0.4981420013001579, -0.08859359372369978, -0.8839752970374803, -0.4519885495801148, -0.4381085866585357, -0.1125749456520057, -0.42847271081674854, -0.6762276305341306, -0.00705694406252346, -0.7421660693660591, -0.6917280979723648, -0.49930497618632574, -0.49273784003252996, -0.2168413862865973, -0.6392287391707937, -0.4217538997496676, -0.6318109991369771, -0.3997480987849401, -0.4320359507102626, -0.6939045054445668, -0.652808958517899, 0.19639030187148934, -0.6643675571227822, -0.7093677649401535, -0.37204123319571847, -0.7161877064229325, 0.03512489343274649, 0.09469494813695727, -0.7464245889873732, -0.24877113718227198, -0.6873761890354778, -0.596442676198048, -0.9382714530848495, -0.7287259168118172, -0.09486748850247506, -0.5527831269626052, -0.48866929103484974, 0.14684993057214946, -0.682269540863604, -0.6302761731919074, -0.6088252830521325, -0.7802253022364574, -0.6082980610268955, -0.444664900047585, 0.229747483495999, 0.23023239463727146, -0.21516069535701934, 0.21199372482459755, 0.0026819326877064744, -0.6591089251649921, -0.21202248915030253, -0.3311380418007462, -0.6097784857525078, -0.5965323811473472, -0.6044627020427468, -0.1881448963705993, 0.11165161127897212, 0.0490949940471015, -0.035297914781411636},
    {0.18210151822899373, -0.44511133471378656, -0.33024973045769057, -0.25975404856486795, -0.12164658919727254, -0.42245564473343006, -0.04990868457853606, -0.6198484104032347, -0.39117984356553254, -0.71534968651167, -0.04825043372281059, -0.6990782049884632, -0.5031161701813144, -0.34680691730801444, -0.793551177759155, -0.7324986629718574, -0.16084251640157768, -0.5091075270346539, -0.08850423649428697, -0.584180194294131, -0.6589174415010394, -0.6661403967287095, -0.32072457095532836, -0.8385881239035016, -0.6019743162931845, -0.6316335922758691, 0.18659450005679015, -0.47342672111643475, -0.42559441827553635, -0.37647405608624185, -0.794315763420593, 0.05468929235550875, -0.24613831188759508, -0.7145252267303563, -0.35512587540415114, -0.664059022570036, -0.6145707264464497, -0.45919775196839313, -0.7987475106625184, -0.38882292821035874, -0.6155375272928171, -0.5951798348452908, -0.06551382610688598, -0.4828555276149265, -0.6215304293104712, -0.5917697274582026, -0.9032325516994387, -0.635662887248389, -0.5269105834803752, -0.1051614053167093, -0.1456812817343353, -0.14043077990781583, 0.05345326627951372, 0.004137255985253553, -0.4930009275600534, -0.28763185044869244, -0.7291822362844992, -0.6950505077057252, -0.6793406478396549, -0.3838111446286377, -0.5465466708200227, -0.1709451814485474, -0.1423607152080989, -0.12903659792284675},
    {0.20166675221592412, -0.48420808946973887, -0.2441886203066481, -0.12544498546144828, -0.2738319580666266, -0.2858305817421073, 0.01350823059608439, -0.5491671991036351, -0.4401314662211889, -0.7381630273313824, -0.08468723266921165, -0.6298535044953285, -0.4234902418748742, -0.07622915826500301, -0.7408759781418931, -0.5838620944877048, -0.2921862872455206, -0.6042924752694386, -0.32244647456889014, -0.414611552739099, -0.8524604934954488, -0.37730233516558365, -0.6228145915732176, -0.6286269365688177, -0.7310657311371977, -0.7235074345684551, -0.20694773260970697, -0.5727649878467933, -0.46358384096889443, -0.26562372672579043, -0.7793667849702711, 0.0415701050301158, -0.09906591530622297, -0.5495805833837365, -0.33965362141468497, -0.578715706574846, -0.5318903631419241, -0.25365313753091884, -0.7504717719445151, -0.2755979893126262, -0.9215269312549332, -0.6340890992240719, -0.15544859213853315, -0.4690594581960861, -0.7335150569439591, -0.4820210943413969, -0.6596077082041945, -0.6623949564376292, -0.7096607746203518, 0.08658242990899108, 0.16102941177648186, -0.22212919836195666, -0.38003589688720063, -0.1590040938179143, -0.40218378180593584, -0.0921752884071006, -0.5437220302811677, -0.4416504179251916, -0.5516976927681416, -0.6163611211527649, -0.38541789880334715, -0.13087822100052937, -0.17453251277330534, -0.2045161618803845},
    {-0.26939795404880573, -0.0307748768795661, -0.29719403847559583, 0.019864514916751987, -0.318428659027922, -0.323177467239491, -0.26203599356196156, -0.796836045508714, -0.2235601223213415, -0.6524003611884058, 0.2590462271945927, -0.7759605959972196, -0.40544837153912644, -0.569262320674693, -0.6611267856751687, -0.3067469933110573, -0.345202504334727, -0.39237806767721983, 0.06452992167367046, -0.40716336112042256, -0.46320398638353877, -0.3701591047051278, -0.5906450327257808, -0.4512300941274166, -0.8411689827517809, -0.8247491838788407, 0.19121286509572996, -0.5441981009101339, -0.8279706423510101, -0.38800051069752295, -0.7116482199083981, -0.27319297518993507, -0.056014783356015924, -0.5727378679570515, 0.06146799148890389, -0.45567887645514416, -0.4931383484715004, -0.3534997847042385, -0.5249531008019275, -0.16322715447903038, -0.7007048498659088, -0.48912756948753017, -0.13592053888617392, -0.49171959449615765, -0.6817029758125378, -0.6022944282918773, -0.5290889140312156, -0.6740643814012923, -0.5139678519072585, 0.02877501907063787, -0.009163521230093612, -0.27133263939730345, -0.2148064209964979, -0.12158093584461965, -0.7688256167010339, 0.17659094234485367, -0.5444535471920577, -0.5193177184168857, -0.4444250897268739, -0.3633589173342057, -0.5078629322664056, -0.23168685402845673, 0.12550444350677736, -0.17558749524584097},
    {-0.26682206662676416, -0.09586278137305855, -0.3306389943594798, -0.14624260926978833, -0.09370770322903207, -0.05689233281863737, -0.15694581711840636, -0.7298104603083891, -0.22807354226294205, -0.24298228189719626, 0.02502862516603875, -0.5097985107287308, -0.8529617096110642, -0.15873332787452926, -0.7068943796497991, -0.2663702584073571, -0.30566119173572937, -0.63683673969938, 0.1467989294421521, -0.46892043592540267, -0.5840952384725069, -0.6141016660315907, -0.2873482610190391, -0.05846554583899197, -0.5239764621148694, -0.31098281444524734, 0.2399364385308054, -0.24531498768731097, -0.4322474595760706, -0.22854516712707185, -0.6651580344305777, 0.1486252648414802, -0.05979208026219196, -0.35052436403795323, -0.06885989655776235, -0.4859082416274946, -0.4599952748668385, -0.21806217146944826, -0.5827154913727602, -0.03727379292604965, -0.8476132243673175, -0.46994467704087894, -0.10674859930806747, -0.32940299945179813, -0.5530189785647623, -0.25407305496491744, -0.7328604127962434, -0.36626608784417963, -0.403432993067185, 0.08412584829268874, 0.4066022490991399, -0.2791218861981958, -0.37855549567085467, -0.09615703149634983, -0.21098156034137713, 0.0941400276346961, -0.2203387562321652, -0.3245876342967075, -0.6014239211578993, -0.3761489128119385, -0.31659618214260427, 0.06776230340248397, -0.12793516094966623, 0.05153944608877207},
    {-0.42955406573336347, -0.24331370840372676, -0.20478748705533883, -0.2321275949052162, 0.08663859078528267, -0.09680548211815423, 0.02000163546534066, -0.5258056824693865, -0.5081819917226146, -0.21496121567170956, 0.2337405578434402, -0.7174630269932225, -0.5518563792804012, -0.05261188227604916, -0.46960118328688055, -0.4389708035494637, 0.04608801498706146, -0.16189716383187802, 0.03402128967811732, -0.19851597434289162, -0.6593865808892573, -0.26070082614857626, -0.22905703307766478, -0.35093998198785803, -0.3936676939737586, -0.4406957999610205, -0.2052505737754598, -0.4915001022958527, -0.40794866872466207, -0.4693872601600104, -0.7653194836549582, -0.02763228118964742, -0.06378091174798385, -0.458575944302285, -0.15995973249540651, -0.394047495278142, -0.40321611219785486, -0.4076102835625691, -0.3395297154361729, -0.16719931935547083, -0.40543767635413214, -0.33127589398203194, -0.20894886762020376, -0.2962339864675119, -0.6568337656164585, -0.24860530992189822, -0.7136484084038209, -0.46287393985938435, -0.24402327014872355, -0.023210119654627825, 0.19302585796969837, -0.15801235677295633, -0.23737209077735197, -0.06453877238970195, -0.685984331773623, 0.2163095217287466, -0.2782782469368004, -0.22838702100378008, -0.3699983334627624, -0.49589476454518294, -0.3115904883129788, -0.21730506864692367, -0.09696429163716955, -0.2796195744471488},
    {0.017629897456670564, -0.33085558227494294, -0.4977618557802904, -0.06195647621823094, -0.06532347324787853, -0.23352136567641318, -0.29110873785018, -0.6450468493021518, -0.23305444667336897, -0.6565403382204849, 0.1494790778048084, -0.8677704779118547, -0.9164469285109463, 0.12302161643744532, -0.7547243326174945, -0.48366923321031075, -0.5803917796713673, -0.7803524302680667, -0.3254242651186951, -0.5118676647656171, -0.7920597892528839, -0.5019652764239975, -0.522423821911018, -0.6171273735495025, -0.7719274573877228, -0.6945498932414828, -0.35324930793620457, -0.5440345712617078, -0.2791936463256907, -0.7708324886425978, -0.49708098565150827, 0.07030381768786513, 0.15378779787695954, -0.5572200437775546, -0.4720038882663871, -0.6106814471602326, -0.5672601209568785, -0.28773083627094803, -0.41685581319429127, -0.5119236051229338, -0.7336647349592301, -0.7317681302927592, 0.05657390414951148, -0.3821697171879991, -0.7932745230493047, -0.5403550901141523, -0.8244218437819754, -0.6551317461364325, -0.7149307590891867, -0.008334999392983376, 0.3462065341916084, -0.17636599057363198, -0.08115411607089894, -0.09395242755334873, -0.8590987246820844, 0.004197269792565303, -0.7486589511846181, -0.5084084090292544, -0.698169362313897, -0.5376857923722748, -0.470216287947455, 0.07767560773247831, 0.05040439387320957, -0.03839949097652809},
    {0.06142086251506308, -0.16066045942644952, -0.5017353078005348, 0.1052820369897101, 0.1769096032168683, -0.20257429980474864, -0.19559471249325025, -0.642675870076149, 0.08890014826749522, -0.8444906360399871, 0.17274408991040985, -0.7219133503678281, -0.4962260842422409, -0.33694861125944625, -0.5651387041391449, -0.6362066562975667, -0.4131382510569182, -0.8304508528620633, 0.2320336130283848, -0.5207042479882453, -0.6493851243682952, -0.7367587030623849, -0.4209648545282729, -0.7262176404094035, -0.5343652181322167, -0.7140143608144559, 0.25821851852706634, -0.4538823110289745, -0.4420043683010552, -0.7068423573091174, -0.6342671787711849, -0.04667004464994437, 0.2899422125901164, -0.6451414073214874, 0.1247093796138927, -0.5886281398188864, -0.7819812979775995, -0.4552809277960696, -0.5469628375764414, 0.05785198620726724, -0.2079150117780903, -0.8296182307873042, 0.4111025954811796, -0.5404899995489411, -0.7320512189013938, -0.46962110451182076, -0.3483114505671222, -0.7006589448645829, -0.6758765330409626, 0.09569241030782057, 0.31920282609539075, 0.16119133044425885, 0.22092942498442164, 0.1965890166515329, -0.6361816194771142, 0.3714698497674397, -0.720439157286217, -0.5303041858445041, -0.7146385609642496, -0.6643439795298683, -0.30400905543985285, 0.22127348042486814, 0.3080328001586144, 0.29541627735374265},
    {0.5505620242909823, -0.26166764420055033, -0.3374236639998396, 0.09038175845530047, 0.4016557242081646, -0.2063663331511928, -0.4817337883567176, -0.7654474687922306, 0.007502980416482283, -0.45178386472576215, 0.18889665463088565, -0.506949240423839, -0.49306934518366186, -0.12615286282580157, -0.4885532383134371, -0.2397683869189591, -0.006882958376208108, -0.48699121363110925, 0.1168196553145087, -0.6020763493042357, -0.613196403586599, -0.6119243312533068, -0.5479989699403522, -0.5212081129988481, -0.5015980634526667, -0.7212269771539044, 0.14382393552303932, -0.3955062556726864, -0.580561282371959, -0.7291800357922757, -0.6645182879636315, -0.03384910678100352, 0.10114240936666972, -0.7419162943411801, 0.10399237130561523, -0.26857389866165615, -0.6792742096305672, -0.47348352503181723, -0.4253214066329642, 0.004808328377169524, -0.6112058497256586, -0.700481786607561, 0.17449046976069282, -0.3622627996097112, -0.5794121093841839, -0.7210882576778602, -0.6551451891221444, -0.26972586844738666, -0.7713853020217177, 0.12467807344689241, 0.40758061385383204, -0.042661631743949206, 0.1706675303703656, 0.18557173652530126, -0.5444649292525644, 0.11480371884352028, -0.34335768668183625, -0.6397051730701462, -0.850379534164377, -0.5164429458775106, -0.16107450316628202, 0.25462202449858695, -0.04346438045681472, -0.2864614796661238},
    {0.2900866027530624, -0.07919013116349675, -0.46825767555208, -0.08230942003090232, -0.14128576302484996, 0.08455463979945274, 0.034228385186298324, -0.28100208601640464, -0.3237802436020504, -0.47158613725232096, 0.11477575791200588, -0.6365045306270898, -0.7382934341116615, 0.2810434640220963, -0.6767059369580147, -0.5531315849637287, 0.1926052076885906, -0.6621175003054297, -0.12170348726334662, -0.1639843078439872, -0.7237105178312583, -0.5301115178593894, -0.24970901821484273, -0.6987949446950587, -0.5802608586386669, -0.5915339038675861, -0.21348741143715694, -0.7256455337987493, -0.6225574413225731, -0.45155249189838853, -0.6547418980254738, 0.29335459072845066, -0.22393086652032684, -0.3247159073819931, -0.3701717786544073, -0.44347286624281546, -0.2753641243864209, -0.1768747076030685, -0.6218899109744072, -0.2614338772686764, -0.7088763417254995, -0.41595458136205843, 0.2012175350213319, -0.34933859906231257, -0.4868660261062924, -0.2700793248574631, -0.43054561167392724, -0.38161786093241207, -0.7433259641252794, 0.4137592612531589, 0.504747442132044, -0.1341167221675256, -0.3580915285092046, 0.0031178914616311086, -0.4017486872152045, -0.010343604574126529, -0.3520834799826224, -0.22432376697667022, -0.3976810960036313, -0.2817395083114641, 0.07273762047199948, -0.3581199343172606, -0.16344355389443194, 0.08708005631208268},
    {0.39234981674292724, 0.0302848523157184, -0.41659075039118665, -0.047358897326695445, 0.02883736687784348, -0.35290212083793565, -0.2402871287471481, -0.7208249722497185, -0.5198370101659994, -0.9250513090411716, 0.1940905039593593, -0.6538916859929048, -0.5833235158005272, 0.10073128845331338, -0.7671051173266183, -0.7364625479876722, -0.2499722864014126, -0.7021907181434485, -0.18741605657493376, -0.37510794944692, -1.2680980952296461, -0.4300948024036783, -0.5870971775791113, -0.6069065671605317, -0.7280378976862898, -0.5470890957323682, -0.3320761871866593, -0.3596372662476609, -0.5052389276923976, -0.5674264051847455, -0.7633627017146407, 0.05843866875023122, -0.07411483146678731, -0.7697216405683829, -0.3708900695385357, -0.7857570669400955, -0.44146242473330843, -0.28772028347316303, -0.4913580874351802, -0.521137920407778, -0.6700378026684259, -0.34738027327806525, 0.3706392683561039, -0.34837009588816953, -0.6340697496405386, -0.5632921340420438, -0.9757911964606941, -0.5692388279625299, -0.6853760966077486, 0.41787038418307176, 0.36886064112511413, -0.12706885096942544, -0.04971131755704142, -0.024709266788514938, -0.517543652502326, 0.13578070405332612, -0.257084819826899, -0.3070279210075158, -0.6590085090392878, -0.315291275034643, -0.2278499617622848, 0.011223639438144334, -0.04989425885083839, -0.034585417367536744},
    {-0.11849476346944561, -0.16287036569827118, -0.7079550217315126, 0.05530244221259756, -0.17704387049941203, -0.2211382917003248, -0.17112344979886143, -0.9707656800155595, -0.3946395970699332, -0.519514191511598, 0.16348974248628476, -0.518226859306052, -0.5895038415321808, -0.1569831248827007, -0.48708130446802433, -0.6233446455967883, -0.16468393803004305, -0.6217796664426021, -0.17972595235187436, -0.38721220117289473, -0.8907364172721507, -0.5680556041325765, -0.444275604684533, -0.5101858792771875, -0.6707126382934596, -0.716926595265475, -0.3012642761710749, -0.4946203748834246, -0.4030009540464179, -0.709624534134323, -0.5234666907959984, -0.16849365916802406, -0.013467997420203907, -0.5842830472801733, -0.029097496337322195, -0.6085142821674069, -0.8652440680023177, -0.5437415174543856, -0.8049066920833259, -0.44020789898194473, -0.5882815743709611, -0.6439950605822242, 0.32848718975275293, -0.5452651924108641, -0.6713305743471012, -0.5313485677859924, -0.7459168047381741, -0.5343084325965156, -0.5101657696805526, 0.16666184818978236, 0.21912308817784268, -0.18566689757326316, -0.02120535759093668, -0.06422881888430267, -0.7787511604385056, -0.0008185895900985145, -0.512964771087759, -0.48298518009872665, -0.7214409361776228, -0.5474482655335544, -0.58189445060708, -0.1903320818165227, 0.10175733338118, -0.0001533964294583682},
    {0.22518986190656995, -0.06118784708767899, -0.25893081802124424, 0.15491571200616122, -0.31752339927356943, -0.018670869640382892, 0.10002366692748177, -0.6760066987894287, -0.6728829558567355, -0.33478956359464807, 0.245226981857213, -0.9928557884198825, -1.0196227996002671, 0.3529141313488822, -0.5513545747088622, -0.4667143496986025, 0.15909200833478637, -0.6776102590749649, -0.2583498236714669, -0.3268201980666422, -0.8778976096666459, -0.12923003709285777, -0.13644829582917006, -0.30513762072050765, -0.5551387999460264, -0.5672442954850122, -0.4433501200658311, -0.2638645131515301, -0.31618290135347615, -0.2992182425211412, -1.0944121973562526, 0.27981518083613427, -0.6279817997427196, -0.24766024509722084, -0.27087150781193214, -0.6386048847808123, -0.12082024217490578, -0.09396651282809176, -0.5774026186041129, -0.5071783388821893, -0.6889058918255746, -0.44624824402554797, 0.21183475371014696, -0.330301064452043, -0.2043906724065158, -0.4659131531794056, -0.717052719044142, -0.6877809091996783, -0.6149392212641344, 0.225658804599861, 0.6197078022178018, 0.07684107305756599, -0.315513498756741, 0.040782870635153054, -0.25460920337887105, -0.035495392122964334, -0.2693314332271021, -0.27739279600022965, -0.6663429350397587, -0.156386394773223, -0.42523890381551416, -0.4058591325724968, -0.23479602194452653, 0.15791081058244075},
    {0.21320766217818662, -0.018558892672079726, -0.1920819968290677, 0.1061077514416056, -0.2291864930548226, -0.1496367905247268, 0.19433924168703054, -0.43983542006749715, -0.27802529526374953, -0.46626185453964264, 0.22814472899836286, -0.8172627129143835, -0.9807140210447635, -0.09491716863621141, -0.4538865751734803, -0.5937314796867296, 0.04455805986326186, -0.6609499554984439, -0.22825430549509626, -0.27075490549017633, -0.9581938992935642, -0.5829853371208823, -0.4222722625788651, -0.5492186640679145, -0.5805771683203582, -0.5622866958229432, -0.3191112952888839, -0.3285825390451306, -0.35386875692672215, -0.27775749830914565, -0.6042348490009021, 0.16295428000049214, -0.10003255257965321, -0.7464769884683958, -0.18910687154099518, -0.6793306643611264, -0.7599730912388775, -0.37201085319799937, -0.49109538954561927, -0.47899906705323014, -0.6731841143541389, -0.41107281029868087, 0.3152827521921543, -0.36837711006434753, -0.46347538927594517, -0.34596260809244783, -0.757731396086003, -0.3693438725948071, -0.9209950693998545, 0.1637532604550619, 0.42225151766768476, -0.1636148773518316, -0.12387783263704066, 0.007424853678686702, -0.10228850501746509, 0.37864933632758113, -0.21264793534429793, -0.2823821346585803, -0.5881636030474429, 0.024696062072960236, -0.5382145530967655, -0.3984506254263055, -0.010081352065296518, 0.3247709572788264},
    {0.26143777548757385, -0.37030837777846104, -0.37376948212781685, -0.14447563033347924, -0.14813214656449672, -0.4181863275189026, -0.43754534572121373, -0.7462843145654847, -0.5912063457586054, -0.34612690610150215, 0.08736058237065082, -0.6473561875415612, -0.7099492423805852, -0.1083332921904983, -0.4539042537678473, -0.5899933649803678, -0.1399530614301248, -0.6378422622112068, 0.002810521485339605, -0.0052938432450873344, -1.0979743411097276, -0.5232825375131054, -0.5067772892024289, -0.5323647165970524, -0.6585360226552323, -0.7052364588876432, -0.17785271823233345, -0.5489452305125057, -0.6006716588640263, -0.7644459403134081, -0.6165454620389779, 0.11393741040002317, -0.1695031124004993, -0.9154454058632943, -0.4700783188445494, -0.40902195968202726, -0.47906716223157386, -0.3951694373382022, -0.42661638983466754, -0.5819456586797302, -0.8925324594025834, -0.24418477221545568, 0.03463626684781674, -0.7485753382580771, -0.6637486311486233, -0.4123535226743123, -0.8134114223720368, -0.6962130444232687, -0.7846862933893596, 0.4191169999213643, 0.6083200531127393, -0.22355541987413985, -0.1019293202142028, -0.21898344944763676, -0.4567545765636107, 0.2695108901888362, -0.3622253456253509, -0.13220738583890213, -0.8831248199466813, -0.2137910619103601, -0.1295429582227057, -0.47056952230862503, 0.0945184151117959, -0.07362983902364956},
    {0.2508484385128757, 0.036303541696671854, -0.2871790483139002, 0.024463054920518142, -0.18584392321246473, -0.0338267420663759, -0.16351227134052695, -0.5597236595308581, -0.27365121457051617, -0.35640922530884267, 0.23882171594103774, -0.6163410834740078, -0.8394341335426083, -0.24478741741305707, -0.4622939415992697, -0.5906412807394815, -0.13569372521730094, -0.8166887131912356, -0.2222220570213462, -0.17749206593785638, -1.0270971034824687, -0.5605945055769799, -0.42832846905000604, -0.4144932690331975, -0.826593377654051, -0.8454096486943283, -0.27181373759361477, -0.6951581866473693, -0.4854323217112158, -0.3536058083983097, -0.7650999643697127, 0.1791715651267895, -0.07612766005660601, -0.6349477533006024, -0.3128145984649862, -0.4179853612320329, -0.39678076184406186, -0.18717145223161125, -0.5331303519051984, -0.4212857318178265, -0.6348803638915855, -0.5539536740442922, -0.09103689009831525, -0.14443468078938337, -0.5234185112576002, -0.3312458982356165, -0.6318962829593354, -0.5614060813337072, -0.6007935677276721, 0.18083714109202867, 0.5986586368440105, -0.06847284769670828, -0.30406145058262973, -0.14306209453342442, -0.6264096824720218, -0.18831430920418457, -0.4656144631041692, -0.2523040865400602, -0.49850890146813637, -0.3199840453733156, -0.384846158272487, -0.2447231580668046, -0.09414898538460428, 0.15222655928644088},
    {0.5528492093003081, -0.22324381972850874, -0.12261350469709086, 0.29432093244456253, -0.19418481879907545, 0.04497154985560558, -0.3958978754398649, -0.5355744148478462, -0.2673600288171648, -0.22695899998850982, 0.0653158324859012, -1.0091825042677067, -0.947548132350651, -0.29277747189396053, -0.3298959376550058, -0.41724653201936135, -0.2364890534260834, -0.6311392043364451, -0.4362010759571717, -0.252320694312999, -0.7200548904978296, -0.554265656867282, -0.3711637556608928, -0.8446885276124667, -0.7919982461036154, -0.7264485205156367, -0.1223817381938178, -0.5072902291084491, -0.6460741338451491, -0.5201215352703533, -0.6551800202632242, 0.033974556435753187, -0.25094823937522626, -0.6052827429386525, -0.24088960252228062, -0.43290158391568, -0.3608817366908091, -0.5408545408164517, -0.21067727338152356, -0.6160725845115489, -0.7168829455874101, -0.45140626378530624, 0.24001236826418032, -0.30628347709369325, -0.2693661039922407, -0.6453827475033287, -0.6863509721998721, -0.5933282321137586, -0.729337372786803, 0.35392851144860554, 0.43849038911029925, -0.3271102821075355, -0.4310563530366377, -0.11611467771481027, -0.5127275934283289, -0.14436294982124317, -0.5996302313523943, -0.1929346594312356, -0.9293087714908408, -0.36963442266400354, -0.500257518134247, -0.45679848024293057, 0.0065915156670758885, 0.1967808678989643},
    {-0.06669722341539239, -0.56958085060316, 0.12595328380649262, 0.4312235677823283, -0.5171117958970712, -0.0934372674224468, -0.104307918948879, -0.12816088403922354, -0.13466746443319097, 0.18417922391634514, -0.22445859324341097, -0.4591602954707398, 0.2138988820142475, 0.021156421680164943, 0.3743487044899053, 0.5638291831170356, -0.0023666140856401004, -0.6898364974652409, -0.12587115972406335, 0.4090181012339701, 0.20465307815298384, -0.11169407004331959, -0.24243970302645265, 0.31751778801049324, -0.44316034728375625, 0.20327830834531127, -0.1501393694046314, -0.3874504262701183, 0.14879149692738025, 0.31946309321288135, 0.5113098031967942, -0.4282634664069686, -0.35352382136569677, 0.4397032058437582, -0.05313704502358051, 0.2372656531075596, 0.2618315574172741, 0.11716452015015831, -0.37596184134454425, 0.1340147104036685, 0.1627791239133082, -0.062322532633309904, -0.14349081511776282, 0.3248828123264811, -0.34753291268835185, 0.18587640991991358, 0.09233568530511674, -0.4092132209197035, 0.20435914771954808, -0.06283276172332582, 0.4995478150410387, 0.7084839482463201, -0.0807605435543903, -0.4598172346660985, 0.1453262203555348, 0.12671798533017617, 0.3132603523351704, 0.28667887097930334, -0.2816253028041278, -0.2845715852935108, -0.05343014463971981, 0.027837482887735247, -0.038465454104745715, -0.5756042981952689},
    {-0.045784458912080994, -0.36495063053063653, 0.19713052627558747, 0.4218896700570428, -0.5880954374871952, 0.7107819779439623, -0.44896521748806467, -0.11179332191620123, 0.03719062891590806, 0.5870195241884423, -0.11563997676654705, -0.18613634093969567, 0.10502537864287036, 0.014841966007411321, 0.32737176746257934, 0.8408330920128512, -0.18161236580228127, -0.2915235358264414, 0.029258771264075143, 0.10240994294077857, -0.10317742847392601, 0.01390755663195073, -0.3774022517118731, 0.6595249439685367, -0.6403491051664002, 0.5147984249359943, -0.651325629041948, -0.47204832763413024, 0.1286412976848663, 0.4918741898264667, 0.3900004147232387, -0.5464194439089795, -0.202510139723032, 0.6525348187879437, -0.03111035394000694, 0.6312904208065184, 0.480968258612722, -0.07318859678734554, -0.33692441546334007, 0.10975944499831047, 0.2863522485987969, 0.17212143877101554, 0.09926273945530256, 0.40553418562965, -0.05219099419461743, 0.30218463358444037, 0.2464406473558196, 0.07021603772851952, 0.2240072922857385, 0.16160385264017454, 0.4745426819448495, 0.5937356470893762, -0.06010874209194191, -0.32832000096027975, 0.4470328407485506, 0.507380772098379, 0.8217032557131433, 0.4646537548635946, -0.16473992520588268, -0.0834012111240837, -0.2333403938588157, 0.05648694833234687, -0.2621459257386164, -0.3320341201845457},
    {-0.1579478063572359, -0.3228918897519628, 0.36058539358981473, 0.03930711292449071, -0.7217810144186315, 0.4369082141629745, -0.5583194735362627, -0.12649256917601193, -0.16582849992615295, 0.19892603857672736, -0.37103433237558414, -0.5579651912350945, -0.16158654490629734, -0.30289770092734797, 0.7022833281658417, 0.7333359214792096, -0.3959775826219784, -0.37125949131611163, 0.010825739693725347, 0.25538280885119163, 0.04689677690156783, 0.14443875572686093, -0.5664413292405609, 0.7649572266222471, -0.7074186430669814, 0.07215671612522671, -0.5630779439152025, -0.6579705506425084, 0.10710029861701664, 0.06827384871121815, 0.4788929600433412, -0.43321178468290705, -0.08317095590908173, 0.38440258414948797, 0.14260983896251228, 0.5298927452917283, 0.44869844369276496, 0.06518927004393411, -0.022803105370646393, -0.1681732559282251, -0.05572285897679176, -0.1810319451167223, -0.3347793055211941, 0.3753293687661626, -0.029237490512706712, 0.29174059453393036, 0.3769019035100955, -0.3865681372884253, -0.05723945837462254, -0.3826813308142628, 0.6890722092919899, 0.7013955390324249, -0.49817805302903, -0.4595621187568446, 0.5888985537820695, 0.545420895849808, 0.535284292054217, 0.37593879201309016, -0.43294140459165, -0.09854157668262666, -0.2999354840517421, 0.1645680241150673, -0.38043127978911045, -0.45803769830371144},
    {0.29311306162578843, -0.7015853149899054, 0.6147721121436579, 0.013043810755741795, -0.6915356615217022, 0.36788810443774583, -0.48674558779204974, 0.007875080929305412, 0.2298663840600026, 0.4333960889342032, -0.5936245291524753, -0.1736715163334611, -0.253303259322393, -0.2881457365571599, 0.2814995429918388, 0.5830108090336631, -0.5874172470200392, -0.6436813022030029, 0.14116726481098066, 0.4000432927702293, -0.002801892675343635, 0.17764098097140316, -0.475129704265089, 0.5016758404545577, -0.7367688751964443, 0.39087089656718427, -0.24823595521861724, -0.4987675773296628, 0.20564146252214086, 0.5099448716989162, 0.6535502288636698, -0.5841284511383095, -0.3868211508910636, 0.4362790796101452, -0.015150058610081361, 0.4465543105102787, 0.3086335028784295, 0.1245205951800748, -0.6316361179617269, -0.3787614826522998, 0.12504890162408955, -0.2206158091643937, -0.443032037950184, 0.013169376292169454, -0.2716373893785828, 0.27509115574749426, 0.36921018057178473, -0.6864976058208989, 0.06130814311482319, -0.28391178218977775, 0.10694645480009081, 0.5235547391675482, -0.14252094294284026, -0.48155203493170656, 0.4499321539584739, 0.26843473489937475, 0.44699451105758525, 0.3845827883978708, -0.4647747631955981, -0.22882131410672849, -0.35567276794704217, 0.2794230383122394, -0.4238813965664183, -0.4863276222933793},
    {-0.22677008125095632, -0.5751766880595083, 0.16106949814241692, -0.12904733385546516, -0.5879081902444853, 0.3545711321607464, -0.23477468139446817, -0.24570933585612897, 0.08796078992525572, 0.8019721565282077, -0.6165792310735101, -0.2985081317054511, -0.05542864904664687, -0.39554691065997416, 0.2972183655315175, 0.24882689500302627, -0.5858810360265885, -0.308028462197295, 0.04569572225526811, 0.3136585158056149, 0.07187340927034874, 0.12382016614590698, -0.34835835312450975, 0.28716212701978067, -0.4775293740526606, 0.3647313995301329, -0.18968950177681349, -0.2863439139564481, 0.06532265877644078, 0.16586856995475624, 0.48486217420944655, -0.6379669068763177, -0.4534132462305403, 0.35857950600230115, 0.10274324283120564, 0.6163997073976616, 0.24891807807701932, 0.15057541824492943, -0.44587068024372295, -0.21165688050871492, -0.22502893352052533, -0.2145331438684441, -0.3694005611620929, 0.1555820027403618, 0.11219434557860972, -0.1254584936350283, -0.0782866534249838, -0.7250623162574344, 0.2975192982103855, -0.3440620586869985, 0.01692584635945766, 0.3266280631586934, 0.01381013939626056, -0.44732094986086646, 0.5015952983361919, 0.682610944451208, 0.43330139506704274, 0.4430702046619116, -0.4519348004697837, -0.06667248046334369, -0.4264829139999671, 0.2433655631731743, -0.16849229087348916, -0.5426500626753392},
    {-0.12636725747106997, -0.5960736549071673, 0.4515968383237437, 0.09128852974964305, -0.7339111116822602, 0.834306620371792, -0.47371249736282356, 0.001463497478225746, 0.10806890892847597, 0.5409782005181607, -0.43529184291636835, -0.508912322849151, -0.26505057434176166, -0.15964581185821175, 0.29282064359468374, 0.48522001434071216, -0.5606684779298036, -0.3990168260050999, -0.0008312166407318977, 0.16349223632844959, 0.1714013553854555, 0.1276779639593062, -0.6622072838949031, 0.6032233579132666, -0.7984054029568085, 0.2755970556856676, -0.4192074848927885, -0.4635676163087737, 0.09226730584387738, 0.025221363706798904, 0.5836983491644475, -0.46856982004745296, -0.41236047307760476, 0.43089483173562526, 0.006196513230506473, 0.5507266144006371, 0.39046699899267195, 0.20373841141569257, -0.49239357086655855, -0.34150673175545204, -0.09279124171719734, -0.1742104222112283, -0.2834504414862622, 0.3017381283964544, 0.14276565423947202, 0.08226838686793439, 0.23575124593028346, -0.3237029211082798, -0.09761015009540178, -0.7586279091898266, 0.36535303947098263, 0.4397268774695112, -0.43210699720333995, -0.7149452668887787, 0.24216907320500558, 0.5146879429299539, 0.2794087460022443, 0.2734676243774437, -0.6486743957875081, -0.14706652948623877, -0.46424955045099325, 0.2140949179706086, -0.4804758777749015, -0.5379336955475071},
    {-0.27580017231640025, -0.6485649651541624, 0.5618912258069026, 0.1959437989532253, -0.582658460064798, 0.7295027577873648, -0.5324849949127778, 0.10674752426450736, 0.053751985368033404, 0.21775373642979237, -0.595287282570847, -0.3704628737672453, -0.3484459999022339, -0.3753775937692372, 0.2678924180075459, 0.4293306956734122, -0.46875558466924977, -0.33064369532357835, -0.1398453528369185, 0.5435808328732415, 0.05262224509287432, 0.2552503854829275, -0.5963337715183885, 0.4305330492233862, -0.5479479569521696, 0.21932559534236767, -0.6464645981659611, -0.5423789838624548, 0.215801079088251, 0.30545452909254406, 0.1204353063500983, -0.671074637991273, -0.45320391464757775, 0.4752127414579086, -0.029536550120890643, 0.4336200238252982, 0.37593556649664445, 0.17820565748930164, -0.33374803097785316, 0.01886755921427127, -0.04202568074438248, -0.3238418902645747, -0.2847469779837113, 0.21027960594432307, 0.13957494249221492, 0.15312705291483383, -0.05265339026913343, -0.2779666071240194, -0.21202881419239186, -0.49581170205041225, 0.08679318450493559, 0.45144813398152867, -0.38081920072367287, -0.48818090424819083, 0.3036758374377227, 0.525093945962329, 0.3915642478793339, 0.16544545456672166, -0.5547869452962821, -0.1627555860337216, -0.58971040152076, 0.21741012556388098, -0.6209984061969126, -0.8949514460067078},
    {-0.32146253578173395, -0.7630793738405951, 0.627443995432013, 0.22170072690452172, -0.6087913724350683, 0.2579646684834557, -0.3445465344045111, -0.010475589972187118, 0.2997040666026285, 0.05918634795563311, -0.4351069644143485, -0.21431171912352445, 0.1046773014023503, -0.5152182926526091, 0.3428280377850256, 0.6642856132487879, -0.4615351390744048, -0.45107094733380937, -0.09081166504170522, 0.44442883984474185, 0.25209719007375797, -0.03853587422885484, -0.37315812726703645, 0.39304420622511144, -0.6194953352652653, 0.5155063495781929, -0.47777038344966577, -0.6974627631455472, 0.52629332052739, 0.5180603433116874, 0.23705492163717487, -0.7287461086843998, -0.5118606522149809, 0.6585023822212044, 0.0343622373229203, 0.2509367747669449, 0.5365361362341676, 0.3751970585345576, -0.6236135009793409, -0.010427510796826578, 0.15055824771375362, 0.019592063904347368, 0.05120612894275464, 0.26780247549762715, 0.10792609267862628, 0.37529303754784266, 0.22022021194726804, -0.16502727223677127, 0.29317350206997056, -0.5466679584759315, 0.42513257906427526, 0.6264970204445214, -0.47936985596421333, -0.5038804798106694, 0.2573604277638693, 0.4757432440381438, 0.6270082016257603, 0.4253973435800096, -0.572842110887128, -0.17162803417470637, -0.6403954644561595, 0.4688772215346446, -0.5312229940017039, -0.5175198887675938},
    {-0.33899478134743066, -0.6926933102694302, 0.8241720953193915, 0.09636413599552668, -0.5172618013580692, 0.5540577361935004, -0.5038295620391317, 0.04523713510052671, 0.1859763404310542, 0.12630248223693963, -0.40186953082844123, -0.1685071443619329, 0.0405102180358117, -0.6985084902898212, 0.22556998099431, 0.8227235737854199, -0.6162906188010933, -0.6038903742337022, 0.19128975881295196, 0.27107469129877476, 0.16420767649838824, -0.1612352713855595, -0.47808737787411043, 0.4420690506065036, -0.4406039323934363, 0.2548535856077907, -0.5118497994788332, -0.7711247323523798, 0.5892702351857249, 0.524465567943268, 0.2719211490234128, -0.3879156333263691, -0.18835678442763665, 0.45259573894741334, 0.13404635506547757, 0.31762824921722743, 0.7377237395205634, 0.18350730369779458, -0.5732222920653068, 0.2765507976436669, 0.2903966449236826, 0.0767857570725329, -0.3080352646448677, 0.1978860952098294, 0.007066273477012749, 0.45741340416110304, -0.046965572254528146, -0.6300041613401401, 0.052929612574689804, -0.489537503747795, 0.4723440652254704, 0.7579076245454746, -0.4126928568533526, -0.6384092812679337, 0.5102584164619501, 0.5624628362352473, 0.5193006439989792, 0.6892572928069797, -0.12102205045215048, -0.382063187338346, -0.6860673115866373, 0.537214745907356, -0.2847736527279142, -0.49207812121070293},
    {-0.1229870648013973, -0.5574305068166111, 0.4983604420319365, 0.3027507425724296, -0.49323316596466565, 0.381348867457122, -0.05560970400425048, -0.01759250772323962, 0.2099910105618846, 0.19647423354069382, -0.5496927637104958, -0.407728110436571, 0.14734507658810347, -0.6142461855681717, 0.3493938852362547, 0.7201930029021026, -0.2273556892044711, -0.33578840673467975, 0.08862645404629188, 0.4156770992416016, 0.4579977163690074, -0.3204738588790418, -0.37857028893505146, 0.689265685102616, -0.6264818828188176, 0.3022942185394154, -0.42214467111099835, -0.7794582001575782, 0.436028989676128, 0.4575924805362367, 0.3762120413829688, -0.2741888478666747, -0.18345040606338273, 0.4955991561198019, 0.22266693335334875, 0.49351131580334273, 0.31404606707828286, 0.19126419344888232, -0.6078333005650997, 0.30127187993897897, -0.029806769680006173, 0.06341649173415674, -0.15893069188695594, 0.5140380540945526, -0.3245840617828188, 0.22309204480208042, 0.12391882210628678, -0.47970660831959416, -0.12508974198135125, -0.14692803212407998, 0.38641886933643044, 0.772737612562569, -0.2851286572719601, -0.5004379002897626, 0.6214246647723447, 0.3666379144361544, 0.39456342262255323, 0.4461653043230797, -0.22849794306203042, -0.40075815278595633, -0.5803703305857048, 0.3274090729912777, -0.4526783043401757, -0.3596870451016912},
    {-0.27052801549688127, -0.5386449679809986, 0.569150874910513, -0.13000009095138465, -0.5054886074170601, 0.5624279215074591, -0.3185649578320617, 0.28478673741762317, -0.02179355820941588, 0.41540357802728844, -0.7009703435869844, -0.47311635665535007, -0.09519689911995012, -0.5354648556998574, 0.5083496170397986, 0.5883759029753265, -0.6813042873768556, -0.475497966108236, -0.2507683792692571, 0.25818790674708736, 0.2909230746632907, -0.17128568223900276, -0.4775258874242763, 0.400581387265695, -0.5377896884923424, 0.41301492181185134, -0.5298817137217731, -0.7048386598877286, 0.595520723840093, 0.39647575026067133, 0.21705771184298872, -0.39012757322827696, -0.32168069388744064, 0.3854689479802316, 0.25588576738995206, 0.48822807586473344, 0.2175526180692736, 0.425505625210767, -0.5554306659565388, 0.23015767582641583, 0.13916958926975187, 0.02170864512060377, -0.43693362889252824, 0.3367788599692945, -0.1121136105163482, 0.4530076075951339, 0.15198514648736913, -0.5612211346395114, 0.18536302489702494, -0.3232908311272817, 0.06813351579182234, 0.7537823640606637, 0.09440580755137509, -0.3435757723333099, 0.5761316892020916, 0.6596308979031491, 0.6865700599042674, 0.21166929498051157, -0.1515304874728949, -0.4164505487210786, -0.06351949675378532, 0.22684322461916787, -0.29668471765797183, -0.5982516659552204},
    {-0.21785815521014748, -0.5880203981837081, 0.690659453357602, 0.16597113612543787, -0.6531427129747907, 0.5632602370559272, -0.36010471104008335, -0.0791360656575387, 0.07765395406653289, 0.5416775117458382, -0.47834770805623705, -0.5771177205790317, -0.00832888494628239, -0.693021696630102, 0.32479348279205955, 0.9015922000663219, -0.71905791463896, -0.584342421997453, -0.2682892083129032, 0.38452375492993207, 0.30036513648729135, 0.10939160877653623, -0.4053966685792625, 0.5632456053474194, -0.4147666500646187, 0.42551941993211395, -0.3703220212737158, -0.6102169298307093, 0.6395984922930985, 0.48217835323112546, 0.39229558072523324, -0.510650585733318, -0.3205499536787452, 0.6364635107028869, -0.00859118373789238, 0.7180839718101224, 0.4385058667085418, 0.23371704522189526, -0.3878351393149122, -0.21333917152390722, 0.14110386425491542, -0.035057850840925976, -0.7294389766033255, 0.39873649877327705, -0.1659486332589222, 0.4447478889979323, 0.4417306977338006, -0.6034145019821429, -0.3096638051413132, -0.5796202580023155, 0.25602247917482307, 0.7106337572713605, -0.2565267070555027, -0.6173295003947818, 0.3981482956646973, 0.6845116880837706, 0.40232714517636115, 0.555368110679713, -0.3901441333335432, -0.2621410211232766, -0.5677314440308402, 0.17270472567460313, -0.6450707337983579, -0.45022253565095255},
    {0.06912947751203373, -0.6055310801590585, 0.430060182677336, 0.1340963369089385, -0.4898104696526197, 0.6239193664048892, -0.5691766482981894, -0.4906479353141022, -0.032137166600511, 0.1627881439917536, -0.7193597839719444, -0.5780768437708403, 0.5928133271955922, -0.5316929230044649, 0.5843735863814808, 0.7001710246590747, -0.48420133033052165, -0.6314739855030501, -0.3863268626024645, 0.5033251231804423, 0.11856745262380138, -0.17748347419209573, -0.654683596663487, 0.6617063352901668, -0.2670146652774476, 0.3974965427333187, -0.36106197213231317, -0.7294514616236115, 0.9306050579261608, 0.46222115249837076, 0.4690828680301769, -0.49337942480543723, -0.49941984768069, 0.5000746925294935, 0.06361671978755355, 0.3593101695587596, 0.46754003479687906, 0.20099172678869623, -0.4882117314713183, 0.23370225615226406, 0.17664471069354457, 0.10852626284925987, -0.4862102317767506, 0.5215896650454679, 0.11745756331645525, 0.4157507973389618, 0.6711615267806543, -0.3203648979851847, -0.3420805703733519, -0.6029686245974071, 0.33891021405268085, 0.7224057322356253, 0.027356679053467017, -0.594685474805505, 0.17552840213012857, 0.631928884458258, 0.4266926625255644, 0.2268131667310805, -0.41778153234705623, -0.11967280959506041, -0.4561806729989911, 0.36806086047343917, -0.570889770542615, -0.3626118324190237},
    {-0.27537563560231326, -0.40031921015784383, 0.46439407490357487, 0.22508728183618743, -0.5798443512958035, 0.5179956572893248, -0.6679824249302025, 0.08609949263801162, 0.09188942205157741, 0.5063120086388219, -0.5120834607154303, -0.1276880856977079, 0.31997901581634886, -0.5255006807970604, 0.34849916574506357, 0.5591730282272332, -0.5635483114236984, -0.7854408530261023, 0.06731359501460385, 0.6313529030651047, 0.14643303180105194, -0.003050176316410233, -0.33100338553779335, 0.5218238466293128, -0.4105927401741805, 0.20920107773536648, -0.2260756162006505, -0.6880830546323414, 0.7646325785403523, 0.46949406723380255, 0.30079125949585594, -0.4621869777771829, -0.1986658291963447, 0.4865827083336251, 0.4303088308139282, 0.5152883118788227, 0.30319796432508406, 0.2193431937067753, -0.4446671974781668, 0.1698078821671998, 0.009545276457164265, 0.20812230292101272, -0.36840619358851096, 0.3287041140237427, 0.19024526305570758, 0.42584978218971503, 0.2846382199603851, -0.5032297293328434, -0.25645219775567724, -0.288259060118559, 0.6720366388281784, 0.25881510295195354, -0.23664366069320641, -0.262540958405083, 0.08433814890396056, 0.3275463948410853, 0.6621930587640363, 0.37062340991146125, -0.32529435895472775, 0.011387922232849818, -0.6708950296136084, 0.28038629582982477, -0.3152327032007896, -0.43999670252593803},
    {-0.22527041462634645, -0.6583291010385428, 0.6363362813646879, 0.1968899204919765, -0.5708064564422811, 0.63482159547107, -0.5816605810172437, -0.16477692542376451, 0.16573553016789694, 0.596193461409571, -0.28394676968334803, -0.30698729540037345, 0.03208799640722251, -0.5895787559720365, 0.5311925667035654, 0.3649048360698377, -0.4772537470768031, -0.632773460983127, 0.07791433937389965, 0.2961869245212473, -0.01045401747937476, -0.2306770947863879, -0.3444459228699406, 0.4158550855051066, -0.4374968725812907, 0.259595366344419, -0.5290917328918266, -0.6932622382086109, 0.3673244268239858, 0.28640259301361704, 0.19572583009250302, -0.6042379653880622, -0.6515246219555466, 0.4446726492607402, -0.19846287759110767, 0.5853754288506813, 0.3301546504124173, 0.26122991250015803, -0.3732024145484969, -0.14376194194476558, -0.014217514767648053, 0.19229168663470025, -0.1996568373938805, 0.33202330671390556, 0.04772779719568312, 0.06238027696200942, 0.4012996069472837, -0.7138824072274669, -0.1377248586111006, -0.5049409533051766, 0.2948069320727537, 0.7614202832138233, -0.40636894671814827, -0.37331073620212174, -0.15468261971570516, 0.2588108440130219, 0.5657650887150277, 0.5204504882587453, -0.13033632234540074, -0.018095822143040327, -0.519948919944864, 0.23265227703376748, -0.4703181596767555, -0.6033721567793516},
    {-0.11870998388753241, -0.2587980433510146, 0.23836078346151301, -0.10897259667110476, -0.24128928732783575, 0.27249889939951794, -0.15729293407059916, 0.06909752853860443, 0.15270510768620774, 0.29280440229275373, -0.4748988897638551, -0.33154434703638713, -0.24703178856216587, -0.3819359349603291, 0.19464793321507845, 0.4747009604208354, -0.5913978287648258, -0.4179176686280842, 0.180830825342719, 0.4217688336086517, 0.037454157221195425, -0.2108567961444683, -0.42114954085984374, 0.42683026951101627, -0.6112325298629542, 0.39107276581546896, -0.46269202942187876, -0.5145328221696231, 0.39797373899994637, 0.4692749556594887, 0.3168127977681739, -0.41335447924532465, -0.2310087618967463, 0.4713755899596752, 0.0384583418142978, 0.23845111952524628, 0.3889269643804319, 0.1359836894548991, -0.3184421812577935, -0.11534509420912648, 0.017511697623398374, 0.3353501630499811, -0.20460906766748474, 0.09821077615599656, -0.276036801513366, 0.24707854052710757, 0.1949146991754666, -0.25070424777954364, 0.08793424664304647, -0.39064257415800757, 0.4536842943028407, 0.750651118223603, -0.40932688180598487, -0.5449594669230758, 0.13727388519366682, 0.5403076284170631, 0.7510178278829636, 0.10307358546083202, -0.47452429563644644, -0.3086936138883839, -0.2472433491554791, 0.40800890435268977, -0.33894407574929736, -0.4167210970243637},
    {-0.2471153738555605, -0.37159962334024027, 0.5086704542444742, -0.38283485400601897, -0.47387410653392564, 0.33432595387481207, -0.7260873206179355, 0.13279404822338978, 0.07724630681354394, 0.1853564542558571, -0.48436563979029806, -0.5742613898540971, -0.41242074604860457, -0.3461638481590598, 0.5532828327933776, 0.46313670777979465, -0.6072410713926218, -0.25240504291084503, 0.14691311404761656, 0.3582212797788987, -0.027286628003738253, 0.13761078894544115, -0.6111857293681557, 0.6605025267325833, -0.4647324266280007, 0.26556350703488923, -0.26662825333810913, -0.3794971599507039, 0.34506707704938544, 0.7037894835685573, 0.5847600865841744, -0.34345712962934133, -0.35480569862608635, 0.3676890185432462, 0.29310998490336465, 0.30799884917732406, 0.41443750918896227, -0.17712316832757494, -0.36631791760945015, 0.04859828867609283, 0.023914622613217702, 0.08982073423022673, -0.5728858346056644, 0.37667662135418273, -0.12749013026804765, -0.03288907148223718, 0.19912559646192168, -0.5276887753934039, 0.43403980771134093, -0.33132784375310104, -0.025403625321868375, 0.7215383635765168, -0.2539208963904833, -0.42689359381314496, 0.2613480345621932, 0.7224763223129895, 0.5083497482617308, 0.21632494323627488, -0.45652988516396287, -0.7108943840356918, -0.5773211523312908, 0.23864254862009932, -0.3194669650242157, -0.4850340716611844},
    {0.11262629003213807, -0.6004670422210293, 0.34812589258431687, 0.11279259506322908, -0.2308350606492262, 0.25117237642225126, -0.5639567693187558, -0.10945565859619295, 0.2331439287785401, 0.22213147538198755, -0.4973800574723607, -0.38662628397890675, -0.02034438680750283, -0.43455622703142655, 0.6265192416995701, 0.5670176065162339, -0.5516615642813465, -0.7207177377838725, 0.36466537283278894, 0.5093071581319243, -0.01955475876089682, 0.0563239543886815, -0.6489778163571642, 0.42062552583830837, -0.4667530858285577, 0.11411077062375766, -0.42259904665162784, -0.7001839785628191, 0.47102302867425916, 0.40300271617923816, 0.49454953152017, -0.5550591001485649, -0.3450307330199059, 0.10027937875091436, 0.17563321878763405, 0.39401277089565506, 0.3272131509219507, 0.19144209152152272, -0.6320274529562331, 0.033566068685905816, 0.2940067060405673, 0.03222290769440914, -0.2888605568172684, 0.455461273573097, -0.05098207884639063, -0.08476034661159602, 0.15445675708821907, -0.47211815362952103, -0.07197737443787436, -0.42365134453749914, 0.1762596233000825, 0.7583754987881106, 0.05196258508498077, -0.3918501871892124, 0.6360353961165782, 0.4933699786923483, 0.6207732792831852, 0.26142178178932307, -0.7490477480904074, -0.5586056805359874, -0.3966144849945692, 0.23953630848280316, -0.4914900905862295, -0.4511191137076101},
    {0.18612325581816086, -0.6087228958512055, 0.7684560412924756, 0.0799197548029212, -0.240835169344084, 0.2800621224362903, -0.49385764813365296, 0.13618479483203408, -0.024633877512983224, 0.14124782274316194, -0.4185390294865056, -0.4508787334752327, -0.01726538596204182, -0.23433194147341363, 0.588677678636023, 0.7382591178489925, -0.6299918786552591, -0.3959928003602318, -0.12113170822853715, 0.10353421457572246, 0.13815393687223235, -0.18303772592810127, -0.3325364906241459, 0.44278676926373256, -0.5197651233751935, 0.3756975409310204, -0.4610253378125768, -0.7150194043657024, 0.39335918170714873, 0.3249533879774218, 0.31638329941144233, -0.4913556601979985, -0.307379914134149, 0.25892041888729034, -0.14630649673634485, 0.7416833818498064, 0.715828505746541, 0.24614456298002207, -0.4663867189874651, -0.053779059444408174, 0.10753550100883714, -0.022513024016115466, -0.3672276556322407, 0.2753118541065378, 0.3085033972121704, 0.29408911477159716, 0.0022452597412121714, -0.5007417091587696, -0.28419348360429714, -0.4010007047327453, -0.04294517691102706, 0.8336104513767768, -0.25642755234085235, -0.4161631448951869, 0.5410953315120848, 0.3680693044580852, 0.5639412611228278, 0.4483778444754776, -0.3920683454998316, -0.15453533363941835, -0.6547304439874081, 0.3031951835217178, -0.6020188222164543, -0.4143514628246537},
    {-0.13033507274308356, -0.465166398566703, 0.803478439360637, -0.26460050261430434, -0.416183731125165, 0.5259203161795926, -0.33636052966545815, 0.29724722612749144, 0.28835735858632233, 0.23373713329560777, -0.7502956594973549, -0.5140305854411928, 0.04103173710248839, -0.35216859535531003, 0.46377261906187534, 0.7902530268875401, -0.5418005348527924, -0.4524374396916831, -0.11965147454811573, 0.3956131644896405, 0.1366902667087935, 0.199556995835097, -0.5725886500909725, 0.42151355487978, -0.488826368044999, 0.1125804577178235, -0.7898663389194335, -0.7020282023829045, 0.5765807750092575, 0.421171031143182, 0.6730377271038029, -0.7447341171680149, -0.10248505270416915, 0.5931860501524692, 0.1772118927168008, 0.43512439497540517, 0.30617869834127803, 0.45757104189137904, -0.31344348259900123, -0.013338457685439377, 0.049799835056566176, -0.07003487262785675, -0.1623045226055435, 0.31009602175662776, -0.052353428694879627, 0.5656788879883364, 0.7346198316898306, -0.2231806865122963, -0.17327207153208637, -0.6276704027088643, 0.1485888739607272, 0.8483562042541202, -0.20869377021568017, -0.5811161795293859, 0.13265031931078394, 0.25653378387115267, 0.6606257244740668, 0.25080367337654985, -0.5446955992911806, -0.07026498983502935, -0.44253922874049406, 0.6437326639240146, -0.4935798747817728, -0.3909306000213343},
    {-0.22879662000744955, -0.7006841986500308, 0.3495463408944367, 0.06303866846020671, -0.4975756092185101, 0.39041807562185976, -0.28008450373977145, 0.23534488839949333, 0.0075566314330873605, 0.392184218132173, -0.34544748890431115, -0.360663720580671, 0.23814944668716273, -0.359704476400032, 0.46363037126068235, 0.7090747482571198, -0.6108026175433864, -0.25069833263904245, -0.3188393322678796, 0.5493346248829925, 0.08029633144861419, 0.15650241760775083, -0.4788116437385367, 0.5626485995669896, -0.48554818324662385, 0.5763063829695362, -0.6904020624616128, -0.707599600392647, 0.27933546806536214, 0.48764618854271785, 0.1872144325470195, -0.5187160757231875, -0.48720458024816515, 0.38299336759601055, 0.020436169215102478, 0.4066980094910901, 0.47493441951149745, 0.2678050889220241, -0.1557563344519291, -0.009629893615748583, 0.27305335411368026, 0.2190406057990857, -0.18629184355108747, 0.34053557529600825, 0.10836063874254254, 0.2515725755051619, 0.49357284492120806, -0.4199906041808012, -0.13812188329832634, -0.3034091327376406, 0.31235520225169644, 0.8135915578697874, -0.2558813747341686, -0.43272519718955527, 0.24058316644505032, 0.1548873462235535, 0.43575532086026875, 0.3106647162027893, -0.37394846417262684, -0.11295565679047939, -0.6519395366367866, 0.2515014740785517, -0.33139433464891693, -0.49154653504309864},
    {0.0424707953823362, -0.45994975879227284, 0.6828839632518047, 0.21875128276080125, -0.5005455342979483, 0.4602796317071754, -0.4367043131200741, 0.0027454285598149377, 0.11342747643272225, 0.6125654444059251, 0.037206658648911435, -0.3281073297851943, 0.019692531680224497, -0.3324408811645573, 0.540477605104243, 0.7186561677125795, -0.4071439272293393, -0.519679958507629, -0.11332044025438487, 0.1908903601744715, 0.2463638236085603, -0.15788743380820242, -0.4248432608434438, 0.5354692663403244, -0.33772070605672166, 0.5159752212763633, -0.47680761889974066, -0.6981797289833859, 0.5208756911595427, 0.37744831282286234, 0.6396664684445731, -0.5905500056370532, -0.42917435200508713, 0.5811340139577618, -0.0009115121401133464, 0.5752242600138607, 0.6138194112325316, 0.3347643417359333, -0.2712186169402483, 0.1383723675715351, 0.22870845432136103, -0.0495263970152858, -0.5532902831075612, 0.33725740468218174, 0.09634296142338859, 0.30986403925723127, 0.23728272424369098, -0.4628473675370581, -0.01545903883759056, -0.017533630382713262, 0.42793667824457926, 0.8424523550192802, -0.24060557925445933, -0.3375706563561466, 0.43008338414159325, 0.43853103351091355, 0.48746305275076024, 0.6543501707342352, -0.3840843602054469, -0.14533940166447473, -0.35228771934917874, 0.12790248800793788, -0.27786435710507945, -0.5944012568532973},
    {-0.19878951676990492, -0.48469233453296084, 0.640671486416728, 0.1049401892045827, -0.7603597259095349, 0.624363559574465, -0.2379271304326967, -0.1639864692344251, -0.035264721331779984, 0.6075456317936985, -0.36354873585785635, -0.3914830888859143, -0.07387710736303764, -0.35050108274713315, 0.4204376364284486, 0.41779520082965116, -0.5071544398775943, -0.8316714712714861, -0.25383168640658893, 0.31014803277478215, 0.11342868680589598, -0.07341049552154084, -0.6133411587569828, 0.3260187255700194, -0.5187668339559085, 0.35616715370622215, -0.717252930610849, -0.7547883104191405, 0.402374950780654, 0.5706128044406525, 0.5510042611458588, -0.33432912338169707, -0.3688920800976931, 0.532165187004804, -0.06121918776979508, 0.6076543490612611, 0.7158077108899303, 0.36031042312191264, -0.24058709794646624, 0.009924681101431063, 0.20848653974017584, -0.08256517103914139, -0.3410756921344043, 0.16418618315552228, 0.13299679576996043, 0.4209468038531822, 0.24554607728506392, -0.4399396116785117, -0.17253888890533536, -0.5147327752768508, 0.5196705348569146, 0.9335557505665202, -0.4474137685575475, -0.6912810777516241, 0.42888919180137003, 0.3097070333308685, 0.7774807086741065, 0.405214770630221, -0.4611814872581111, -0.5535893352798306, -0.5152188494720287, -0.202593983298082, -0.5562125327484135, -0.6662124092887779},
    {-0.11191118069290597, -0.5752345733062355, 0.29369191207060014, 0.015370799297240835, -0.463468639979856, 0.45856751332837054, -0.506905947159497, 0.02070263431469814, -0.10829521361804025, 0.7661723606309462, -0.3812556706986279, -0.28035491123272493, 0.0005420892784472713, -0.09726663701053237, 0.520131538541945, 0.7925472660907995, -0.6300735932954539, -0.6163596350863955, -0.023339057313592558, 0.24439300201011127, 0.14217930499445006, -0.10111180610746623, -0.38655466503209307, 0.5003872738124988, -0.5033702020785006, 0.3677079480511125, -0.6640876249476969, -0.9915152955159915, 0.660311817452704, 0.445604132300385, 0.5838105520652894, -0.2415894806767239, -0.3866781298344831, 0.9026059066630263, -0.08211423086726219, 0.6446138064994227, 0.3342615603522566, 0.6857796422284425, -0.44366177006299684, 0.032252560574718515, -0.23310034546933747, 0.20072609406662223, -0.3018508054046234, 0.6916816544012208, -0.03130157736548512, 0.48700682822685976, 0.648275148646422, -0.2189305884507826, -0.3605119839704729, -0.39414720840535, 0.27713926193850236, 0.7250316281191622, -0.13838248999564007, -0.8015241752604702, 0.4951784857741384, 0.6250607732617182, 0.9022558426285584, 0.7180087407997197, -0.4539999966278147, -0.1867282603112482, -0.13698790585185075, 0.137550280345498, -0.5944929916855757, -0.5607256719750988},
    {-0.256383257893776, -0.6849724522416125, 0.4397871703902893, 0.05614548895897874, -0.8051610496123619, 0.7229467005428993, -0.5357644755510247, 0.03628607434890572, 0.01284558615944874, 0.35490157428788777, -0.21233359363958995, -0.30970279925595945, 0.13606794462204572, -0.28913963314027186, 0.5084775899147679, 0.9020858773138687, -0.410660623062025, -0.5095706367411852, -0.17653070926211387, 0.14712843814039164, 0.055942615523066744, -0.04914481526330032, -0.7189719998518824, 0.5529773008085556, -0.37691058267174804, 0.27387830960343895, -0.5825104518540754, -0.5951157618543447, 0.5878873635714095, 0.6723175367485426, 0.4526202241390029, -0.5818055955846722, -0.01636807863317792, 0.6132589587093633, -0.10810340716047859, 0.7113455287147801, 0.46356570902869587, 0.6789209318633666, -0.3896353921153705, -0.06649456167874453, -0.07696740232429834, 0.23087426796008653, -0.34758760530027066, 0.561955211892556, 0.1419875915906754, 0.4789005291574269, 0.6559232073870821, -0.6007427627900284, 0.007790563222429454, -0.028055372337004187, 0.49045317051904846, 0.7780992494383449, -0.15929106507069635, -0.752660064775212, 0.2793911270799691, 0.3686475276030369, 0.779857151649752, 0.27093126282656604, -0.578115664095457, -0.3863879451886225, -0.3622903439517926, 0.49849686642973334, -0.5080923512958212, -0.9096035721858604},
    {-0.19680909332778976, -0.3507000972955672, 0.4897305372024822, 0.029983016711213253, -0.6906049815060382, 0.506117247988145, -0.6703965315871574, 0.08610104661941685, -0.006861088503891241, 0.3717416230180588, -0.5003832798069002, -0.5042396032758746, -0.35621837958641783, -0.45038765318242346, 0.41390542281856946, 0.8425313336530861, -0.5618521449552071, -0.6886709774160887, -0.11565971089865486, 0.1955225993382684, -0.3800419364700709, -0.14506204901351002, -0.4465804820856428, 0.5557430452889004, -0.5608865391144173, 0.4108361269126058, -0.6319931455097968, -0.739138160606812, 0.5308029826246656, 0.36156973539209425, 0.3015658542654877, -0.5575445639174758, -0.5357533396433947, 0.44188547243013276, -0.13538620421232556, 0.554417072967544, 0.5107110739727323, 0.3490349459154759, -0.6658313066659683, -0.16089106888402438, -0.1523328425622171, 0.07471140777605893, -0.1537875446789673, 0.5230427108598255, -0.34685618066754376, 0.3052440200783004, 0.6578915798690035, -0.43576734934297834, -0.6843707179022737, -0.20393893412866881, 0.3244980928484179, 0.7358373302758864, -0.3864023691586156, -0.8616567848163126, 0.21244372282214746, 0.33801206405102996, 0.4804716823951874, 0.3900750835499513, -0.47562513626710085, -0.4700317308164929, -0.320540980394163, 0.1757552707012511, -0.4980930504912881, -0.6642101211762056},
    {-0.37649073521960896, -0.5099485579019774, 0.5172319360930996, -0.24123883786300032, -0.43043217522540744, 0.6461561584527594, -0.5466467574739521, 0.07470593359626276, 0.12334440898839824, 0.3398367724386687, -0.4753109340212162, -0.17743824004862307, -0.1550928964407502, -0.3213711059072989, 0.6474401546546696, 0.4877124478994584, -0.6038460573300255, -0.690361784029483, -0.026236809363828936, 0.2934806461176094, -0.13652352825982458, -0.30258849468121324, -0.5735773213710864, 0.45192318331031306, -0.42277998644326215, 0.3082637072643731, -0.5649353271137614, -1.0516302724876578, 0.5843020987529314, 0.33350014669719474, 0.291510518992354, -0.8187199173989022, -0.2118164057363462, 0.5719220651057184, 0.2575352751158038, 0.48699829446548615, 0.6537841331254121, 0.31103937307231827, -0.5140152507538587, 0.02921832124837132, -0.08045156256372007, 0.13787778585585975, -0.2786232228175239, 0.33173472289405803, 0.06935204506162201, 0.22838810976789126, 0.5882629688261042, -0.3735041046033853, -0.1483147960417846, -0.34137399434564397, 0.3243279897907609, 0.9039034246048214, -0.09250767611532815, -0.8541620890285895, 0.15359734149183482, 0.4786837614118901, 0.7226209899916933, 0.33229037059248906, -0.4966628151456403, -0.3080772418151016, -0.28692367433628957, 0.29141926710118204, -0.34243377268329456, -0.6967959142969562},
    {-0.2917206431106855, -0.6182884359162629, 0.5542733817152209, 0.24639478513992094, -0.5272106410382486, 0.4639864715297405, -0.41045266783086964, 0.008332529987359337, 0.12041287613285245, 0.5671834357226517, -0.705084235429729, -0.37705901296871047, -0.32144794210861916, -0.42373326487770857, 0.591485342109334, 0.5855985682722791, -0.5665532498019393, -0.6291809583020078, -0.22821563088838387, 0.41822881501072307, -0.029208313128757258, -0.2484590868734618, -0.6147181009461121, 0.7810628324288544, -0.7632825606300427, 0.6265486672869411, -0.47987738375779476, -0.6618718107265028, 0.21155658771855954, 0.3600692931531791, 0.2092722374298375, -0.3769449915378314, -0.4732534826542714, 0.543507344278152, -0.25226153551811387, 0.5752748157232657, 0.4169554721300656, 0.14313446901986723, -0.16437740807989035, -0.15130464511935315, 0.07035748529736642, -0.003441131349941233, -0.25995151723701304, 0.22996414491472045, -0.10067359466491774, 0.5175619961462874, 0.08631335063289092, -0.3942897825331859, -0.10505633409202506, -0.41214897868960587, 0.585873203845143, 0.837871101830546, -0.02007683225546939, -0.6498906791571761, 0.5942281492058142, 0.3444313208614391, 0.4933414521486439, 0.31273627533867837, -0.436256555948603, -0.30512625520597425, -0.5622908933785887, 0.20329004806901585, -0.5322313205896305, -0.4522392711454948},
    {0.029137259429805922, -0.4233529998483314, 0.6234618320715937, 0.05622969730920506, -0.6801065357100763, 0.2302524281331173, -0.5676500459318705, 0.05589303198972532, -0.12956198698830115, 0.4126764113368258, -0.958385619125479, -0.5029950959072857, -0.16019733642777784, -0.6073658688675652, 0.33968605585225214, 0.646829189062859, -0.3076654150413277, -0.5468209995641427, 0.07814570826713219, 0.28676735535980213, -0.182249079689323, -0.2026969137394223, -0.5718398114748552, 0.5938045239119825, -0.7902226858207558, 0.6471929870943066, -0.4139915977511858, -0.8973373798148958, 0.5492173768553578, 0.2622079689210187, 0.39937258113079266, -0.48358572599002114, -0.2949930504927133, 0.44582665404336397, -0.09877122496124055, 0.4668916243910985, 0.3213305617356866, 0.11206379910402328, -0.3577851680053429, -0.004613170165853401, -0.15866598213986996, -0.0024351485048816277, -0.27809218481865855, 0.06280740142941725, -0.17153182301222425, 0.5153850774242742, 0.2838485014571506, -0.25579785918042924, -0.38590015967461194, -0.4003950981711417, 0.4270337798381594, 0.9124932113180738, 0.11975474891789391, -0.6064519922365941, 0.2725366421818623, 0.33884213592886653, 0.5119738841097307, 0.3880293479621912, -0.5643269656016822, -0.42106331414814957, -0.6424641703094858, -0.005941847003705887, -0.36445726643256765, -0.5981207288145707},
    {-0.416315083422759, -0.6420165302048692, 0.22118188022645136, 0.011516780723805327, -0.8322049261495337, 0.34940254389405706, -0.8132977102424827, -0.33928027425181234, 0.0016182268863061693, 0.32247553819084274, -0.5109461678638202, -0.5616335596839203, -0.006326828411545133, -0.4146937540854215, 0.5325018966279103, 0.8060478638140486, -0.5133934238552754, -0.6314196124702824, -0.28830779544222407, 0.3377110988433539, -0.4700705857543764, -0.1375910393720546, -0.6197829136453703, 0.6218666425973186, -0.947957885691162, 0.19390903464439638, -0.42856705579771054, -0.7715656666955301, 0.5482459083041266, 0.38455522279619136, 0.27546822326287784, -0.3957353741385386, -0.34713780662303334, 0.7714377966028784, 0.11510610866531167, 0.40254581539652706, 0.44357808025504963, 0.18297736859321342, -0.4201882832074989, -0.07263776892187074, -0.08400372262861706, -0.23665245905516202, -0.43703801568692785, 0.17592577640457066, 0.11475010157603864, 0.40405386212678746, 0.44181903827629826, -0.5216193900022479, 0.04951000429504007, -0.4693047258670091, 0.19295835883378953, 0.9009503508503857, -0.2973035209334666, -0.568529920846265, 0.2467870912167554, 0.4556505255053335, 0.5321034418826295, 0.290268949553518, -0.7662525092022191, -0.5360355757012445, -0.8048595332819973, -0.09471198869263366, -0.7117937877913568, -0.6812022579555286},
    {0.24781659762257316, 0.43409789001786864, 0.07906319204604506, 0.490745257939573, -0.5384675273317964, 0.5319933287229163, 0.7878346294064764, 0.3418412274193555, -0.5614382145920178, 0.2594766988693351, -0.06471706271011939, -0.6240662750323516, 0.17190433581795245, 0.41477807896028096, 0.198284695425644, 0.042447222454535985, 0.1557771616732021, -0.24745678865200127, -0.5008191609211504, 0.39167211471940266, 0.2512641611156718, 0.4390384713195535, 0.4824253291367116, 0.1984682574491018, 0.3931685843381261, 0.27133006286212624, -0.7932799829767574, 0.0019755173617970623, 0.5847030647047213, 0.47822619034388497, -0.34894258914883597, 0.5741085388468108, -0.5508327518485241, 0.423258198739487, -0.8205383388684814, -0.3190971309523122, 0.13424728073666206, 0.559559965547446, 0.34935323495887055, -0.6060337444109939, -0.6355276090071749, 0.3402709661982501, 0.6203337300358651, 0.5767014379259869, 0.5209702258084412, 0.1731108858552706, -0.09284058146198783, -0.011322674234648946, -0.785646513231754, 0.7557070888321115, 0.5495449415864909, 0.12150887317279657, -0.39584346210759264, -0.4509652699472912, 0.12280512809368231, 0.5302166011047166, 0.1397775481706107, 0.02240371363522502, 0.05898973269618213, 0.4108192457476057, -0.08643855511482465, -0.3306236345278441, 0.12494642749240283, 0.2950418647481732},
    {0.1746135654121529, 0.1646342208258717, 0.1842432609496113, 0.1370589811629818, 0.24139096286850692, 0.08579278251171243, 0.224802111674048, -0.02588160294562741, 0.18321039658915586, 0.30925576270319793, 0.42508453368290494, 0.23310802902985545, 0.018304680613791705, 0.16337060994384484, 0.1324181874556748, 0.4255624296496759, 0.4062162816094815, -0.004140221041755193, 0.12640931446318543, -0.1800284286515844, -0.18723620683835224, 0.29063876931478777, 0.12380681666223999, 0.15429975481488667, 0.3950511157931856, 0.20695316291154583, 0.39723801727082414, -0.49636407716733366, 0.1674264007970365, 0.11092213134713592, -0.2681965364643836, 0.07422953732143174, 0.23328267268059705, 0.5055112530339767, 0.02845564725690245, 0.23687289757387422, 0.29373026937618446, 0.03241181758713, 0.24858916399052502, 0.06807658561464189, -0.40523668828685044, 0.199698616403058, 0.24580964448299303, 0.1412103619468447, 0.013825511171209436, 0.07560201639331984, -0.13226273165522254, 0.10084978045417524, 0.12179997323582228, 0.36208309176414577, 0.24200055269924117, 0.06444425695560521, -0.03708259880038024, 0.2176606626693153, -0.027542130841764583, 0.01437972968449046, 0.291620601433761, 0.009955246275033504, -0.20016751415131173, 0.21780762151285893, 0.09753394222051456, 0.3494943439018406, -0.09522001469251189, 0.37380213629238146},
    {0.22153291250151563, 0.012608980866798526, -0.17070873541411968, 0.016934415798768285, -0.04268457582138045, -0.16672842593212, 0.060989986055958324, -0.33987511096755757, -0.384207995168902, -0.14795599944608667, 0.2703619563120349, -0.48288500411748997, -0.8934111829135782, 0.09607053742825697, -0.2842083844574391, -0.09762244223034167, -0.07673373903640296, -0.613004813048111, -0.06424476828881599, -0.1896496572080507, -0.5694318691752037, -0.26801016951631307, -0.22930544100488848, -0.027600183381134225, -0.1955201417399769, -0.26298094769931474, -0.2146019431076216, -0.5881047922715317, -0.12721772781129517, -0.28449001290377174, -0.5712278850696444, 0.08700120346375369, -0.319484024166286, -0.18995291273996198, -0.5380979740337696, -0.2627452259247834, -0.28065958524756496, -0.1603453794651895, -0.4017670128260638, -0.3784542149936843, -0.7268243003815346, -0.304901081783675, 0.29291363910153695, -0.2476923751156563, -0.07682502383876327, -0.35636075001353373, -0.7021856086628389, -0.19385717777887412, -0.4981066427303543, 0.47724715868809175, 0.46355044907158627, 0.042599753287951396, -0.20379792978653072, 0.177017202039061, -0.4067814179851161, -0.07644900900238981, -0.1983358398652073, -0.577353768488255, -0.2660429416694256, -0.0779025508082409, -0.23996717590518188, -0.4512598228389259, 0.3372393660322262, 0.2811218847929725},
    {-0.18509567108992933, -0.1284102426743349, -0.31353624337880726, 0.2272695038961086, 0.14601881367115663, -0.028944530898972334, -0.29359110785832193, -0.2889335029284192, -0.3635210102743916, -0.43652990920104207, 0.329770610565621, -0.380193649547783, -0.44940385272198835, -0.2009074139791362, -0.46976722607058113, -0.658331916504193, -0.3185596703164734, -0.3874707743556872, -0.4148335793338096, -0.5755440071354173, -0.6897747288456662, -0.27336807001859664, -0.21484891262926628, -0.17487270157155338, -0.3534801606486229, -0.6318471753444875, -0.07289183495365727, -0.3462988632228647, -0.36126835736050317, -0.4555350290791164, -0.6490255251103495, -0.13408551648091818, -0.15159501987903262, -0.2595003005561794, -0.3728105851535706, -0.3634382805402507, -0.26973467724656264, -0.16349864649750953, -0.5414438292706281, -0.263371871611947, -0.5427152360027003, -0.3831039135057601, 0.21503431574083262, -0.45861697371487087, -0.5068900271173941, -0.15861751734974722, -0.5651805578831459, -0.5971850951097573, -0.297255259528439, 0.055563115572275903, 0.08286400512214925, 0.22386146325962503, -0.051520995964123094, 0.12543730201044112, -0.5408638601257844, 0.174484988174241, -0.48376465492454707, -0.4450666080821419, -0.39410335291208054, -0.1648624847995798, -0.16727377254511158, -0.41757214689011446, -0.23186079367669468, -0.21471106437334742},
    {0.307417509784854, -0.1834344494740142, -0.263959275385876, -0.14485469718788452, 0.15177511273750718, -0.18401250672696953, -0.41721112660016774, -0.5013684123680152, -0.21825355238500144, -0.434456924214754, 0.06706272379649847, -0.09397511939965984, -0.6153075818488477, -0.24678436216802258, -0.700861492548873, -0.38684315496948535, -0.3347985061423255, -0.4941678026162069, -0.026805927024390393, -0.4300019991198655, -0.647559059045343, -0.3836643219617959, -0.28044939575096073, -0.3743309211404953, -0.4572022913357112, -0.6721555193020621, 0.18632337635632823, -0.45291734665201766, -0.42634607217584397, -0.23948324655660147, -0.640283698338175, -0.043623843421303904, 0.10811706999794865, -0.4950885221487645, -0.0454647057842941, -0.5227248974783908, -0.4119145318649056, -0.19475063164466672, -0.34793957067925446, -0.09606380513893113, -0.10624594232463738, -0.32486681732359834, 0.14642491583863984, -0.1736869888580507, -0.21143314772954924, -0.3695159882767118, -0.5369220599663296, -0.506378210657609, -0.37798040840425395, 0.07951863889781485, -0.03305585849367185, -0.07324671198264582, 0.20087780533594646, -0.19235295796717217, -0.6823621900986375, -0.19555098488976344, -0.5686701093926596, -0.2869785792187729, -0.12593367884148088, -0.23765169940930897, -0.567168393010402, -0.09852006650485494, 0.11502615945162754, -0.43970970878612653},
    {-0.26168634527872514, -0.1261787057575731, -0.3263867410749706, 0.26495619663221603, 0.007837996528232465, -0.47023846888440596, 0.07971299254598477, -0.43741750961727244, -0.11104462851189759, -0.09290554817716595, -0.04699146721522125, -0.24055436719531745, -0.3499050339036444, -0.09742890060308546, -0.48362637197340164, -0.342361562901087, -0.07399118215312805, -0.36663046913110015, -0.08414612297052447, -0.4304168157411358, -0.30304070227397506, -0.29709057738657474, -0.21668197061434546, -0.3735765074872251, -0.1997276590875018, -0.5029538398797072, 0.1379758703239027, -0.1393622673366006, -0.23757101140861936, -0.1705028398965033, -0.40297485673607714, -0.22917095235516063, 0.32352797422886614, -0.5016071919780231, -0.06232652403126822, -0.3516606866902952, -0.36200451322206056, -0.41655689224597675, -0.49216030137663785, -0.26887242889316254, -0.1888919629283428, -0.10830853836817056, 0.2426234147526616, -0.4848292662088933, -0.6012872027789387, -0.25916407657669605, -0.47181528384154375, -0.6612638531088, -0.26726302646009054, 0.3413976367163267, -0.38243788052686456, 0.12927433176889752, 0.121283747174331, -0.08934312772785172, -0.5681043849683882, -0.22100143515676446, -0.5503377541890492, -0.10825705741923371, -0.4054347034004058, -0.1907078113683563, -0.06053157426965652, -0.15128802642856762, -0.2286268983126139, -0.08646445735291838},
    {0.18669922084200702, -0.10990391291306356, -0.31603556261557714, 0.21364720194401246, -0.15561096000813132, -0.17227405632746282, 0.0003316488521771726, -0.25597774281560365, -0.3542002148540729, -0.10744865323047276, -0.23719315911149766, -0.4779096847165532, -0.2202006921501295, -0.1305054556644476, -0.3846416207484862, -0.34010306463483697, -0.3043795310960651, -0.1819992071325083, -0.3342016346198202, -0.07800933758354707, -0.23004022799336787, -0.16101793845776932, -0.09071564189269761, -0.37448181747572207, -0.5206106441661975, -0.2724750957431574, -0.3232032342521265, -0.2696381994218821, -0.2740017045017789, -0.3335053616085804, -0.44797700502312976, 0.09819585466720601, 0.29861794336840863, -0.4886848928132937, -0.16567857594355187, -0.5578058412834543, -0.0490764149330832, -0.17237298288047456, -0.15193735021174695, -0.1394077863483479, -0.1651822213998618, -0.24457624890871763, 0.16011922513007776, -0.1908924387712011, -0.17794188971277394, -0.0773456153768687, -0.2983726307699183, -0.23171230517454192, -0.23113167809691487, 0.05515869366865767, 0.09041802966893622, 0.0063168914484053925, 0.035786195192221475, -0.1910605978817204, -0.5093065916515499, 0.2618948247728736, -0.28218170463358666, -0.30696062110427513, -0.34847369507511045, -0.44482628415251146, -0.008118423080932882, -0.060974032315689576, 0.06250969669566565, 0.08792583936498755},
    {-0.23218579233502287, -0.1356917529707233, -0.4883370585503274, 0.03794555586236936, -0.2616820685841658, -0.19943606772347017, -0.12812124317286613, -0.4615492047095698, -0.2236116707955031, -0.06525906436687444, -0.1652826130696055, -0.12091481780111338, -0.38502055555786435, -0.3843170383377088, -0.3845181604336292, -0.09690870720901643, -0.31067094750258445, -0.6018540972698834, -0.20570025592824315, -0.21770040779934813, -0.3906400888919966, -0.5123345316153284, -0.03195670445116933, -0.252021417648751, -0.33649815458621996, -0.4409572885086537, -0.09925114997900666, -0.6123481154200663, -0.2529875323189451, -0.5456356472303652, -0.2684422473128918, -0.051861035101444714, 0.07117357285787526, -0.31547976390310983, -0.23805989874040653, -0.1893381175203517, -0.2862709703944847, -0.034241202660094186, -0.45166576580208456, -0.10971942788966893, -0.5760712827620493, -0.11562480411637459, -0.48378106297481044, -0.19602036024821012, -0.3966892319487307, -0.05043599603985478, -0.8830447358455717, -0.45382609457458184, -0.2416986848234107, -0.2346481662249273, 0.4608645774470356, -0.1939104780594748, -0.08914259489313874, -0.26750663403802194, -0.5449397538481917, -0.08215590040697719, 0.18060725990251275, -0.534399177318803, -0.3169586130218867, -0.5019991028696306, -0.35296309276705506, -0.14469838664232493, 0.032314119922829315, -0.10347876129773452},
    {-0.1312091198603607, -0.11999315020783144, -0.4387972933300032, 0.3205939053922219, 0.17488837872980995, -0.40995252999559545, -0.007939655013365346, -0.3600860567615119, -0.31127373863536034, -0.19425680622985986, 0.35060758895826755, -0.1686194054635607, -0.5714344105142375, -0.40308467133959547, -0.3539567569227747, -0.7927201372983551, 0.043980492607125575, -0.3625896404414318, 0.03909097012405975, -0.5282676286529909, -0.19967543313675487, -0.22779299258301966, -0.01822929249526445, -0.0907371423964495, -0.27937824010757095, -0.4550780629613974, -0.09553935566419346, -0.38630102792731197, -0.41973529615637306, -0.4848910212397844, -0.3732131521256176, -0.17485621924131445, 0.04718536691695125, -0.055418083019762296, -0.224188185371068, -0.14565976537290395, -0.21924860860513679, -0.12709960774036358, -0.3119700934442418, -0.07961533664211998, -0.4376177550525676, -0.3515116015833884, 0.19769494714696376, -0.46120890976561124, -0.28739183850013733, -0.15509044818555362, -0.7262298646817755, -0.47252712529972785, -0.233613593176012, 0.012893388732036704, 0.5563466852536298, -0.021223646258357133, -0.0776566633867394, -0.13935250688060222, -0.5819207086278573, -0.25847906480585275, -0.10713712796330928, -0.42373484714614196, -0.4486379982074866, -0.30850316948145046, -0.39444302665462344, 0.34216098097896935, 0.21316765546587937, 0.09660766839835176},
    {0.412761454630622, 0.06621939298599165, -0.04572229422813939, 0.49446412901541414, 0.1727416656303907, -0.21897825053838704, 0.19323316141627928, -0.37556928957655455, -0.17310877565220992, -0.35817438567234, 0.19318139413035215, -0.5900046090279903, -0.45868879477913027, -0.06856858806166456, -0.2832760328238252, -0.23817466520178676, -0.4405629281814812, -0.2831053765194127, 0.02084014705981869, -0.3079594094455736, -0.6062115117112168, -0.4580853192147583, -0.1949029807989887, -0.41711904524600374, -0.3522572214641773, -0.41212260279766394, -0.002106400795402263, -0.045137964226676465, -0.33040682055765347, -0.2959215980104048, -0.6494594516381745, -0.15887404541864752, -0.0814065898970099, -0.3954248032447052, -0.30756571080541795, -0.3902183465115329, -0.3965496120111608, -0.3948135273848097, -0.13588444381128242, -0.3150640874117793, -0.297810900902337, -0.5100434576283581, 0.48705625375230116, -0.2014865773536766, -0.1210240587914132, -0.3047973638367804, -0.40684503684893886, -0.4283919906085316, -0.5571104869958505, 0.3455690079575049, 0.5446567999580026, -0.09130415681411316, -0.02009318664218797, 0.024232389783172104, -0.5282501080650661, -0.0763571801631293, -0.17555889015418466, -0.6423798898713655, -0.43048326553887023, -0.2680998690039985, -0.083270118278936, 0.006096463558129712, 0.3766649087662599, -0.09509691526536142},
    {0.2884548817818216, 0.2978732816579964, -0.29923077616755295, 0.13738406227880512, 0.414042388529255, -0.12932886037630853, 0.3804256397064884, -0.2442596684681629, -0.28058853132286715, 0.05854574914113094, 0.09212739124720289, -0.5575050475960478, 0.018285011754456668, 0.271189731246472, 0.05315320192558405, 0.002902716321230929, 0.22935987510910288, -0.1881476689395431, 0.06715812055087515, -0.004999763796726208, -0.6454921627627569, -0.16447251880265237, -0.0364707233497089, 0.02284369279591115, -0.2850322805588235, 0.013457403291675702, 0.05532951762085619, -0.1419284346448016, -0.05586922012599017, 0.15300900091601552, -0.5082004626078357, 0.5601005388124634, 0.2222736712739077, 0.016473250771089985, -0.08131563349209861, -0.01992901955341479, -0.2570020506196885, -0.14091440945712633, 0.174344015248774, -0.16079239208237653, -0.2105507917582711, 0.20072841393564633, 0.11413014136680326, 0.029473204648777618, -0.24622557825471436, -0.13018195569242214, -0.052807958456063196, -0.5639487053092923, -0.39888576590114544, 0.23342759555455841, -0.030306850527404033, -0.39785251481436923, 0.3007736373232356, -0.11783825463344556, -0.21288418072943366, 0.009185494675800654, -0.2557961758879276, -0.24573023041365272, -0.3784487263400937, -0.10608026421724284, 0.27017628530692755, -0.42304976479550693, 0.18610583574827505, 0.006548403959391622},
    {0.1662071693652934, -0.08774814984279282, -0.27522333017328593, 0.42038302911164027, 0.08803965129863352, -0.08339190253625817, -0.05155309481333609, -0.413991102996642, -0.13706875830962628, -0.3907195644936442, 0.19529161787542507, -0.8141592835577669, -0.5262621760462891, 0.03639978053585102, -0.636484986590074, -0.3429680014343923, -0.06969647368808732, -0.37614706511905044, -0.25196087895168, -0.2828565926597305, -0.18789420843394955, -0.5200445513371778, -0.28507101644477545, -0.17388486247855356, -0.04790021136910283, -0.4034257325682961, -0.05748128388114772, -0.25371774654341234, -0.16325797644259288, -0.2493748698918927, -0.611326876012288, 0.19168993393544492, -0.02186838533543309, -0.10996005643914177, -0.5353003705125, -0.5686493402247803, -0.5340158124955732, -0.26305901652947866, -0.47510849697539254, -0.1957762850805279, -0.40005796288350914, -0.4809092902081549, 0.2026711886711827, -0.3279209875223353, -0.24739863912777751, -0.22486460592716995, -0.6000888981983384, -0.8521392830980434, -0.7230135926646817, -0.03795150726524012, 0.2616078191952775, 0.18258069152693662, -0.07455404104640351, -0.2438524961828596, -0.34352182985736873, -0.07681784192235387, -0.5274346937780295, -0.4585077854995915, -0.5266353363951811, -0.18048969277421434, -0.022386071897194416, 0.2716658330648611, 0.012879281564408302, 0.34402665954486733},
    {0.3179218679495903, -0.07148743867901373, -0.4843586373345935, 0.3140006647685872, 0.06988718908075524, -0.21347423088824377, 0.024803760487811792, -0.4190620421962119, -0.2015713642913973, -0.38805053921696303, -0.11749546766144307, -0.3791037032806514, -0.2513346506435928, 0.05007020379663769, -0.23610922143333093, -0.31447732789104393, -0.1946007446328336, -0.35921315608333887, -0.05136042137980708, -0.12386842275038788, -0.7458468132485745, -0.3885003113193745, -0.53837437293619, -0.2566379106542749, -0.07197920786907623, -0.35681845374448146, 0.11935476558950596, -0.5548689301632435, -0.5875483764714546, -0.29989987183581696, -0.4422221369128384, 0.005047567487987286, 0.23257663852052468, -0.30838075976072604, -0.11633871207746853, -0.681855879229964, -0.36714585896707636, 0.07660768010081033, -0.32833802047397836, -0.24534794046304167, -0.44253152219156966, -0.37820427616159547, 0.19638776177497902, -0.13648980934313043, -0.5375506839660905, -0.4579782415194482, -0.7532374929618154, -0.4013040033165071, -0.6362081454614854, 0.27786804248379104, 0.4693754079798699, 0.03846859586790313, 0.10167734682237735, 0.14815548222119843, -0.47470466329454625, 0.342993523203449, -0.33133852416840104, -0.36546771153508856, -0.05350927387753521, -0.3752701866034338, -0.3474719627697754, 0.03537911285434054, 0.13469355397121194, 0.298661393731409},
    {0.4082745329694463, -0.1266806492944555, -0.3079896764452897, 0.0030357472582619818, -0.0868118832281845, -0.13992439390655065, 0.1785477367363146, -0.4324488506988522, -0.5961845287672832, -0.5441396275771265, 0.1462900164337027, -0.5913193055981275, -0.43440565733141784, -0.06051175371621066, -0.20994793242610169, -0.45478957534309367, -0.04189009713984636, -0.5091431668245663, -0.20705798930837555, -0.24607377385112314, -0.5835215112642491, -0.21982615824968396, -0.272440574901294, -0.2361417481474648, -0.22743400325296265, -0.5145056862427858, -0.16891812870347883, -0.3915492998215088, -0.191628511409645, -0.04685893642737678, -0.5872906395548211, 0.19619454643046713, 0.06178243658615856, -0.5708821042541068, -0.6226646263001635, -0.24518014611778222, -0.3011339182429017, -0.4155328622568126, -0.3283223013741484, -0.6174308639267981, -0.36457023520621173, -0.4887945613706716, 0.13535964996175742, -0.30368036843275237, -0.767155381561778, -0.08833648387685543, -0.5059523772504846, -0.5586786759931546, -0.39894240669054953, -0.004904602777333251, 0.38103786680018714, 0.05685879964970386, -0.19809132628747497, -0.16082023980531354, -0.4508886947879572, -0.07245287695848215, -0.34948999980426776, -0.225828740694206, -0.09977694027141036, -0.21657381904048767, -0.30022521304831873, -0.25493561725473124, -0.036811489624501384, 0.12838058672763109},
    {0.4479988160147298, -0.14548217016221404, 0.09238292751063619, -0.11794772700610644, -0.12568883427754254, -0.22045384699381249, 0.27070694642647425, -0.21112022784094503, -0.12830553941523754, -0.24492838733378947, 0.3981156286097921, -0.6163731470703195, -0.42123047454021073, -0.2560710967574243, -0.2963687291801746, -0.1624860010641224, 0.07117460854882808, -0.5302782044102197, -0.25669184167880427, -0.5862838396341822, -0.6242531590243828, -0.1351971828216337, -0.2415256258790222, -0.45786473543812156, -0.2662131136654475, -0.21667891561229724, -0.14830267014721293, -0.13335877426477913, -0.07408442474154919, 0.00969473733535099, -0.6343210176425295, 0.27072010655639317, -0.024030585717500705, -0.40428588834930757, -0.22938073311658394, -0.4462253449371345, -0.3306339312722693, -0.33026961993431886, -0.32044833463216993, -0.4008017374349771, -0.48152672750182385, -0.2763365554421194, 0.05669182767848101, -0.38935375137627765, -0.41178793418628096, -0.26120639412178626, -0.6644637448955235, -0.2940984666904491, -0.28936537522130873, 0.1577325382549509, 0.2694959722680965, -0.1844583855954285, -0.12175794003326246, 0.024597733775072086, -0.3897261479856551, -0.03456491745517751, -0.4903720890647207, -0.3522367849435202, -0.08179440793189677, -0.12038209157341052, -0.3382534174844153, -0.4179168096234039, 0.06244075519630834, 0.22319152465591155},
    {0.20663532689522368, -0.30589776209313124, -0.1358680197132966, 0.2749624511753043, -0.17440244049012582, -0.3060896482265791, 0.12529712488197708, -0.44464084189349096, -0.5762470567888268, -0.3655654872454672, -0.06853532907773931, -0.37605779065086126, -0.6748184375052584, -0.10279904597815324, -0.4181358080055501, -0.5059843601922026, -0.1937680623996813, -0.7398190706680252, -0.13773128277474408, -0.18757299342464973, -0.4299772030371, -0.4404456632498591, -0.20701933337224318, -0.19356579489654535, -0.7128028630827995, -0.5898915909905645, -0.16359841544989487, -0.2601333209276469, -0.035775385414164855, 0.0026739501651411994, -0.38922870351492467, 0.23344431372686963, -0.5043305221951442, -0.3760079053209486, -0.6008464469216974, -0.22729115544186027, -0.7592018725156702, -0.28532116458178747, -0.4218501430491388, -0.2601514875057448, -0.4636295785625303, -0.504970076207582, 0.08854473515043194, -0.5781771914050962, -0.5555806442654987, -0.43588999766537445, -0.6711463527193862, -0.7302957843953729, -0.5352509646839857, -0.06999690039671956, 0.3518806679299646, -0.12835481853467304, -0.2093350365721074, 0.12929402524067696, -0.3741417937916868, -0.16418355943640364, -0.4377064016374462, -0.42162710238290996, -0.4825579059970478, -0.145240646209825, -0.20334940529747902, -0.5147292393793044, -0.05379058651116435, -0.27591229178159477},
    {-0.14957341701258736, -0.43965838041655625, -0.44656466361977865, -0.17231028891880648, -0.19377326240731876, -0.4661851940800793, -0.051118215794405994, -0.4434500837029972, -0.1570764806555485, -0.36481659798425314, 0.25688643028318214, -0.5836022937486717, -0.4339215006529825, -0.22033664741749606, -0.6825233256728169, -0.2866681088856164, 0.0456643060329308, -0.3711465161930792, -0.3044534861216727, -0.37854716392298166, -0.6925750268059958, -0.12353221832031268, -0.6209781160373519, -0.2714799623092877, -0.6671180641830232, -0.12700568895703623, 0.16464710524008913, -0.6168638361278157, -0.27166286947761537, -0.2911764908737484, -0.7920835294934702, 0.09282772841239005, 0.053968930177800495, -0.43670266539856967, -0.39757653882380317, -0.5147277444620563, -0.1640064082444314, 0.06652362113178913, -0.2503737783703781, -0.12100941974353395, -0.5229044731509263, -0.29106744821742614, 0.1790778803076538, -0.34611318093001664, -0.36641059456748704, -0.4424256963098355, -0.3095568273054436, -0.6547777807017736, -0.5733323990311864, 0.10628971227926882, 0.06047699106732082, -0.25639182930758886, -0.285037329282826, -0.37957666481096464, -0.5439678016131738, -0.13917679386034315, -0.3772835176340211, -0.5577857664208059, -0.5481656758491702, -0.15800922776748919, -0.36769933021018664, -0.3797154834325753, 0.05243603939226102, 0.02114710895717282},
    {-0.06679309098968754, -0.18702606923556825, -0.19160573927142124, -0.025882893681866036, -0.14628212871293642, -0.19936456018017715, -0.06196260955770566, -0.6363216251611776, -0.708408895508118, -0.5146940472101863, 0.14867768776515647, -0.7597732921398538, -0.7415013215524323, 0.17255122580255955, -0.46101996139424367, -0.379691328176861, 0.05151367800195258, -0.44982723646923617, -0.20189022023032702, -0.03605814454250796, -0.8394851259383086, -0.3526155907642155, -0.4234297011200026, -0.28867821519538706, -0.4823749549483623, -0.4277619934413113, -0.27985827793612444, -0.5789237138688957, -0.633468608333912, -0.6509122287994961, -0.59090932129831, 0.3166787902302425, 0.02901250707059099, -0.5592033378276958, -0.3925933425960547, -0.39219287505903955, -0.353589314292853, 0.08027586980829586, -0.2160264479052989, -0.4323055107830312, -0.9322151483373511, -0.20532286657184395, 0.3053000218876522, -0.1468799472380479, -0.19116830778811897, -0.12984688166916802, -0.8077370558655146, -0.48424823700815417, -0.5198993806959203, 0.4653814017803477, 0.30605368311244374, -0.05881915131485398, -0.267924004138988, -0.1096456594408409, -0.4500312983265742, -0.1582991054577313, -0.47668857493411954, -0.2659923396761212, -0.38261522629635636, -0.5601375401450028, -0.25745656555668184, -0.36389053012433925, -0.1593253762211037, 0.25417494673607033},
    {0.037320128462026134, -0.05158508824163133, 0.021770747913942866, 0.05870411666352626, -0.0815707007468042, 0.11027823117711434, 0.2915434078899752, -0.2305487622121553, -0.44413733848401143, 0.008985432325970821, 0.2977732193180838, -0.47440755683243074, -0.8258062032010232, 0.4217486598179003, -0.24919666323443032, -0.2506138898966785, 0.007041690454690822, -0.44564028992665783, -0.04327278161240886, -0.07781470693510742, -0.5892571664470416, -0.08411500096812963, 0.05138734462564151, -0.26733327764032133, -0.6944217758404027, -0.29257458182869744, -0.4180152023406247, -0.3301616557373259, -0.27270313050005934, -0.18412138920544444, -0.68834317789972, 0.29903162944241063, 0.025474519236864186, -0.3749895098313708, -0.4348898323727581, -0.4093363936148844, -0.09581263788891425, 0.03399594065065031, -0.3385646968173271, -0.47242303308059497, -0.6954668031867108, -0.1997902556172865, 0.034166093014976785, 0.14504781013339618, -0.2209431942696188, -0.12369090034943972, -0.6210372501943423, -0.1940407079749873, -0.61461996935906, 0.3254838860491792, 0.5993795010477382, 0.1009831318453827, -0.5961169581637752, -0.27119021436300017, -0.7016241584597046, 0.04111067086234102, 0.13706711909250122, -0.10756169400679093, -0.3864560406352181, -0.2506980785043536, -0.32419133388973315, -0.17230397709470785, -0.3167655667773234, -0.18849522025817994},
    {-0.0045528249966944635, -0.13105280824470558, -0.46379344811766654, -0.12451006347068737, -0.19004242954072761, 0.1132328195842119, -0.1744818903477501, -0.5914787885937813, -0.6811651546506005, -0.3258275962908593, -0.011029848705401857, -0.5694913912878004, -0.48967045943144455, 0.22829927817132056, -0.4657940445515153, -0.3186467206851802, -0.010561883887391202, -0.5179304000458437, -0.26846556005167393, -0.33655165511730584, -0.6755468043946131, -0.2953630735916678, -0.40521770437522725, -0.6894029666160022, -0.4010824671253625, -0.5209091631795855, -0.32834312162368356, -0.4658750726473912, -0.2755003155025805, -0.4345722701010921, -0.7117900806172125, 0.204957282323217, 0.17056236240123973, -0.5093524623896776, -0.748255445161701, -0.4049181241722623, -0.2960896783207119, -0.18777220662424476, -0.2768317482191616, -0.4827000324470542, -0.5884131138901583, -0.5763760077053763, 0.1701607807163263, 0.035551928686276525, -0.3518611772467766, -0.5088798195215816, -0.5483932690058722, -0.5877911680468151, -0.8356995768135967, 0.03887045623142682, 0.3894782358383885, -0.013797385756969698, -0.1482573170977692, -0.2663351405004673, -0.8771592040514482, -0.14422671791875277, -0.210073726368752, -0.23625637126129506, -0.8439566535364604, -0.3833281440600383, -0.23864061730314928, -0.32475516717810976, 0.054512043059763475, -0.23908857038207154},
    {-0.07233382583765774, -0.20575377929554495, -0.16429929831656864, 0.000338396897913626, -0.070216816624263, -0.018374543162124394, 0.029119319883577417, -0.6012420259949686, -0.5151643007838277, -0.5577515345772748, -0.11290449211738192, -0.5647218783911949, -0.5984032170441792, -0.07993638229764985, -0.7130205752177192, -0.5612793399054348, -0.14119149152126564, -0.5990344740153394, -0.06634523731459266, -0.5153920601261787, -0.6784135527413506, -0.4723924761084218, -0.5583806722512461, -0.5021187501646527, -0.5183541466808577, -0.728306305720982, 0.032886109156032454, -0.4880987052069607, -0.6437203505563418, -0.40442681243220585, -0.49717501952703896, 0.3293389252086773, -0.3690610827643217, -0.3151519118750496, -0.7779729230242275, -0.6093406574994211, -0.4964057435592389, -0.2438409045252116, -0.5018487413508842, -0.5446651797033354, -0.6264596690673082, -0.32669971166127926, 0.5624668588848764, -0.3477174030801867, -0.4480309965730594, -0.5839161987978929, -0.5056325126661878, -0.6250249696207827, -0.4923110106297747, 0.1802643557816273, 0.6088823025674629, 0.1285047349729505, -0.47384297004808396, -0.3064206568834072, -0.36846759350874403, 0.08529653064224504, -0.558706663288475, -0.48902720844598696, -0.6368494876538418, -0.5039412863936169, -0.2158700833808366, -0.28197708744691313, -0.004919371905114025, -0.0028708025834412966},
    {0.23449486206659326, -0.32399555120006157, 0.012823485505043402, -0.06086568608180958, -0.2979720661818832, -0.07879973532115929, 0.05820683784041996, -0.4583274074003202, -0.46357888524621993, -0.3367175581456955, 0.19797845097589475, -0.7600010953041382, -0.930206753720701, 0.13305729463688254, -0.76064275925861, -0.5723484302732383, 0.04588617404338814, -0.8723540633749659, -0.5498058670871521, -0.0003789866705317754, -1.0584480016634052, -0.5038577280861081, -0.48531470954862704, -0.211652593523624, -0.42292067252851734, -0.4569503950008671, -0.31493730354790017, -0.6235592252985819, -0.348045018155262, -0.38901163662030136, -0.637554957036073, 0.21593693232057337, -0.35963355633861976, -0.07597817006514589, -0.7465093120575891, -0.5337145025946247, -0.4407703765099345, -0.25099473832513425, -0.5476584405545423, -0.8189206938758828, -1.0223532767682326, -0.5249418343878938, 0.11672701740242909, -0.24645695586943397, -0.5005197605457703, -0.65306091067155, -0.8270440055428557, -0.6699227931044499, -0.4045556862936963, 0.23046377138305513, 0.41703437818263345, 0.08165008644263005, -0.5862915980719626, -0.36736770775050515, -0.44199634506727825, -0.2552476106789448, 0.01921486229942054, -0.7178395308180751, -0.8452635613358257, 0.04573916422703315, -0.40562103234665847, -0.7486851048094263, -0.43805816884778165, 0.013498299188488806},
    {0.584878701515598, 0.18502654385133174, 0.23431262203795652, -0.13233885293892686, -0.27123462114977825, -0.17183433656367536, 0.36642906140637327, 0.11684600717092217, -0.5112333737483101, -0.17985029603786287, 0.3559025765950523, -1.0061722476408994, -0.6414614895584418, 0.4320333452954059, -0.29631770759228615, -0.38440167591982544, 0.19930059599037983, -0.6948810460500817, -0.5497232710210952, -0.10894885838836028, -1.1322997464618716, -0.10468537315652514, -0.15027369288662917, -0.38886378654500015, -0.5874562147838553, -0.08505498681486512, -0.5661149060013444, -0.7224104208296172, -0.07069459243391074, -0.002202232329971385, -0.9102249812077402, 0.38447444246295637, -0.4116051347892076, -0.21883149054773135, -0.7940294169744044, -0.14038018573543334, -0.20599811820204167, 0.25384949135243734, 0.13483578501622528, -0.9999400974206762, -0.9842647429117276, -0.24770162730383977, 0.311389096160032, 0.04895092162084343, -0.0011073475318643942, -0.46102444792084646, -0.7428281690283927, -0.5185860648505517, -0.9187043201503957, 0.333592535235822, 0.44644775515784385, 0.004533228753366, -0.8513447638899713, -0.34006931157835907, -0.17390837012782878, -0.13545599134336006, -0.17792032746060718, -0.31594985546167376, -0.7885652928836011, 0.17157360858411652, -0.4618909787750904, -0.6643966085666604, -0.23096538246371326, 0.15102793713557633},
    {0.19916006466966105, -0.03514661295215568, 0.11032655673609747, 0.09556582362319913, 0.10566894550893224, -0.2851498925342366, 0.03758162342851488, -0.1147475948761993, -0.6458238106244427, -0.32510194561673467, 0.14086649221583916, -0.6959798845450504, -0.7427790970913715, 0.1292448706627733, -0.7100052680305008, -0.4893752427711039, 0.3922467441009986, -0.8293080958429271, -0.5745139457610562, 0.13773022582703304, -0.9214578153919801, -0.04566201192814316, -0.29065920825880026, -0.36398435459122097, -0.5756128418045356, -0.4615732492087352, -0.4638161833467186, -0.7452876885419458, -0.09365764102541929, -0.36647719048884303, -0.8583812496945271, 0.24042521614654436, -0.4188629094783764, -0.4260099566254683, -0.8147086771148273, -0.4284417025038086, -0.3091540293817015, 0.18251770202390907, -0.11750002356568653, -0.9461392748681057, -0.9823428480908384, -0.16310894845580326, 0.587756669837559, 0.02075588797931029, 0.019190583203859236, -0.4109554855067777, -0.8513791033083141, -0.25333072081728336, -0.8961741816377425, 0.22343794806381023, 0.6624958605097223, -0.07336664364876755, -0.5942223286855935, -0.3525155645916163, -0.36898460750143675, -0.1883606071574721, -0.18326651906366856, -0.553105383303712, -0.6577461738135233, -0.059721403625766445, -0.15181074362205643, -0.6181172836175577, -0.12419566449208022, 0.3356294125931608},
    {0.28449895769522304, -0.3797803506637415, -0.2619968690514089, 0.2279171476549441, -0.3862026663448612, -0.5381275609494717, 0.017318030419761214, -0.6907940594103552, -0.5357647902475928, -0.42279324333328266, 0.1040571825160173, -0.5418576607142632, -0.8418183902292741, 0.045791952424262074, -0.5544883102432717, -0.4948974506698464, -0.043185442171872944, -0.829089693379188, -0.46829461737441186, -0.08221424849276057, -0.7328092375135202, -0.21933694791837102, -0.37482965357349857, -0.468144470564725, -0.5171067563515459, -0.5162635724925166, -0.08074760124800584, -0.7560677581273706, -0.5309377250721307, -0.40756550785044016, -0.5611446247836261, -0.20443946224100445, -0.214718005544693, -0.22222317735554756, -0.5791744564441501, -0.5457305286197736, -0.3290844489133509, 0.04934455449910437, -0.5415047603553118, -0.6436061766415646, -0.664688280335202, -0.2500449336778589, 0.16413996519415047, -0.33241645561643535, -0.3315420280768681, -0.3171732819772522, -0.6040571999558468, -0.6762657437007172, -0.6207640084456758, 0.2778285724808466, 0.5754012375364739, -0.20565986019061153, -0.38953495313565284, -0.2655363782382034, -0.4785223233140286, 0.06481552610168828, -0.3450077471962827, -0.5143170948033751, -0.3978484125956281, 0.011408785563190051, -0.0882229266126566, -0.23481871213532152, -0.3369487563375407, -0.12897224471540036},
    {0.4455360578684079, 0.1336998743961303, -0.03672450021113598, 0.0519618766774617, -0.4214385193809975, -0.07071180058937147, 0.09331893140269776, 0.040779488924724355, -0.5624221029337663, -0.3825743983121663, -0.03407797582159086, -0.3752159111877607, -0.7630879028712946, 0.2158946886838043, -0.3626314459523327, -0.16906039132770484, 0.46377846920390325, -0.6557451860400003, -0.5979733426083308, -0.0444177417672458, -0.9886245810220601, -0.009803672409566403, -0.17941971897253486, -0.05730918287393581, -0.6653561705168699, -0.13413446657620684, -0.31102651513338053, -0.5239855197707832, -0.08527117191679304, -0.39187214515323243, -0.614721100984855, 0.3710619103833017, -0.6593401226878748, -0.030160301438934913, -0.5698968879680062, -0.37385536788823265, -0.1619980581083509, 0.17897196339879073, -0.0026817404189232643, -0.9263655197077864, -0.7464371471961677, 0.16863640682651038, 0.38133870130104786, -0.05651667135040895, 0.2900426099081683, -0.24532531595670531, -0.6058109532220846, -0.4757001303492536, -0.75537554585379, 0.4343181667556327, 0.5790083510162745, 0.13594088040343708, -0.6961392904683981, -0.2784297030378715, -0.2411231385336289, -0.11829603628744104, -0.08771223651266453, -0.021074317607179344, -0.30409644274692393, 0.160060515853183, -0.10022156431073632, -0.6018461073122788, -0.3000540224810731, 0.2165895444009239},
    {0.4302044166396024, -0.05815601736619798, -0.26301893566691864, 0.2123560826753726, -0.29647360683157936, 0.31907665817177855, 0.45587026335389025, 0.0365555954975903, -0.6117775277318082, -0.20151995688496302, 0.30953118313981454, -0.9929737178623701, -0.6950385916134943, 0.3463690090016858, -0.3561319383104961, -0.11956115038213345, 0.3653151302077291, -0.5792953755331378, -0.6863969789101658, 0.36974311434144375, -0.703724417629379, -0.30503910743494683, -0.033002130552162966, -0.13515457094268804, -0.32609338096045415, -0.327331907040063, -0.3059624262691276, -0.6397811676600758, -0.11442099550271397, -0.1691570345983054, -0.7941987661256001, 0.6965633860532071, -0.38376132115485223, 0.05002025489281814, -0.8381315809436436, -0.41943761954055575, -0.5025866218938972, 0.254359179847261, 0.5525890926246366, -0.9812564006243605, -1.0816904504872686, -0.29110229212596217, 0.5218646475192305, 0.18724774844352055, 0.028481791916155453, -0.27089266722796723, -0.6457459917823044, -0.222126119885497, -0.9063587940844762, 0.44181714560272933, 0.6010241801000938, 0.2705057160669895, -0.4962362449311262, -0.5167696792038354, -0.011610793347697735, 0.14976010794351918, -0.15347180179156525, -0.6699594697132165, -0.45390147040736395, 0.19609629278516352, -0.2458051077595946, -0.6749369339094045, -0.10894698600702551, 0.361642729269838},
    {0.39363877625920757, 0.011859936843106182, -0.0013406400593335725, 0.032841729353724376, -0.28266924900857193, 0.11431770178992667, 0.5622683465514701, -0.0940257601274965, -0.9156096820957487, -0.2722420078773313, 0.2297404948346816, -0.704819358847272, -0.7652110220972768, 0.12463988904582333, -0.39255926620975673, -0.46846540742221693, 0.44154769282320844, -0.660470649023533, -0.6349849389249048, 0.16792578955794835, -0.9221733510705444, 0.08655818343523032, -0.27225087573910195, -0.4125453177233445, -0.6511689268515056, -0.5820508950455469, -0.5295095020994016, -0.4834362253376405, 0.0501873767823406, -0.14371819879128894, -0.9084291342747346, -0.06681726899053292, -0.2636213153945984, -0.4739896686286351, -0.9294600007386838, -0.6081063176473511, -0.551360755703297, -0.20700915023336214, -0.08758644199026792, -0.6345594533027271, -1.047618383326085, -0.18650400755141733, 0.15295975928454866, 0.036084146777163165, -0.14735202788436833, -0.4002518171103182, -0.8308143247819803, -0.569170096177705, -0.7700505785044703, 0.4534357355118872, 0.46289811081517795, -0.02470342106818464, -0.24187111528309704, -0.0954704101314007, -0.3978794960402863, 0.13038959106028733, -0.12830815026466708, -0.22460133654530018, -0.6458555932168142, -0.290272313083451, -0.1229705933235132, -0.6097536089925754, -0.17207111629463087, 0.058137366565911494},
    {0.5457141094222628, 0.26071659150239634, -0.16112912591377873, 0.03201744359561911, -0.6116677311906679, 0.30450637287660065, 0.22450189426832548, -0.2843531320330472, -0.5606295209111983, -0.3865548712691396, 0.3611775460926807, -1.0130014485507954, -0.6500188740464649, 0.32966110410231425, -0.7503166008600193, -0.45858569858482207, 0.30287630350506967, -0.6523610026701601, -0.5917509979172655, -0.008006472402626403, -0.5857720828849046, -0.05551490301215551, -0.058297242621670936, -0.23468983350078437, -0.3732810856066123, -0.41447800428510717, -0.24594631503235564, -0.5624371541719568, -0.3236918322910658, -0.20481313555009545, -0.971026889394466, 0.2819709332654262, -0.41744574917444205, -0.14468324264476695, -0.7442288100667307, -0.5772974603665977, -0.6002711564384983, -0.028753562788912567, -0.1083136342469134, -0.7724736932986437, -1.1497087478148469, 0.016695326884379164, 0.445233491684766, 0.05416778460460171, -0.03533797027983522, -0.5145447871323018, -0.8654364606326368, -0.4640888389639938, -0.884421208736696, 0.5114058036018815, 0.5290506763786703, 0.045313776003149404, -0.5373371580138552, -0.24702075301257864, -0.06634154000439547, -0.20579218429514903, 0.14579929244098833, -0.18166310048373913, -0.5918515672186144, 0.10690378547113862, -0.49192958222269056, -0.6106640994707275, -0.11888869921877146, 0.3092645262016192},
    {0.4161092914481107, -0.22621384908393086, 0.02549145495430358, -0.09648277923924643, -0.3157742885814918, -0.19407295877089503, 0.033986898675781335, -0.1826202298861643, -0.7795826934375623, -0.30935219803673436, 0.16930895913106278, -0.8446107933195991, -0.7431156387385366, -0.20323369976282368, -0.40414467950786753, -0.3917536879508512, 0.21897248062380417, -0.4329366450931337, -0.522056419643314, 0.024721641239304863, -1.0114234729521716, -0.08971227066037056, -0.46308599718348753, -0.3687739444588209, -0.8715190490315449, -0.45350370179265825, -0.4282805318274495, -0.5901801818411025, -0.35959171140404933, -0.13855708602771366, -0.6230216396255843, 0.2994905389950477, -0.39430310275927893, -0.3164415089246827, -0.8437717033425118, -0.2419371391438734, -0.264514620657725, -0.11098683308373611, -0.2667126484807435, -0.8064904203996928, -0.9265109144182174, -0.1259225280236474, 0.4435343106467125, -0.08027402853846012, -0.07611802141369671, -0.427442933134663, -0.5239829672931711, -0.5184098162648826, -0.8684560544722947, 0.4224351005677771, 0.5293052991709193, 0.004290846894696469, -0.7725025161707455, -0.27831866882666945, -0.14561016517963754, -0.13973340455901712, -0.284279778991701, 0.10516880255582169, -0.4692177883956692, 0.24880462466794337, -0.38867518260273165, -0.5899816767817392, -0.19145538212419622, 0.258986890889302}
};

static const float b1[64] = {1.0172251236276812, 0.824676679589252, 0.9316778056364106, 0.9245265409477423, 1.0157635894380872, 0.9416937329188562, 0.9576787829028379, 0.9649239855260217, 0.6195351285455419, 0.871240051242814, 1.0217528832718776, 1.0422087449660087, 0.8550653370069433, 0.9553560399700358, 0.9086820491015845, 1.0053039138494457, 0.9695499829673341, 0.9667639918057527, 1.0248053259262995, 0.8658714143679205, 0.9598149001239826, 0.9225287242567743, 0.934299791452092, 0.8441405768447469, 0.9565682451810306, 0.9400268331081547, 0.994251061266447, 1.0583200617546766, 0.9427239407962404, 0.8337483691986101, 0.9281883942098496, 0.798051977351098, 0.9363465000259696, 0.8890398145726666, 0.9550304457179627, 0.9035808426871385, 0.9289892173765544, 1.0102398002230142, 1.0168863942171973, 0.9811693551242444, 0.9280483776791333, 0.8319270600105877, 0.9675699063715492, 0.9024820098445002, 0.9155848172752802, 0.8414520441508293, 0.9815340370551358, 0.8629881109237934, 0.8752594024019238, 0.9874366351431646, 0.8907256264400761, 1.0404511678298036, 0.8037445322777136, 0.8746585105028246, 0.9921273088358095, 0.9129212653992191, 0.9195767994993889, 0.8656849609898447, 0.9099833125322926, 0.9181034458813052, 0.6619192481244569, 0.8349971733271918, 0.9182376551455429, 0.8912674901914369};

static const float w2[64][32] = {
    {1.0082352643117187, 0.6352859998955872, 0.7321655574681551, -0.29088748516327145, 1.1054730801455461, 0.7314339238819321, 0.5877301757003808, -0.3638269642510367, 1.2977543218302676, 1.1937211667152192, -0.3049667606011893, 1.4170998416174472, 0.48779260520793, 0.6738733772835017, 0.6379858627063156, 0.41716191670056874, 0.7590274594294457, -0.32942000714908803, 0.890456985589106, 0.05865655711606842, 0.6644208672746172, 0.6416703812833625, 0.6312849121321422, 0.4802747611273718, 0.5971389970463089, 1.1593684059114957, 0.6833786512804866, 0.6590583008383928, 0.7061005812986003, 0.8409107579842672, 0.6462164081068954, 0.9908436783549144},
    {0.775984782692497, 0.8516779136456908, 0.9266629852543665, -0.08450610166062543, 0.4243602107749473, 0.5961917384446626, 0.9304809999971948, 0.4315849350146248, 1.1051699653947267, 0.6063043466214504, -0.16620362966871413, 0.7566466812223502, 0.7333647930679207, 0.7668705474007826, 0.7546896479393954, 0.7869777444889365, 1.0071841756431008, -0.013139061371759058, 0.535585239114028, 0.14785528950526167, 1.0076217026258008, 0.8864210070808917, 0.6912278389361238, 1.0727001520441617, 0.8092644108039212, 1.0402658722786415, 0.6206786393536253, 0.6190093066870179, 0.9748911802178132, 0.7067104171640175, 0.5520498536555033, 0.9259645841192891},
    {0.8179438818244488, 0.9845801408850668, 0.5280000019921426, -0.2367164074008137, 0.812023203154808, 0.4740904713575698, 0.9787993455021028, 0.07115274024843164, 0.5807340770962556, 0.8123440365810682, 0.10718316345217478, 0.7513279988980468, 0.6048504185215271, 0.6854712992333082, 0.7189696589190735, 0.9926011962611252, 1.2919015721250768, -0.0636170672761409, 1.0765018282887466, 0.06935896532097423, 0.6379649334658096, 0.9006866669635123, 0.7302390827810902, 0.6356331776950144, 0.862874238381673, 0.6966009279702876, 0.9941029288522848, 0.7712384225333578, 1.1140547506260217, 0.7805007248345169, 0.6975895733737647, 0.8983800183429911},
    {0.7767039566923686, 0.7320609111460347, 1.0217129336086563, -0.0094662324220952, 0.3252319797636201, 0.5788364064919346, 0.6939143925556855, -0.1439102265528591, 1.0178330275143683, 0.7566065055468209, 0.20944091071240234, 0.5080748050161477, 0.5777969100616968, 0.5051812455170596, 0.5474320445879144, 0.8466404593728128, 1.0055117938188995, -0.017520971243966555, 0.9051400252293507, -0.07484786921398356, 0.7991316095705208, 0.810093720945684, 0.5667306662158417, 0.46777905298008854, 0.6129288690204667, 0.9287638844483203, 0.8647431145422967, 0.6361237288364566, 0.5195874498974998, 0.8609028723090468, 0.8311340539198361, 0.7327376145161167},
    {0.9351487886377751, 0.45254435497213186, 0.6776364606913388, -0.13429142898132168, 0.873459715599388, 0.4181671647732388, 1.0660492783882862, -0.15175570139433148, 0.96847081757519, 1.0264347831600764, 0.028063305022125562, 0.4846635598450625, 0.6702629784932675, 0.7418612826644565, 0.7349998083548398, 0.9348504214320642, 0.8489543061441706, 0.06432354531067237, 0.949192676212454, -0.27818370852032126, 0.785931484007697, 0.5014520293596, 0.8738827327184903, 0.6184791613316212, 0.840505063023472, 1.0433173959445967, 0.9867983823467082, 0.4441803667031352, 0.9616623875414043, 0.6081247663964582, 0.6687340843190396, 0.8871890921833643},
    {1.0185699560324988, 0.7131701646152728, 1.0104840636255077, -0.2791459283178556, 0.4386726050392739, 0.6051890843993695, 0.8625758792174342, -0.37397932956439645, 0.8224114174435544, 0.9094008723240351, 0.1308803864981829, 0.9244009757157448, 0.5395769884536643, 0.5693899338667595, 0.7966251924176929, 0.7338380655533956, 0.8831166632368419, -0.06137271472533027, 0.9290159873193106, -0.27711382403190465, 0.8409799895375254, 1.1502597526975533, 0.8332567844349157, 0.5705045290796007, 0.6159867822899099, 0.727887792034561, 0.7282899682960721, 0.9668438601645133, 0.8299568682877231, 0.6790741876380225, 0.9878574735551738, 0.602403922916446},
    {0.9191697656549003, 0.4835996083566009, 0.9343864611916571, 0.04282241944701165, 0.44465343757813547, 0.5408689021773896, 0.8200949086161521, -0.018171687247579553, 1.0484092598028054, 0.9393421987743018, -0.29133125862455994, 0.7722292155612124, 0.5244706254664138, 0.6270012597998693, 0.5056705874081315, 0.7761848252672227, 0.9463783856879641, -0.33290457586115907, 0.7752542242799321, 0.10228706617830276, 0.8190516967988799, 0.6290576074648181, 1.0411622124088156, 0.9532348958311918, 1.0153360347312572, 1.0508348837731665, 0.5204255171613406, 1.072438003895663, 0.9601062744173254, 0.7840424883899612, 0.6618562432905529, 0.8317702175826879},
    {0.7362724366970349, 0.5648294145411897, 0.5654770522756409, 0.29620358932876, 0.9017546896872726, 0.7843016967170895, 0.8589539923930315, -0.11443552102343706, 0.8466174897644646, 0.7167023842727064, -0.200481339038669, 0.5806053681748107, 0.7339218023106763, 0.5406238321865184, 1.0270293533362327, 0.593363459364022, 0.511071273210303, 0.020786018056955683, 0.7487809977117816, -0.30142268629854274, 0.8558531998746733, 1.1953355900517049, 0.9615489321479812, 0.48917016375899397, 0.1386114564859006, 0.8807310886256919, 0.8993670718363597, 0.5329171785070564, 0.9840103714466926, 0.7827210571734761, 0.48331557303720357, 0.5760340667975993},
    {0.4321486383077529, 0.6278497760560977, 0.7308993736113608, 0.0795216337680982, 0.31421999086291225, 0.40867577939905103, 0.8718687817375721, 0.02249885111935937, 0.7934264043447976, 0.5800142083296627, -0.03300899723924075, 0.9833590384171006, 0.588021021946943, 0.5183999860077788, 0.7147915800389046, 0.605966444739533, 1.1322450100353403, -0.0038461682368488136, 0.7612843526719424, 0.05639284973540931, 0.7241535704933609, 0.7849296136039056, 0.4560497027865334, 0.6274219554812908, 0.660003969190751, 0.7398644595281525, 0.683586259598069, 0.7579025141116724, 0.7028531319668865, 0.7418715974335458, 0.27627172399642425, 0.8203796171106654},
    {0.9647115747283013, 0.6218136805091603, 0.8393059367968821, 0.08184941672022128, 0.673953878310345, 0.6915041169735315, 0.7153391717045774, 0.21475540739335344, 1.063294546416445, 0.9104741555574666, 0.06016933146788941, 0.7455404338810719, 0.9310898110911695, 0.6751019429783571, 0.5943311539035749, 0.7601088790970463, 0.6755881776567756, 0.06090338118934505, 0.6165890006456224, 0.03161127049222358, 0.9312851974473063, 0.817747423699524, 0.7790462850080139, 0.9680870190481037, 0.9291120254085509, 1.1658892592365178, 0.9389557514560334, 0.9380887387080133, 0.7197977157663727, 0.6776123336054084, 0.5876426557284011, 0.7928150183435909},
    {0.9919051678103035, 0.9201918100609755, 0.7004444157574372, -0.1591739432611797, 0.7545796031696235, 1.0015091367506694, 1.1037203320442743, -0.17112988354096342, 0.8553907549853881, 1.0438103602347946, -0.32766348468350154, 0.9177460317080444, 0.7361997334880602, 0.6628243445243137, 0.49836309382883665, 0.6258931891894614, 1.2223821829755896, -0.18257759417047628, 0.847346082212196, -0.006616609110655562, 0.7245766546086916, 0.36524840488267935, 0.5238211842285891, 0.5848422940271075, 0.8506319114525139, 0.6838742266689021, 0.9915794718210718, 0.9101945845448411, 0.957737426472217, 0.7838634722428924, 0.9157308902666729, 0.8522312882768484},
    {1.0576104425642676, 0.4969113506814434, 0.9040060210631611, -0.17496665606413028, 0.1567475432582775, 0.763272342895281, 0.7424221271869463, 0.07567368898587354, 1.1996500831990276, 0.9309678331006012, -0.21360521004899283, 0.9861989055169353, 0.584884586626036, 0.9891199943771859, 0.8366782879048669, 0.6456956715499429, 0.8863118168900914, -0.3245959595513847, 0.9045201973712639, 0.2767126490580165, 0.7430939574176881, 0.9141512325223279, 0.639729304959866, 0.5485973204347129, 0.7909107994798774, 1.0473337178046402, 1.2020190931607755, 0.33513433287453787, 1.010666231289526, 0.8540845838107249, 0.24368237438515788, 0.9572521254665235},
    {0.7552401116751138, 0.7948070370622157, 0.7017335943696578, 0.1252069188985958, 0.8281363133446686, 0.7296299969077475, 0.8034100725161892, 0.19494600091711478, 0.8395569473565206, 0.7236660590844484, -0.14198521787447324, 0.8059973533397976, 0.5954483261035757, 0.7974934813701293, 0.7055759661224114, 0.8276031441551396, 1.2360524680154907, 0.2311409589422655, 0.5623241026898484, -0.10528608160319293, 0.7046668808450338, 0.7660942350518742, 1.0401848020384428, 0.8360427017894289, 0.7704285788593556, 1.0920137417836873, 0.8249429235552967, 0.7399427168693903, 0.8171556422554898, 0.8557430445052094, 0.6131092812865153, 0.7354113053388824},
    {0.863211042306352, 0.6940640707533782, 0.8192306492051374, -0.3882809210913723, 0.47374171860919145, 0.8294458227244844, 0.497560773538756, 0.16583339149811396, 0.5983772763423465, 0.9492298687031033, -0.19162851843625192, 1.37529390788707, 0.7994625918413691, 0.7709197146947091, 0.7722721345781445, 0.7992888056335896, 0.9072522001921464, -0.5035563096073932, 0.8207241089849927, -0.260325467472497, 0.38616676966869107, 0.9730294321901359, 0.792824663953075, 0.7772737633081891, 0.5969155718495669, 1.048322464952586, 0.8375584050499232, 0.612320674294995, 0.8306879038875136, 0.6169938587146256, 0.7203589143822775, 0.6352003189668436},
    {0.9956166086407229, 0.8437219913997527, 0.7440316712067641, -0.11359454097184836, 0.29200570946579363, 0.45612420663117287, 0.9425034494814417, 0.07677561513256524, 0.8183195449579207, 0.6930975143991658, 0.06118926474337515, 0.886861117049966, 0.391509644172376, 0.7216067025263294, 0.6418422849873449, 0.49206475205166744, 0.7538887770945037, -0.1579485714831881, 0.7857001228945252, -0.052149880936558646, 0.661966331948926, 1.0289443115193382, 0.9980689790061206, 0.7743698774500086, 1.1535423356497014, 1.059489850053246, 0.6304428124131362, 0.8142986489153292, 0.8469404307067911, 0.757536134871568, 0.49791074196058976, 0.6807614437174513},
    {0.8087862816260583, 0.7233470399830425, 0.7814673023791503, -0.21359660276097878, 0.5747210621528555, 0.7617625586197683, 1.06039138652093, -0.09621453537481998, 1.0086079366985594, 0.5019187030420433, 0.026173717645143944, 0.7077606150121245, 0.7445532286202682, 0.6187264645640759, 0.6127776778332564, 0.7112453742013711, 1.070329257764974, -0.10503633202511842, 0.9310227513080941, -0.07813664375256214, 0.7009679191312712, 0.7657225176135639, 0.6879782994777267, 0.8275703052824919, 0.7255511899441367, 1.1105846394263337, 0.9838855234517554, 0.24887265113036833, 1.2386597625816615, 0.5938832027757643, 0.44147916311125524, 1.0093186475232667},
    {0.6877898908925872, 0.6695644732474552, 0.705319238732056, -0.03136352244442922, 0.8765437470243318, 0.7629544442618512, 0.9327564172805499, -0.27697144396739526, 0.6138543516432176, 1.0544034526294745, -0.10420697644638895, 1.120608401857612, 0.4434374193863918, 0.5238510693535161, 0.9100731714379992, 0.8975396933333027, 0.7043320011939315, 0.07744117393335785, 1.1142993976704645, -0.1640890088472687, 1.1007844601635524, 1.1067079262038548, 0.8669909580580498, 0.687261470577833, 0.5057881048004094, 0.8052733311511913, 1.05613141817074, 0.4190032999136409, 0.8967847148771041, 0.7282694331209653, 0.7303749006174323, 0.7908542656703336},
    {0.9606273943869853, 0.23776348276322218, 0.9568318086430199, -0.26337455157869055, 0.7287077214278793, 0.542499049549203, 0.8116495330950535, 0.22914038186536456, 0.9810098586737026, 0.9148249819999612, 0.03848200584290098, 0.6238379337174318, 0.3772648510522033, 0.8796768051458679, 0.7370760526029541, 0.7111599110593049, 0.5797413718149859, 0.21920874143708963, 1.0790819716279456, -0.3310268481040174, 0.7497359077116351, 0.5792564881711519, 0.853810053831732, 0.5671619779461315, 0.41854535199775095, 0.9177023076818245, 0.8043799508542695, 0.6090260887411381, 0.874737590612739, 0.7740330545550348, 0.5160199110219061, 0.5730596579859886},
    {0.9500445865746563, 0.5971927627452344, 0.6705092827914985, -0.4318234779252724, 0.49188600763801743, 0.6980760364839882, 0.5951002714416344, 0.0041232344756512475, 0.7873016069947523, 0.9121873085007459, 0.0435153194032005, 0.6463912785091681, 0.441004933263074, 0.5732287890432884, 0.8524864404537134, 0.48039483473604466, 0.7484750091422178, -0.14426966330605448, 0.712967577706067, 0.06382327377409949, 0.4467631016241239, 0.8545291830923932, 0.40794932427550773, 0.4259770430923761, 0.7397950295835446, 0.7282531114845039, 1.1230739619546948, 0.5634770247267855, 0.9864541639888067, 0.8691391412254283, 0.5148066753609544, 0.576144333606},
    {0.4529065641890632, 0.5571777670701672, 0.899415441399339, -0.01439543216295773, 0.4994447718902601, 0.7404488519100446, 0.8989374269652934, 0.08454264568150219, 0.563505189058632, 1.2082857308800146, 0.03392232759358222, 0.7936499489879891, 0.46780999877796453, 0.5701071174279709, 0.8562268561926274, 0.5614901539495931, 1.031655671103196, 0.14789220052621477, 0.6850301188956471, -0.11771287254413403, 0.7878000708733414, 0.8650144533674912, 0.7077768956966833, 0.9660462275511318, 0.5852288497354635, 0.8036523130578281, 0.8919334883075609, 0.619685043675207, 0.6436874343856754, 0.6834047661174536, 0.584011124157586, 0.9596014092479958},
    {0.9017077940490963, 0.4944514132854323, 0.878852159065866, -0.09924870481965853, 0.26535598269476235, 0.41503612792164196, 0.6862513760428646, 0.06845632307221373, 0.7161303442422752, 0.8469881878489703, -0.13765234968730108, 0.8166585476533199, 0.5988254001319167, 0.7683647872994365, 0.8557405945802955, 0.6207574492462363, 1.0744464625021248, -0.023537860606828602, 0.7256988786849602, -0.16594767242183306, 0.642558271149555, 1.055876593250803, 0.8649745754417715, 0.4732032877339755, 0.9075717037025234, 1.04098825103558, 1.1270381520508461, 0.9384427878013794, 0.9770351306482403, 0.6280756505278119, 0.49722968976946097, 0.74128790636679},
    {0.8128945878346171, 0.7878699297779607, 0.8254926921860737, -0.16488518595299614, 0.7807085403562268, 0.4797750351813726, 0.5634591640758699, -0.12405579481237866, 1.1606824467222314, 0.8892192496689755, -0.12567196671536368, 0.5007220406945743, 0.2449860586232711, 1.0255890447160059, 0.7969889006134906, 0.6545458722912776, 0.875899485491374, 0.0028349721372652524, 0.8520013156102574, -0.055203028124083585, 0.5937473815230734, 0.8605189905887617, 0.8856518858113505, 0.9207691146082191, 0.4500261638771745, 0.9255615594386647, 0.6838285465520249, 0.7800662953081491, 0.8807904030743244, 0.7517028363918944, 0.4575170985444935, 0.9649549284254978},
    {0.8914000013099712, 0.7602690050193487, 0.8262315863829944, -0.23596098812266447, 0.712562609250509, 1.0184596577797276, 0.6393071263483322, -0.1109524121997887, 0.9386554721133854, 0.8439184002428234, -0.07102303673665566, 0.8266479438092781, 0.6212546868716381, 0.5426328228194589, 0.8798342259402225, 0.6334819006279537, 0.9036772083251879, -0.007095746220265153, 0.7353761313961346, -0.05319714048974476, 0.6609651443782082, 0.9017616832784265, 0.9608619128490213, 0.5220582997790434, 0.7476468314860204, 0.7826419356771506, 0.9659498508962221, 0.6566604393220622, 0.712216613913771, 0.7380287425675341, 0.512822220256296, 0.765453507625479},
    {1.0055111878619527, 0.5148954180586219, 0.5000349528127829, 0.03093347673744341, 0.439296145729394, 0.508414099334202, 0.9834983089449036, -0.17560057744967913, 0.7099833202473125, 0.8437861601283786, -0.40231584210915594, 0.5973492496055363, 1.0927256220570747, 0.8929772737536115, 0.9148503799368118, 0.5637539379389661, 0.6768017659416901, -0.03404662481650517, 0.6977614314180609, -0.24428408031439297, 0.7333181804446464, 0.6651786437957151, 0.6607051124123796, 0.8102002801076229, 0.9795330385303973, 0.703986536788037, 0.7733873086387916, 0.6993594929377466, 0.9989532036677998, 0.46511324276992827, 0.5248269507333495, 0.6883884825519634},
    {1.0143128176207667, 0.7757888951684894, 0.9104653394880683, 0.03894645563229539, 0.6653246622385153, 0.34467353237004994, 0.845920722040563, -0.4941105571612327, 0.7658894974072694, 0.9350016395992901, 0.15868245774196235, 1.1311686659913966, 0.48251296153645445, 0.6624974836399807, 0.5956630741858693, 0.5344717077323691, 1.057708945463608, -0.040771423241401955, 1.0059094046275403, 0.042537483675500184, 0.7805344814877236, 0.8128204031431095, 0.4614226205086143, 0.7966451617857986, 0.7086018598768856, 0.7526473403688417, 1.0761199204691865, 0.554748087997205, 0.8719689061584005, 0.8935923579147181, 0.6072665632514694, 0.6388898186586253},
    {1.262472515689855, 0.8171552958153199, 0.7887161018218309, -0.03512962460997716, 0.7002306919058803, 0.6899425037349677, 0.6520350040431439, -0.2724209499813019, 0.6275051666741592, 1.128679468224669, -0.22505447657016406, 1.0458621367475944, 0.5656580454918874, 0.655182792890192, 0.6853686987934537, 0.6331412024810296, 0.8598736275535636, -0.3438588199810802, 0.6453736120610887, -0.09464174379129511, 0.8780625906481855, 0.8051829260088366, 0.9439161877278837, 0.5588698600187104, 0.6555094878450161, 0.511034699368733, 0.8938806338089337, 0.9447375854949482, 0.8171841836651058, 1.2817970406934327, 0.6988883494995771, 0.9439924496680528},
    {0.8533363373512329, 0.7856690376805481, 0.8759206629843967, -0.11803121677142092, 0.8073275883062303, 0.66120791059467, 0.592506667650055, -0.11598850993348625, 0.9081061600644383, 0.9936971561507438, -0.20751547150439875, 0.5287572248386534, 0.5920862482811845, 0.6489855202850154, 0.6402008188745726, 0.704092093278123, 0.6310129911222916, 0.04973187184575862, 0.767203628932899, -0.16407020635839004, 0.8061898516089139, 0.727125788613317, 0.7180456969130625, 0.6646669283831964, 0.9371365572177627, 0.7642033874560449, 0.7992226851562516, 0.7287557911641258, 1.1506232328864356, 0.7414632992032112, 0.8990942702592638, 0.5013849410907019},
    {1.1126362536540604, 0.710826455093092, 0.8229366893743358, 0.2435988703697893, 0.8341914175809492, 0.6746604657376238, 0.6304790221494501, 0.011016487061567607, 1.0437407768842646, 1.034675995635368, -0.2168437378240425, 0.9230380508864625, 0.5222698633163138, 0.4424637990840123, 0.5984600396185932, 0.6720704293926153, 1.0724214954883546, -0.15590612144174287, 0.5367130521096705, 0.28417693630782004, 0.83421055145271, 0.8167693409121283, 0.9357008519021948, 0.6542650138320562, 0.6960733046517055, 1.0098402266074475, 0.8750713343617835, 0.8642643147263155, 1.136249836767252, 0.858090122253392, 0.8494529103625532, 1.0015645444392434},
    {0.6275358900354143, 0.9276874498308036, 1.090474220878696, -0.035547204102615824, 0.6242001468131394, 0.530703513916884, 0.7941436037923554, 0.09007743319976148, 0.8435131794066365, 0.49836203376906474, -0.09434969613756365, 0.8441584069332257, 0.5353059732132549, 0.7155898517931807, 0.8444186135297944, 0.6866329104445565, 0.794872606371213, -0.14631717887635004, 1.2501046118295884, -0.030802536822328558, 0.75228674567863, 1.0535690885530768, 1.3229268060291677, 0.7117498319929157, 0.35872994239236594, 0.9008111792073938, 0.7741099410685158, 0.3591547778801822, 0.8244665434299987, 0.6616997151551728, 0.343053914467529, 0.39914069872887614},
    {0.9175539523508606, 0.815075359191818, 0.49930592469551865, -0.10228637469018344, 0.6194586499404688, 0.6728461793759635, 0.7058156539789388, 0.029908375196525415, 1.0862234769427122, 0.9398657768101565, 0.11449992788632873, 0.8277769015657428, 0.7312166797540917, 0.711250341152501, 0.6718131647672828, 0.8121847000951797, 1.0001900250340117, -0.17746312879748824, 0.9426491569329066, 0.07195945987811167, 0.8308229402785521, 0.91032705580805, 0.6300505583669522, 1.1599673333876053, 0.6371290882286642, 0.7633134185597901, 0.5279096094493303, 0.7087881133637761, 0.7411109911742322, 0.4524216400956309, 0.7855757504665859, 0.8192707400857473},
    {0.9493496851372203, 0.9473128381064109, 0.7032993251196702, -0.13790693373109356, 0.4722411041294796, 1.0372758115189802, 0.7375352083914746, -0.23670917751493503, 0.796013665547586, 0.6238522096450202, 0.22642677208312034, 0.7450243262133672, 0.87837940447342, 0.7763442377809227, 0.6625631037844915, 0.7209646611426604, 0.7739316321188877, -0.417179285504194, 0.7818268744235413, -0.11716017687561377, 0.933612841406374, 1.162072656102688, 0.919802073619656, 0.7440228829677021, 0.8640407010066878, 1.0538470077418876, 0.9351887084660397, 0.8639375160846631, 0.9611369559477178, 1.1458706418480462, 0.6377799597457036, 0.8579283514901713},
    {0.6951063323057558, 1.1047197840156622, 0.825969680728729, -0.28705900166807974, 0.7077014094705713, 0.7923320369844471, 1.0184511423811113, -0.10934959838850537, 0.6686353359886634, 0.9195465039132918, 0.11645577455031297, 0.43932943493015186, 0.7542965358155547, 0.8145192502505884, 0.912386712632623, 0.7990383356542022, 0.5188293505190601, 0.13936639782944094, 0.8364601507451904, -0.22707546263634887, 0.6148681397400845, 0.8551796489605183, 1.1892619737119057, 0.8102674313514914, 0.6366020200209153, 0.893731207083659, 0.751526257674102, 0.4515260564005582, 0.8405050633179364, 0.6834199922287297, 0.3802640258876204, 0.9673029256363066},
    {0.8997737287077907, 0.5519349648127154, 0.8724013376873335, 0.3148083024043427, 0.515763515960904, 0.562008476707322, 0.49514167506589174, -0.1884712242935918, 1.0448801917322017, 0.5553372819674819, 0.08958460261600805, 0.481075649172553, 0.44908661190342497, 0.6596409076879625, 0.8263100317836095, 0.39517302817012495, 0.9950337299587276, 0.18688590966335608, 0.8028949217730117, 0.061992156321346394, 0.774987101521797, 0.5687954861388466, 0.44537460021250974, 0.5174315426784817, 0.8001581284067187, 0.9302744747923444, 0.9573522135061121, 0.9564658220767412, 1.0605936153038344, 0.9943536881841468, 0.7321454035951207, 0.7654132611063544},
    {1.3055780704843134, 0.5892491277982409, 0.7324893835151917, 0.10196083833822657, 0.9739448283145125, 0.895095629589132, 0.8718997295786578, -0.03810126229971244, 0.5666012953371833, 0.9369830682296961, 0.05556727981873297, 0.70377791162221, 0.09676496309292373, 0.7829966587212471, 0.8792273490091571, 0.5115607725992573, 0.9331536277195082, 0.013557359253748246, 0.9769581505048865, 0.023429239810915017, 0.9044479344189761, 1.080022710610672, 0.8785866135370605, 1.0189831157354012, 0.38987153939200586, 0.9034147715291478, 0.7696441540214841, 0.9389245585356082, 0.8811958598780972, 0.7301126973619794, 0.5387026665606667, 0.6375364678673676},
    {0.9013552714464947, 0.6946035628082821, 0.7925637394030058, 0.10381686220542943, 0.5656178097955205, 0.5346126856706316, 0.7324812586891237, -0.2063611786181787, 1.0097859464297811, 0.8379188544632401, 0.39618049272414513, 0.7709285523278316, 0.6702387962484713, 0.7996211405458156, 0.6377261363068278, 0.6706868309182196, 1.2983483341926383, 0.12626350986411683, 0.7913615136689325, -0.10831004304766087, 0.8978574292232989, 0.9698467954518454, 0.5533022164591678, 0.5945383639673103, 0.5473369790158622, 0.6128033984425959, 0.623590035909206, 1.1723567448074976, 1.311534356532138, 0.5131052194762358, 0.890776239690832, 0.7530848534438985},
    {0.6350094433316015, 0.670481902394895, 0.8609769596500277, 0.04286623429357771, 0.5608160111395545, 0.6134898468226394, 0.9020990304254323, -0.06574807768476644, 0.8572799558847201, 0.905771166112836, 0.13142363822210804, 0.37678944252013635, 0.5268163510621565, 0.6829162104067344, 0.7464163741779857, 0.7039198445443541, 0.9677504487543757, -0.009755227802652238, 0.9571484197938717, -0.18843520156374144, 0.7197670255054452, 1.0001299379857325, 0.8696760536317691, 0.8336469003369984, 0.686432578743831, 1.0253727475906294, 0.830859756804094, 0.3243728666851038, 0.8475628312205494, 0.4734837762357889, 0.6197728972640744, 0.890504719465433},
    {0.7802893544551398, 0.7360717197585359, 0.9179298357833184, -0.10043695918400349, 0.36079935818485515, 0.8183632664401999, 0.8537890114070215, -0.042550433000073475, 0.5103578479308246, 0.7166884949509122, 0.10541280892412294, 1.0222072485482998, 0.4857159059659557, 0.5101389433935737, 0.7298475335087813, 0.6805040052969961, 0.8474127750629741, 0.2308596102527098, 0.7039985638464168, -0.18553381026773677, 0.5615447249897774, 0.645879677684284, 0.8345553689972312, 0.6260398346152733, 0.6296645219939542, 1.05723192800425, 0.6691734581147158, 0.5359769277203527, 0.9957059980803307, 0.739009861323973, 0.3423662682501628, 0.8294090102537328},
    {1.013210719573192, 0.7883905639602232, 1.1510014958029897, -0.019832462188897237, 0.38387207800288026, 0.5142556249162131, 0.9651908185609485, -0.21534352790633574, 0.7085232294132697, 0.7610366274577969, -0.11371471514637768, 0.6939389097998849, 0.5940474695614981, 0.6420388861959091, 0.7901564141641906, 1.0521213894319899, 0.9143550009856856, -0.31325974416361696, 0.8453637204007547, 0.04945532818659704, 0.7344765322618358, 0.9699887149167546, 0.5141752716604391, 0.5725794604044161, 0.6412291909476134, 0.7322294583991731, 0.801965724468092, 0.9257531749376092, 1.1679233431028593, 0.5643934846140191, 0.6229337944656097, 0.7674426726091303},
    {0.8299871509757386, 0.7112661264689053, 0.9756796692385523, -0.1391723448775376, 0.5009215976444809, 0.69390941202109, 0.569696299541721, -0.5437783478269071, 0.7593210736674069, 0.8213044514976294, 0.2710115225132487, 0.8463438445571014, 0.3498654960240813, 0.6090143537175955, 0.6648266033850996, 0.5150717499475357, 0.9318227719504276, -0.17711364905005078, 0.8526861724727116, 0.04475386051057015, 0.64717565919775, 0.9135697129883231, 0.8313693460592415, 0.5788276265132031, 0.5074572982107945, 0.7761938210266969, 0.9670357168164117, 0.5289151680086185, 0.8826538660522797, 0.7027244187156104, 0.5445089681128211, 0.8060797450317597},
    {1.0751834506840658, 0.8947548638404669, 0.4226028361463876, -0.31777696322236676, 0.6034624903155907, 0.6996760502198858, 0.8786011363860836, -0.058388840446621286, 1.0607401112241361, 0.4828952418173453, -0.11494072178511826, 0.9288362381684846, 0.5315058698576148, 0.5492833512114819, 0.6633271009915386, 0.4933805315979995, 0.893162758179924, -0.3705830355823291, 0.9400528358193039, -0.22822566417882267, 0.9632621985577874, 0.6400126169427509, 0.8033112935398055, 0.7729403408175644, 0.649727113636499, 0.9306945805922445, 0.8664158251942919, 0.655144855701493, 1.0656134654315264, 1.049839545047417, 0.6665860577291307, 0.6855549131691673},
    {0.9819988923976991, 0.45404424494526135, 0.6872517222535448, -0.07968769492686362, 0.7422790366830596, 0.44260729891289896, 0.7480670063115683, -0.005235137395513197, 0.694322707110407, 0.9935350791930333, -0.22633643554202093, 0.8643360420100233, 0.9259932837904176, 0.4055956152937754, 0.5440487973835019, 0.9837750088915258, 1.0127818894543388, 0.04546049224471495, 1.0239854684266976, -0.21653405070904785, 0.8435978455035825, 0.7261943385805097, 0.5239636116009206, 0.9618447714650311, 0.8675710019194225, 0.9937270251650342, 0.9541817315015747, 0.6799286351383574, 0.9641707174351188, 0.8300838260198239, 0.8462333894527849, 0.9653128655656403},
    {0.9423134542570871, 0.8507911392869988, 0.8745991654918678, -0.3876346584211626, 0.7970452714704036, 0.5961551936534891, 0.6229507987681067, -0.008348160666386304, 0.546310567237194, 0.6653097327143378, -0.14278249496025203, 0.7415790850645932, 0.5682364968810201, 0.7899450771530853, 0.5514175137818771, 0.8699114225141354, 0.8958286446422686, -0.12853892469497072, 1.0811683831779093, -0.02448352487457211, 0.5554832974963584, 1.0110924938774144, 0.8222622227933525, 0.8974984221338622, 0.9496791703795926, 0.6933933716440022, 0.8050261514941055, 0.5892091271027338, 0.7650466830513687, 0.651440447076731, 0.7868450646729374, 0.7169525777581485},
    {0.9590627579629514, 0.5223445578031581, 0.8534409888402519, 0.027797772388016707, 0.7852076433841564, 0.9053883926056631, 0.9560917919730635, -0.23229816179467727, 0.8288950579011423, 0.6754172115734983, -0.18129689480223485, 0.9271272133274283, 0.3890842405364222, 0.670004978697148, 0.868330187082965, 0.6640301669429517, 0.825751347534849, -0.09680792673651951, 0.7637002218762122, -0.17819046800954227, 0.5269720567964782, 0.6656283020993013, 0.6517387251890311, 0.9186774394791242, 0.8101727384230328, 0.8993280924922703, 0.5377231205357969, 1.212163670781596, 0.922204144338139, 0.7448749417625975, 0.5175665959615001, 0.9915445965121694},
    {0.7367820391649849, 0.6342441833863115, 0.754496440859511, -0.08550068983658961, 0.7102823517926146, 0.7335399003198925, 0.9666310803700645, -0.006987064341408223, 0.7827502698314596, 0.7996215129826064, -0.03801936738140587, 0.6732773266222312, 0.8339123716742094, 0.776702797589711, 0.3715693278500188, 0.6647426694523215, 0.957728918432273, 0.17134202022879774, 0.8794057731558733, 0.10478329079109337, 0.5149773915713511, 0.8822872528698947, 0.43457818504132606, 0.708000692267173, 0.9104963978711731, 0.7037573089242821, 0.8950414180551405, 0.8415747923925164, 1.068541346395009, 0.5447685044101074, 0.19418929238836263, 0.664103897247207},
    {0.7351253330720426, 0.7170882354744261, 0.8098544316939282, -0.01176707070879016, 0.578404647529072, 0.8132653630742385, 0.8592374159088797, 0.13930483922276746, 0.6205452087020057, 1.0221018379324334, -0.10308858662669536, 0.9881108817713317, 0.6785633595092201, 0.7225899459752714, 0.4085039564832213, 0.7580518371527966, 0.6772906707791753, -0.04431813872469434, 1.1269688053693419, 0.08139679951247772, 0.8261768032312883, 0.7122393510757835, 1.0916277799358656, 0.7279701654135113, 0.5729185726025477, 1.073413241765231, 0.6833143929550998, 0.5245313578222235, 0.7252560483151743, 0.7579662119429547, 0.7370568280946637, 0.6327518637781736},
    {0.9416659435349272, 0.31360508576988505, 0.5673695194988331, 0.01525758164927625, 0.5065482333327894, 0.6442811868010204, 0.7238808282976934, -0.18680930596400713, 0.6167816710903125, 0.586017593458514, 0.21799572261183411, 0.8252528486656187, 0.5625560725646537, 1.0417556031172408, 0.9535865935417105, 0.6135932189346579, 0.6677422672787069, -0.21155482021576527, 1.1837582770827142, 0.2253817597248241, 0.6938924967921468, 0.6139999274077985, 0.5888222629851587, 0.6600696233904008, 0.7722323041153697, 0.8268780935197491, 0.8826487811836516, 0.7490415189283595, 0.9567877643001015, 0.9174512230603029, 0.5586904677141595, 0.5957793103175937},
    {0.9202237834232692, 0.9583630151942354, 0.9633856154392992, -0.15755419686886793, 0.34346250861065625, 0.8950822787201397, 0.7619123062504984, 0.11618813907330258, 0.4953056813833361, 1.1093288569829176, -0.11239221680128085, 0.8747898578406255, 0.8606810894535436, 0.6469554180881903, 0.7393331977900736, 0.6905372076203166, 1.0289192255288997, -0.13983882475070952, 0.7727797785598111, -0.024322536643822328, 0.8034159155059016, 0.839379812218228, 0.7030664516290733, 0.746078182152833, 0.6959709968522173, 0.9512537564915974, 0.941732462674131, 0.8624561378758075, 0.8834369403031755, 0.9718503536224818, 0.47544110684905266, 1.0009896428018954},
    {0.8322424421503198, 0.5179994945770362, 0.4451359534813588, 0.17777496862127817, 0.543688176718666, 0.5023169722992072, 0.952715807259553, -0.2898626287832831, 0.810459242694786, 1.0410410590457269, 0.24750102118731285, 0.8320834997522633, 0.8598626534776633, 0.7843669622237569, 0.8729242945361301, 0.6709354379066818, 1.319694942299116, -0.2155369232059638, 0.916863092811493, 0.18157827545535415, 1.056306009152969, 1.0473499491155405, 0.6873777190979715, 0.9408888366300333, 0.7231962020209403, 0.9902457539304804, 1.0249418898200975, 1.0227409873507576, 0.9391724068853162, 0.8192296232528407, 0.8158315678045924, 0.9141217224372598},
    {0.7681115575546774, 0.8178637591711513, 0.9418156014022179, -0.11667132111980204, 0.7331167024070439, 0.6849185000265623, 0.6056457829811489, 0.009360600229892541, 1.0091717198516823, 0.6252465366242057, 0.01012951864609779, 0.6137381875524894, 0.5061044295524232, 0.820681579639553, 0.7559698070948515, 0.7889403382222148, 0.9997497101468379, -0.13825187289558943, 0.9188658238664871, -0.06618927867899636, 0.8206076025275855, 0.5941784468442814, 0.8256057189964713, 0.7956937274434809, 0.5462009537603865, 1.1557247637510306, 0.8848062514596657, 0.6706743152811039, 0.8865246731774877, 0.71754756237343, 0.8489008893924417, 0.9380549959530459},
    {0.5181728473887778, 0.5544485774374248, 0.8267268997673998, -0.16271283062888353, 0.49964676442095524, 0.5900223737536595, 0.4434882587300258, 0.118333802705048, 0.9221281406298609, 0.8992622636745419, 0.21109881639239267, 1.0845522980946773, 0.4966265510877115, 0.7818097619524504, 0.594329831663815, 0.5390690202995045, 1.074964363116912, 0.4432260566599092, 0.9201984336301432, -0.09157251294005357, 0.770187818204267, 0.7687837334130254, 1.0744630384455125, 0.6930739567636949, 0.7832764932933547, 0.8746772507436406, 1.0046966086202018, 0.7847807896481497, 1.10854106839471, 0.5896291829247496, 0.6519055820779291, 0.9540713486837735},
    {0.9245289340030178, 0.5638782119914743, 0.9473531933744245, 0.04780766489900432, 0.6647602486364771, 0.7558653397583083, 0.7622375868154614, 0.20502946696809726, 0.8462263522084493, 0.8039722495690312, -0.12980102173047328, 0.9431722570527833, 0.7465650316323165, 0.7748637836711298, 0.6774937598923255, 0.5031082046700988, 0.6106680983883561, -0.15823144353786986, 0.6235995040735256, 0.01478403949412811, 0.7787060109611249, 0.792198812211879, 0.787309414643277, 0.6117266597992594, 0.7749967334643298, 0.8236521375645095, 0.5754344301060879, 0.6304145436695526, 0.7935111478241978, 0.4948409462961588, 0.8209003835429567, 0.5448835998508135},
    {1.0527770700461543, 0.8236595336448014, 1.078339531675354, 0.19743781970646304, 0.8689601277819488, 0.7823504341318316, 0.7890462174370234, -0.06640287796049588, 0.7896411689617334, 0.8420868758341883, -0.22098569400628965, 0.8716684098479569, 0.48770759399128866, 0.6920955904209471, 0.4893083993780452, 0.7127993896601094, 0.9704938310157929, -0.007323824992404502, 0.9323099011547896, 0.044056065651072306, 0.6027030820935086, 0.8995597315961983, 0.6062621422502428, 0.7437427520881278, 0.8012270095549832, 0.975872509996127, 0.8768461940024731, 0.5725981928607669, 0.9697851824597229, 0.8395365667512482, 0.6021439418449052, 0.8984996864560129},
    {0.8951209068429256, 0.588727710582767, 0.6059725237400726, -0.19035684447218695, 0.2564096124111632, 0.5743814691592589, 0.7837850199485855, -0.2656105454776308, 0.8548819836656188, 0.7286012392778042, -0.11143411198206402, 0.8516833366631649, 0.7509866997902657, 0.6232668448974266, 0.7709999978389054, 0.5597231967740622, 0.7711827471671457, -0.06996348453254808, 0.6910681818201072, -0.23644498597910232, 0.5458757674238343, 0.8648222332966246, 0.4772947051700216, 0.67610194432385, 0.8381526900858588, 0.9765965750861073, 0.6490128040813649, 0.46588309255039045, 0.8504850189178135, 0.5542391362076365, 0.984593266939841, 0.7636673544703407},
    {1.1326477175218939, 0.6964105514422496, 0.6430994280094228, -0.205012169683173, 0.6360568845144422, 0.6416442947508717, 0.4521835884711948, -0.08026664172876043, 1.0126911189049197, 0.8904036171433803, -0.3371777550080088, 0.846308754751414, 0.9152886587508685, 0.6674467134827075, 0.8190324303502459, 0.6733784976970408, 0.7786774685335652, -0.12013483302569701, 0.9444564881483422, 0.10133755102201406, 0.9518502705607949, 0.5757617719442897, 0.7649269593530734, 0.7246957134745581, 0.7275404649059958, 0.6423237530351208, 0.7986498374724292, 0.9426245550917397, 0.7469103771340212, 0.7185944821501269, 0.7695976175616522, 0.6311798083284638},
    {0.8894900204725354, 0.4708178710032941, 0.9936330683723326, 0.10578278085667918, 0.7176790302775049, 0.5475321549590044, 0.7640642381855777, -0.02373659266204916, 0.7728481188412692, 0.6496461901203725, -0.02344142053920427, 1.0175409624239742, 0.44251911353118717, 0.4700836346382797, 0.7963342797468211, 0.6180582919618062, 0.8615395565602214, 0.04926975255749402, 0.8676431616665353, -0.03390962566807609, 0.7246837965155718, 0.7214800007153, 0.5538222801098128, 0.7644753953093839, 0.6219798663644152, 0.9135619201114962, 0.9271115992942679, 0.7452391739367427, 0.9845067239741728, 0.6478541732668547, 0.46072853067995884, 0.7552572412813072},
    {0.9045388088129309, 0.602073730128592, 0.856039359631322, 0.06699136034297343, 0.22929425001918563, 0.7374213747425289, 0.7872447142195003, 0.06509982252916943, 0.9409868626175548, 0.7052104619802504, -0.6454717384491545, 0.8105010870711933, 0.8766241400471414, 0.5032197923043958, 0.9292907119146113, 0.6845393389280251, 0.9076398790015286, 0.06301288586975096, 1.1520300871673288, -0.045426413505864474, 0.639097631240402, 1.3082550493159937, 0.7717135285139898, 0.8702523399411758, 0.6591073131485067, 0.8737528845321266, 0.8510342353965413, 0.8261647964113698, 0.6915877576149152, 0.7618464414084023, 0.6075628378799772, 0.6793814867909831},
    {0.7877372769888284, 0.5409512346997273, 0.5734790760268592, 0.2535981674235272, 0.9465116089940769, 0.5393334188274546, 0.6848530072443424, 0.30414179149610393, 1.0225765331348293, 0.9712228430419803, -0.29133365172018605, 0.5861328742369764, 0.8680140174504835, 0.4765945053880616, 0.5872047048383974, 0.5319933913337642, 0.9425420694791916, 0.15380714664474762, 0.9479447891782568, -0.05788073305868617, 0.5881422153566662, 0.7959010586346746, 1.1174829696628155, 0.9368719219421998, 0.7145441057036478, 0.7761258847728147, 0.940477855308084, 0.5735138119725178, 0.9293457727025409, 0.9221751290405646, 0.38688581514471343, 0.6267136519120109},
    {0.8472805299122861, 0.6845321811322234, 1.0041421100236814, 0.4617953538416344, 0.6088391526198796, 0.7013727109716339, 1.038233869393418, -0.012831246609829152, 0.9706492448878855, 0.7793046780979398, 0.019281193435725437, 0.7773525538762545, 0.8103128310583212, 0.889488663853655, 0.9062135138785231, 0.9650926694781278, 0.738371341355165, 0.045570147523096995, 0.8198337012554623, 0.1400060890010317, 0.5512299470512764, 0.9401488129827117, 0.9319928823613381, 0.6573714100612135, 0.8413696444360801, 0.9681242791814986, 1.0548949528788145, 0.9715631516569498, 0.7817105341689653, 0.9614744729381496, 0.8496839798418181, 0.8709184827221024},
    {0.8246197252383012, 0.8167775072036022, 1.005459413993758, 0.33460570895586655, 0.7085362877679444, 0.7485907394202459, 0.9676163955336474, -0.018487085428715785, 0.6884503531986754, 0.8800218408669078, -0.35901324850638205, 0.6814844452221188, 0.7752327529139211, 0.6083522436918212, 0.6560167224254436, 0.6489721253215095, 0.6115478236879909, -0.006432461629653995, 0.6926306931945809, -0.3834241357071561, 0.8082225814457793, 0.8614610216336337, 0.8718721253341624, 0.5911379888947313, 0.7203143072477491, 1.0102112856146213, 1.1854908603645427, 1.031428628141018, 0.928407729672149, 0.8188940261922827, 0.9651866020402122, 0.9507227519805708},
    {0.5081539586004321, 0.6712314406502397, 0.8591633592876674, 0.14625097410206214, 0.45049426209146576, 0.8182899883932551, 0.9170972513162645, -0.18614335286434203, 0.8100403762124455, 0.7722310720214179, 0.059145784788336084, 0.7580378515868116, 0.5463473826237849, 0.6692298572370045, 0.5858048674308921, 0.7280898959472357, 1.3416277796357674, -0.01641285837800137, 0.859376202374559, 0.060440523202252225, 0.43339395496569705, 1.052708723823053, 1.1304685890065256, 0.48975257616011714, 0.6728796973553121, 0.769442426219317, 0.4783453041621355, 0.5132303902626165, 0.9520577640247813, 0.8279921992904474, 0.6064683499863976, 0.9345804854991975},
    {1.0135514653196849, 0.8202908028733731, 0.6020888930770562, 0.10379053205280743, 0.7106465451063202, 1.028974276629519, 0.9692569114293089, -0.3001561759791128, 0.5281134715680201, 0.559768559726618, -0.1554673652782963, 0.7893902730455347, 0.5280325335167508, 0.6749993264057293, 0.9368317573905864, 0.7204206560909656, 0.9232101022916857, 0.1010077205109101, 0.841151990571287, -0.07150684636175174, 0.8612652111394422, 0.6679762203774944, 0.8634440149252808, 0.7974443176526596, 0.6402080181757798, 0.8071230682523263, 0.5833460994950822, 0.4722401209543586, 0.7748132693485378, 0.7451652583244796, 0.7316480676041677, 0.7370089202584118},
    {0.8335270908063914, 0.8577734011247313, 0.8027721175174211, 0.008117919409835948, 0.6814294750874064, 0.5516989046328666, 0.7622906053952925, -0.20986570699953505, 0.8323725790825319, 0.503664153296417, -0.10055315619319641, 0.8052064009508534, 0.6021663665701079, 0.5879803333060695, 0.5492918013815926, 0.7465847148662095, 0.735546480787673, -0.02753145930529954, 0.6381158231878755, -0.16278400607488308, 0.8023863290040176, 0.9244486547700549, 0.44104391775765267, 0.5399969718991444, 0.8851088050776915, 0.9073526910223321, 0.9140971123377502, 0.9036504521452818, 0.8937725045001534, 0.8506780428453944, 0.8941597609297697, 1.0038879975971056},
    {0.7917254163970506, 0.3911604292511966, 1.1504617762129625, -0.11428033577543359, 0.5751152843073135, 0.6485763075382021, 0.9470188959855069, -0.03504993055159868, 0.6934676856620247, 0.6036666246941782, -0.020279700843304813, 0.7322652293851182, 0.5484010930625456, 0.6604413983242601, 0.6464104982767649, 0.7796024427914063, 0.8760178276043862, -0.15768353145051697, 0.6986944435231565, -0.07414571311893171, 0.7463511614934818, 0.6619455753158489, 1.042641295335756, 0.664880169817079, 0.5839052378702738, 0.8644043633310208, 0.6535129065118047, 0.5577235894397453, 0.878260122225814, 0.5459858742751286, 0.9158765384745456, 0.49801704056955476},
    {0.8699089163813084, 0.7544696642355749, 0.7887970187402247, -0.1615492734149533, 0.9696891176824032, 0.7088696645153686, 0.7965808933099116, 0.012068259491390142, 0.8346235597262267, 1.2829128238563843, 0.19379242776873856, 0.6966903812469915, 0.47535246826368377, 0.8788129398255358, 0.9411495981931456, 1.2217168909045604, 0.8971191867790539, -0.37164371859191436, 0.9832643561013518, -0.05201466414798113, 0.6958038401969474, 1.0102816008462965, 0.3437916467929553, 0.9948773287881546, 0.978166374047701, 0.7505577978594202, 0.962508123715456, 0.7228116521164557, 0.9374302914625926, 0.8499852680940424, 0.5155221341977438, 0.8748607254051326}
};

static const float b2[32] = {0.8917582512186583, 0.7289779923989267, 0.8188622686476212, -0.04181071429059822, 0.7297909882186917, 0.7373482518561572, 0.8211516240099594, -0.0638611634660788, 0.883617012027142, 0.7916482039309726, -0.0341779592333263, 0.8425201421707704, 0.639964711178398, 0.6247113965764949, 0.685330659923936, 0.7868625097148487, 0.9374590416012615, -0.039703107982214755, 0.8652085888178339, -0.09888185826527594, 0.7758797103147486, 0.8118723277441162, 0.8318220338526454, 0.655036715981352, 0.6667884753545502, 0.901894639079665, 0.7574184445113429, 0.7187003565924853, 0.8868986779859457, 0.7753337122908034, 0.6197067381571335, 0.8110520592158167};

static const float w3[32][16] = {
    {1.167169945736663, -0.6324778187738602, 1.372688131029955, 1.2444576658056004, -0.3250209865377889, 0.6402156900981391, -0.2799880344132461, 0.013082336990439479, -0.12269406855739019, 0.9026612638840706, -0.3947611233445008, 1.1407384479669562, 0.932210117545143, -0.08479053655130327, 0.3978917444052279, -0.5660521405738653},
    {0.9463016670119986, -0.14450478466382277, 0.30426330120388856, 0.5944086934210089, -0.15986618519561135, 0.711324232456485, 0.3259757740021594, -0.5186147203475167, 0.058195400351655484, 1.2447508605091802, -0.20280294321235312, 0.9438984230296461, 1.3764107771188563, -0.010648078184267546, 0.18596536842007125, -0.06829188150165452},
    {0.5406186840917272, 0.03268577314370684, 1.0943529719882052, 0.5602279565415291, -0.15972556534077945, 0.42710962199308167, -0.27064001245457536, -0.5280115986683213, -0.30267273407810547, 0.8782162552806414, -0.2650935338876187, 1.212602869822084, 1.1452354083700762, -0.2411761887815918, -0.5003131687603443, -0.4770772151675355},
    {0.06014563894359946, 0.017919577345071293, 0.08970399816431333, -0.3983417855185348, -0.20488553806460344, -0.051959274458834255, -0.18357310847122862, 0.030377962536088626, 0.3651505694974919, 0.3367613851442272, 0.15750703811712163, -0.038614198718123535, 0.08509801817424786, -0.38998359291138474, -0.2891230649799291, 0.3680250453933376},
    {1.2038321420521543, 0.06219645429993953, 0.28633101603761085, 0.759245544195863, -0.47806022640481594, 0.6387637998457122, 0.12359455965625565, -0.23469967369599992, 0.040658163834978035, 0.2959569024550754, 0.021163034013366167, 0.9649690876675336, 1.0560696651297063, -0.2601637785875466, -0.045357588113321724, -0.2829329857373426},
    {1.0396979291430735, -0.02556990554175054, 0.9568094070646017, 0.3384787139885997, -0.34039195947849354, 0.5057268143542738, -0.21250606269124472, 0.07098027839404313, -0.18883950890674428, 0.7682044941925302, -0.036691803216138276, 0.8544678676422899, 0.994716645603733, -0.26718538664343305, -0.15704227777042043, -0.33025474040596714},
    {0.7549454756169868, 0.02151160485826746, 1.1379119322473021, 0.8361080529976649, 0.26833480402621623, 1.4148836947110937, -0.04160954099327585, -0.03040273332648265, -0.06197637695163065, 0.8699459022795495, 0.0060005165136092576, 1.487707559771006, 0.5513554148294807, 0.0779861550888988, 0.21914538628063618, -0.07869085677644679},
    {-0.0039369701419143905, -0.06002940806091745, -0.37336582352672315, -0.24781760380363824, -0.004182624887347329, 0.11967020460453466, 0.1742158549052554, -0.0052002753284421605, -0.024534425770758764, 0.05666930666161751, -0.3152341313810553, 0.4546391921425836, -0.05270251082181683, 0.19799034846446206, -0.03833756208985278, -0.1785998319097109},
    {1.0315618513996347, -0.10715877107103841, 0.9897607984454003, 0.9343903157098904, 0.09025899140436205, 0.9596687475115153, 0.049873928586036925, 0.4635831563559538, 0.1465854794674903, 0.93577217005478, -0.3414782607467088, 0.9855276532737712, 1.4659592607453096, -0.13996491550780588, -0.41570866744123813, 0.17854703386926826},
    {1.1035509623421142, -0.15513651699067046, 1.6137031825669623, 0.6169123703014653, 0.10985889011308317, 1.4978706782212245, -0.2458542853084027, 0.22191771315979936, -0.12350435882773196, 0.7960787120494955, 0.296388337149016, 1.2739842633905698, 1.436335494681302, -0.153505819575714, 0.28521801757340554, -0.20305101914044169},
    {0.12998302795545455, -0.03708057118794822, -0.07900119967244898, 0.07930645234124267, -0.5671837855611954, -0.1582796515649747, 0.12025851383251393, 0.061496607294292266, -0.3404455365484441, 0.2568867590642763, 0.18871989198632083, -0.3032123480176676, 0.06822606678145685, -0.18004274533019277, -0.03024759412649867, 0.15663117472476296},
    {1.3130762434196268, 0.4287594702325058, 0.8827755632611609, 1.4618249248011936, -0.11720805847850214, 0.5457325542203161, -0.07548685989412449, -0.26842729012721733, -0.43744080495464843, 0.7835479886480783, 0.008424639232540887, 0.8164818919304703, 1.1543118031021855, 0.08483814448195358, -0.1952420700878259, -0.0855669716578393},
    {0.5906279783875106, -0.3903730871586893, 1.184522251040456, 1.0710627384524212, 0.23764256981885087, 0.5033498845785601, -0.033846256217738964, 0.3990236896887277, -0.12854777942588252, 0.7611502999513474, 0.11452782727321507, 0.7994431834948292, 0.5886370070625498, -0.029372202809010158, -0.43106310128967135, -0.014760662704166524},
    {0.7805527119095435, -0.1022051674244237, 0.8622240084021656, 1.207139322279949, -0.3193842166398011, 0.7351786222375178, -0.09957591666334663, -0.42475499552331464, -0.19557340768693923, 0.7705542892336943, 0.4406128381946055, 0.9479477291794864, 0.43589038433780547, -0.6681792656336042, 0.1688024261156281, -0.11581898994301794},
    {0.7332288231548381, -0.38710807189769403, 1.0552501739751587, 0.8460032344015251, -0.13826085617299447, 0.6759436846133795, -0.16392541355762216, 0.1588023072467777, 0.19540356716621893, 0.5362580923675027, 0.1462566061640116, 1.2331246536848606, 0.5872940412974794, -0.12703426883510072, 0.17166442578174498, -0.17167933931745052},
    {0.5829251593982937, 0.22596050604709775, 1.1010782174793372, 0.2697122930172858, 0.31064723815183953, 0.8608473943019784, 0.1629093751988733, -0.49309738166607003, 0.319490351986177, 1.201752110634938, 0.30702553368244856, 1.3677767341988638, 1.090153968911948, -0.12095217236575724, 0.5272408688349081, -0.1990470381572909},
    {0.909523105548964, 0.1801056550808924, 0.7795504668677471, 0.9862828350995003, -0.2934173377811066, 0.6994844886690457, -0.2509872385190726, 0.02558828654577073, 0.19245405131733345, 0.9315177275658012, -0.15996369314726572, 0.9820942522641564, 1.0906655845801076, 0.0402346824478037, -0.10316423229545786, -0.2084502778725738},
    {0.20581609144831478, 0.4036020842553534, -0.43972566289116144, -0.329859368084365, 0.008729458696918766, -0.208902674229652, -0.05676909112445533, 0.20374753906084608, -0.26277802404857087, 0.047235504549464055, 0.26607597733130756, -0.6356970115914823, -0.17876688317783407, 0.47593446793990674, 0.08915827084306463, -0.2891022368238742},
    {1.0967592040413787, 0.28878310722830297, 0.9102799796708676, 0.9630967632269642, 0.1737873981349576, 0.9210466310147569, 0.04090036765317104, -0.044207968401574205, -0.012397538425546608, 0.5084919263613163, -0.11724005407957669, 1.146019475876618, 0.9886042652331726, -0.01754578473137697, -0.2869557761235107, -0.1359337349711127},
    {0.3597003556411271, -0.619636334741594, -0.2462546706213729, 0.03772597151678412, 0.043366883105910164, -0.36455727774771407, -0.08978379977986942, -0.24814391543656397, -0.09676080868356063, 0.09389876827331925, -0.024984921565657868, -0.22445897263278589, -0.26555588185933304, 0.10042956772400333, 0.21492088812002497, -0.4738392261108076},
    {0.8496883103596199, -0.15277542525616084, 1.0938307299605452, 0.5186343284635301, 0.06779949713423637, 1.3222344732025009, 0.5265096461557338, -0.5718700788401582, 0.2047413760517879, 0.7945044555201055, -0.19284246257893548, 0.6500886603194763, 1.150457692505175, -0.14895106515470624, 0.030571236108647502, -0.2130130533377507},
    {0.7120158429098494, -0.0720164322483852, 0.8385478530433068, 1.1881369105355901, 0.06450896345755297, 1.0562629848485283, 0.4891841458469955, 0.18945882961267027, 0.08413044310159228, 0.7818845291788198, -0.2525685430284827, 0.9542191270531372, 1.346333015735511, -0.21804407088851627, -0.38671880907226736, -0.3852591699453368},
    {0.4298265450683668, 0.2974103983244939, 1.2108957773195612, 1.229766607109821, -0.28771290186641696, 0.6609351891777031, -0.33239900064106004, -0.34163713785302174, -0.17358420018211965, 0.9999616186903854, -0.12404886104319947, 1.2569635629295717, 0.6447198309370004, 0.5648955073124597, -0.08793326973563852, 0.1370081099426168},
    {0.6724714851456814, -0.1795467768073874, 1.0383767344139476, 0.7160664204814069, -0.19702320302082754, 0.6934687461089226, 0.005974493458925441, -0.10052734704474939, -0.12021053617271796, 0.9707101645628936, 0.748222111799207, 0.9797487695156305, 1.241121555811494, 0.1397584990618341, -0.1622006016661221, 0.18693893903618589},
    {0.850205272802513, -0.09147348049924808, 1.2028199792880303, 0.6496578203202379, -0.1514464961427383, 1.26555719628714, -0.05706996540230701, 0.32376693622007763, 0.1044384929288509, 0.5866297935561676, 0.21439040818735253, 0.7039062413684968, 0.931627493034177, -0.24807695666038382, -0.18019309067758796, -0.13560617322090043},
    {1.0923099641942335, -0.24612598861068963, 1.174903734814687, 1.0728779536214614, 0.10234606212905363, 1.4822002717873484, 0.041099410706876255, -0.32542288812357045, -0.31329536333033076, 0.9144615247655905, -0.14804727175842886, 0.8976403536209159, 1.0441488791763245, -0.7005010949966005, -0.11677494068085939, 0.03658479175046784},
    {0.8698680399546185, 0.13026146879375702, 0.9068195219938896, 1.1598691982040452, -0.13372386122638102, 0.8766062369753703, 0.13364417340326168, 0.40513189449599357, 0.1798429446721732, 1.0660057168329913, 0.07229845898693309, 0.981501906864664, 1.311255450490614, -0.6910252016055052, 0.06803696406859669, -0.05575191602736773},
    {0.9607322365221165, 0.07349297236007712, 0.6538530909873965, 0.9740450417495379, 0.10413999252207759, 0.8963125214003833, 0.02824351646750803, 0.2856999395936262, 0.2427757341320612, 0.9363882078279068, 0.13049078474854334, 0.6004127064964592, 1.210199973668604, 0.6996527785445924, 0.17686500413947676, -0.3018272334956814},
    {1.0422000570028855, -0.24490663721562597, 1.5716097134943945, 0.8418806336535257, -0.06458127754134732, 0.9844065839414813, -0.108680809155922, -0.234097744629412, 0.23556600962183222, 1.2281506063740453, -0.25060557680191103, 1.1795691124246057, 1.1693154838181015, 0.3094510103292212, -0.12870871802771197, 0.4843898182468587},
    {0.4663159443280164, -0.09235749249822878, 1.596868061852602, 0.5529450781906399, -0.047708159745182825, 1.1206643649327732, 0.25665187369202813, -0.0588164238209476, -0.19638132423027346, 0.8070792545711137, -0.017154695987045967, 0.9308403119800573, 0.9154892544028114, -0.10329915788867233, -0.6066159661282617, -0.06398783375505283},
    {0.7996793994027079, -0.06659660393739371, 0.7354709039888733, 1.0116743933490098, 0.002346426193818593, 0.8434313151913364, 0.3494346475107266, -0.11279912896601547, 0.16847913153050473, 0.9860668732545691, 0.09031713042487438, 0.6977712738345863, 0.6597223769615297, -0.08753198647094891, 0.38803121563878035, 0.1947143587980831},
    {0.8319909432449615, -0.11588213660902338, 0.8557612154542352, 0.8310952794886598, -0.12345867579965071, 0.8730453759535037, -0.636764532314008, -0.18356974103798102, -0.18514035019116418, 0.917748113415523, 0.09711703617194085, 0.8146840108260147, 1.0653015068666212, -0.32212134450563384, 0.2964316173744058, -0.24391515596267396}
};

static const float b3[16] = {0.6183530375559544, -0.06986939745548465, 0.680086083735557, 0.6245881107926552, -0.03239393467894205, 0.6287853550979497, -0.04205987983551805, -0.06479043519034261, 0.0833226687623188, 0.5910732283259595, -0.032452565502139964, 0.7021396634435164, 0.6342320114441594, -0.024101200235991195, -0.03771418564866306, -0.06952185991382756};

static const float w4[16][12] = {
    {-0.9956292298056865, -0.28569058731228925, -0.1671792186042329, -0.9218296642276739, -0.963010561406092, -1.1029444074940082, -0.8263618863603732, -1.010397334420264, -0.2658285154685172, -0.5898487682398594, -0.9152607002674107, -0.538868103742739},
    {-0.49135335206918923, -0.07295871163625472, 0.4783693770759466, 0.4912790198644654, 0.07748617478356604, 0.06458720363367121, 0.13508876981035922, 0.12258932969423635, -0.17455321132482027, 0.05156384260590414, 0.21931850286233043, 0.05581728398189115},
    {-0.4343230687888059, -0.8836221257061224, -0.7313495134716813, -0.3882998094769662, -1.1284351306613527, -0.8888949499633821, -0.7224356082728373, -1.0119254663602717, -0.8447722674808682, -0.29254238409557215, -0.6782348356493252, -0.9592138393447288},
    {-0.25351172427115626, -1.6695798384622376, -0.6769708307079269, -1.3203497131603232, 0.09093762229647694, -1.3857800574229924, -0.7169476156018267, -0.6908765051300542, -0.7036519427688733, -0.9955061001402026, -0.7360118572840643, -0.16628281422038446},
    {0.8447004113656914, 0.6069902329218682, -0.21581030522223685, 0.03637671594052112, 0.013219856395900072, 0.23400570872246024, 0.21798920332675328, 0.4549359102402481, -0.3150677661653945, -0.6705227683167481, 1.1762599325687721, 0.33509181674997907},
    {-1.0452173262249569, -1.0071935891741333, -1.0245301454516842, -0.5328951311219002, -1.0013692941797234, -0.5513369623029524, -0.632959888815164, -0.14992401873560457, -0.8655702989250033, -0.3113414164255929, -0.7925647133227008, -0.353158675741058},
    {-0.6827753322020442, -0.0012431707097155982, 0.038905280273208505, -0.009274505563769103, 0.0862217252237358, 0.38819195285769204, 0.337210229757291, 0.06843200763506949, -0.24117070593994128, 0.09005271781675481, -0.5675769505473212, 0.7785289928859741},
    {0.011004780300425652, 0.2970731264851001, -0.27921734757563155, 0.20728508206101895, 0.26992152661383767, -0.36863705950622744, 0.3373086769750482, 0.6289119699057546, 0.11112044438375514, -0.3996525662135535, 0.48152341415407485, -0.3021490126664004},
    {-0.14944595580183867, -0.24635416602048055, -0.2314010219504454, -0.5385271680743051, -0.4488642013168793, -0.6971044707609739, 0.5480964526631126, -0.24943535957603527, -0.1713961489587166, 0.15184380296504268, 0.03532936146268533, -0.01945761350356246},
    {-0.8190152288580161, -0.043861071026822476, -1.4300090186193544, -0.7527924669479877, -0.46012768444786756, -0.5657146786368731, -0.5393839884713026, -0.34910418112774017, -1.2195301047845943, -1.2282193987607888, -0.7036653614578421, -0.7685737657795336},
    {-0.05213603403942775, 0.3649627772628189, 0.14687498370014893, -0.7623893284391596, 0.20971436380089578, 0.11489428753192094, 0.1145325934197251, 0.05704943644298499, 0.5346604086053525, 0.06182078410281054, 0.13517021200446117, -0.34619646911419355},
    {-0.5772131334177779, -0.7356050775879887, -0.7060159069031172, -0.7983783163574415, -0.6630519885190181, -0.2497434007784708, -1.1303472401658337, -0.852447522397882, -0.727550076115294, -0.9792184364302814, -1.0654794056158547, -1.2487515856817764},
    {-1.1470708204941136, -0.6274648666040146, -0.5667671825942306, -0.6133630433502619, -1.0334065506547407, -0.6050818939025456, -0.628052210669844, -1.1085210429928003, -0.6517217889029834, -0.9111027074862422, -0.38285807252553505, -1.0652729495905977},
    {-0.2488329644432352, 0.12656435933219848, -0.12941394974082943, 0.0023489840387862157, -0.5016040765313746, -0.055394567511414625, 0.255821882117728, 0.27958387344830793, 0.1193248502043284, 0.06880775174741499, -0.14100444793159037, -0.08453603316806567},
    {-0.1742868459385018, 0.21981442508679627, 0.2985131202550969, -0.13070493318164242, 0.5163693239810119, -0.14965438467276163, -0.5384847548957028, -0.3004989362315057, 0.2544442768113905, 0.0514687547652638, 0.3855772009511034, -0.361905608615054},
    {0.7741029215664406, 0.3012408539765459, -0.23888213074799636, 0.28568126440099884, -0.017465566562238077, 0.6411194865878005, -0.3018484077337782, 0.2342520175617193, -0.2800153041206421, 0.12564304859345662, 0.42555668660758156, -0.22256027176383422}
};

static const float b4[12] = {-0.2970582553462458, -0.21025200968039434, -0.16943833297927918, -0.18283227118530218, -0.23689183939185532, -0.27402750022117944, -0.3047655609024627, -0.17043544598451427, -0.2533855752219872, -0.1814887593264534, -0.1695436822250061, -0.24652578624726945};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
