#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.4505893871788155, -1.3799308715239047, 0.22105106538254699, -0.42903273855960944, 0.6863416698639798, -1.1856336255963096, -0.0026223568733532232, 0.8346221106812749, 0.5684073470253618, 0.49199567217657647, -0.5271183353132126, 0.7421942354501128, -0.5909442634737514, -0.39494320524932824, 0.2804423000405106, -0.4250851304114277, -0.5914789168195858, -0.19979894391000352, -1.3200641264078254, 0.28462365064853584, 1.0958272744559492, 0.9716766823577064, -0.5918162678073428, -0.7687846368545691, -0.2857958782880218, -0.4069020493575148, 0.43887420305197145, 1.0988681992147826, -0.3928798963799724, -0.21582914810736578, -0.02360394599835208, -0.5945802805266002, 0.026944812830689148, -0.8409289870349066, -0.3083130415337414, -0.8020894550634539, -0.2629574782413708, -0.15476849728480283, -0.1776632919598034, 0.9902063025272717, -0.5217182832151672, 0.01819254809248398, 0.19406266638888248, -0.5153129307482734, 1.007435000592517, 0.03332467009321661, 0.39121772302430086, -0.22704460804492912, -0.8466720380399693, 0.7527220806398252, 0.7895204396492622, -0.11615946621472424, 0.7923414927683099, -0.4163467348146333, 0.2661666097487283, -0.32729065143261965, -0.1410090119709657, 0.4106259733627728, 1.0464823352960841, -0.1983305318427311, -0.9088185662456992, -0.8178282852306359, -0.8119439841359981, 0.7831502273842244},
    {0.7222618968172334, 0.5837641152429901, 0.7371611569135955, -0.5955290188366175, 1.0286855424945498, 0.8888423674238984, -0.8911725302489962, 0.3993629811901318, 0.7893639406093964, 0.303665813322288, 0.33019228168647546, 0.026738815092898292, 0.27545693893517176, -1.0231107871374545, -0.047972232532331516, 0.20906352476220325, 1.2658466752101618, 0.8229630749597653, 0.14115968978924565, 0.9180056475461988, -1.2627586063012144, -0.1425189190067701, 0.37309156885556377, -0.47430700067560355, 0.45629168142563126, 0.022971242979960418, -0.9978769952600038, 0.7733582830926072, -1.0852291355616943, -0.8927531264314285, 0.4621743929751853, 0.17629877003971572, 0.07112509153620253, 0.8989559050005385, 0.25123801292711795, 1.007664429495417, -0.7598565264843931, -0.6152715686049932, 1.0000844889718066, -0.9294514998193992, 1.3760128964647567, -0.4910343729611789, -0.018924905720450476, -0.6360240584877448, -0.8023178866314936, 0.871963255978975, -0.6171706051643354, 0.871058650851909, -0.21192495801108824, 0.38802988444369424, -0.9457852269161413, -0.35802555879462455, 0.9058317644411864, -0.39990184725481376, -0.9854468404270875, -0.20911206465312335, -0.9589356711913528, 0.6265549047941473, -0.38625843007710997, 0.5612264680202981, 1.061676925675701, -0.4982570506710935, 0.7276541476813597, -0.7894327255165569},
    {0.43679402394968675, -0.6331241781933866, 0.7879342856849864, 0.5344011650897317, -0.9700960317752824, 0.9468924846331613, -0.2836673896359774, -0.29822481726486544, -0.9671565746396718, 0.06072133157588556, 0.31072452023502556, -0.9398780025669876, 0.10673322450373898, 1.067049875865545, 0.6477142233992186, -0.05120446883362554, 0.7459437547807668, 0.6466302883293278, 0.966451665030119, -0.08368555685018024, -0.4468302202740203, 0.5873177687715014, 0.7157237257991768, -0.5446425118147405, 0.9598374092998371, 1.127347491367555, -1.0580025126909263, -0.8654423996894468, -0.17850553900492036, 0.5964519992451214, 0.8857631028473486, 0.6952178311379607, 1.1598330976285174, 0.523329405105909, -1.0775126736610336, 0.9778830387378769, -0.4972975137181157, 1.1051404937033449, -0.4014740209733459, 1.5061912533922213, 0.7251407630858064, 0.6962340266192154, -0.8132474043293678, 0.34900729096843175, 0.7688973247407804, 0.21399416624229464, 0.16159336312207756, 1.0232151823089348, -0.209136360810969, -0.6344637393054888, 0.7456729428918912, 0.3035719242838126, -0.9031818794978995, -0.9656790929440374, 1.2043720611177764, 0.23818907311705187, -0.15326519385237686, 0.8068414837775169, 0.7043561734346038, 0.6588307178985963, -0.2227789863926879, 0.9563688773743618, 0.5083395772699455, -0.470913526188251},
    {0.1079133877112714, 0.8930716570482902, -0.49229521384255703, 0.38632348243663406, 1.0382494260499033, 1.074111354444955, 0.3615086702913484, -0.08333207687869944, -0.9297022630153456, -0.0028899420419980573, 0.7826948531680915, -0.15341911648134965, 1.5526827504165666, 0.08918111768593844, 1.2452217827852259, 0.01317455475301314, 0.20159704410753843, 0.6124919174291676, 0.004362342309147829, -0.8288525291070338, 1.1879159951666547, 0.5476373023540826, 0.680702176473806, -0.7419749759645791, -0.32797742865481766, 0.9470809079870376, -0.6308466098645744, -0.18816325844457876, 0.0352422728636656, -0.2934879434488547, -0.6234255496091387, -0.2772535180142075, 1.2006694262662405, 0.17677236241038355, -1.01811007166909, 1.3950298099496536, 0.3305554214959385, 0.44992295770928403, -0.18995257784748965, 1.5102300203129038, 0.553624233734082, 0.8948383477573274, -0.4630816735864732, 0.24147424582340526, 0.038009968007873346, 1.143764423782742, -0.37239234422766937, -1.1354223676401354, 0.027035428237144738, 0.9723738392100941, 0.875575233418657, 0.3702140106914928, 0.5601544467780663, -0.09526142597784006, -0.9907158911268159, 0.48205331632206794, 0.34447206135463715, 1.293432300819634, -0.6561131537970972, 0.8205341557935794, 1.0438506245516659, -0.502458511616429, -0.7190939501609993, 1.0139423321723924},
    {-0.07750899728369588, 0.32809384963750615, 1.1962135921531198, 0.02065363638815812, 0.3748881523991502, 0.7358065990593012, -0.8365735424748366, 0.9483120321619982, -0.938349360920978, 0.4150435766587295, 0.6690386032874994, 0.2570615923517157, 0.7085660108882541, -0.7500578337218712, 1.2063108969357936, 0.7843998671716572, 0.02769840538026742, -0.5357999102316143, 1.2244724959739142, -0.45690917177500895, -0.765834244597681, 0.4833951276238396, -0.8803843582340316, -0.9721576435777832, -0.8953227292844966, -0.7302606942771163, 0.08373232533153549, 0.807303960767577, 0.08589276733423386, -1.0358828560771212, 0.45046484598864034, 0.8995644781671277, -0.4579532754891434, -0.09660607722293683, -0.8278547403309586, 0.5315715654435063, 1.2759471826416633, 1.5635526940221531, 0.628606725581303, -0.031129983284312497, -0.24419288994193192, -1.0843592499149273, -0.554327844391671, 1.2152979436683085, 0.9335018630529069, 1.3149687666353795, 1.0367620470960037, 0.022641569182526796, -0.28155602209809816, -0.6424843508070837, -0.1718765214241088, 0.919523675076837, -1.1620662510617188, -0.3712815832201029, -0.14243448862472347, 0.021092153719187774, -0.6792987327442301, 0.19307651918580795, -0.5696970032234121, 0.7379999689212642, 0.689311249035837, 1.0200438443096305, -0.5490282047870324, 0.6543788644157967},
    {-0.8872511384732793, 1.0376367540668043, -0.4337889754654887, -0.5438248435467722, -0.518957581271952, 0.9337140788694653, -1.0733892046217077, 0.528126021000532, 0.8478304884265597, 0.6946685213001582, -0.49298141093757386, -0.323602017406409, 1.1013742846958274, -0.875965656673596, 1.3023701303543822, 0.1169974687519281, 1.2764713860014476, 1.2884985804625764, -0.4543963615819404, 0.6465417453454907, -0.5630549407134432, 0.6138190513674717, -0.7903144560261508, -0.16956934114396865, -0.8519805996968954, -0.12535695636918306, 1.3967631833414784, 0.5300706586845403, -0.8456514470970707, -0.8338015735532527, -0.039500652057917265, 1.0216061959630776, -0.8325859842803682, -0.250370196266192, 1.0843916989373645, 0.31257697940692986, 1.101941544208218, 0.5824750631883951, 1.3217031488309785, -0.5460636700442816, -0.7062370850521077, 0.41084562300695526, 0.45509775668510055, -0.5851739871202524, -0.48592826120332233, 0.6747661479738616, -0.5342046610243435, -0.19401373426704352, 0.17960647406174018, -0.1441546635546675, -0.4440283783652585, -0.5703145413851607, -0.8712492460128267, -0.8650873098226904, 0.9527300941504199, -0.135506467514449, -0.9299551052449635, -0.8585708698951536, -0.7978288697247039, 0.43760811119162446, 0.9219348614969004, 0.16543003961480995, 0.5147213316448829, 0.8319131220414441},
    {-0.06523717025734509, -0.1961673915566549, 0.867523361419693, -0.41779436013466126, -0.5400645612706029, 0.22212489015216685, -0.7064774630745203, 0.6221824733185513, 0.3329307278605376, 0.2500976462998489, 0.3534212167987926, 0.5108851228518226, 1.4355007263786925, -0.5089179695637218, -0.5262375410829626, 0.2544395158113006, 0.6421421528621206, 0.8636642687551859, -0.09352625984628836, -0.6435693479307995, -0.10177564338091181, 0.5286590303653642, -0.2636190376901535, -1.0445037950758955, -0.5818476100589027, -1.0033730783775112, 0.8360574477666494, -0.6275493178147458, 0.31201883276023795, -1.1713161437142656, 0.8349173885196298, 1.0634330682660595, 0.20129024370194148, -0.1158662363312404, -0.33139948581611806, -0.430769623659293, 0.4300136437053259, 1.1708734313224543, 0.47092003920912673, 0.8744748811352412, 0.4490301349231067, -0.9841725891457982, 0.3636021048624962, -0.3537688758170767, 0.2600738840495113, -0.20382521581296617, 1.2316728105566885, 0.43146591129504924, -0.6795560857092285, 0.8487038883621407, 1.104404624256182, -0.8905029480103683, -0.7450350230103087, -0.5308087943123145, 0.6044641477698741, -0.21702704334725115, 0.23947502698102363, -0.9537564930229399, 1.1562910518807645, 0.9522850035468118, 0.5969471474191972, -0.11161175386149831, 0.6354414526964712, -0.7528513032498613},
    {-1.1316175814007292, -0.9577662494380947, -0.710593674315745, 0.34192015155812444, -0.8102925504881135, 0.7140142785335328, 1.0260477885209365, 1.2343365200714007, 0.8044268387480094, 0.7769065805310084, 0.549580954795659, -0.032845339479500066, -0.3307683724311114, -0.7333106748919324, 0.8470074565983483, -0.34536762223711165, 0.029322180431616118, -0.08664002726749921, -0.7060470595301186, -0.5245328198913486, -0.18476330843775585, -0.8605228097935389, -0.10557959585053907, -0.8340140974090852, 0.9321574736087257, -1.1507928171863624, -0.2661528379978688, -0.23990189164340758, 1.0144266609921437, 0.9268251538633115, -0.30603470105854336, -0.20956664481298234, -1.14549609513361, -0.2137112102350575, 0.8136794328591732, 1.205292563399419, 0.4537486245010892, -0.423706618900277, 0.9932339932375588, 0.640251800318816, 1.1367337596887683, 0.08296114889128291, -0.10210182647195386, 0.4356960541782395, -1.0261987038682279, -0.19288376558967782, -0.16136036560274947, -0.3479457730789409, -1.070940287218805, 0.8032045833785422, 0.44326951455199093, -1.0353707424098768, -0.9024104140730432, 1.0268317829631872, 1.2216053614122053, -0.8082510475700476, -0.0853596821204753, 1.1348754210211907, -0.20024254629720037, 0.8806452981953343, -0.38550980007280544, 0.2428985562062091, -0.6560911628918151, -0.3867971467855952},
    {-0.8895716692824271, -0.12712155803871306, -0.38554937065526124, 0.8024971344370992, -0.7993449547597363, 0.776176644470353, 0.6006815183304396, 0.2891230338573016, 0.03635177753834936, 1.1562252378330322, -0.143894922515471, -0.21211476675860352, 0.272966026532229, -0.1721016683190216, 0.7328985112986706, -1.1325420668613781, 1.1418481237029514, 0.37886150537787366, 0.9652698260897712, -0.4787356644226603, -0.5741580872458248, 0.6280961979987382, -0.31088701583422557, 0.8165941660669842, 0.0709827092944294, 0.05565528068446203, -0.1582137779556424, -0.6917726470467594, -0.2799240659694242, 0.32747680507511306, -0.6373253268662765, -0.1363720949875429, 0.4813838287642183, 0.9220868650986273, 0.47398059890377653, 0.9313337682868946, -0.9217320358219273, -0.6277569177937977, 1.1301570708314201, 0.6784138350736462, 0.5026465149160896, -1.1364706442856305, 0.4086767798235735, 0.4952770345596176, 0.07144591837777921, -0.8653773611437898, 0.7774452030769778, 0.8356285997468965, -0.1469064104722197, -0.38372059908758427, 0.5793129091104193, -1.2019229333713206, -0.2014878617768326, -0.44714176897133956, 0.49434402879911366, 0.31515048997588946, -0.34309756196439184, 0.13762774222440147, 0.4993705944365599, 0.6667928379705619, -0.8914733054653449, -0.28660011387308487, -0.8293499733274815, -0.9290966292225367},
    {-0.9993671342562181, 0.35213300162688804, 0.7382562566386315, 1.0227586260545565, -0.5461236833766066, -0.5937662564903451, -1.219011431747349, -0.08054499017310904, 0.6612266594985249, 1.012490706425593, 0.020112744744550756, 0.24192569412612022, -0.8214914794954853, -0.21016316168663188, 0.8646919294799792, -0.6483648098610404, -0.21528778197014892, -0.2521425884325641, 0.12406502027360376, -0.2860372553952118, 0.2988664840120145, 0.0007885526615448976, -0.14053005352028525, 0.8414404036578774, 0.7827672931400218, -0.7242417023023515, 0.2523450255674528, 0.9931465343472758, 0.23077540395291674, -0.305041776120907, 0.31532523504606336, -1.0895982528482797, -0.04908322040262259, 0.9079716994153119, -0.38756504945980036, -0.37793163740861646, -0.516641247016141, -0.8915021999151325, -0.5709584017221727, -0.10966844734755192, 0.023870054999506108, -0.4957986116677509, 1.1014576094285187, -0.569681386421671, -0.02055384058449394, 0.2897974480672998, -0.49897182234575443, 0.16006811816789782, -1.1377303066520201, -0.13243286326663886, -0.38068761809443225, 0.8430661519228527, 0.05152892489817294, 0.903484335687949, 0.9748769199900197, 0.9387186573338706, 0.6647623919363727, 0.8202284682189447, 0.6443571790942827, 0.8554886767440885, 0.5917129083963975, -0.5720894639044638, -0.4754685651948517, -0.4091003363828095},
    {0.6363837390402034, 0.30327248244711397, -0.13825049689545235, 0.5823983799155055, -0.2683406692422168, -0.4176639215374283, -0.764226725751066, 0.16060518483264655, -0.19229958288890656, 0.7577520022869972, 0.20139588764511757, 0.8111185861041628, -0.03735392699883795, 0.482755141954643, -0.9201968458755939, -0.35982362777531135, -0.3067442020078262, 0.3986601796650786, 0.9463422500884617, 0.3854986556176582, -0.10755797257583533, 0.6502429605769917, 1.1633667471426397, -0.11340504902030817, 0.6639232492921643, 0.7743343484584723, 0.2228700521145183, 0.031138363972866435, 0.09826076428113827, -0.5589545698817188, 0.8561945233923294, -1.0551355967040623, -0.9658203120926127, 0.5833019638908812, 0.3487546096675165, 0.6877117848173231, -0.18845211238834036, 1.1713319824002655, -0.2737240337174594, 0.8747986958180933, 0.03656746569486517, 0.6600354258966161, -0.39766477332849887, -0.41468833472588373, 0.7228691939927094, 0.07665106846891058, 0.7278131441614145, -0.6793951054843538, 0.23554857434252305, -0.3229126487282783, 0.3568374557573492, -1.0209789315105384, -0.42464953534100497, -0.24682162767465138, 0.9998586216417574, 0.5721388011879367, -0.5562338154936212, 0.21106146865644235, 0.05353102599683421, -0.4340573342299706, -0.7516130296570018, 0.9696115049971766, -0.6295087931105492, 1.0436703520093307},
    {-0.9955803775761132, 0.7966994863214153, -0.690987389873909, 0.5964753875185399, 0.9315067208833351, -0.3674403105628569, -1.0824305100823357, -0.6886828236229741, -0.46377694293963234, -0.5466184744417102, 0.922350128297913, 0.44223107889999297, 1.1384453498333356, 0.8857124050490423, -0.24735770346613337, -0.06935426132236258, -0.9203418235627184, 0.5257250067001364, -0.40708904077623775, 0.5839443079462222, 0.3614943162947596, 0.20358180489751954, 0.41947204379394626, 0.14739914299056991, -0.7453366351707295, -0.8873478517033742, 0.38800529580009485, -0.4896085590003854, 0.9041933229800739, -1.019953495555529, -1.0737264468784202, 0.1135606681601331, 0.8254458364286733, 1.0207332250443462, -0.4490930693583849, -0.18250071237807808, -0.9575183962407586, 0.18914455039148326, -0.14925480891033233, 1.0842380521074881, 0.11609085540288368, 0.4244364620319206, 0.13746092241845645, 0.8355859537325022, 0.5286061156635139, 0.5660203744217849, 0.09519835241094854, 0.10401150538612762, -0.7656097074902941, 0.15145361228671153, -0.23340164503137137, -0.5697027697282017, -0.19169698497159396, -0.34748675859012307, 0.7582768604865479, -0.026770696034139386, 0.9486478847179816, -0.7214571991864389, -1.1053260979794692, -0.48358024105489894, 0.2477316765530361, 0.19121649937931695, -0.6902587818371774, -1.0630356128613347},
    {1.1525528990462592, -0.7993529400014812, -0.7312196782777258, 0.5126731235539773, -0.35262493028535996, -0.15868603982877666, 0.06362887013047358, -0.709585625846128, 0.12801228207109497, 0.44133677997669757, -0.9905545943589621, 0.09748374988736153, -0.7489771998289149, 0.0305203618998165, 0.10372136146082941, -0.13298080221536934, 0.7751044416986039, 0.6744491968103119, 0.1051474767038401, 1.1807114258709157, -0.7211634364326831, 0.38762091611047456, 0.7001885290111423, 0.9729980067906003, -0.07901104663025647, 0.4819741980254997, 1.1531257631879248, -0.38192223044388335, -0.16994342335263304, 0.5069619398883941, -0.9932409039934695, 0.26883635184098514, 0.7592357286042939, 0.38380922321179745, 0.4586341013443893, -0.13122056414374597, 0.10091746707606157, -0.8964037464708667, -0.45047746918221326, -0.7646259132984125, 1.2650296423098286, -0.026092217356357198, -0.10540028588571136, -0.9917995096983541, 0.3932496402803412, -0.8843156598496463, -0.282110098110734, 0.9630874836715867, 0.9111175139083797, 1.013965563722622, 0.39295028358930956, 0.8439335965664561, 1.3747317347806987, -0.23164538485422825, -0.6021406008821655, -0.22857907622916196, -0.7095044588022793, 0.7494497362739798, 1.1746024566136448, -0.6921121735380608, -0.8544220637311192, -0.05271896946694375, 0.3145718129394874, -0.5219635239589084},
    {-1.1573792759525396, -0.37004619040048065, 0.35473128400221976, -0.27704606360525297, -0.2694279662353166, 0.25319510431422554, 0.7982594120111681, -0.7103877228116614, -0.544887978230453, 0.25592305267230747, 0.851895911820629, 0.32987555308275796, 0.7548932451658784, -0.2523915529483668, -0.9500901820509424, -0.4176437586567268, -1.2513974450655136, 0.17605377695003388, 1.0592939747521837, 0.23708803385533272, 0.6484307998219198, -0.22639442005919555, 0.45641080412010243, -0.5387711520366704, -0.36636067428288754, -0.09323382454574022, 0.7102389486706645, -1.386358630620994, -0.4891097908739612, -1.154248656056931, -0.6460817076943974, 0.8193069790766487, -0.4401598193724772, -1.0462775778212725, -1.1663535916732597, -0.05895473381664583, -0.2323288273197706, 0.3235486686856985, -0.21121351891602833, 0.6857612579690836, 0.008525391017415616, 0.9945242665904752, 0.3001359839254093, 0.2603253949032432, 0.4947370523895122, -0.6043550242924421, 0.7010905537652803, -1.2267715156814032, 0.17831493883333546, 0.14877247861791928, -0.8975908480698275, 0.5247463019754918, 0.4617838344973493, -1.211998129160978, -0.7824657012107665, -1.260569179084946, -1.0369226451918852, 0.20270162789798435, -0.3381087418202576, 0.8515765944114041, -0.2298091794685183, -0.8722477070575085, 0.584482155727291, -0.6194991102232065},
    {-0.4811016487793399, 0.7247327545612983, -0.32526818168732785, 1.034823856750915, -1.109408607756604, -0.20967562942987286, 1.3161660037126377, -0.09441641163329094, -0.1501682516685395, 0.6334065708225661, -0.3856875417195675, -1.2116793517715476, 0.7380997198179576, -0.7865712674811136, -0.9347876949631031, -0.6896601431675001, -0.43927833007457434, 0.3907226090445736, -0.6366295901103224, -0.7582457061154897, 1.079753942709105, 0.04366570406861981, -0.21377407350979907, 0.7148146607799286, 0.4106174389459799, 1.22006850397284, 0.39737998644678485, -0.22080975259375402, -0.38127864275723283, -0.994167571176358, 0.9216516719197632, -0.09575006361095263, 0.5069227555461399, 0.3394127146865402, -0.577144414024705, 1.068190284063078, -0.42152712103604445, 0.62497394861543, 1.104643605084946, -0.24381657163240855, -1.2917081266921604, 0.9442040783515152, 1.2238462146894225, -0.3266093901643341, 0.4153787197129548, 0.6045813863477411, -0.4632345521403535, -0.4827344406964388, -0.9462806633766568, -0.5581744446082506, 0.09958170203218784, -0.09890027582731664, 0.004343786518013883, -0.3371193818709189, -0.8658217553892221, -0.02084997824863459, 0.8176115178171519, 0.206606217083701, 0.8162522928894309, -0.15424292830479536, 0.785640060623715, 1.2578705025382892, 0.6138425782725946, -0.5637841295191078},
    {1.0516419110839075, -0.7256067900858428, -0.6946212920761841, -0.026308873666564987, 0.10092581122948882, -0.5232429508224857, 0.5127659327229287, -0.3870290941854169, 0.34419068493596994, -0.04331967066153332, 0.5987563706291602, 0.4471150270876035, -0.7855295009908481, 0.29926609244176033, 0.5450498300157353, -0.01532224545530381, -0.6127396377501434, 0.06701420574416952, -1.0288962837725666, 0.6160336898776733, 0.6767339386925821, 0.027587103843790484, -0.8427078027146585, 0.02055139739696042, -0.0586074939434531, -0.5833952488897883, 0.39014820861269206, -0.8012255536194299, -0.5054730853915503, -0.8905108109306556, 0.6193151735866471, 0.3141712751333599, -0.4115669816133234, 0.5950552969155458, 0.42682226627313063, -0.19047847968864332, -1.0548777669238592, 0.014627671800853467, 0.8876733964985152, -0.13634228980298307, -1.2047013347490776, 0.5912952902710509, 0.28152416700067345, -0.6502876475142334, -0.47840059727840445, -1.2598325333731575, -0.9669631867934659, 1.1809227156094175, -0.07119846610211678, -1.1049903740947657, -0.7865197169372709, 0.4257026900053958, 0.4120693959399453, 0.2900648610181381, 0.975461975371875, 0.7592458584883678, 0.6120383635508735, 0.10328403079403319, 0.4091136455635518, 0.16648901588816256, 0.9629811864481005, 0.07531401722563318, 0.7044440927561746, -0.29591679806946136},
    {0.5059804167482375, 0.019948516606208635, 0.08425489854105138, 1.183767079780502, -0.8042384334545536, 0.8866553715189135, 0.45350768228871546, -0.44614182453786033, -0.12814697282726245, 0.5222693540387083, -0.33634760980776746, -0.2394380391471167, -0.1718568091304695, 0.6043845054439662, -0.20061105121509132, -0.06882737826076424, -0.12854259460024017, 1.2226872848593748, 0.10767417663761095, -0.23632375893997257, 0.08295786294944403, -0.28195409361769713, 1.3362717602793268, 0.48203074245506783, 0.10175807686416434, -0.32662119872910084, 1.3332310095425046, -0.9488485375436814, 0.0886155255174219, 0.06839697443082586, -0.7790177107176318, -1.0998989743020227, -1.017785372206321, -0.607384465191724, 0.040065133238431964, 0.45648083577841125, 1.312493892022207, 0.7596912024866338, -0.21387704583021025, 0.7183625211236521, -0.3868052528943896, -0.03844837314361801, 0.5764117617160481, -0.12456530893108958, 1.067743198077573, -0.6987979396271993, -0.940408883813365, -0.47473634080385885, 0.7424378181872937, 0.5789337263848874, 0.6937644785558039, -0.3276430313284539, -0.28522397531014, -1.1429580779231057, -1.053198648074532, -1.1930801717138526, 0.2504736838473595, 1.0467677331116665, -0.9449965504207765, -0.7087011491210216, 0.7694837121529859, 0.33918679768865784, -0.2231540510390804, 0.3673952659421525},
    {-0.06608136231379047, -0.06414481913114997, -0.18044408332206316, -0.24161631596285965, 1.079300279281118, 0.34518506267632965, 0.16210757666385847, -0.5232894185579116, -0.9403930790280316, 0.26234640392745834, 0.8339132283265785, -1.0185968894289275, 0.2842506586983303, 0.987246029471278, 0.6406931709819842, 0.8190535932279922, -0.5455969123445801, 1.073174938344296, 0.4553127936016088, -0.5651662806386669, 0.01843049481601146, -0.30912097486847095, 1.4033564388718394, 1.0082692696536222, -0.12145211139659455, -0.2902113913628124, 1.197490576006018, 0.26650984257513066, 0.6387143333156003, 0.6332186025243981, -0.17834652893572214, -0.5415580449706349, -0.20461933180285305, -0.47156130829741083, -0.709816011868994, -0.5863203140679054, 0.8547193267492046, 0.36616101172784227, 0.04816123849815155, 0.3195906067995221, 0.3649875036511465, -0.9860636039608519, 0.8844732018076716, -0.6342583710088818, -0.6477541969275982, -0.5795763476551412, 0.21604141744636926, 0.20689792334506604, 0.09144451103817491, 0.386721668866805, 0.0533700290515036, -0.1126637548813587, 0.938625873357349, -0.4219092938933786, 0.2787038934417714, -0.9090920269698636, 0.7414344219901946, 0.8804640405345583, -0.3969078667022971, -0.5024909245791671, -0.005111703989899856, 0.8554510233971987, -0.48506743800816243, 0.6156913528427208},
    {0.16475508134825803, -1.1118855697952335, -0.09306796251637674, 1.0855295763709085, 1.012220540806777, -0.4797175399417784, 0.4227444798774041, -0.9723830187017449, 0.5332458265827835, 0.9990250729812987, 0.4209392180086806, -0.9181255836158393, 0.5679946217364793, -0.8616121413382116, 0.996075880297243, -0.08441015354443579, 0.33553917714761616, -0.15699355754948272, 0.30579537977036836, 0.5945159195545509, 1.1912248404997001, -0.3285238379910424, 1.211022516324298, -0.40847422429820385, -0.8211195017447216, 0.4498658806692382, 1.0567233860686538, -1.231235703644394, -0.1517574710740158, 1.1606312570548025, -0.21882197982126533, 1.11196338132471, 0.8867582323065938, -0.2502047332954734, -0.37945258595728754, 0.020514223222307768, -0.44935394020812175, 0.5279269452810009, 0.4614896498211692, 1.0865903097531633, -0.6853714352879203, -0.6039723283527486, -0.02907129817773363, -0.06284842967129137, -0.06819296340114836, 0.6172566212925944, -0.25468260764463546, -0.9088506069576145, -0.6108064803377514, 0.9261405685511526, 0.986005017638459, 0.16859739543483476, -0.5607962626315558, -0.3581866123324852, 0.3874050808924648, -1.0881270502670413, -0.333744598377817, -0.3225162655306495, 0.663436327042921, -0.5863692872383428, 1.3604174561651479, 0.19047899947419195, 0.28940451555659163, -0.8160318980766984},
    {0.5222668143178162, 0.16709529832109915, -0.47480145980272015, -0.48411182332449065, 1.0647674451954194, -1.0101314939424824, -0.5267035542116459, -0.03355486903975689, -0.6150669699044834, 0.7529138589520726, 0.005836991918541741, 0.6467292716327934, 0.5005828222197377, -0.8063869323122652, 0.06561480376617308, 0.43006436838630163, -0.8398195116416268, 0.36543979116242664, -0.5731909158276847, 0.8585750354059004, -0.44297530563895815, 0.9858608564498901, 0.9148982065788935, -0.7264919415088638, -0.5716400137406773, -0.19834201108439567, -0.5159839895199748, -0.7610244273619536, 0.9012131748560341, 1.1851520981586992, 0.3580873011260313, -0.12980068251701532, -0.46995621963285733, 0.3962836823172017, 0.3900235365011119, 0.4299083680333791, 0.8626575176288243, -0.5390154104564261, -1.314295464827202, 0.427145750122742, -0.3645017852331145, 0.230698886749059, -1.0327662361248995, 0.2968147739735133, 0.6696694817693094, 0.516720727301161, 0.566763019374837, -0.49021168549934235, 0.7995939812063851, -0.364658821842171, 1.0572420273930636, -0.07752570777192433, -1.2185353475512597, -0.1478239581526315, -0.6225128222983893, -0.4388938511105844, 0.16742147541072416, 0.472093138343669, -0.7549518571286429, -0.49224468904760815, 1.220799977797111, -0.05797363285763322, 1.344250775730625, 1.214288846689071},
    {-0.7471993074951201, 0.3710294320002599, -0.45019933368871484, 0.5629789957533957, 0.19099317241277913, 1.0521757615737168, 0.9236876098260391, 0.8253968286133024, 1.0824169431560036, 1.051155774923245, 1.0186699844515323, -0.47230271249112843, 0.7602146109143467, 1.094322806121333, 0.7864167524720811, -0.30293505882995153, -0.3887987740130229, 0.22978657950984793, 0.6345079552734109, -0.05062615913459604, 0.9653935627905291, 0.5828937800038247, 0.5827644296505905, 0.8603148785741691, -0.6575491405862423, -0.42211405481400943, -0.3497560231924296, -0.5849234207832095, 0.4725422970325045, 0.7212351510953818, 0.10591262026920391, 0.6725022865103837, 0.5242508748006485, -0.6170612802663641, -0.24640519811094522, 0.6043695452715744, 0.538121880932922, -0.5458889074482904, 0.14011610584307338, -0.11747217841240987, -0.9234920056650388, -0.5788948392973168, -0.7270013492547878, 1.2089421757134884, 1.0081564998305774, 0.5007417714318638, -0.014922708365650052, 0.7141129325396012, 1.042289140320821, 1.2615044404262912, 0.6883139636254058, -0.08438191035005412, -0.06311980897448596, 0.865256761062912, 0.03890855267806464, 0.37996427239911856, 0.16694376973198638, 0.3291796541867394, 0.8667000258620192, -0.26732179413689194, 0.8411181709162655, 0.6774007809605648, 1.0411898676162157, 0.11347990408706606},
    {0.7439994433011528, 0.4572294818617531, -0.36711643626810914, 0.39250521001872735, 0.30287579101975304, -0.357999868568824, -0.1732947035702006, -0.20386178191529025, 0.9265043105396259, 0.7506380471829809, 0.3800854021409649, 0.4318737163649919, 0.393943387326075, 0.4977446423805674, -0.37458805550684, 0.3728035175716358, -0.9053403568827992, 0.4456204523586915, -0.508759384118809, -0.14243450315385017, -0.4847883175188811, 0.6936792151282541, 0.3214690446968799, 0.4654892489011756, 0.5039047115955226, 0.817558919001954, 0.06389082644866971, -1.3299345848293231, -0.9771574460075254, 0.20317433236817323, 0.48016937714324087, -0.7731570607012813, 0.24533505903778, -0.858979059104762, -0.9882526947192745, -0.14426476174827216, 1.0280873537086217, -0.698077183528332, -0.6051887737948176, -0.6391145692748892, -0.4724605505813653, -0.4372385435778376, -0.774434775990165, -0.7664106615489874, 0.6122139192618713, -0.6604020913268982, 0.9899351683046468, 0.45207180199001934, -0.8569581214078554, -0.3886347054249158, -0.472449955494188, 1.087365915042995, 0.6782714727391075, 0.02960027975446871, -0.9233366244075657, -0.9571149465186083, -0.7283988267679745, 1.0224550647879862, -0.5475701190092747, -0.4823539178775103, 0.2501385576619672, 0.04358587203365545, 1.1740358400458033, -0.7609131981258394},
    {-0.2940703983134601, -0.19859433571635232, 0.8920659892101845, -0.4939599141509644, -0.8669424398467708, -0.38819374956275704, 0.4620379559987942, -0.7364752296032665, 0.6938778562883822, -0.6999517401261265, -1.0147736381615222, -0.7687165120653269, -0.2623143028159628, -0.38226741377604706, -0.03277388398921142, 0.49295831379060423, -0.6365529721117489, -0.8888420729299271, 0.8891836731889132, 0.8912961472196486, 0.6821625806595394, -1.0897751113728262, 0.9943243574997319, -0.8859866429277641, 0.6264680884330177, -0.5939646800647708, -0.938589341518374, 0.6920253205192564, -0.7619299805176598, -0.5164387721814674, 0.576523729938955, -0.020560507290448615, 1.1122205826538505, -1.1539115787125303, -0.6057682490251138, 0.24683389531172548, -0.5666322781440388, -0.6327394071138696, -1.1090637047674647, -1.076249216562324, -0.5948161848553528, 1.2516251830329914, -1.22552512086186, 1.0327926220296038, 1.0129996626393463, -1.0959965923875468, -0.18730904903879905, -0.3757659240972493, 1.1030649210350763, 0.4458777735569424, 0.28034381260886376, -0.7142302447367783, -1.0959847207560292, -0.1699359600509439, -1.5846982733886077, -1.4144373554724696, -0.6583074385409974, 0.8665208508718438, -0.9665007538927087, -0.3950488269467288, 0.14930980472807112, 0.014745987986367625, 0.44638354414934056, 0.8584525240666113},
    {-0.48347283946141334, 0.5556804636766022, 1.161516634998473, -0.38605126028575826, 0.7092560218456152, 0.22186289021014277, -0.34744497335102187, -1.2961473983545329, 1.0984861409677285, 0.22282423356610764, -0.5280710122496397, -0.4559471059372481, -0.7033186624696731, 0.9730615584127781, -0.49709132244922855, 0.6056558452399169, -0.8210850810514303, -0.47666282606536203, 0.5590363482536073, 0.2229311643744301, -1.190667986548347, -0.717015667436685, -0.7872975212730084, 0.7288528569397789, 0.9096288645530162, -0.9558006387619289, 0.18919581649402997, -0.41074682559375814, -0.07681163346752191, 0.9526692992685265, 0.4038867811992097, -1.342574551299515, -0.653209279278626, -0.4420381331134673, -1.1864148716889173, 0.19817845029442013, -0.15822106797925894, -0.500462184719902, -0.8401600853615987, -1.4297830043162643, 0.5195499078976813, 1.0977822612271977, -1.3886317212344748, 0.5061302838819386, -0.5788408797979957, 0.08099911750484326, 0.4136447628131582, -0.24135061209147976, 0.46488395144512223, 0.4668414269053364, 0.06433102345800383, 1.0549920050326733, 0.19585149910528446, -0.5905773501847251, 0.4974928095289773, -1.3002180958463607, -0.35879587958872844, 0.46678683699962614, -0.490038614884979, 0.5986407897200611, 0.6260671758827367, 0.04608337296305174, -0.43492207011930734, -1.1818607240203454},
    {0.707651642880727, 0.15743284617790923, -0.28690574041729067, -0.21173034544403957, 0.5541774822001816, 0.6038453231380043, 0.6836438301028953, 0.13657430284790037, -0.474569963147714, 1.0893065848935426, -0.9171509245056996, -0.7793127192271265, 1.0760652047125046, -0.9481024311629456, -0.6374153034386341, 0.010326409037199266, -1.1157436526058817, 0.18599719150998115, 0.17937694178401895, -0.17033438771876272, -0.35530668291208056, 0.800334892877595, 0.10731861304559338, 0.17663370593571234, -0.5583568782112317, 0.8821637393620319, 0.04940565728382989, -0.852107541912746, 0.4096972342206112, 0.16999082351118158, 1.2916405421223525, -1.1437378118222394, -0.8068736055527497, -0.05636991221336281, -0.4164509346552555, -0.4911755616074388, 1.2857051465293126, 0.6583336099575007, -1.3501679002856006, -0.2629366202102283, 0.7220180318387257, -0.004058797116434106, -0.6813951564775043, 0.824598132676964, 0.41339405752784875, 1.181297942006919, 1.2206156766816798, -1.269570905748471, 0.2707261953319136, 0.48439767033505593, 0.13525049174305298, 0.8873594223185365, -1.0038205360241528, -0.7202838059423742, -0.4292699698254729, -1.3646558183844355, 0.021025623324825406, -0.23865210151176205, -1.1896732410014987, 0.9896556626165857, -0.29141072856576233, -0.1281084699239891, 0.3213759229837124, -0.16185576608113506},
    {-0.6538001773507949, 0.5521715137180754, 1.0797688120014663, 1.008045232392139, 0.6699568803334129, 0.7559853806784653, 0.1906950062162762, -1.0187172796537636, 0.547272258170587, 0.43795477531762356, 0.05142375320239223, 0.07977708623866893, 0.9991411598162945, 0.25515460224896147, 1.1057736324718799, 0.2903017357890579, 0.6127594241336024, -0.8615870015432792, 0.25452319723550565, -0.06378465424164727, -0.1646968061351652, 0.5974051434583143, 1.2495364075468567, 0.22502094537880452, -0.39369358280264505, -0.9266870460978618, -0.7918378707898125, -0.15443060329790717, 1.0767512490120374, -0.005016171270465327, -0.2850697723067403, 0.2882368557145123, -0.7213570873957879, -1.11404230381852, -0.8084194736271558, 0.5272597300631394, 0.7631158556472333, -0.6466098891368605, 0.6140691933382963, -0.4229015340472876, 0.6042531381213225, -0.6226902586993446, -0.8007872819097331, -0.3344224849349836, 1.0239177368488048, -0.741091408427745, 0.2631457255142956, -0.8487094756644495, 0.8451322712242503, 1.088964115442483, 0.3392894241641023, 1.19780484016246, -0.9612771617405854, 0.08003878860560067, -1.2582663633512188, -0.9020773321740996, 0.6746021575183604, 0.01065785729523222, -0.7991110041945628, 0.7368230605773263, 0.5348613368754317, 0.10474258529387562, 0.6760475193509735, 0.30151584705446305},
    {-0.21933440874459706, -0.3004100526009033, -0.8421210663168756, 1.1404446433475088, 0.5814637207325535, 0.9430240806280168, -0.897603855670225, 0.12748476267968878, 0.0026215610093591824, 0.5535775516218757, 0.34878160196258134, -0.15902495584463403, -0.009828065573673902, -0.10161443257033385, -0.4947609535643256, 0.6244888527293629, -0.5536928137388706, -1.0910983506462624, 0.4393305484382174, -1.1307088698629961, 0.7894218285052017, 0.017962144771114186, -0.19417168067535437, 0.07811656767998687, -0.5929341273196144, 0.8542207600488257, 0.31095627217934735, -0.0492546003286465, -0.34860641598305053, 0.7214830153463697, -0.4818668239759655, 0.5119789284373292, 0.7791948928092625, 0.4394450868771028, -0.2961128820182898, -0.7817319100295466, 0.7100327567591604, -0.4837857756767126, -0.45542852344844004, -0.8367076445157711, -1.2137152766489012, -0.44274147665095026, -1.3185201070373223, 0.7127895790536742, -0.5236764989496986, 0.29785694130109897, -0.4995697856914223, 0.6632742657364962, -0.1753212955306778, -0.6289504347582139, 0.9339364215292602, 0.024776894995046487, -1.1473178843036553, -0.978626030563695, -1.2139004727626843, -0.5016180432777093, -0.7337579888119388, 1.0926369810176706, -1.148598186666995, 0.6923866859418722, -0.3293998731282778, -0.07082076266231414, -0.7285575766209912, -1.0591760360647169},
    {-0.0776821869224062, 1.1166099339546862, 0.7566256662479058, -0.6050605487531872, -0.5253632953416669, -0.7709420737471232, -0.11010790530405454, -0.6502002604924594, 0.7447858878250702, -0.42990523619029875, -1.2192089200550151, -1.074355475952818, -0.8663354225607396, -1.060540837010612, -0.4647454939784092, -0.19495503330737135, 0.767179036614292, -0.43918113483978755, 0.6754695272440578, 0.5643135420034767, -0.22740443673766889, 1.075292348198372, 1.0983604166587264, 0.49860268258091583, 0.4763751779182947, -0.6540050654427155, 0.3393453445932143, 0.7301847864570525, -0.14954939566240766, 0.6612904785799318, 0.15648544655194674, 1.0500324347460204, 0.18583056161987188, 0.1513597340375545, -1.1297121433168302, -0.5739390871180817, -0.4892743050862135, -0.07722018441700877, 0.2923266222305418, -0.23403405311541753, 0.5422765400222115, 0.6452867693644347, 0.7018803093509309, -0.5144063582123364, -0.07797817636954575, 0.9426497000457418, -0.09968970500715534, 0.3628481232855803, -0.48138065963851806, -0.8424183242673016, -0.5142177028481808, 0.5589874271467494, -0.4531257200214086, -0.7652161107810336, -1.0396726955516815, -0.19044938106742315, -0.9114801696223144, 1.1165268008285847, -0.5120420931702517, -0.20346890778271134, 0.1788786988745844, -0.9709039382519724, 0.2906890936267693, -0.43097857136539136},
    {-0.7265743618615863, 0.9377400730659422, 0.3134815604493979, 0.6053710189390734, 0.7273318626586385, 1.1644892243057352, -0.35019915468789403, -1.194163392815284, 1.1267447289758747, 0.5555061138827015, 0.752071961584674, -1.1632335747015967, -0.21539726446901417, 1.0647578879597024, 0.4313779116478071, 1.24689007844803, -0.6457313279626056, 0.09441469799843628, -0.7410535502257833, -0.6454548531234444, -0.5091005265771155, -0.5507804169174124, 0.7955008759263213, 0.12825655429691427, 0.6786568463795659, -0.354312952713037, -0.0647809475215836, -0.2147997432641382, -0.8881643355744577, -0.7312572692592212, 1.040621880149426, -0.62369854762771, -0.3299904091028771, -0.9213417055504008, -1.35960909061796, -0.7673712971569366, 1.0983573435270166, 0.8809250648730275, 0.5819496670120746, 1.0180776142253234, -0.5757559625873386, -0.25101623208388435, -0.01651738067569008, -0.7536983007406941, 1.163397256273031, 0.9593921304958848, 0.8421450892972336, -0.4319720160931585, 0.16816843648375748, 1.132271876535478, -0.23480595731490633, 0.6761272115723286, -1.0296662535353036, -0.04902815416579101, -0.7876473569997448, -1.2550362800306047, -0.6935483942211693, 0.918672129636426, 0.7629143871661895, -0.3609519483381885, 0.6757091454780981, 0.4841620659776896, 0.41822769942033045, 0.07654633471335111},
    {-0.2967791079262008, -0.9170138297346309, 1.0687684856217647, -0.2246346163658327, -0.014956140146923215, 0.8225556283946276, -0.30866296359427087, 0.11099654460593433, 1.0631588522196835, -0.7775097458530184, -0.9653107623307381, -1.1857579458866045, 0.8878438596361661, 0.06689933083051323, 0.16889684198640184, 0.5898382500467558, -1.0439404521280713, 0.3628974107142744, 1.0230946447527434, -0.2324670759255644, -0.21263447821187773, 0.44180206242467107, 0.14139616606411323, -0.38890447812108664, 0.4685460637506306, -0.9698056241959999, 1.0495527240699718, -1.2533075624849142, -0.15238056550000428, 0.8424741364643185, 1.163103710472014, -0.011837814699908196, 0.5311382599787077, -0.20940586135104447, -0.5485595705207403, -0.061831014963125944, 0.15192784762449604, -0.41615276774397836, -0.44231083422537926, -0.9098023888364317, -0.7371071783572709, 0.5260895725769109, -0.9234491550933773, -0.27584162977276017, -0.9139925865789367, -0.9171855826316853, -0.46113439492008407, 0.4328839069543932, 0.13492778771577071, 0.6298664095580843, 0.1984862971316031, -0.8320679516073437, 0.5621505157137853, -0.1394355266267554, 0.8891839492817842, -0.6216657558575371, -0.8246346434708847, 0.0005716465977480392, 0.1442721644109358, -0.4981928299843948, 0.2918482674452676, -0.8192649008866698, 0.42687216220905466, 0.7569200627700975},
    {0.20192032362543905, 0.09671871623978877, -1.0620148968933714, 0.8249730400058236, -1.4067540680232025, 0.21465259422003113, 0.22652057529735187, -0.8162064435876687, 0.9434088944015399, -0.04369953887217059, 0.49228094610151685, -0.6619841339964981, -0.8199729074430284, 0.10545334042706185, 0.8674228828402646, 0.4070327562318588, 0.7443672334850583, 0.5048063423992275, -0.7768140249604621, 1.0832554627333075, 0.9768088059069899, -0.1913983031823334, -1.191318352026058, -1.0037727588854062, 0.1546722762355712, -0.5613892923702215, -0.32541922756101704, 1.0415070399434863, 0.2940034920018812, 1.1815290205833584, -0.9079696335795353, 0.14039093498503627, 1.084073608944709, -0.5812458569163914, -0.8094801249492529, 0.4492508496278741, 0.15271784527309534, -0.13091450490968243, 0.02169281443755916, -0.11132285974883702, 0.001606332364617121, 0.5734455282949108, -1.0043345316751005, 0.043629456170026705, 0.3851453999859572, -0.3702632269651232, 0.6971881350982315, 0.03341499999596301, -0.9880294910666085, -0.6918407541601573, 0.9355166836148072, 0.859824349487402, -0.4900831190328677, -1.4605704667195667, -1.2816597191178911, -0.5405779859786116, -0.5932105776153755, -1.1294927319381665, -0.12145095041499848, 0.3743167220448248, 0.13482908044355751, 0.1991280217264468, -0.2683290339313269, -0.5099156859967113},
    {-0.8284523797032924, 0.6921568680790691, -0.6930065031571686, -0.6787937003677201, -1.1731417266236683, -1.1559227390772855, -0.023607391154285527, 0.013136136683169819, 0.34440018384519044, -0.6291419263903871, 0.6508104361524988, 0.6481154257289908, 0.7044503542384399, -0.7756165786249917, 0.07067254865765668, -0.8377663564713913, 0.22528697070837547, 0.39524928371540213, 0.566523263559003, 0.9464578186421208, -0.6651872870966172, -0.8862043123041402, -0.9098128959555438, -1.0201993848521989, 0.7181929780620017, -0.8812860759655587, -0.4662741765977519, 0.2758971981740475, -0.09621692750446736, 1.3209770572815998, 0.6933241946464345, -0.8827003079529862, -0.4531581877694801, -0.44969315321574904, -1.2068061244457535, -0.2896227817130157, -0.08027225920593102, -0.7617776020369461, -0.8793018270154155, -0.38990018846485974, -1.1148691256242973, 0.40015978651424366, -1.0794761337816423, 0.5174591798392576, 0.3712379963480255, 0.3246177848777592, -0.9555688565420334, -0.4856449043616796, 0.9082008827039932, -0.8888991394686298, -0.6060460375980596, 0.9299727393248272, -1.1461908484659344, -0.8323225987860589, 0.2359353428148904, -0.09721256456176765, 0.13842897085994726, 0.7698562646801297, -0.540304840540999, 0.004883523772119346, -0.42800992700502455, 0.5811057181072691, -0.26222076364653524, 0.8183827918409647},
    {0.7113835366194562, -1.3560775865887358, -0.048675666517711845, 0.8841974225056162, -1.1509517694047906, -1.0397011133654233, 0.46017377935629905, -0.3191446987885832, 0.17456019457910407, -1.2870787437386395, 0.24636399537616982, -1.16491950929023, -0.926385720855739, -0.8376125674288784, -0.072686466878994, -0.7795108776782339, -0.11450436059091365, -0.6138100226112957, 0.17071151066549964, 0.5023658569149003, -0.5803505587220689, -1.142865845385631, -0.8690952540148073, -0.8402300261191729, 0.26449693141780617, 0.17182979505430737, -1.0708955386004206, 0.3402784516237424, -0.5023226889696353, 0.47415025696199914, 0.9727295855624453, 0.22785419791402295, -0.44026994884004134, -1.3028551599147837, -1.1365013993111814, 0.4486987382749441, 0.33546309565194343, 0.5348512668594799, 0.6302717224506208, -0.2579082555056638, -1.1861943541839133, 0.996538632878067, 1.03736941265316, -0.4041031861317871, -0.5870607139764399, -1.094204719236574, -1.0430141092885663, -1.211138414415568, 0.6090186099191903, -1.0356727985189609, 0.965681869472754, 0.7180146751084617, 0.8292911669295525, 0.2872509433883767, 0.8279838631585548, -0.17221845734170427, -1.0939260771435193, -0.5918240659349097, 0.014106213809645544, 0.4460425916765811, 0.33240924329714155, -0.6426125354457872, -0.891158562659816, 0.5260086420933732},
    {0.8685127250162068, -1.0477658624640067, 0.3416780883661535, -0.9014752885773498, -0.5285351608051023, 0.7724538670145583, 1.0282926025807102, 0.5741395525186336, -1.0033748945801424, -0.6918453469472889, -0.016998571844259916, -0.3802977774674196, 0.5785891379001568, -0.34549113730319975, 0.7580209611437406, -1.2833619314871578, -1.0396195541938904, -0.8169164057145629, -0.47738557380586416, 0.8266011599603986, -0.6019445131528031, -0.32553546295934777, 0.13029682431337997, 0.36043476762361737, -0.13817172090644075, -0.9651851010603222, -1.084658449087963, -0.11098982611984505, -0.6674628145185518, -0.11092629381195016, 0.0847361954062837, -0.09920616549549298, 0.43954896854808523, -0.7381918080876937, -0.6522347227759989, -1.0522884400445311, -0.8629369585246577, -0.3473579194167965, -1.097100669679847, -0.9969941500606464, 0.693896654286186, 0.6245193405140285, -1.15034925210765, -0.38645869922984577, -0.6132414591162992, 0.7311151695701943, -0.3039732311274245, 0.907205131172204, -0.7675290030093538, -1.2023983494696644, -0.736921919450475, -0.6305613353126025, -0.45148444284047284, -0.9500651517038736, -0.8714579550529683, 0.9532096841164783, 0.275400090698021, -0.9371524197370459, -0.44751670832537493, -0.3810726866515769, -1.146264413781781, -0.24285547336196486, 0.4038199092738272, 0.3861667621002464},
    {-0.9643076787120926, 0.08169693599816444, -0.7194136153124934, -0.9235760992914983, 1.1190726441152976, -0.28357491496331577, 0.5135385680525393, 0.8432526144796684, 0.11946604995233015, 0.36637638890699137, -0.8437400926641717, 0.8238236112983398, 0.005050314825087262, -0.2629059349779293, 0.9227638811427205, -1.1249850587750108, -0.6452413431734159, 0.9143723750358241, -0.7210718798665129, 0.8890255782944879, 0.19955347359447262, -0.19135254873237462, -0.5078626510968554, -0.5475908826985287, 0.10418499439656519, 0.3410111129670694, 0.15995595970529278, -0.43630657106097265, 1.3944804836979716e-05, 0.11593098376933576, 0.7086672034596518, -0.09169631767061227, 0.8347777528214657, -0.9972594375307272, 0.3759589351600651, -0.7636657232212312, -0.38005135859488853, -0.6001976354867385, -0.0629507568578725, -0.1515778332205084, 0.017649798231917216, 0.6671864650926517, -1.1342425089965231, 0.3313005612572948, 0.7946984945989783, -0.5695150047461282, -0.7210066179239757, -1.0093428852904756, 0.7797202619372033, -0.7748467959679533, 0.7062056261258357, 0.15951881635437876, 0.6830941638009952, -0.6237316540708715, 0.5956970297512973, -1.0452889846982754, 0.6226831320459858, -0.7357546144248988, 1.105009529660133, -1.1158372094752989, -0.3280291756993384, -0.5266442057085312, 0.5923560874601503, -1.067936692358207},
    {0.43704475516217517, -0.17384299469866205, -0.9896994776716884, 0.21340867799232588, -0.34516858882427665, -1.0914173123860345, 1.1235674444727777, 1.0441816456520079, 0.1563429906614799, 0.004619070776761562, 1.0457729106658877, 0.91938186433531, 0.80212863743348, -0.5123907653718504, -0.8416536458488743, 0.4823900059983739, 0.004933185781535541, -0.608720778333507, 0.3609488389302195, -1.0621182453755325, 0.1342478634720094, -0.46961062965001754, -0.016330628864211563, 0.8303511353070241, 0.023913641415775632, 0.8956280459533348, -0.5593805115993952, -0.4450757917729918, -0.2841746458456825, -0.8838946778045418, -0.5572854752013393, -0.07216077877011164, -0.44328636828405327, -1.031923223968487, -0.7732163771185804, 0.38843602298482227, -0.7806967212471384, 0.3852620262497021, -0.28841033783483144, 0.6116818337807681, -0.6343741126515594, 0.9982994407016229, -0.41049221377775463, -0.08185003437245926, -0.8369841235685688, -1.0446437653619078, 0.7840510311050686, -0.04892642355537982, -0.5992757697498592, -0.13640803265301182, 0.12105121004494368, 0.6062372481150728, 0.17224834015341067, -0.5683398478080465, -0.45387858300721845, 0.3484593136940377, 0.7121314026522458, -0.7883731200405683, 0.5130266273533446, -0.20478244668085535, -0.9197517088991242, -0.829550409131484, 0.5432063977119107, -0.407638431342263},
    {0.27361846508412035, -0.281956830865492, 0.15126714046169695, -0.9703687824905449, -1.0141871565292264, -0.5593159110478729, -1.015353673584487, -1.0724019651755001, 0.21354583893083345, -0.6845168431090216, 0.6444586181422699, 0.20994794817159196, -0.4408933995405282, 0.2008996531025678, 0.1551695023896398, -0.09293605647049033, 0.31406480641863377, 1.1169369372061526, 0.2986128325375024, -1.1927603759091896, -1.0842814987234803, -0.1427310795808129, 0.49178680339377057, -1.0631131933069151, 0.05123401972552256, -0.8668010316495871, -0.5252275997231195, -0.8049982992451248, -0.22850577576731534, 0.5189989490752488, -0.902294944899185, 0.7408363016553646, 0.3911814733971272, -0.4085648490613648, 0.3719304430978366, -0.09814342786934753, -0.48496011968278846, -1.0293860066523604, 0.3188935771488048, -0.756361889960408, 0.1828457872389296, -0.028769839392040194, -0.3926248408208737, -0.9542442431645476, 1.0479528761679366, 0.22969243063475803, 0.3211974674049928, -0.8497038500835443, -0.32396260662094994, -1.3762866407241816, 0.34535974555433563, -0.7429385803746309, 0.47316286015992653, -1.271512551745354, -0.7996911357564618, 0.7414521966468302, 0.6397210596508867, 0.28884076742552794, -0.7146910012507137, 0.38196488937374634, -0.7762218842747728, -0.6164285283228929, 0.2361099099837692, -0.10078527685506258},
    {0.8810435764283334, -0.7691425838183447, 0.22876876477690414, 0.29754631718749086, 0.5526685807470461, 0.8356816576085834, -0.6318254267128558, 0.38803848004230784, -0.9683641648952369, 0.807788999698972, -0.49756935755319043, -0.4475560139086041, -0.2769848881929303, 0.7102065782822421, -1.1344901751485432, 1.063045425011155, 0.8355653281454933, 0.766676789256792, -1.0596270186066634, 0.6841794086155474, -0.917798989995923, 0.1375449157268814, -0.3390839938244608, 0.5287764890166131, 0.4689092256832124, 0.22839530675632086, 0.16598392723782024, -0.30076596334830574, 0.4996545324242926, 0.6841238312375466, 0.7697311788371174, 0.8388870592151435, 0.8309445515031642, -0.011941758481444333, -1.0601404085342154, 0.0889501424364685, -0.6233013594880846, -0.6564149955046611, -0.6015186261845713, -1.0250132436592099, -0.2679054559008208, 1.1431228729248262, 0.8423669829515454, -0.31158727938338077, 0.4210844468982701, -0.23544220355629064, 0.055361445147682556, 0.9194875553494112, 1.1169992897611356, 0.37260204111409406, 1.1107927264092112, 0.7521772905661687, -0.10871415529094633, -0.9715422419542269, -0.8039929769507698, -0.01706765757834491, -1.2295715113410917, -0.14405808318266863, 0.21277737367065475, -1.105932066754159, 1.072290515888424, 0.13957738732902686, -0.4255547763779205, -0.38135913076448974},
    {0.4297899022587155, -0.03228700709816691, -1.0294740210540856, 0.7760229912781197, 0.07912095991551897, 0.600823437148236, -0.356240430921407, 0.4566147974587631, 0.8416606351295179, -0.8630876280512549, 1.047186856700472, -0.05546221191222573, 0.053796529562402294, 0.5559038954400619, 0.19463673785550786, 0.09176836008954913, -0.4338682194773915, -0.6538190783542802, 0.9082858040153743, -0.6273901758206826, -0.38015824058440034, -0.9979135533538532, 1.0283251524515402, -0.9920636542747424, -0.6820047394206065, 1.019310703886214, 0.5832876069622875, -0.7053093633799531, -0.986435321477836, -0.19232514459898867, 0.21763596882508388, -0.2522429854574959, 0.8404328749341934, 0.9054559588531205, -0.5347296549631068, 0.10506443954297713, 0.18304961839855044, -0.4967206205372779, -0.5272497652289807, 0.9235598842988504, -1.1548923499864152, -0.6076594920723969, 0.9686265133229656, 0.13761859672115923, -1.068847365202547, -1.2436585114450187, 0.6487183892334799, -1.125088070267546, -0.888180071251694, -0.07487072791678252, 0.7498632885732996, 1.1297736872166213, 0.1896099851593337, -1.407020754116182, 0.3451406115878253, 0.6504201373718245, -0.7352053012580922, -0.9757786418120432, -0.9370833801656445, -0.8595627936921987, 0.17816537646924907, 0.6013793190347684, -0.6966180592881583, -0.8022204276552621},
    {-0.7468954084786465, -0.11881976777511928, 0.345946758406161, -0.6049859509466649, 0.5925121670250951, -1.2583051435972707, -0.22157283300663383, 1.001318212460245, 0.3176504504778307, 0.3756057193472928, -0.4498347565670477, -0.38390089538421635, 0.8604255909683357, -0.6044342708120999, -0.5445692676990949, -0.23986928912886993, 0.5493683715085803, -0.6552240619101809, 0.2129449204898088, -0.7548337099065707, 0.24377845162239395, 0.12737740360843017, 0.7925003281681975, -0.5827509954699338, -0.08065825537824518, -0.3267498795619845, -0.43952523071087873, -1.299465892095213, -0.6695456448665359, -0.591536448634085, 0.4570672198235278, 0.7129873772774942, 0.2607822731152314, -0.829663487303523, -0.6005033181230438, 0.6675010890532697, 0.1843747042048139, -0.9899774081753644, 0.831593022751024, 1.039232543673534, 0.35952041400950524, 0.18645893849865924, -0.07984717470672421, 1.075936746774804, -0.8865866489512738, -1.1106554047147312, 0.9314871795358918, -0.370719212938503, 0.11579337124052241, -0.1457606649663611, -0.9403511309230399, 0.8414336690874725, -0.07085468293765435, 0.1198097441075973, -0.05237178625885939, 0.6973903344521919, -0.5465291395422667, -0.4903405166405071, 0.21812764812684976, -1.1131699113553282, 0.4676033242541654, -0.6746888409108301, 0.345950507229331, -0.024323579287185773},
    {-0.8419263470641924, 0.32019593715791633, -0.7546160346383958, 1.0001466640504943, -0.3627617062283367, 0.05134642014765087, 0.8396799352460825, -0.8638959672132286, 0.10493671440273555, -0.6463907232287964, 0.7952104139172752, 0.7515553155830637, 1.0410009233579682, 0.27863408125557154, -0.21238817513660743, -0.7881755648964562, -0.6167058679659552, -0.8979729922289907, 0.6548682334494629, -0.10299138180532723, -0.3867821808058708, 0.22826307087415146, 0.995843346200832, -0.3142590519683864, -0.11018322857417005, -1.0218346201928192, -1.1093152528842192, 0.3924729135421546, 1.0557089953367482, 0.3434874803805315, 0.8986798770172117, 0.11277871557783246, -0.8429918246617252, 0.029841893481056696, -0.5933375512416038, 0.9040190918228052, 1.0269823636879571, 0.3401905106573776, -0.14747592000401286, -0.7725890037828688, 0.7842671219172959, 0.9120462756101868, 0.31636265541179626, -1.0083368892001618, 0.7582979689174213, 0.6496158543714373, 0.8172696942256863, 0.645160642426798, -1.1271332461391648, 0.48265625679555824, 0.37692917852131363, 1.094460818391806, -0.08818923934595457, 0.357738483270189, -1.050529992036945, -0.14726443000001802, -0.08658605166674711, -0.5620552626660658, -0.7642454287547209, -0.3134099943807194, 1.1719812777808296, -0.10044513541685748, 0.7264794399286597, 0.4267977647725022},
    {0.8836936969945169, 0.4924969766310153, 1.096408198630801, -1.066192347376455, 1.047528834691676, 0.2265958447740209, 0.7248633844337758, -0.8195621204651493, 0.6465140677773519, 0.5801535946879643, -0.7205115058706453, 0.07452796755567849, -0.37456721701289575, -0.9205355558876189, 0.8753788599438754, 0.14297532264496757, -0.4500530436495688, -0.589634189153882, -1.1613266801707367, -0.7311980411888184, -0.9563312970200768, -0.38395624541995854, 0.9443614047942096, -0.9447596393361836, 0.9093622257070051, -1.1615457492866161, -0.9688434359486234, 0.9395873495736656, -0.10844888915416015, -0.3303001710933974, -0.14477509141406114, -0.6016468873024736, 0.46367525571842677, 0.1107554678701932, 0.545264916184782, 0.19931233862873327, 0.45988868913412506, 0.1942511727582955, 0.8432589069845349, 0.4770154938816445, -0.8108777261265161, -0.16281969019519765, -1.0332534409295757, -0.3821059674859504, -0.08828121496762663, 0.9165549076154077, -0.8804965717992165, -0.056089978260678505, 0.9096759226940431, -0.6482954289366575, -0.5830687502499147, -0.019042832161631176, 0.8057321181982628, 0.9097506861020812, 0.3560969344401319, -0.5332051847812364, -0.7071059841771337, 0.7155782998029577, 0.8207751313634338, 0.8837495998637792, 0.859417676489696, 0.32646847433900655, 1.4322996239516432, -1.0338421450472353},
    {0.5410522340017409, -0.6475216864135799, -0.9447497260570948, -0.11308411014919759, -0.844117198673423, -0.6616613293862634, 0.7720006299743258, 0.25998286747734733, 0.5122630220369431, 0.8039896363614093, 0.2371096704014309, -0.7986460732151982, 0.03007681531216313, 0.8211200965235385, 0.17976824741675945, 0.6261655277714833, 0.9579001133782405, -0.2196623893860598, 0.5191778514366896, 0.4462161474372942, -0.34186705912031534, -0.1845738731631277, 0.8255354712548147, 0.4898912080594368, -0.24422513655251377, 0.30208628549693606, -1.1624409279697068, -0.948639068981055, -0.4148775438286709, -0.0766646259376184, -0.6477221662162992, -0.9332338957605648, 0.8711939507433597, 0.17239448582960284, 0.7037643756220966, 1.2496877884118296, -0.9074148993483604, -0.20944679545032643, 0.31193114935648447, 0.8865497962470341, -1.0607704636907012, 0.8514459153121127, 0.2490798325960771, -0.011517515642220342, 0.8208218841757926, -0.3753433140443459, 0.2080562271110979, -0.1308595006767075, 0.6840039716065425, 0.37273427752729577, 0.3179823627752465, -0.7457861939972542, -0.008042933627145393, 0.34629580390019843, 0.18526623642153656, -0.15725634709119193, -0.29812991557216206, 0.9151281443786716, 0.06339050028388242, 0.23993525274712993, -1.1788787008483448, -0.3715768643230629, 0.43619102927004955, -0.6281669621364723},
    {0.7681462615484429, -0.8198584419375197, -0.051947169440483394, 0.4210801480912445, 0.5310876273797035, -0.9206286724606926, -1.0975272793443227, 0.5984512561527868, 0.8147308161930713, -0.5493690668985477, -0.06615149483404505, 0.3033633008060046, -0.11561968935465165, 0.21870411886327792, -0.9047160908629391, -0.6746381520843535, 0.5962687075320504, 0.9612603985053201, -0.9613242460204254, 0.06323250471207913, 0.9931504356533759, 0.9588517447728353, 0.06759496686953297, -0.45421449137455905, 0.12051578344123105, 1.0448488511704193, -0.8849178369224839, -0.13698716960163115, -0.8638822172992481, 0.6912546831902096, -0.6658086309800526, -0.22707831296946612, 1.227234848399735, -0.7284937981939333, -0.7436746714871564, -0.7595103392038564, 0.8884423761785838, -0.02088041208451205, 0.29090706267151223, 0.30692617156138097, 0.1886506223385869, 0.4071207914584767, -0.6655556288968264, -0.43725744034154773, 0.08823350716203812, 0.43275238764040624, 0.23075427172086238, 0.9262245676365757, 0.03765585098759164, -0.9060437288466294, -0.13689715957412332, -0.5099185199166355, -0.30367102272651375, -0.47786266635809294, -1.0802852526526163, -0.7106435340152756, -0.7183060223833276, -1.1361991927410058, 0.38788156883641894, -0.03767042473881855, -0.5777216419064245, 0.35462462211078133, -0.7009580330323226, -0.8672043875835699},
    {-1.0432237701853653, -0.31351965629910505, 0.49182459383294413, -0.9314748123825463, -0.36775178970272593, -0.47268869401537944, -0.6980845021024136, 0.8727323055895796, -0.8667510030894193, 0.5499636702179034, 0.5585996433614483, 0.40080085729012654, 0.28777620381418473, -0.5871825600166103, -0.19017294678232893, -0.2817066773896521, -1.113446499078581, 0.1368507546695043, -0.18468510202317856, 0.8020166662940815, 0.08950551342096942, -0.8263929991452577, 0.4491222844285872, -1.046310604046726, 0.6036881823991074, 0.25842486128780945, 0.30572598589840666, 0.3751051165463032, 1.1097507035364371, 1.275695550616397, -0.36749183323455636, -0.9953617277665522, 0.745935295646227, -0.08401896740269632, -0.1351963413040385, -0.09643193105638509, 0.47719606442843304, 0.07699669317115265, 0.5756946357426939, -0.5959131223643577, 0.6890297426169092, 0.23966950653451685, 0.2425989963001456, -0.6399356124144463, 1.335608155549158, 0.12427564983750129, 0.8362110630265522, -0.8297748041642837, -0.04394419440865417, -0.6157921699602811, 1.0949843021938441, -0.37426992813432963, -0.8326629990118324, 0.7403661276798624, -0.24626330690772774, -0.8912851043116737, -0.3428952454775914, -1.001700399956009, 0.19724333226537094, -0.2704611229283572, 0.38057670869597243, 1.0277972478715258, 0.017182228282117594, 0.19508870482055377},
    {0.9241597207637758, -0.2638696337395181, -0.04588594932702986, -0.24086503664817113, 0.4443078220916322, -0.6421364502162993, 0.24405199593907737, 0.04485486907830218, -0.22191536853960003, 0.5034097985921346, -0.39598220563093434, -0.6024141896950728, -0.7999566026436439, -1.0289805899139786, 0.3281900423726091, -0.7528181846291868, -1.1168870883908213, 0.0892503847555975, 0.01343139607826293, -1.019495165544006, 0.26982158398420847, 0.3345466024965707, -0.6452728535525137, -0.6482754514522077, 0.3274699846540223, -0.7792163510918576, -0.12640675328978485, 0.623886870878014, 1.0808347983893238, 0.7835990530771108, -0.9461618327914907, 0.4467635636903975, -0.38452223001850727, -0.21024461633156327, -0.4359067383044052, 1.1167720476574048, 0.7912747388222096, -0.47729125850793475, -0.0501399370574581, -0.7188152934544131, 0.11864401496133468, 0.5622785088325171, -0.44394180314895404, 0.8154352296104799, 0.6500913066656422, 0.9393524315706914, -0.5982275923833945, 0.011165851842637364, 0.8537290154397861, -0.7928537584447829, 0.3167403853510564, 0.6724149714775508, -0.8442861338392349, -0.07742584650352852, -0.9304793750353613, 0.121792304364197, -1.236895253283912, -0.5484130548390248, -0.09740448023877116, 0.47300180346870835, 0.626592012397753, 0.47757769856136756, 1.0828665620036393, -0.2334657779725986},
    {-1.0072777318047772, -0.7607537906294995, -1.0029178960077898, -0.8797754018231686, 1.1067285563109759, -0.10107664172288171, -0.7984709958001589, 0.0716287452717252, 0.42910959639560214, 0.39609123053076994, 0.23176207707484892, 0.5283823218288288, 0.021891029910380735, 0.04494818242214237, 0.20479838169242595, -0.1385539490202054, -1.167699907268426, 1.0387916727224695, 0.13603973440107864, -0.9492736753534252, -0.720482740095926, -0.23040268844163836, 1.0284716541477914, 0.5011682271168654, -0.19960784537728396, 0.33216001898330744, 0.5082929163901826, 0.03257766449955102, -0.1665189874579197, -1.143028001789583, 0.9968346628246254, -0.3576649963998413, -0.07311942487828905, 0.3526734093723784, 0.9191922961433061, -0.3515239091014503, -1.3331181491650523, 0.11151113067793524, -0.1259757298672164, 0.36818844888959207, -0.03201325048126792, 0.8872808778731901, 0.7731004934180233, 0.4645813954764215, -0.962817451050606, 0.08164327377114479, -0.002635417173418474, -0.8745176439044896, 0.6774464931423855, 1.106442413521854, 0.30397242356865745, -0.2963641141188604, -0.5971092808321941, -0.26926018951487946, -0.8520169637112638, 0.6091887145564485, 0.8943107928606081, -1.251185627799004, -0.6863481934708836, 0.3835627603947488, -0.583702855746316, -0.42805022515773666, -0.5613188579603865, 0.6855308896419868},
    {-0.38145731471258737, 0.28309597879362197, 0.6202420203377119, -1.019480574005197, -0.50149086270211, -0.15435522512091931, -0.01638561714276716, 1.1571355949400746, 0.04003095626310949, -0.9292195735581945, -0.22645744656076583, 0.6017448647962081, 0.679164528226862, -0.3516039934828489, 0.5946062384741133, 1.043316177021568, -0.2945407362606961, 0.1259020511408275, 0.5272224916403564, -0.9387576638090672, 1.1364673973759334, 1.182038902760581, -0.9510461775266791, -0.904681210694317, 0.8967246416670059, -0.5707420275780117, -0.6191639186062508, 0.6337971959225718, -0.7148834049183636, -1.065425434893529, 0.6165840199927802, 0.1228632557559349, 0.7222771981135891, -0.1510053235455627, -0.9664332832956126, -0.12249805947980588, -0.9116346576387885, 0.22250128653294857, -0.6177165556333655, 0.5959429181461029, 0.4645604626442192, -0.12077830732353644, -0.8882812973808822, 1.0842523388012737, 1.2495167301078278, 0.7827507054787652, -0.0954856030829606, -0.49209995851095406, 0.8045430415707031, 0.6776390236767088, -0.7841244292722997, -0.2674983550099447, -0.9256199102554015, 0.8326421150052677, 0.5557941842579331, -0.08722117747067466, -0.036769594056030246, 0.5585734141563456, -0.20155191112960358, -1.1893265974718, 0.16127323896098522, -1.1108886098452804, 1.198658617522663, 0.1507022034672378},
    {0.21749365564519046, -0.6961304876624625, -0.3380913449399113, -0.4404409773392234, -0.2881568482701727, -0.461561469934514, -0.6197609822047387, 0.08447675340675691, 0.7426176178860232, -0.6796138194095698, -0.9883153368900813, -0.40930586486057424, 0.8887104880707147, 0.1711262726577581, -0.3885887184644114, 0.31796770768441257, 0.9577385874744212, 0.33075785677674124, -0.1192698482840077, -0.9046362687522512, 0.557698079538291, -0.7424496259567318, 1.2126632454701314, 0.9074233641410269, 0.013201468342096203, -0.12176055156661444, 0.7205812028659472, 0.14036622218517403, -0.6992488496418493, 1.1949588887109532, -0.3043569224060475, -0.9001405642342558, 0.7640563238683105, -0.6282688757075464, 0.1768377640327106, -0.6641106846806388, 0.05192959585540153, 0.8275569739899157, -0.24202148719985334, 0.3256328138007823, 0.8279812252777483, 0.05886785109326498, 1.0618410310261728, -0.2833845389011957, -0.4046279221693449, 0.12139102226066001, -0.9812249939107914, 0.9379275634077822, 0.8085865509259678, 0.8426922497054613, 0.3780704546161114, -0.6363217617232505, 0.23678715335892692, -0.923235075511552, 0.9384363050983838, 1.3602190885139491, -0.3903249151970695, 1.1041743668124577, 0.8633269878088807, 0.16835996104161544, 0.4361701471706561, 0.1600280924463209, 0.4230870982251684, -0.16671620477173865},
    {-0.13633375286376853, -1.0323408347901963, -0.22743411295195734, -0.9572100871199182, -0.5525789028925178, 0.43150153946910946, -0.9477909982806328, 0.5107837543540005, 0.47748613645396887, -0.8357585683443625, -0.32400102035298406, -0.04156845220398812, 0.7150400645973918, -0.1431880425083747, -0.8267174990034903, -0.13284585099770307, 0.08827220384295069, 1.0102418695826596, -0.09318014017795519, -0.2724463501265855, -0.9102755742432934, -0.6927016513121333, -0.15980550836376328, -0.4611615399014927, -0.8661740939851669, -0.010569738885915373, 0.6155195236576522, 0.551990904302073, 0.23729726334306525, -0.021454103649492087, -0.6965399499869092, 0.7233454420336977, -0.577711981242753, -0.7395059501006016, -1.0126174610747536, 0.017112184041639385, -0.341544253950072, 0.07406683947406957, 0.49641299959807145, -1.0852996625780456, -0.9850369590178938, -0.7257286055317356, -0.05905044103112723, 0.5709250418151908, 0.9183105646873924, 1.2370676947499606, -0.29381334251368396, 0.6589338547558703, -0.2757464393884264, -0.3425407156142893, -1.0743259899010307, -0.16589351566839905, -1.1179986899598244, -0.46784662125939236, -0.6408641260916558, 0.8979415802749385, 1.1038505124810516, 0.9462349205735592, 0.6529119453758933, 0.0433590131354198, 0.3836502278407454, -0.9456422785418825, 0.14609828929198462, -0.08912415441427289},
    {0.10773362040416874, 0.7874071420960073, 0.448999075003895, 0.5490175461750727, 0.6091384830354413, 1.1277015221942128, 0.3535855725303804, 1.005816172290757, -0.10245801359069334, 0.3253333610830502, -0.7705100457793438, 0.6177102145105727, 0.8115231791145525, 0.7570654259930768, 1.1701622442932305, 0.5904509123899979, 0.32435632991755653, -0.10875463998214016, -1.0728853075474594, -1.001874979598133, 1.0574219389261832, -0.19493789781725504, -0.35382523056324, 0.8868175910036173, -0.5292163298533032, -0.41838618817661216, -0.11074933409012594, -0.1297317528514768, 0.6502442561490295, -0.5297016161513949, 0.7653656202966052, -0.8697466912953681, 1.0879670063620002, 0.18818168189223924, -1.2935378163294318, 0.5466209680729304, -1.0042473510735412, -0.027130807772466223, 0.7867832119524867, 0.9065215321303911, 1.0677782455926268, 1.067497582058686, -0.8231643693445007, -0.8252892489220339, -0.6988560272823533, -0.02965713863846985, -0.08563047299262184, 0.9235953047794538, 0.7693462806927915, -1.0532249101553093, -0.17766578493980184, 0.08607270112154077, -1.114456736599945, 0.27906095198869035, -0.6898996477886316, 0.15021627613710867, -0.07302790455962363, 1.2290192652170562, 0.8464829319862899, -0.5235535195534675, -1.1077458408840417, -0.32114470398650063, 1.0380233176182536, 0.6332037695556852},
    {-1.1196219950643722, -0.7627965459700227, 1.1841035466059888, -0.01734312724350135, -0.21346725006447903, 1.1116716182811055, -0.04143798188766961, 0.36311322748364566, -0.5532699565108091, -0.42544761784311264, -0.7775665825062452, 0.6111744547038686, -0.7639342019574547, 0.7768141349896232, 1.0863914691464498, 0.9581379517358022, 0.680964452424529, 0.4993889950484118, -0.7692075390382686, 0.8545233661675324, -0.2271753134046206, -0.06012729048466637, 0.9857997439670743, 0.859666026143419, -0.7975831305183381, -0.5299059883178169, -0.6769769881939827, -0.010104248123919968, 1.1900964541513344, 0.8134918844708809, -0.22583596141503412, -0.28594651972088986, -1.025584087329399, 0.8071105390590337, -0.49371820447707165, 0.005022489829226789, -0.33854236030743223, -0.6460779447193147, -0.7794250219509292, 0.18785774280210563, 0.7214537932827262, 0.572216599851781, 0.48312719557647454, 0.9472126495243394, 0.7137908481128394, -0.717488529224735, 0.5474313464441081, -1.1395254076605166, -0.2774773154000264, 1.0776614999462202, 0.8672827939236885, -1.0123336396846645, 0.6441118074917614, -0.08336628135047564, -0.9191720796834173, -0.7653284326127235, -1.1388388841501578, 0.9580665800778968, 1.023999652760806, 0.24228272730889866, 0.9340889524045217, 0.48501874783849475, -0.004473405024841488, 0.009529584859841789},
    {-0.609988449296933, 0.4683062693866733, 0.5120234097834743, 0.788532020115449, -0.0551674678922323, -0.5134220349127471, 1.1929016174040636, 0.47458213536565874, -0.21568261711004233, 0.7457965956288388, 0.4693375223955415, 0.714557388167398, 0.460271250767047, 1.0947259591752214, 0.6834575252910656, -0.8345979050489161, -0.6043709368402914, 0.553786601763439, 0.08893145973460248, -1.148055339629068, 0.9250317529358338, 0.9876382530583692, 0.3410270905277793, 0.23167544928821182, -0.24614459093017285, -0.32236521044309313, -0.7036436384628272, 0.24051014615256713, 1.0879935377375172, 0.7673800460518625, -0.1427245064057201, -0.8577456568667741, 0.7141706133721865, 1.0777860407653856, -0.09734351004580974, -0.3080637555735524, -0.5365709377112656, -0.4618346450570494, -1.0416174969997554, -0.6688496269181657, 1.1309308309670523, -0.8681286126149244, -0.06802817542894363, -0.4039302687811326, 1.2129550491610923, -0.3332261277671117, -0.22851713065723303, 0.6200824247406354, -1.040338302677159, 0.7472842127165318, 1.0800171564522152, -0.1484092585840673, 0.6598434588260206, 0.33757071989062015, -0.9703382259365987, -0.5848891042868607, 0.5642525729900714, 0.9827761305719063, -0.41727617219623564, 0.3598840677924161, 0.1511475788131451, -1.1161769441835425, -0.253100122369565, 1.130339400352292},
    {-0.05129385926102554, 0.3390060317450981, 0.6475473658162347, -0.7698130132214404, -0.667504172406353, -0.9252416058066996, -0.7922116454489964, -1.2311590133210593, -0.15688134165107276, -0.3184776882271102, -0.2059037508810763, 0.6565025285843187, 0.6420568577378658, 0.8285596718782491, -0.6517768488833015, -0.048169194509005524, -0.008610117462996393, 1.1952628376840804, 1.1272436361713705, -0.9113428996029498, 0.5965002696474029, -0.7439595271510417, -0.6006001990933854, 0.3767690064085059, 0.051226040712830954, -1.2266783670095436, 1.027717546561885, -0.21370464851967094, 0.2215664641086905, 0.28958569881320195, -0.9346160361404051, -0.20507841213908093, -0.4297983151441813, -0.33908817467415375, 0.11425332263134853, 0.8899843329207987, -0.3869183796168751, -0.5816055578698673, 0.19156224493872975, -0.6506255392399685, -0.09366329262298824, -0.7430749985312096, 0.07196816829605479, -1.1157188810329006, -0.39345594330785694, 1.1911560895752986, -0.6367482832145286, -0.21310003686828222, 0.17745445346857439, -1.1397140253436409, -0.7341623893920198, -1.132508496456935, 0.10409862117112505, 0.041704452957780025, 0.8727261840915829, 0.5453282922797414, 0.35986170928657224, 0.9373052524512937, -0.23811717421510664, -1.0075624168096229, -0.8225677208270191, 1.0195040528322687, 0.4895344926229, 0.6502073440281939},
    {0.8971599522822861, -0.6743578659158427, 0.9782165753834741, 0.4552274571370289, -0.6428720439214487, 0.15414923369590447, -0.8447681366569861, -0.5934813472283667, 0.516728994489572, -0.024735884948396406, -0.22273320514186146, -1.138944467148868, 0.24260436510072264, 0.5113816756761067, -0.7263143709556656, 1.0266498006844302, -0.299099278270749, 0.7826770332349118, 0.9115479197454314, -0.8749184198438931, -0.3980051015410956, -0.38223524200748815, -0.15358644922215037, -0.24067855311980185, -0.6636349564168001, 0.713952783919674, 0.6505526353807923, -0.4426787441896375, -1.0601758947569215, 0.9615984371229491, 0.4241973561609802, 0.24290259422869012, 0.4518900443331713, 0.1999968036516692, -0.1185090277509788, -0.16599410179985163, -0.7693476711864125, 0.17394787068694043, 1.03596565022493, 0.44953522377901917, -0.9273430236724053, 1.0867408027848733, 0.3056859428014854, 0.07291579891489544, 1.230290669353075, -0.9114790280399198, 0.7082952851100579, 0.18544769799151029, -0.2839554846999864, -0.2631549584701975, -0.18032949819634625, 0.8644977081644774, -0.47784429260273, 0.0022612132503038156, -1.0231649910483074, 0.1638050385590142, -0.43499807958592873, 0.0028205517395494223, 0.2994450245327536, 1.092730074726952, 1.066826594851102, 1.0588904974948072, 0.30646187544722847, 1.1912124866677558},
    {0.9348597208745529, 0.8058431979384709, -0.5903421939276525, -0.6472738753003335, 0.2970355643227831, 0.048197700418454115, -0.09520836139057752, -0.7696955805756259, 0.23469834074352072, -0.37856926708704824, -0.3046000253514147, 0.31466104914320653, -0.34036808956204184, 0.9758858414681395, -0.0015487512393580326, 0.07666072540154391, -1.0983827447606773, 1.1289936024507248, -0.6618159527180927, -0.6989983434831752, -1.0170150528830046, -1.0406254294941046, -0.6702495682428161, -0.9222001542774866, -0.5415665517837883, -0.11019955120715409, -1.0452899936855022, 0.9029459331708968, -0.15557757166694794, 0.34498944056987724, 0.06721336666850294, 0.8108797171219159, -0.9025372912754468, -0.5439505711437067, 0.7718706020918606, 1.0367074067023403, 0.9183518280518905, -0.5590849015023273, 0.28531745963920024, 0.6424205621655774, -1.181329305058413, -0.3522563889977533, 0.47983704004058103, 0.7178704232105962, 0.21771653694007448, 0.89268212028169, 0.9835643135815719, -0.8137857952471688, -1.057442387890935, -0.2475550439664744, 0.49313534348492766, 0.6988867480253906, -1.0907210913503353, 0.9040791827026302, -0.6490891372912704, -1.2753569465107468, -0.5586819157103633, 0.9686220546001334, -0.5038412825910165, 0.793829627239339, 0.7769526509666382, 0.6462517937089909, 0.8166033595564437, 0.38422213991834736},
    {0.5922527284352135, -1.1138419497291592, -0.30918462520631546, -0.735977950006149, 0.03248757716923633, 0.18682604965214464, 0.4600762681804451, -0.1078831886316882, -0.4112388822763844, 0.8646587052483439, -0.25728939759483127, 0.05548399839046458, 0.5932810021509465, -1.093308567716076, -0.7838952122141251, -0.34036659082261445, -0.7762124879531334, 0.7431652477160896, -0.9984808631565564, -0.3933659986607218, -0.5389632752232798, -1.1154071235757097, 0.15504645399518904, 0.24370354876837044, 0.946065607535008, 0.18872157210807755, 1.0494113699319798, -1.1718859430211421, -0.3596954763297255, -0.8261561222224229, 0.8327280149794185, -0.11753173201576277, 0.4462237191919797, 0.7321929665665773, -0.5201924735659422, 0.5038205316266142, 0.7045898465178805, 0.686464033746683, 0.13422321232076448, 0.5716284566136595, -1.2351565745373358, -0.03787088866161497, -0.190843366269352, -0.584506963333697, 1.1347252683797315, 0.510709016937702, 0.37869863093422834, 0.3066010478546155, -0.5272006599550286, 0.018278313963159418, -0.7232292037978775, -1.2486886053945443, -0.259498657902262, -0.8194726287212534, 0.8481832289558616, -0.5771399698623753, 0.12964357583505542, -0.14798849410840756, -1.0895878450433067, -0.8688532474953774, 0.4100565583170519, 0.2230824134282713, 1.0376064339001831, 0.9741381196256061},
    {-0.7764327850206223, 1.1343355738790288, 0.13497554552676164, 0.15727222967779916, -0.3366333618518954, 0.2545910903768754, 0.08200552251232783, -0.7477891134076345, -0.09353966308331493, -0.23712726053550615, -0.5056655948276724, -1.1874761704186043, 1.181585888581705, -0.28667419941565253, -1.0720818978580107, -0.8205677242959135, 0.7652395811396001, -0.7907714733812978, -0.7790731904247326, 1.0910117599984979, -0.9427860156007905, -0.4484010606159313, 0.39146347663091574, 0.07612764114360446, 0.47608816815236615, -0.794951894379362, -0.3167615094956533, 0.058905322417677326, -0.1414156292042372, -0.10011385714250494, 0.2295864891295088, 0.7510285247813728, -0.39907553063929774, -0.6059844231966025, -1.0505581568990268, 1.0725813232117174, 0.4279227649513833, -0.9237725254293632, -0.5222847037317581, 0.47518599019767177, -0.3352773827187827, 0.6419551832852931, 0.4031175499966677, -0.6351076842777451, -0.6787151461090544, -0.10892327242875872, -0.33858860108763994, -0.4364814420529357, 0.7675911835251203, 1.0372924235513605, 0.7156499741623401, -0.9559563794153673, -0.3650506513058479, -0.3084293121904187, 0.6327153777370438, -0.5252610315465684, 0.442910740263854, 0.4426476311139096, -0.6773859716956429, -0.45394020631799864, -1.0220571905395235, 0.13544641861404744, 0.8685221637983676, -0.4763172269460925},
    {0.46465710936925336, 0.49456677247803865, -0.44243752727220376, 0.8245155423410043, -0.4086425468462991, -0.851530542842536, 0.17065187604680415, 0.9191140629350226, 0.011488675788148795, 0.1872531448309569, -0.9551402495022073, 0.7624480843178957, -0.3026754867971033, 0.5538174852146658, -0.9598104324735295, -0.006555094503080646, -0.9904078820724995, -1.0089933644774856, 0.5834668171740172, 0.8807942544469377, -0.5463067987103155, 1.1287190685388373, 0.09601094592138089, -0.7779659878919741, 0.936027252500382, -0.31311804889204214, -0.775711854611832, 0.5248120953285756, -0.29397711482303956, -0.8046281461375279, 0.8272694796104684, 0.4451908721900922, -0.15031426780783305, -1.006650338892353, -0.7890700531984909, -1.0171346415921914, 0.8446510238467014, 0.7115844596779569, 0.8898010784281438, 0.7363287907657272, 0.7298983420671492, 1.051683841140027, 0.12644144855986614, -0.8462203071325448, 0.5108542843043178, -0.1069500540940126, -0.30849356044938, 0.5726875351405782, -0.25183722368861616, 0.23927417979489124, 0.6799437430399222, 1.051888950504491, -0.2560279246857434, -0.4923021095789927, 0.9397130637850979, 0.41319943922165037, -0.4293404343330401, -0.7282628514427835, 0.3697112800970741, -0.9985418515200519, -0.22220895781229213, 0.21831286981654296, 0.1931574800451081, 0.2775185274094184},
    {0.39631398001650153, 0.5787790637345916, 0.06165539412480747, -0.20132961909693273, -0.9083097436014693, 0.35422108940263025, -0.9148387556704445, 0.7596396972605676, 1.1028673918889906, -0.6091841409556451, 0.2626349103780531, -0.09973495981707559, -0.25827174090162763, 1.092867013091883, 0.9454617398870265, -0.9785147901289168, -1.0157068267224718, -0.7354623146343667, -0.5909745348066168, -0.7127538017719259, 1.0584649080785946, -0.2406444642207644, -0.3509225024739941, 0.8061606409391948, 0.7430238312455203, -0.481108251312954, 1.3050480627844134, -0.8060599941504265, 0.31863050900507817, -0.8214594820168414, 0.8525000351602331, 0.07986838741141532, 0.03050794540935275, 0.9902766476690373, 0.45654262298014703, 1.1277660542029533, 0.9129197276218779, 0.9649609738068201, 0.6278180759674528, 0.4018623692352157, -0.5033246051909769, -0.9392974643435457, -0.14322246905470093, -0.6817188864356646, -0.9568536043542735, 0.46855708133836727, 0.3386691396846572, -1.0814308357543252, 0.24943700144585262, 1.0468564175156474, 0.14691612431815224, -0.3157778819560321, -1.0802341231350954, -0.9217112018245365, -0.05343564112020828, -1.0629462588870002, -0.321096996552763, 0.9597985786614869, -0.47460630057570435, -1.0958466535725981, 1.3208345061271338, 1.000779655764483, 0.8713816932525202, 0.7382843440429087},
    {-0.2752765403754323, -1.107869317368862, 0.5696970249811592, -0.22894542730849102, -0.04012032963409228, 0.7585818937274398, 0.1652846832425699, 0.2082549166101272, 0.816485618965994, -0.014029306080710962, -0.9034597800623426, -0.09648985918129444, -0.20389485587156336, -0.9702145665073884, -0.3460431065783925, -0.1828316087359924, 0.5161450819928723, 0.6122973656829718, -0.7934615573615479, -0.6311467672779842, 0.31625645040628086, 0.08863675154261619, -0.3895947846448033, -0.4899755110637409, -0.7259628550106156, -0.951121485556559, -0.2553406401382324, -0.48768334393114765, -0.5856031512558217, 0.8882236523775333, -0.4547544611698158, 1.146796618210903, 0.4210100401965434, -0.8503286676738318, -0.7281043920714833, 1.0121757721695137, -0.7601813378947739, 0.34374592993997977, 0.5963660132221095, 0.4325296125492098, -0.3042805237813645, 0.947448916563144, 0.42245412243681985, 0.7738686356411479, -0.6371683419130443, 1.1836791746772723, -1.0987494124492219, -0.43381883020560535, -0.30729857756828405, 0.053207243823811125, -0.39441581461935443, 0.5744324990935469, -1.076547727865768, 0.02253643556363113, -0.029176928313042035, -1.1286919074272561, 1.0409777119773962, 0.19522493354128415, -0.2204066367126692, -0.11594469870784917, -1.11422407261388, 0.8560738647502311, 0.1420616813241071, 1.1680182735820022},
    {0.5820457213972305, 0.5405166455632315, -0.225601202774471, 0.2772408931405723, -0.7486789344034084, -0.23091279799358333, 0.42117206988409334, 0.033647603023379165, -0.8785759799699817, 0.14671940708954198, 0.9121354376651409, -0.27717991801069225, -0.017322106573281874, -0.12324492943057096, 0.49608704306260343, 0.595070902685069, 0.33914535082869096, 0.9754777123401739, -0.49859361824682236, -1.0780312851998968, 0.5328504164688532, 0.6825526220369934, 0.47995831667153815, 0.4623793387931454, 0.17062997482864503, 0.8128621261832695, 0.8295679055333234, -0.3791492666416462, 0.2870517176465417, -1.1659935549876121, 0.11513590760701987, -0.1826642792215688, 0.716443702468322, 0.9421546404843534, -0.19419760404089187, 0.17038059693703042, 0.9809836320242916, -0.7337883882949647, 0.6382673886391279, 0.247676833971976, 0.3639786834100686, -1.046285652573969, -1.0453571465929707, -0.3958566640666388, 0.40080615939174136, 0.9313446155258307, -0.4068868471342993, -0.7772712761380921, 0.35624465522905685, 0.6674504799031976, 0.6502325668777756, 0.6980949047954311, -0.2066359107407449, -0.8588531602391312, 0.9177530642286583, 1.0267991020703406, 0.31145253700788533, 0.5618254920117257, 0.843421676417627, -1.1404953333653998, -1.090761823424386, -0.5297485533124208, -0.9071226921304665, 0.19643077514148985},
    {0.2721595329771949, -0.945294644058346, 0.796835666908666, 1.0591226226224126, -0.8997343028159338, 0.7396513355072623, 0.5029245238200415, -0.3635851773407773, -0.45391991814196136, 0.4538789310517994, -0.34495646397450336, -0.4197930836656021, -0.5745649792763553, 0.9596730080061611, -0.09008402203424709, 0.27024383254851175, 0.5473605337034888, -0.12492660516477559, 1.2158195479453808, 0.5031775803588481, 0.1754920704149878, -0.8860949347745876, 0.36924484826251397, -0.5207156237629457, 0.9802440248445197, -0.5816355189527588, 0.14482045487438888, 1.0578152209073937, 0.5699041892802981, 0.5932258306759346, 0.7979557424070187, -1.0918725780636644, 0.09889125580760594, 0.8818122702683846, -0.020113014350091305, 0.09323315124987593, -1.0017125927173471, -0.7068918773658459, -0.3502327403580406, 0.7907370501151323, -1.0734961811722883, -0.8155193695180326, -0.45826869764552774, -0.4269724659185776, 1.2216027016423734, 0.050379095796387, 0.2062912353977003, -0.736065394187254, -0.9604219120064958, -0.4670438598089573, 0.6447494198499312, -0.5091762124453135, 0.36597445113247873, 0.009053828941877574, 0.13365580911086283, 0.8092462427908582, -0.05038052969012693, 0.2178185704757431, -0.36456217501047644, 0.06048996256071832, -1.0525126140540646, 0.0373336314229311, 0.8418984701692389, -0.28331479389244385},
    {0.8626952421488012, -0.28927416504569864, -0.8890739182152699, -0.4074475067705334, -0.6076702010476369, -0.9118079807724304, 0.7051990769254721, -0.7138287095922514, 0.6120153695125619, -0.2968573828473406, -0.5364522928274353, 0.8166825840146624, -0.021614247169349867, 1.0159936013286743, 0.740755872444734, -0.4080174847462754, -0.5710508648267352, 0.14520556798218304, 0.48624689514005764, 0.9926934677659375, 0.786317020630909, -0.8418018217371974, -1.0803711558077156, -0.6245676499478137, 0.42189337666428683, -0.0814492879805901, -0.00011092086536946367, 0.9247003307466332, -0.057122065586101764, -0.7870443911320729, -0.31470095556905214, 0.40126730890075324, -0.9961714519542839, 0.9335712366999509, -0.5385110566541799, 0.24516166312858087, 0.5972698944384501, 0.06885382815519056, -0.19729988800805393, -0.49107412693034963, -1.1910001212942347, 0.3699464571840635, -0.8873722468318316, -0.00458757671424618, 0.580565372836503, 0.9837608216714726, 0.8719644292495424, -0.2431257046110882, -1.137130618359647, 0.36137025399901995, 0.5173959530676924, 0.0736420294957588, -0.3379194820200207, -0.5990635361429123, 1.1889612348446918, -0.5309555187188544, -0.7342008247307098, 0.6426910216254187, 0.4871313692602208, -0.4834910508091151, -0.7869867860232486, 0.9295282504087174, 0.3625500507434131, -0.09037498759032049},
    {0.6465623918983804, 0.24271735711703832, -0.25136179808644143, 1.0400590087632184, -0.30165337624831595, 0.1842271897739673, -0.6804624404462067, 0.8882700515653998, -0.6130958740244804, 0.8947863641247088, -1.17042879747733, -0.18353019928582912, 0.2285681770378236, 1.0629069270301401, -0.03046802429165688, -0.09341309738877598, -1.1013457354008134, -1.010898720359729, 0.47461125399604065, -0.15488589902356867, -0.8967351122074555, -0.12826240366710726, 0.15317097917371467, 0.8467669590144545, -0.510624957710503, 0.8163854372750512, -0.4509388721560864, -0.5131821216639207, 0.5565385217680541, 0.8474989792056198, 0.4878153907848837, 0.689633951345772, 0.2549123202828878, 0.0916446512026876, 0.5037323952533072, 0.8860702377447407, 0.3575871992266796, -1.0410174162408095, 1.1648290170375655, -0.5816212382679588, 1.011112252882258, 1.1353806242079083, 0.9964093511892492, -0.885720624235181, 0.3711939874565068, 0.18717188240562205, -1.000231700907955, 0.8263388200913785, -0.7066438517373379, -1.069141249519211, -0.6233263249121637, -0.7584468496701091, 1.1321006051642026, 0.8965100591422878, 0.19776888707136525, 0.3324060196721558, -1.1243258938753407, -1.2213119417500748, 0.5260286050051252, -0.11298704335310679, 0.4757989032913382, 0.7581809496696713, 0.37635473192535945, 0.8290295701504777},
    {-0.7104829089909716, 1.0171947469188343, 0.07779751404013009, 0.14653436409142018, 0.6716046278165229, -0.09753399563212276, 0.14675331169269584, -1.0866692069970112, -0.11741364486320245, -0.7183128005470614, -0.9557331939732776, -0.20260520743134636, -0.6482533995027807, -0.9942929560811415, -0.6992751882678696, 0.2639855045454861, -0.6846695317530532, -0.7598572138619735, 0.3555535874016353, 0.4358475862303498, -0.17165514933091783, -0.9943065632602527, 0.17175927648183892, 1.0470321065572783, 0.6155530436569948, 1.281255400923743, 0.2443714470168167, 0.9623811882183482, 0.6469921648267065, 0.3054415290621861, 0.760776465860306, 0.913157533195148, -0.2769355504751459, -0.2736296102125385, -0.11874279240816392, 0.9774217661004194, -1.108743243116829, -0.5681467165684868, 0.9014697240940767, 0.30460275095717476, 1.1591204717901873, 0.09908930232238088, 0.14411266696187322, 0.5542265586541022, 0.33488167222414766, -0.8882272101429317, 0.09751591838494716, 0.78771588144687, 0.03861493497202901, -0.24908279331278532, -0.13839847794242868, -1.0654547720023535, 0.9456918098980979, -0.660223595579287, 0.8560498913225891, -0.5093143265290553, -0.11469400180156371, -0.26012053773161353, 1.2136278141139596, 0.37428724848916095, 0.8449139596582821, 0.04185214595300374, -0.7912928060629554, -0.07920432061425807},
    {0.38471015581493506, 0.5294799182389711, 0.3913261103122244, -0.20736554690901055, -0.8849461225090222, -0.9573193346833289, -0.27535238888414587, -0.3403788212794471, -0.8940611985932437, -0.8217292768327978, 0.8621446581585822, -0.02706840662375383, -0.8436857783185087, -0.8796112600351411, 0.9159268525189929, -0.5147358239471276, -0.9899517390830933, -0.8583092234672335, 0.45198435260842207, 1.23136631659505, 0.6013869614869036, 0.8007052700637228, 0.569569786145917, 0.20587032975766426, -1.0264455463442643, -1.0088867651647937, 0.8855757303037723, 0.23095044091805553, 0.7035800394409195, -0.17252472610334624, 0.5519927300596685, 0.681114904835936, -0.05594045822380082, 0.5417896636484075, -0.5978994255580391, -0.5421406304534778, -0.7264968285924547, 0.8860979743783828, 0.019836268998811715, -0.495900856705163, -0.5600302157752872, -0.532130297579931, -0.06884306273037263, 0.21204545632598149, -0.3661557044565854, -0.6247893453849432, 0.7027906462059864, -0.2557738154874587, -0.23899515899201657, 0.3791913567457921, -0.8060078644191354, -0.2523610549761751, 0.037086329141317924, -0.39600423050103256, 0.47784101712590854, 0.976846975907422, -0.7236764490104536, 0.7615652795379411, -0.08099033338681828, 1.0687741482732145, 0.1646040423569805, 0.6678191323003836, 0.3732836868902994, -1.1072575116761616},
    {0.9953039673673663, -0.865832203245179, -0.6455146852863994, -0.29415964364464925, 0.13649093344304694, 0.9777890806135157, -0.09169565493489146, -0.13295350767321845, -0.14886067299940003, 0.88975562882102, 0.3824586634008596, -0.812234154349279, 0.4469210128902635, -0.4895934463555502, 0.30212677682686784, 0.6838971042738918, -0.9152539813895557, -0.02452375808236827, -0.23780845454765295, 0.28380086686968564, -0.09529823858184136, 0.5289726094888773, -0.9369163805985317, -0.8109744734639296, 0.28383504961799494, 0.021446264141282062, -0.43559728883488613, -0.027231288104846096, -0.8065638741300309, -0.05630093060308904, -0.5579481333530837, 0.22739003326325327, 0.42637165612192274, 0.2523456731089018, -1.1467382032173128, -0.7167978539989444, 0.691865596555482, 0.4926971076135891, 1.0707391751793058, 0.34011611692286553, -0.6343642221655389, 0.14793217221246033, 0.19779291769378168, -0.8122932693354704, 1.153105217412967, -0.6850758322577678, 0.8788894995401518, 0.08369255085137209, 0.24377051962141216, -0.8562902651265373, 0.9522075663822259, 1.006335633027027, 0.7094451669769354, 0.3850244599909611, 0.601258612402394, 0.17522152928623644, 1.1584527476255617, -0.2502722510412701, -0.9712077037748447, 1.20145743912205, 0.2469509900162709, 0.11334639358307802, 0.32655082592659607, 1.0314468624455273},
    {0.4986484882630954, -0.6393555075854239, 0.020374036601347435, 0.2708046425805167, -0.1667549589466014, -0.7657489061920096, -0.6579158297023189, -0.26242813803740916, 0.8405372047014632, -0.8338455556496152, -1.0498525728458536, -0.32406867575143106, -0.4850577178695019, 0.3186826068607872, 0.2722278738691661, -1.1062621703370807, 0.20840010236332704, 0.935347414768385, -0.2631115329964719, 0.5308884827338387, -0.3994028313078906, 0.36593757343264316, 1.048235041943506, -0.23959796061654315, 1.1843920750797936, -0.9314409273291782, 0.12024165084605777, 1.0795495741624037, 0.865827551117895, -0.5068691546048761, -0.8602269993046872, -0.07665482117662285, 0.8477496079512965, -1.0441038795001432, -0.9020288321420679, -0.7165942991793155, 0.24026157109062846, 0.0758644576773404, -0.8981082184231582, -0.11620570646984049, -0.32657947168415324, -0.15070800956558517, 0.6612035031483326, -0.6267780383330438, 1.1284427507669677, -1.1036514926175287, -0.01663780315557279, 0.8650941420000409, -0.8070277964875677, 0.6743252078505805, 0.5999358873899538, 1.1586707558382867, 0.26631796044512207, 0.4136459949219173, -0.947387504883968, -1.0203186256083812, 1.0614007227368023, -1.1908939212604428, -0.7338351769428039, 0.9836651243024911, -0.24890655217267926, 0.7395473023540521, 0.9130221370827208, 0.7555893318885027},
    {0.17373652030657455, 0.4135130989818005, 0.03292590815837808, -0.3750828249315621, 0.4271558405601868, -1.2147744349984668, -1.050633193757636, 0.10821747192203136, -0.06928823613406292, -0.3081720456861097, -1.3385996369873234, 1.1553497987193457, -0.8762701597849865, -0.5636750347619546, 0.506233553242534, -0.9151047793117736, 0.3212837765140471, 0.9141233461064857, 0.4679240735258807, 0.3289815121749925, -1.202402521194424, 0.3018920652864954, -0.6414335494626384, 0.9592913691603318, 0.13045051518456577, -0.6562555045270005, 0.8604749263804123, -0.023807613478694787, 0.9266067245795646, -0.3751296257476897, -1.0371580891863372, 0.02926129019043169, -0.5536673349912559, -0.912961325953186, -0.013889270267122106, -0.3164898817931266, 0.02382914861024853, -0.32910030097425, 0.7501262908321109, 0.7053786381308861, -0.5179310713683725, -0.491786266347023, -0.9720267193313341, -0.7718643314377425, -0.44175705784559155, 0.9277332148741407, 0.6567544838968937, -1.0310805148849307, 0.5666136805008043, 0.2569609014554854, 0.3336932688200169, -0.9081489928402183, 1.0438617282367022, 0.5572181411365714, -0.5797830986509668, 0.755689740911644, -1.0208167696989168, -0.7834192989049075, -0.0954396477868858, 0.2850751615478969, -1.0960082258456452, 0.0005036807295101671, 0.7470478173982493, -0.2539202950237291},
    {-0.6587749066040393, 0.9063318244688214, 0.7439774242107116, 0.041546219568621263, 0.8095675071058606, -1.1171362351265133, 0.5488391518368988, -0.07339604815826141, -0.07508225876565353, -0.8631778827307782, -0.011348703417991761, -0.3058464583356281, 0.8643779707522183, 0.7334589156102906, 0.6219105344913606, -0.02768380815531086, -0.1734903588054566, 0.20855747313716247, -0.7840426654794203, -0.4371145237131588, -0.4017695233473618, 0.6982032554898727, -0.3292552380042867, 0.6064895185456811, -0.9307910437219188, 0.8109112329986451, 1.0649850250998913, 0.9596828842048649, 0.21584016904188374, -0.18616276035332643, -0.8832938431106033, -1.0915034607183065, -0.10013308839933452, -0.192571876047684, -0.15150581241155844, -0.3052274034032565, 0.7278426838493064, 1.0143083150270438, -0.7237765715887257, 0.3352757880721925, -0.9759625232872341, -0.47264453275001156, 0.9834789269993827, -0.23281828259698464, -0.7508438381666541, -0.6346302575206179, -1.0002208531898995, 0.3759275141691651, 1.0867499232647453, -0.5654221036291845, 0.11257169670356595, -0.42386862724250157, 0.2707564782865686, 0.18351484680391503, 0.8116976606029649, -0.5902212656759701, 0.7614523069766034, 0.9291891477751185, -0.6836126527063499, -1.0463604372619204, 0.24696075085339325, -0.6979730561092737, -0.9979406724893901, 0.1476186351577762},
    {-1.1429246314748744, 0.26839093946113063, -0.713006698847404, -0.8778443475065311, 0.5877336815290419, 0.7333332336096975, -0.17354880967608985, 0.4540049699247658, 0.28220955359357375, 0.08469376782836059, 1.04205899091257, -0.5269150919233564, -0.009357030409859817, 1.137086963336421, 0.02434859179241999, -0.30971693501805375, -0.22918466147353747, 0.6695886774325617, -0.19231199212733255, 0.26590567291352507, -1.2221524683640657, -0.9045519743750482, -0.3954314463841239, 0.047010284152394624, 0.5164409581431442, -0.4782850381365038, 0.8884553225207105, 0.12858436540213258, -0.3897441922839045, 0.4854706306691591, -0.9608759907757174, 0.08820109246585651, -1.1068265471865675, 0.882387216153182, -0.004560065488056939, -0.6354557588281246, 1.2020727326853864, -0.39849571320813143, 0.46740567295418717, -0.20069391065133954, 0.846339057320245, 0.696424118572702, 0.515383189237643, 0.6184233129555473, 0.9753921230333137, 0.7995513824413613, -0.4066649033157305, -0.02709053141527496, 0.024419036049660073, -0.7474021263186985, 0.16346133519219722, 0.014825578091639879, -0.8811964242587526, -0.33720523201155184, -1.090647684382679, -0.9818935787444822, 0.15989988180729348, 1.060760794484325, -0.4468923481632113, -0.4503956881643244, -0.0427401930309833, -0.7722780566555802, 0.6296757690001898, 0.17336264617118732},
    {-1.1284269172067722, -0.5419133934090486, 0.5814923936515943, -0.30565572206492225, 0.7498369856538386, -0.5139798827452924, 1.0522428552043845, 0.569097237565714, -0.852382697949306, 0.9442438453744417, 0.40140698013229825, -0.1833093177523583, -0.4134101367494579, -0.11242204507611604, 0.9722126447093304, 0.9331496927179761, -0.3265393157221946, 0.5465607872093236, 0.08931878939278852, -0.7230931864299116, -0.5436368843184667, 0.13490055891716635, -0.7707733066635585, -0.8457879123522317, 0.5477600232198765, -1.1723647023916723, 0.35647215907702645, -1.0649586162106242, -0.36138454433412487, -0.4776669324289832, -0.06631515335842922, 0.7823259208735914, 0.11393622649912397, -0.5541301120428183, 0.8422544427016425, -0.6193125577398813, 0.7184609456882777, -0.09525889305672693, 0.2791979591489258, -0.6262878782529879, -0.9522527767264343, 0.42558472448809836, 0.1392803473226605, 0.8881196759504242, 0.5968593292068541, 0.43061069150078196, 0.9140907034566005, -0.8616026021217218, 0.9583234467525215, -0.6314349403440499, 0.5745608686211227, -0.3900150231173037, 0.7322353784575704, 1.0449812061539692, -0.3114045179409914, -0.845248239778898, -0.7049038657929138, -0.3591262542481359, 0.7698352215115726, -0.9261021536368751, -0.5733680577946016, -0.949423845969688, -0.8401141980752831, -0.8701568132879053},
    {0.11026113914352266, -1.00015525137401, -0.7371457428417394, 0.8959950543143091, 0.23706693063769102, 0.06255344081579388, -1.0220361836895493, -0.698440249517014, -0.4943121827520232, 0.6699584666712112, -0.9854552129698806, 0.13183235761825104, 0.18556245256579695, 0.8738242449980066, -0.2041647434470881, 0.2961303465096536, 0.230630680922591, 0.5049639715308392, 0.12022587144965761, 0.9854517205450282, -1.0111400080194428, -0.6881123551295694, -0.761362320500515, -0.028374431794151465, -0.601025870376882, 0.27791096135090376, -0.1919745808056722, 0.6281096223970419, 1.1843562026565266, -0.8887348940288734, 0.3855854035221652, -0.06372367027531868, -0.4814387124474362, -0.41339806828969633, -1.0066734909242614, -1.0879730394147507, -0.9291699087297365, 0.1894948104062706, -0.8907200936622413, -0.4085488293070103, 0.6652740326596699, -0.05063262606729009, -0.43470365472940914, -1.0409241520184083, -0.4832382892579703, 0.9949644102056882, 0.5215325611265859, 0.647603451850222, -0.33683371967008885, 0.5343938247616423, -0.1106596552518828, 0.021026601869761845, 0.5252276372660479, -0.17324176624938978, -1.153460999146585, -0.8463832050423502, 0.6814311965717188, -0.6310493018522254, 0.8838644018418136, 1.0157223312896504, -0.5279342994282213, 1.1448361376931333, 0.5060015625521869, 0.8073555954195917},
    {-0.5057485398602811, -0.6326889948422876, 0.8896154032952494, -0.4480240241715395, 0.6988644998922985, 0.7989430013579284, -0.3012658968448883, 0.9004693018910995, -0.6438557959401534, -0.9103089491903579, 1.0876171184207135, -0.3622561700605406, 0.5569258985788974, 0.6412738750177837, -0.6076124267674653, 0.09944377852774995, 0.8426973132476898, -0.6796837085815312, 0.45101914397972204, 0.549659477291072, 1.044829847115184, -1.0324105186837722, -0.03292180330837436, -0.3331895104858948, 0.509102068601043, 0.15840682575296583, -0.3291342424049479, -0.0996984502667744, 1.0529391632582208, -1.1018633504702533, 0.2987362068822465, -1.0565361163257, 1.0113212400202987, 0.7403230519497306, 0.5049234380593994, 0.22715880151192963, 0.9378055017181447, -0.7557997859907172, -1.0039793889706305, -0.5741597691792273, 0.03723078415974361, 0.25998829017747505, -0.5301208771609712, 0.5085711334050327, -0.33921885416499475, 0.30158477807134154, -0.07001178802579205, 0.5008640068597581, -0.8848122385834284, 0.608440017258211, 0.6283268299914373, 0.34303298768132806, -0.056448499804825365, -0.1320723377054471, 0.21183585096260477, 0.9261011890134687, -0.14182220638220633, 0.5208106514378125, 0.8214582451163412, 0.4725306721591237, -0.5100366931282263, 1.0486726999728098, -0.7626717579092189, -0.019979305122735543},
    {0.08837348074568026, 0.8113242127773406, -0.9833079533750356, 0.3151261993494575, -0.2811835893636283, 1.1003181162095128, -0.20724673355351028, -0.38302423842963373, -0.019414190934436568, 0.8078060715847202, -0.8732541021357244, 0.3359743969629259, 0.11442991270103221, -0.4275109820074384, 0.8540634430992822, -0.9068853605859288, -0.2702061431987373, 0.5078302186812435, 0.011079884609441011, 0.051192128517134616, -0.906706085649772, -0.20506997878497737, 0.1205867312245252, 0.21751656812446243, -0.4977302435004278, -0.5635826277453184, -1.0997513852640601, -0.16218073251432777, -0.0034119095825136643, 0.4180771840420261, 0.32793869634337347, 0.41380861099407795, -0.5914535295107748, -1.1513837423573743, -0.06961508617377593, 0.0038398019389415186, -0.9323261189837082, -0.06370324997364266, -0.2865657703934299, 0.9475254159455867, 0.623271553863461, 0.8134511913650572, 0.22815598176717866, 1.1245757078683956, 0.6788241638171777, -0.9448221665692134, -0.7466518758391518, 0.5091166558942122, 0.07269350590329066, 0.09981988435038312, 0.9748385845468749, -1.2096604577841377, 0.21654434387594076, -0.4689616343587129, -0.7839045716528161, 1.139624671569197, 0.8038616451868366, 0.7041429973625921, 0.016263337527905743, 0.9231272790282619, 0.6029518385883131, 0.4672219253939144, -0.27733373001873646, 0.3224239495919093},
    {-0.701068370313751, -0.9719409753995523, 0.8501479110290276, -0.8329571953092778, -0.7946633482987855, -0.9910698467853434, 0.3788872204454666, 1.0662435238633619, 0.4254122693464352, 0.9772636792652312, -0.3254677582298039, -0.6929593283882348, -0.041293595974091386, -0.41221186533997456, 0.9352727993410115, -0.7733658626335053, 0.30246480286145844, 0.8196606164984234, -0.6057892367567234, -0.7863792425644358, -0.04162857659489844, -0.06438481192061936, 0.8157922687520411, -0.7625201195676276, -0.6629661303181431, -0.24799277603481917, 1.0934062902495814, -0.4748399926319715, 0.6533077492089215, 1.2435446545493296, -0.6280463230861982, 0.28542499394884396, 1.178586591598564, 0.15873178979735783, 0.28759327493058423, -0.019060359603229108, 0.09674449872353334, 1.0641184959650525, -0.31997115296826045, -0.8801720363924939, 1.1037116398448146, 0.055779615268090194, 1.1682547738107425, 0.37227204718144263, 1.08557903534892, -0.7679386091115866, 0.39602881305763, -0.2604311733114832, 0.07361322250734997, -0.011289342759307385, 0.2807836162644306, -1.1670205759170393, -1.0257045750955265, 0.17234901972262245, 0.7836403586010448, -0.814039525147599, -0.823167429094126, 0.2491588709589182, 1.1581622002007683, 0.5049023889158458, -0.2367349145077948, -0.8197516310534966, -0.25484602926196176, 0.45606829750711325},
    {-0.5799951463511639, -0.1380864707967678, -0.796745037709196, 0.4419361931262145, 0.4297997729928829, 0.19107519173751653, -0.9306737196629761, 0.8749260201368745, 1.0633259189478135, -0.6199870589895284, 0.8419009552591434, 0.5256391312334041, 0.6360347093238355, 0.913397208342952, 0.02912068378123429, -0.20427854655188257, 0.8283502945577604, -1.0493008202662617, -0.3114163593164297, -0.865373749078052, -0.9160049990658986, -0.7813699831199554, -1.1505131120883911, -0.936830236254342, 0.22032525666745065, 0.8132031397327846, 1.0468644970895502, -0.37755973148103683, -1.1265703273318077, 1.105194862312122, -0.5022400375057192, -0.17678092397787779, -0.5992350541988349, 0.5352343630034258, 0.35217138717395485, -0.0849046287716825, 0.7380467129608826, 0.10509918219520331, -0.760718755107561, 0.6964611224176869, -0.9667252030993079, -0.049269822831888854, -0.12065078484671367, 0.13415264832969684, -0.17258303807243577, -0.6578527681567832, 0.6083271559969892, 0.17589574143978495, -0.8658932360678185, 0.43538367389964244, -0.6061559905824566, -0.5841865403994473, -0.42483508848382245, 0.5004606872517481, -1.1619499015274362, 0.011136916695222678, 0.10522293183393182, -0.03927995711530891, -0.8874652037448726, -0.7872510334761055, 0.5039006333288402, -1.1840831587373046, -0.7106459514563388, -0.7514462272033979},
    {0.5937923151039617, -0.032281910918807666, 0.32270003804561415, 0.8300110824795558, 0.4176788359014083, -0.792350032119473, -0.46306707403308767, 0.6692479539497584, 0.6919435399280603, 0.15537451213885486, -0.47220211128233514, -0.5743438998996947, -0.5708036135978971, -0.4303678035792309, -0.1462895450145336, 0.06711850021599733, 0.45437104821453816, -0.40830267370138523, -0.17764732544884002, 0.944895795789833, 0.6927609182317283, -0.9374012410480126, -0.36910498988908946, -0.5330890426434096, -0.12688353106288314, 0.6395826839002862, -0.5797017057601596, -0.37999183703173367, 0.11254384804397821, 0.03204214255137452, 0.26369118083094845, -0.26830571374573203, 1.0359071227596182, -1.0281881362404437, -0.00478421746700059, 1.1749276764464174, 1.1417354082471434, -0.24439128367589044, -0.11770983579998565, 0.5465570259760577, -1.006278200969378, -0.8965234644591071, 0.8630148394867292, 0.8608986798241444, 0.4516926674542609, -0.7346215390400117, -1.123387736868349, 0.17486308991130853, 0.22090854922971262, -1.0499095809669872, -0.28460276177248206, 0.5364034735580133, -0.7091270713623654, -0.8462149730283852, 0.6776062264013786, 0.2972497714004897, 0.7509575676923662, 1.0490472957384573, 0.43222120727339486, -1.0848417594741204, 0.36209095907175165, -0.7827706537501905, 0.22480373941268486, 0.4161222830961367},
    {0.2732846625980584, -0.7442190298901735, -1.049502868916857, 0.9285081666947395, -0.23822709538217735, 0.7441583734997793, -1.008722185673831, 1.1333922218179082, -0.3302200207347838, 0.25778757149753434, -1.2306555789553184, -0.3395865484823508, -1.040927051640949, 0.6584616247700016, -0.572052248862717, 0.21415450833386865, -0.5925347417421148, 0.20334558014086634, 0.5282314266145602, -0.5819725646413912, -0.667813027737552, -0.9076285172687061, 0.42999446494021315, -0.8128125529710457, 0.8633833185866576, -0.11158181310168738, 0.2025021824986821, -0.6152081935897581, -1.168149928115778, -0.5348941709581718, -0.7756368799985798, 0.9629184036165084, -0.5474129140657363, -0.4324888844699549, 0.7815983326055994, 0.638522023627316, -0.9780341952781803, 1.015389511475043, -0.8011586430411458, -0.16132577728371444, 0.7935473855824574, 0.20077642939536453, -0.9559380424402176, -0.4255055820582248, -0.3835131528293938, -0.11894877048299636, -0.012245249109105244, 0.08335423392324903, -1.0345758687459259, 0.06741157822111896, -0.9213010202281473, -0.5012285966114103, -0.3132019770469688, -0.9678048625737211, -0.08790361785051302, 0.6741453925405835, -0.17968955557031976, 0.290076020756689, -0.2862001223110916, -0.5632512190546067, -0.6695653198349444, 0.4035878140426757, 0.7974281673185941, -0.2039123259542954},
    {0.03440503376497611, 1.1730598902715899, -1.1108889533613013, -0.9899588710489416, 0.7578025421571769, 0.4010031585368326, 0.09385606829132634, 0.06417461521998193, -0.25410796513555406, -0.32000448915271973, 0.003386539921020239, 0.5845879065596176, -0.5720984106111141, 0.9827596499416335, -1.0979074691806345, -0.13963620043164587, 0.48090629759352943, -0.578807893182087, -1.0348660737733881, -0.08005251107246171, 0.5849596647523583, -0.09002571632359686, -0.24722341091118216, 0.20498021621095205, 0.612227045992192, -0.12974273158219313, -0.29439253416444733, -0.9743852719128953, -0.12388537931343195, -0.8147063823045002, 0.2944442573632931, 0.348485137379168, -0.002545091586245562, -0.07826229482024381, -0.13986571404500767, -0.3915498358661551, 0.193062570094472, 0.9422671712662564, -0.6328092209789549, 0.3394680546769835, 1.0804330973412453, 0.7178307309093384, 0.7098938522887617, 0.09236951243749697, 0.5738160669324642, -0.2933447834526697, 0.23103382661334038, -0.7458611804196364, -0.7415219711906919, -0.26870568042749404, 0.4312298341892581, 0.9510530631836626, -0.13547925322713053, -0.9592438856515194, -0.5011504190674206, -0.9700355497781691, 1.05234306260803, -0.3863360164441748, 0.2668124386277303, 0.4841644150653062, 0.20830766172079462, 0.8852910501740423, 0.7765076902517539, -0.17181359596951098},
    {0.03925631304619572, -0.6975318858814552, -0.80337384300001, 0.35560635740083835, 1.221968609540045, -0.2014842855243881, -0.02664457807253534, 0.9751257012986821, -0.1771439506359898, -0.9962751056016852, 0.3098664961804647, -0.9078672910686176, -1.034294869830152, 0.030555398347470453, -0.08929135271016779, 0.13993068179241094, -0.5594877405880325, 0.237243991611643, -0.6249726538916424, -0.9215063364689928, -1.0676184415903713, -0.34300468456342087, 1.2232961526211508, -0.909022587981292, -0.6732945920385625, 1.142072638987231, 0.53085015450048, -0.5461055860242454, 0.923833591007923, 0.12871221091846266, 0.4080788425578034, -0.8545394998408815, -0.017569339100579895, 0.6434921606409196, -0.8965479645803598, 0.8342123164835159, 0.9096155472625925, -0.02252107429787471, -0.6405090077657853, -0.27829374582825095, -0.3973987096413198, -0.3974124026983742, 0.5371142097344246, 0.7753569366204379, 0.6806531962928581, 0.4385753099441071, -0.6337975634011661, -0.7295082979179157, -0.32635137143668835, 0.8045871387410884, 0.981136668983236, 0.8675076389725024, -0.5010056720873529, 0.7378934880631878, 1.105634569684719, -0.9002657349438112, -0.40896154140681723, -0.8485480323169644, 0.9900758037043288, 0.044681765436513296, -0.17644873631292768, 0.8990680830352845, -0.6920960197138764, 1.2319740966486814},
    {-1.1736904249666802, -0.2079922740034329, 0.3481605688698563, 0.06646559005255501, 0.00045847176003362296, 0.7339946554436408, 0.11535937447946057, 0.0716895419643049, -1.0542525489568528, -0.7139137754184206, 0.598547593842953, 0.6648509366204424, 0.014714577324669187, 0.019906089986203915, -0.9494437839247722, -0.381911740780659, 0.5825247065637489, -0.49883901102751904, 0.8430890750100654, -0.30932708713330626, 0.6232003581334956, -0.7721354425436094, 0.9327135982043289, 0.5420128817036121, 0.7557296778833918, -0.9482972668454616, 0.30675341152237734, 0.9864686386844418, -0.0010328499335137337, -0.28507677941624626, 1.02815056670284, 0.18597226183586718, 0.37487313935169525, -0.4463187483176351, -0.9524884995925227, 0.6016219136200055, 0.7496168954976564, 0.903476766511936, 0.35594180937614517, -0.7864778378945618, -0.1460177210402024, -0.7327151423047378, -0.5210818686204252, -0.0033895628731478813, 0.44503348024140993, -0.5719691050023928, 0.13267313600569797, 0.28841213356096573, 1.1132851812383573, 0.8267292280889404, 0.09358661880805229, -0.9770639994136121, 0.42350046330941676, -1.2052597518425328, -0.2043774942423995, -0.21897291228799096, -1.1964895712023047, -0.17249523707589456, 1.0969360630578648, 0.19224449213369976, 0.30642531336192685, -0.917208725529592, -0.8252438853292238, -0.8806141024930128},
    {-0.7044926024851325, 0.9164771781348761, -0.8556539702351756, -0.11392793945412691, 1.2113971262710572, 0.14370771384495262, 0.3206036562383587, -0.8297777249576423, 0.29186985455169345, 1.0583917414750494, 0.37610972688945454, -1.0656303959271736, -0.5039490592084972, -0.08585301808781039, 0.43364468892981956, -0.22078022519930376, 0.8965884727129131, -0.3049316719222114, -0.613438572379771, 0.9848254445415743, 0.7521554648910215, -0.3627636645726591, -1.0109276382302237, -0.3575450274526713, 0.8067069444465118, 0.017754069924381537, -0.1486903899789291, 0.5107353374426514, 0.7602911410202859, 0.6908909763888734, 0.21815463571565988, 1.2014336341926557, -0.9605274859140882, -0.4119780736217125, 0.7551179431239694, 0.22657506870718097, 0.6320969883937437, 0.523507440200707, -0.90052577107451, 0.042132263528181856, -0.09191643838018451, 1.1172659653041968, -1.0332679852452211, 0.6954135787302891, -0.7346527494646503, 0.8591398728170758, -0.609329225598393, 0.670781959321251, -0.8049640125262274, -0.7729874471907444, -1.0252143518958452, 0.7082285543307428, 0.17584804858599323, -0.4154549003820472, 0.775926121445589, -0.052761652482017696, 1.0870034729416667, 0.26838646934256916, -0.06698450310121606, 0.42827428709839077, -0.054105914211289796, -1.097984298638858, -0.1809965487338343, -0.7436935519691716},
    {-0.43325124910400803, -0.5973419765295568, -0.420959977190917, 0.8844535227020202, 0.4542482048292901, 0.21736392311078423, 0.5285088188017247, 0.25642171596557506, -1.0568365972597529, 0.01345645576430003, 0.3456451028632949, -0.6596813671719227, 0.8962182861382365, -0.7129145782172018, -0.7520338123702601, -0.45604781423570345, -0.22949007001018623, 1.0656906200735181, -0.14017038764122014, -0.5819623284508817, -0.07305872331989044, -0.5364050846335604, 0.5664629439095719, -0.9599641531986662, 0.4918012330038565, -0.49280382195624267, 0.2908924794061529, -0.2554426142698716, -0.022843158646136872, 0.40759357853961103, 0.5101978720051766, 0.8001418915914517, -1.16663108669675, -0.748516331198073, -0.15199968524953852, 0.6019201974706315, -1.1284369050604353, 0.3049928045244252, 0.594228415750033, -1.284674967275907, -0.699730768122188, -0.1745572928519922, -0.13005070753105885, -0.3421830765371333, -0.17442418948140817, -0.6652173602707958, -1.1550355226795295, 0.6285834803544355, -0.9340154862247602, 0.2703803937324249, -0.43432313131220673, 0.8108840993192417, 0.41017046925450223, 0.594770371708675, -0.1669652698494929, -0.17724145873391692, -0.6857181342040195, 0.1289024441766116, -0.6166442035328211, 0.07468784299979335, 1.1619912221247406, -0.8831652994651286, -0.6505265224357505, 1.0817476248569624},
    {-0.929412557687829, -0.6166424612737015, 0.9676157752331689, 0.6929873518286003, -0.9229051374351359, -0.4454209079127856, -1.0286786216804944, 1.0632018893232478, 0.43045475741502404, -1.0120201137805878, -0.7765175402141997, 0.3915081944656826, -0.06036093880948203, -0.7115278560285518, 0.06257165476509027, 1.272759341259859, -0.0818622392577091, 0.1686849607825297, 1.0253915615892746, 0.7448304840387854, -0.18590413045974344, 0.598601796295803, -0.11090492687372033, 0.1310501361232208, 0.015153121992602327, 0.6891569488722786, 0.663375210447375, -0.3729463200478685, 0.5943222826823452, 0.19524962551339003, -0.7499671216066841, 0.26732701659387176, 0.09896330580366888, -0.9723177022873487, 0.3525141860422889, -0.16240074790167713, 0.06556676356823739, -0.8085845522935239, -0.29565937296681916, 0.9757681398577979, 0.5450107034198529, 0.8914826142593344, 0.5591424558725558, 1.0042005593513548, 1.2644415990265117, 0.11105882529316312, 0.8143123070839653, -0.21110440929728688, 0.4640979720718768, 1.0841456852425995, 0.9270390337319164, -0.9839371227657133, 0.29994643054685827, -0.3350513843286711, -1.1010433187521684, -0.07847110935943201, 1.0261775546134846, 0.6962029195396211, -0.23512096894402407, 0.6980130117897605, -0.9992658726414186, 1.0276253326423082, 0.458580341975935, -0.48252671681106374},
    {-0.9269954920810254, -0.9888780686958281, -0.4156883424048397, 0.4617567172424763, -0.33604982747007806, -0.38326490345277703, -0.8287005313664796, -1.0852530740013948, 0.6163000128849558, -0.8088637715499689, -0.7978591307638573, 0.1344759138573884, 0.6939539698892468, 0.18609329188208457, 0.8949135213581074, 0.9222832637200558, -0.7134830735690871, 0.9231255010237254, -1.1336447719543037, 0.9516326428122337, -0.19886999256483257, 0.09865974424019577, -0.26693730573710894, -0.29850148044808705, -0.8549147608469841, 0.9675189349592397, 0.586958753555289, 0.7402556660462558, 0.23122932771249574, 0.07326418470752982, -0.423729101609433, 0.38222322751521987, -0.7903493720326459, -0.63360623402995, 0.6270892943374948, 0.7382530280802676, -0.3377186788828292, -0.616625188999883, 0.7791458176085164, -0.1389534745865116, -1.1221959759384623, 0.08792095019170912, 0.57172868683774, 0.740656614683922, 0.5431666161322157, 0.25497810946512645, -0.4707746483607684, -0.0988055652037152, -1.2562474505938468, 0.8236175692961516, -0.19698163368475116, -0.6782688293382567, -0.04243908514023181, -1.0566551493324123, 0.8144523607543347, -0.8625958965334897, -0.16203241668529625, -1.1418510950446903, -0.08705280096501282, 0.09469982564548658, -0.9593601603693244, 0.3771301808970528, 0.628994265331197, -0.1359776702824953},
    {0.39987154502026967, 0.7830532113721899, 0.21429447065808077, 0.36775180852205097, -0.20530768007988498, 0.08807215072564545, 0.5056216494267634, 1.0424726225941061, -0.6265736081079203, -0.970833254378895, -0.062163523274975735, -0.059425177328087206, 0.9673954415831832, 0.08608517866165126, 0.0501949538306124, -0.0828045182444773, 1.0203531585932457, -0.4653219813909641, 0.9978728138606905, 0.02767409686790094, 0.34081913211642434, -1.0448047623327275, -0.7972042869815238, 0.3937942117081104, 1.0122690828777863, -0.5577084848726758, 0.5889733923932144, -1.093169161404338, 1.0089523479691709, -0.7994705654407136, 0.679390528885755, 0.10795426309555922, -0.12055585260216017, 0.5632064452770914, -0.4352787106603071, 0.93317201446122, -1.1558183940725337, -1.163634614437324, -0.4168235910632729, 0.16737846568943154, 0.4924694017188073, 0.23846076312723472, -0.8912506083758783, -0.6534742206082654, -0.007438062140500634, 1.0731148049333996, -0.357736349428664, 1.1289642457579991, -0.868787521895563, -0.5230330896905422, -0.8717047073947518, 0.6247838123742436, 0.30508965214139705, -1.0882342265287832, -0.23290849955509887, -0.67612906572489, -0.025428485820498024, -0.48413385165485134, 1.0652610529507065, -0.3839233787774014, -0.8175140835501439, 0.43723748480009245, 1.0018720647876265, -0.7921042521702379},
    {-0.9045326233245321, -0.12998236412829955, 1.0155113795621264, -0.3750953521642891, -0.18214504746962445, -0.1565254242967375, -0.983331506055483, 0.12256398126532005, -0.8494200149721216, 0.1900039279314177, 0.26707869752752633, 0.0890492969625142, 0.3687802527650144, 0.4678960205098128, -0.6054362451546655, -1.0791522550831134, 0.8891163322154838, -0.4947198338502095, 0.35858034486035567, -0.8222933544129631, 0.16073256302427177, 0.12120568178319506, -0.647705836446975, -0.4058531511228021, 0.46746700116430673, -0.5751315099152934, 1.040375136743445, 1.2962534373468053, -0.9107893443762687, -0.09218171594315609, -1.0007860881550599, -0.22273451932720664, -0.6256973806934203, 0.8359297637917421, -0.1481938437700159, 0.7129809969863771, 0.8429188854797747, 0.4389364412786629, 0.031522306237948786, -0.7602600306465068, 0.2271326420366687, -0.7827984363960152, 0.14086339117684157, 0.9411070494006086, 0.41297733919706897, -1.15420695044665, 0.1215335576288539, 0.1228113450038994, -0.990644157008115, 0.8563261970539032, -0.3116021658162517, -0.8013307308362935, -0.44091080187632764, -0.38317416177094943, 0.565215008732421, -0.42340529218567335, -0.08343707539314206, 0.9146810926258921, 0.5618341802551048, 0.12897644441784414, -0.5388228032725422, -0.7387911532958028, 0.15123981625541366, -0.4849299774740282},
    {-0.6429315711881276, -0.9575317111509063, 0.49076046170796694, 0.19278461012933912, -1.2206271923816747, -0.258745770197552, -0.8590777872025467, -0.8715910429469662, -0.2527531505584642, 0.19867417062916046, -0.606921843261425, -0.01857244115352764, -0.9359835849619615, 1.0741592591343225, 0.6318072001527626, 0.17571979324053108, -0.09662183995524631, 0.6688061349983934, 0.6259278870516743, 0.7513769801298382, 0.25058824164139637, 0.9324523336311944, -0.12611695407686263, -1.1063756890192962, -0.5818714978518003, -0.6964347275545008, -0.9850490760641466, 0.42342541653250965, 1.1854244541870635, 1.0099961637125137, 0.35383230718120406, -0.24200233234862686, 0.5206766031115722, 0.4581294624628674, 0.5918930193858303, -0.16635719017464054, 1.2216783393141128, 0.2961352691856152, 0.022937350807833636, -0.32244285340164885, -0.15173076085250894, -0.24430962291190889, -0.6346570247566179, 0.4442024685072781, 0.15792164939131187, 0.8574862498200512, -0.7700388135484558, -0.4083054526014087, -0.2194466430007067, 0.028702854902406833, -0.2578580442653801, 0.9622373749885907, -0.823160852452827, 0.6876923445575692, 0.0938419040143091, -0.8457017075603074, -0.6413350221907025, -1.0927283802179282, 0.8466460180452137, -0.8762807039639865, -0.2569694052058712, 0.10288435151045454, -0.5676991375962552, -0.012799257101281906},
    {1.0041295969806134, -0.7987693847089055, -0.18441006198842266, 1.127703400149001, 0.12188438745654076, -1.189627206811115, -0.3421397133140328, 0.2706265208476849, 0.12281709501311874, 0.6849617792945658, 0.5274358373872461, 1.0354503502359749, 1.062734548670654, -0.9024744866866824, 0.48935550507800085, -0.07365365635968317, 0.25663554387060383, 0.014439154052787881, -0.351624013463246, -0.7081330104041833, 0.07004182699028602, 0.015469696271939466, -0.39869743927043927, 0.21977657433450162, -0.34546592528844766, 0.9298093084077005, -0.06402403168381801, -0.3443391510967683, -0.22172272344349997, 1.1293335301944099, 0.8236310804998473, -1.3785655342157839, 0.3892617859493955, 0.20435962255876755, -1.1954804912227224, 0.697244694486573, 0.12221386439381594, -0.7464518067821838, 0.8335072262758152, 0.8256323237065566, -1.320396686423665, 0.2827409561977514, -1.1098738915700406, -0.19646025604315304, 0.7960165011453887, 0.4429818867352318, -0.9389037538234305, 0.10557825413718962, 0.19954363470458722, 0.9295265628273504, 0.8880394234590973, 0.008158124693979507, -0.9930761812106266, -0.9818804396992697, -0.6841325872628836, 0.5841452205953465, 0.6129278726094216, 0.3645955262929272, -0.20852215630254647, 0.7041590430806656, -0.4511016202686152, -0.24960931836564015, 1.0853270749695316, 0.6656433127984934},
    {-0.09066002367193231, 0.5629950130975633, -0.3618500969688841, 0.7250731758441146, -0.19879187169701265, 0.4357384190697217, 0.8140877407066753, 0.1452329730576205, -0.10959852090848421, 0.021925040573644288, 0.41824086906559904, 0.7760639609562857, 0.4215461317916139, -0.45923063547993465, -0.005915752439962229, 0.5939840925685985, 0.5466639600060915, 0.9119303562495118, -0.16056386869633577, -0.8853676241856332, -0.01418303210148933, -0.33682723775309936, 0.0435093370906143, -0.3122886166265476, 0.4626800435095851, 0.23478175709743004, -0.8808274435151581, -1.265637203959292, 0.7340780038719283, 0.8162195760939143, -0.71659393683406, -0.3581212215213886, 0.9989144439816913, -0.23160639971671765, -0.874828303981803, -0.7778778929279344, -0.8287590781156166, -1.1628605210596779, -0.1925116684538157, 0.7344005323083472, -0.5221255824917835, 0.535564454581381, -1.0191516934465958, 0.14256536300120015, -0.5075907528728123, 1.0923765985152478, -0.17693689894721898, -0.9528260759718216, -0.7333073554370368, 0.0022975107552056797, 0.23580078376760236, -0.2870695947996694, 0.5660097481226506, -1.196822501023045, -0.20046323895742213, 0.07540223207248571, -1.0445567415322115, -0.2409538992385312, -0.7839784314591904, 0.44669666140730463, -0.2759434772228126, 0.9728656514379972, 0.4308667592383337, 0.756264478224562},
    {0.1524201737021238, 0.3426538614866083, 0.7213025142185696, -0.8367841259345146, -1.3261902407978023, -0.6862230910479449, 0.035034411233232414, -0.5254861512532439, -0.838271129034612, -0.7869447969875295, -0.822337313834859, -0.847798862454615, -0.3169407048034766, 0.07594809269642616, 0.8559412516550766, -0.6375598628698773, 0.2074179339166948, 0.25336865254205676, -0.08918138457251808, -1.0656326088085917, 0.12452455387122972, -0.9686127739970083, 0.3591618497652804, 0.7037498508461061, -0.18773930717707527, -0.3921511631965523, 0.32186711520397, 1.1070119614539746, -0.16605674652934133, 0.11428697936895518, -0.20232171492267015, -0.9037729614040649, 0.8809427818546958, -0.7951200072677906, 0.3287958713529098, -1.0527643950246814, 0.7497154172157272, -0.8221870785154888, -0.26956743177892006, 0.11845740311082906, -0.4858993471497135, 0.6302947029092479, 0.46916366482323113, -0.1161677124038337, -1.1078943439856763, 0.18774725031684675, 0.7943367682086581, -0.23376597966870408, 0.8179542146689217, 0.31458580311580875, -0.5361927635148591, -0.7991610703305512, 0.29866999012534257, 0.7470988845220061, 0.04077887470850541, 0.664823744064758, 0.8930029508036973, -1.1822634998770691, -0.020267831335573357, -0.6156698766629195, 0.5988608271024277, -0.7150692294374618, -0.8842267681196585, 0.1594013805649497},
    {1.0908933591108907, -0.21503952730063364, 0.1707805844628287, -0.4685582380319089, -0.5978782211263793, -0.946887049872954, 0.4425435140265019, 0.8178153169572745, 0.027170805414019675, -0.6683722548611423, 0.9307365119194385, -0.39577365579009693, 0.2359514084651194, -0.42295392058201253, -0.8325008797398917, 0.7528801810874419, 0.5584308844945197, -0.3367858116555572, -0.3598548086411767, -0.7228726925168181, -0.6096924632088578, 0.9652102003347108, 0.10675035845115191, 0.018781350242951394, -0.9156722537372348, 0.3034584999068627, 0.02796205961484313, 0.07191319918563989, 0.27445276607765273, 0.7168165920675933, -0.12219315810105648, -1.007373993646092, -0.04121887853413312, -0.7597274622587076, 0.7666086864655466, -0.8511367583075887, 0.08601488869574625, -1.33068411534542, 0.7813195653370963, -0.28357835609035514, 0.7022863204723752, -0.004662529233482321, -0.3624592445642736, -0.5313569139021157, 0.4993267871317465, -0.16958503158180238, 0.8688486298945668, -0.01900596950240995, 1.0425343669078075, -0.5838131431482119, 0.8492854413850071, 0.7423960972561368, -0.31094772600816317, -0.08043390131037662, -0.6728364543281212, 0.7920878972293253, -0.6887624842929543, 0.0716619984979987, 0.5933867035890801, -0.767490556447633, 0.3298626072551644, 0.6422475002876938, -0.45474436507389027, -0.754542980149536},
    {-0.15211215784742568, -0.05589290185935558, 0.21820407805111675, -0.8879146451812036, 1.0841644098786476, -1.0844937255065807, -0.7609894887326809, 0.7130205658250378, 0.18936927920730195, 0.310596842535315, -0.8208427209563898, 0.8295196558427289, 0.4844973114289217, 0.9917628407012751, 0.4620593704890004, -0.7851675934485236, 0.7265917624514743, 0.9315033059922275, -0.5363147959539991, -0.31116568285235063, 1.1506466538668703, 0.9960998516838522, -0.2826346124676568, -0.5753088358074666, -0.06876481396284785, -0.5165259600780915, -0.31588932209281884, -0.5378437211567553, 1.117455644021044, 1.0423448684038017, 0.44368222737144225, -0.014629123945264057, 0.012968683238864968, 0.2587735061794836, 0.41616807100530395, -0.8197969257622029, -1.1935037209183472, -0.038221314420996064, -1.1948790573773067, -0.6012280937678844, 0.11663243509990807, 0.4790848913726931, 0.1218974304295002, 0.4350044692003674, -0.3960386836837871, -0.459772377258227, -1.0267773391267403, 0.9297060272564619, 0.15438229070702097, 0.9180804706845141, -0.24109563701586476, 1.023378344658333, -0.5565741850400958, -0.9811409127949329, 0.9819688767678818, -0.6625605836656006, -0.7040832083126312, -1.040841841092125, -0.012475492400307368, -0.6741993928142704, 0.06981902184255452, 0.5456689602203818, 0.8867449636669115, -0.8983225106556385},
    {-0.28351699153090737, 0.7926822482310567, -0.6865028012175357, 0.32390258148572837, -1.1007419248538879, -0.9880686906949017, 1.1591912357663283, 0.7139161543862488, 1.0369323929633139, -0.03693371315602987, 1.0721317307362235, 0.3648059904364061, 0.6755962975272327, -0.9422674760843649, -0.3249173341477551, -1.1597221249022334, 0.8893386113218523, -1.1993653554714943, -0.5092602025817061, 0.24802017816036698, 0.3444450948011272, -0.775653243730334, 0.3683052355997483, 0.24710077921234325, 0.08624358820986533, 0.1568288789505133, 0.4605908790200035, 0.834000194376193, 0.103599980310506, 0.21708375919771042, -0.9017446594175902, -0.33568465839696054, -0.13871911323011124, -0.04646271951118323, -0.2750142606916386, -0.13347710084261347, -0.8611498360256493, -0.2877106345263009, -0.8483383481522171, -0.46040810351044154, -0.46550464871340513, 0.008961963417364403, 0.24575850023634654, -0.9241735116894161, 0.05488910654718265, -0.18507861997008349, 0.9455784799019228, -0.4524709342482661, -1.1658358130001083, 0.33246955435978964, -0.2755750075287743, 0.6131169472617113, -0.9525351944668109, -0.2572764116519548, -0.07157273566175483, 0.26434433838593857, -0.5123182728093051, 0.7508575122433976, 0.4875892798400758, -0.4854770669032046, 0.050080761410389286, 0.7108339770124298, 0.3400410296213106, -0.5924678322269735},
    {-0.6520719498427362, -0.09883751496766228, -0.9603340646878117, -1.1533986016972193, -0.828320377896009, -1.1103373388220181, -0.5880975934798328, 0.9445200535950534, -0.8358327773489158, 0.3124364394607459, -0.38794927576526517, -0.840804532696748, 0.32470319734780323, 0.6169081230075536, 0.9517895309032895, -1.1649622880379056, -1.0352961036090693, 0.013105565065402095, 1.0883686337157696, -1.3485386629338707, -1.0758385708207487, -0.341907029298454, -0.5672963295657115, 0.051133244812295725, 0.3831301321511736, -0.4424608115130356, -0.24459808407872957, -0.9252152393184411, 0.9288053438434145, 0.8852774177544908, -0.5132837172823687, 1.037857739808841, 1.09118314012687, 0.5574925819917618, 0.583531829220184, 0.32356130805032385, -1.0070233185982576, 0.38986464226160084, -0.08687454152028667, -0.5638957358730197, -0.8630527533574011, -0.49987772183231244, 0.7375121725298647, 0.03287377052527091, 0.48907578914075167, -0.7483778044719263, -0.2916228887188838, -0.628273597096531, 0.8327875114693818, -1.2415053983105926, 0.8809222686764097, -0.9594127803688411, 0.3236071092080351, -0.6117664057658274, 0.2912670486499989, -0.06005902115078428, 0.774746714060584, -0.2536534799004359, -0.07256195065127968, 0.8416224806729017, -0.7934878008199272, -0.797213688360093, 0.41488282548808014, 0.5104256144285712},
    {-0.057391151457345586, -0.0313930259737114, -0.49560747202665384, 0.9690718777159997, -0.7088568245985253, 0.10878509344522452, -1.3023929469288855, -1.056428029221805, 0.43167765356086096, -0.4404179139998771, -1.2537610881364647, -0.5922969459715577, 0.5991445028470691, 1.0603908338308885, -0.5249431860714742, 1.070300612946366, 0.6192370991882616, -0.6656084607425665, 0.6436526674453127, -0.44497428962953345, 0.7210214185165118, -1.1907132660419841, -0.8765793997925916, -0.9364319269978246, -0.4635881876122102, 0.13351309324371533, -0.6611363487686543, 0.15139391688450884, 0.5149855280280421, 1.0720340013994785, 0.6738622687117742, -0.3600135066819657, -0.9975544657552745, -0.1566972187635581, -1.3097713284850485, 0.42141111584461916, 0.2529427092366768, -0.4159232743866844, -0.3978005235251518, -0.39419802538814447, -0.8218079224309506, 0.47727739721425483, -0.012799294864152919, -0.7087760551871185, 0.2772490278566566, -0.962176946143799, 0.2561212634332072, 0.21158815442929996, 1.0643598835333823, 0.8078160408855569, 0.7088043160614035, -0.0955422437149747, -0.1524390228904976, -0.22430580861656318, -0.37744839087289195, -1.235209982995764, -0.4480872604384129, -1.2935777461221203, -0.4426467598696549, -0.8035056917802625, 0.42919012780288923, 0.841799374269747, -0.8751562595700609, 0.24833429657515027},
    {0.4304265033057007, 0.1567257968747762, -0.045941328222692666, 0.43774522366743085, -0.8048372583227471, -0.47905273404215987, 1.0204467415936822, -0.9813331149453746, 1.1514976012314921, -0.5363194899187821, -0.5912505496888386, -0.20815122106173364, -1.105747827270407, -0.3132071154558982, -0.634116567194976, 0.6309146346017085, 0.8603603923553038, -0.9833920987607695, -0.8408229114017695, 0.8049783324844183, -0.6526817429466542, 0.6591975144187383, 0.23927828577460372, 0.41659067780282366, -0.00672676986506748, -0.5651431336335818, 0.9397559035838734, -0.05920144166357076, -0.7728539944072436, 0.6669342345054048, 1.2138196471085996, 0.02106756398999489, 0.7359267901019084, 0.8473431101194512, -1.3398354996731645, -0.30721496417922045, -1.0878218068278391, 0.4776854335548783, -0.5505860953153019, -0.35697266040678144, -1.2014765412838198, -0.1003308672387467, 0.5934661923321811, -0.8056328008598731, -0.556360854154501, -0.16807816811183013, -0.02713571963108877, -0.7357228682810354, 0.25483096555913826, -1.0154122878323903, -0.044680080051659465, 0.6426075028546082, -0.12889382750603376, -0.1486166500597614, 1.0026569607375067, -0.7659579713082029, 0.6985668426155096, 0.021752885333803793, -0.46981735004054653, -1.4250947676379597, 0.5248353913436111, -0.8779108307035361, 0.367694998146139, -1.1922005604454244},
    {-0.7534310259159565, 1.12729245065248, 0.7891378618340855, -0.5463456383899695, 0.2920175436487033, -0.19760316177971368, 0.033168349039484485, 0.8558119613413683, -0.18832027847599797, -0.1718678651341961, 0.10723591457914454, -0.6565658964635761, -0.8169789455757542, 0.7794221436177128, 1.066769060920832, 0.08059680653834964, 1.2576602768509262, -0.22497864962697414, 0.5659798665876627, 0.5318414315170479, -0.33716008761243954, -1.1887361214394512, -0.8148570594443793, 0.7618652033275669, 0.3483675519706989, 0.733091539786484, -0.7936233746446819, -0.8938715504806103, -0.6356004952740347, 0.47908188857286865, 1.0538520850588144, -0.316513728672856, 0.11337966293068578, 1.0253663818283345, 0.04714832289293508, -0.338659252637694, -0.40437134649192075, -0.6772585282241346, 0.9277605677369312, 0.7064678024220011, -0.10241941979831799, -1.0238504095868128, -1.0029101592821639, 0.8993112046241543, 0.7036218915919508, 0.09624631385581252, -0.625205271176901, 0.12533243161515167, -0.6850588229377096, -0.7286568403767905, -1.0144117218478486, 0.031392070301458415, 0.18179041515409472, 0.5264573645192714, -0.3012187726427807, 0.8498135285709576, -0.10934641352282615, 0.4090677780482198, 0.174314670960335, -0.5501340005029245, -0.6751933282302868, 0.9239493922588964, 0.455280860960454, -0.14251571122191975},
    {0.3212835928086085, 0.1799797209229509, -0.6373030769797301, -0.1638397378060212, -0.7134101601231584, -0.9281377382020769, -0.12307201225517142, 0.8512501905781676, -0.869331580831418, -1.0703412491887578, 0.5622819671979299, 1.255155942380174, -0.5632163477123259, -0.6891830945451471, -0.12648647237007984, -0.8893250992725872, -0.772420323745625, 0.7264646546209739, 0.9360132440966311, 0.7142397702058011, -1.155588370909943, 0.07225323013964595, 0.6127827175335994, 0.34877619686100086, 0.24460262809568575, -0.5598947410330181, 0.3656542810825852, -0.82917017822781, 0.302828481392618, 1.246396924307673, -0.2975128119559259, 0.6116817223063398, -0.36316144846532333, 0.7191364228621724, 0.624083431667936, -0.6269756868277688, 0.6642763327937291, 1.0781127926056684, 0.29325957488357685, 0.6527425022832752, -0.8790475685285102, -0.9082228049524615, 1.0137177440244634, -1.225217141605602, 0.5196953811225532, 1.13562362857207, -0.5036974372081415, 1.0462105346778636, -1.0752709033099326, -1.0578247032890125, -0.5462055177977176, -0.7685115045681477, -0.834060331646864, 1.2146375983800999, -0.0013552425791755428, -0.8518757845534098, -0.08946902857177502, 0.41044314596037484, 0.9091189024079439, -0.6564013243842011, 0.6353140875602281, 0.7392866692580553, 0.26242957126190314, -0.30724682578190093},
    {-1.0236051992773068, 0.7409974484754698, -0.6141164815948339, 0.7558612965403096, 0.4929594307678262, 0.8000729463036127, 1.0307884095055668, 0.7380308502354428, 0.2244259905859395, 0.5859885234886104, -0.5368907236031805, -0.5255968599757542, 0.7202534425343198, 0.5388724594211841, -0.2303582980608226, 0.428344005292448, -0.9016742068349733, 0.5254005749360913, -1.0370686066565589, 0.2859925394544794, -0.9232285250125183, -0.4428714197461338, -0.8796500779888253, -0.8259858118742379, -0.6606244465855212, -1.0350731800208652, 0.20531547984078513, -0.7821053788105946, -0.0014841014186559468, 0.6193944792585926, 0.6633772791496885, -0.9285779092479409, -0.0006811830798940165, -0.14512497741566316, 0.2652116118233944, -0.16714625958544904, 1.1070532253541738, 0.9511218195075751, -0.8102352530715607, 0.6001632307414067, -0.3140583529477004, -0.4123938600987712, 0.36870866047926243, 0.2649262057521843, 1.1409644287172973, 0.62282734608634, -0.21484821399242665, -0.8158901592762487, -0.5852486293206772, 0.057815006980219075, 0.9212488284692909, -0.681840173520268, -0.8299766138564085, -0.921754379672459, 0.7355458176862706, -0.35286965869122316, -1.1891238794417642, -0.839349157844246, 1.0780735133741526, -0.3683081434090957, -0.0023801677249304107, -0.15861482590179388, 1.0087452217556594, 0.05091762650845741},
    {-0.14460545533309757, 0.3981549534045022, 0.28434524802791905, 0.1657391863144195, 0.20030248742690043, -0.8047081572805191, -0.25172099592089664, -0.18848765602883918, 0.44755006932341224, 0.6877386988851989, -1.2363226566240144, 0.5822218941229433, -0.9841781880084673, -0.3070192740847208, 0.41486286273552975, -0.4130403852187568, -0.3348642787288448, 0.625102766927185, -0.092701351721653, 0.26351505668163056, -0.8008043302962123, -0.8590437148315486, -0.87983007454149, 0.1277392578590259, 0.032419878181661886, 1.063504834491716, 0.26068004974340914, -0.8174505306825638, 0.9067446838430472, 0.8201590525550113, -0.01372355576520706, 0.4811293369900309, 0.5133452384640353, -0.13410058349316822, -0.6618631576431823, 0.9862001147148018, -0.22914123091816882, 0.4278592653608961, -0.8794039874979391, 0.36169390577689825, 0.35259923256280196, -1.1133368283549776, -0.6826297062740224, 1.0547587358848893, -1.1110418467603547, -0.975837722716917, 0.20616508340194004, 0.8397342784735685, -0.4022624390744809, -0.7564912349545551, 0.3133517697234493, 0.2990652370286882, -1.3437013869066199, -0.5906456784456493, -0.0167015781163225, 0.3720230169287429, 0.36840559128562395, 0.350883973162336, -0.8712391038127485, -0.40476780904718535, -0.9003012352758802, 0.011988074639998344, -0.1327953012637202, -0.23363080925667984},
    {1.1587080476307672, -1.0493534568052314, -0.8744844097437628, -0.0841674043332729, 0.8529981959077224, -0.2604356217552346, 0.11947466907564155, 0.5217814922984176, -0.6864672281767795, -0.16553859605979196, -0.32235063085272536, -0.48342171921104493, -1.0805618823725835, -0.9689618022043359, -0.19105999836087328, -0.39002460071677086, -0.7858053535277726, 0.19149108916210386, 1.0709060307878902, -0.17885266136550168, 0.0398704889322095, 0.8677964528326599, 0.5020709888386755, 0.9876020528396333, -0.48763701700672835, 0.07137117622623494, -0.616837923744943, 0.7547041975154599, 0.9542399263443271, 0.6737297622065679, 0.764496158895819, -0.6393090388245495, 0.7496733879307523, -0.7721842270714686, -1.09695290544596, 0.6236067945887935, -1.1384579986945838, 0.8754826158607005, 0.08480080029467818, -0.32074968810565846, 0.17659230004558335, 1.1663050570870601, -0.014572180923501247, -1.0944420189222233, -0.8739164464842794, -1.1101515592219668, 0.6007871969504053, -0.8718345688122092, 0.44287402462136854, 0.10551489943274406, 0.8831922643498901, 0.02109046728497768, -0.6168065241681456, -0.4250760345258884, 0.7817783439172848, 0.4339848614605863, 0.3369059207998994, -1.1086503466214714, 0.7319210978603724, 0.5244029936010217, 0.6885269244693363, 0.16006622725235042, 0.2782560063926714, -1.2783900931745102},
    {-0.1209392409938401, -0.6148587468379685, 0.5354048076165295, -0.09713092431625943, -0.2879612383306623, -0.6293584264333961, 0.7405805166301505, -0.22135221642339503, -0.5299623546405376, -0.29849188588835884, -0.04812664912726201, -0.9256394328841254, 0.10841353675324762, 1.0971552824044761, -0.820249416394812, -0.3078499466425241, -0.957723641352428, 0.02835873856476974, 0.6498423410471649, 0.22410703422787664, 1.1478070707576966, 0.31200224497837464, -0.06065834964232751, 0.4241269757561372, -0.5660501066564446, -0.8048344807964832, 0.7933262528025349, 0.4451810665549082, 0.7128545581518676, -0.061777245510088015, -0.7914454746760027, -1.179777121178127, 1.0957920413833402, -0.3105777778115832, -0.605144700493355, 1.0304232602151886, -0.686973839682634, 0.5981852133512239, 1.2287529807863202, 0.13950704490924293, 0.4919369976197747, 0.12995499138916947, -0.7749331873917636, 0.33493838429745354, 1.3036222044219048, -0.24959461074981154, -0.32388406905340483, -0.3382071945477101, -0.8557467396409119, -0.8805674149675253, 0.49315226554621655, 0.8569564300338663, 0.01917996619855234, 0.7767867532410847, 0.8474283781402585, 0.6937802654743489, 0.9592308600965936, 0.8211239235722236, 1.0550875134053082, -0.9619731790961253, -0.18411786954628306, -0.6825870628501488, -0.834866492183958, -0.8367328328646254},
    {0.4180154489019989, 0.12579754406783905, -0.10412677328560863, 0.806993865717503, 0.04660405968428449, -0.7358602925588983, 0.7660391958176388, 0.23107804756074687, -0.5536516792843701, 0.8745659312776958, -0.19472200370283044, -0.7493905514195426, -0.18554644909834705, -0.8419838426146101, -0.2458966673454206, -0.2587492389216676, -0.3855180013554418, 0.8025150548167278, 0.8214973509734118, -1.127111919877339, 0.066714265671793, 0.43495391223799185, 0.18231733080938725, -0.7335775101157777, 0.3199880306976183, 0.33315417380953566, -1.03667158535289, 0.7897843163031354, 0.9167962339877527, -0.3063611852743287, -0.20915326818465868, -1.122939803057888, -0.6349323702982261, -0.22612403869359965, 0.5222364089624738, 1.0338265009968055, 0.5842876186964926, -0.3205851261405666, -1.0269689609256416, -0.8742304900580883, -0.004534285336920878, -0.4774560419020574, 1.0196463441973964, 0.6010859528171743, -0.6723781157495089, 0.5549394551873337, 0.6676405352068898, -1.1958195257519146, -0.42069123247505474, -0.061210776628923755, 0.5777749912212293, 0.29495264550265143, -1.1676036627769526, -1.048267758845755, 0.27869314192435707, 0.8310996705699716, -0.6166785120922381, -1.205228680212017, -1.284450912811315, -0.3672635562265578, -1.0383522037348765, 0.20783697871444576, 0.35073602048786673, 0.9489928403260716},
    {-0.5483424866939347, 1.0360142753778419, -0.4142718502714626, 0.7220989518656571, 1.066677117103997, -1.2404739051339935, -0.9779497317609399, -0.17665170818544326, 0.45138424013150036, -0.21108191547724842, -0.5066503830419783, 0.300269407055484, -1.179427539762607, 0.32482698328994875, 0.29111888358565546, 0.9258494842058561, -1.3167831639027074, 1.0356009456440094, 0.27499398840450934, -0.38931756095914133, 0.11648751166420715, -0.24868833772338547, 0.5596425956336354, 0.5348550526317453, -0.9274557382510767, 0.38308356320235043, 0.05205759571827849, -0.17654724893652357, -1.1713264597140172, -0.2297243493745099, 0.039157405830746686, -0.04950725022437258, 0.1425815856284654, 0.9502319313199161, -0.8953158280267709, 0.042374922558706875, -1.262454638090495, 0.9929578917590508, 0.12306178241388704, -0.19978954270461166, 0.276210143895691, 0.44588467165531326, -0.6767374650336696, 0.9549048523119634, -1.2121761634627242, -0.5897604542703512, -0.25069390824338184, 0.5172867345327399, 0.8524330614671449, 0.1618055958952672, -0.8568487558811773, 0.02885855442730204, -1.303037354871481, -0.9667066563576533, 0.19106272621417864, 0.059667899303047264, 0.5249681211425232, -0.09562579047924151, 0.45669728101672, 0.046152274969435254, -0.42471572483183884, -0.7548487173761863, -0.41954020879589865, 0.2543909750054706},
    {-1.068423901027768, 0.15368474437740093, 0.3383769841459157, -0.4873813809949622, -0.6031307566116412, -0.9121939186845498, -0.16786975723793138, 0.7559577278726138, 0.21741345452285477, -0.045061166393495125, 0.20659947320127364, 0.8951106724025854, 1.0627163885087925, -1.0465023026477362, -0.6295292344197712, 1.1143093604562397, 0.21537806059908726, -0.9604217606660641, 0.12221536187843579, -0.4931291288911755, 1.1338453630968706, 1.1479823277210293, -1.132696542595058, 0.8022126511040064, 0.58592468329988, 0.22552291413861364, 0.943566746825775, -0.6252253127555223, -0.6744470270232741, -0.018952940074281877, -0.050861511028654105, 1.1219347334372296, 0.1519774612882264, -1.0045893864929405, 0.8509139920493949, -0.6708740219061375, -0.09597681810207809, -0.9544737652388282, -0.027027456661227665, 0.34340109012816916, -0.9518520338505126, 0.3500390045338992, -0.6541055782592752, -0.980144069951971, 1.2251383712683832, -0.6747690350686558, 0.6005371599166682, -0.5089694442659642, -0.5463247192996303, 0.6781360116052173, -0.8016064785044028, -0.5778063941618145, -0.49246959467896073, 1.2145766476530555, -0.07670639533504899, 0.22669734021623486, -0.39130495197495285, 0.25789283481954745, -1.2414062077920953, -0.6916265076196453, -0.8843707427374803, -1.1804106606979339, 0.7271755288172003, -0.40031518243274666},
    {0.7678822689466906, 0.8948513242241819, 0.364411889578756, -0.47757130756708405, 0.4392339058619088, 0.9711136232619796, 0.7198199395393389, 0.50561988717775, 0.6184122111277366, -0.6545534909521795, 0.7364913830525228, 1.0198646510672726, 1.1860796906923203, 0.44383246724240627, -0.5723599554563064, -0.17300186058234313, 0.11495224789179793, -0.6298048824123074, -0.8598847823395345, 0.7783997413909782, 1.0314205766148963, 0.1562097910351947, 0.11863043545177566, -0.12538431690197585, -0.20135953877459692, -1.1109607880553998, 1.219824979791183, 0.6566895097678784, -0.2610750011435879, 0.3979400555230994, 0.5027269717178738, -0.9382030233245942, -0.4084104963461189, -0.7043227494570254, 0.9089368185961024, 0.6733112205525804, -0.1261393835576431, -0.025511682119401836, -1.0971478700817627, 0.373120915611172, -0.25154977857865857, -1.1555297262665547, 0.6383835520340946, 0.06779116941425906, -0.4446210735911373, 0.25798044061944686, -0.6117489956127011, 0.006660184232926318, -0.464245400019987, 1.1142930033727012, -0.4493003996238594, -0.7702143144989394, -0.2718734778434224, 0.886477291745481, 0.58286201744812, 0.46817265579820555, 0.876797722205757, -0.9965800617244823, -0.14469913338948492, -0.18954190258389708, 0.025322145861184194, 0.12070830267083311, 0.5523724531487606, -0.17626237575262982},
    {0.9117416386521316, -0.31696662533255426, 0.9968479314609887, -0.6031264356448705, -0.5523336873868571, -1.097967957686432, 0.7669276223582474, 0.33863885344304423, 0.8314576768286379, -0.5726040498679906, -0.5572666010023779, -0.7271461679963422, -1.1423335565451787, -0.05052950765799705, -1.1593647455796923, -0.02004053869641539, 0.07179987978240299, 0.795061141175094, 0.08260016030642203, -0.6224482368260791, -0.4016811003770173, -0.7890526112553788, 0.5100812014014218, 0.014466908910914365, 0.4521043604659596, 0.6253877336334751, -0.8973308048273781, 0.00988544177150486, -0.6687513463947752, -1.0323753348729339, -0.11546074151485455, -0.08097534167769552, -0.5037157120403352, -0.7080282587676429, -0.7012734634602137, -1.1754159885110864, 0.544207167795754, -0.786612593718157, 0.6805373637582195, -0.18575871888298653, 0.13548191490667302, 1.0909447038349391, 0.20568661088222534, -0.49638202964580197, -0.1861517997326716, 1.1229672508298663, -0.9091969853004261, 0.17429815899358467, 0.6849622866310328, -0.546742089816573, 0.3125924654711384, -1.0950675541922799, -0.706595391358392, -0.6641417103872028, -0.8146411306866829, -0.4463784719207733, 0.22793562495750147, 0.2647718095949012, -1.1544445433648296, 0.12777938918115753, 0.8870454377769523, 0.2522689671261526, 0.12843599844737524, -0.42528188837059},
    {0.9647348322396756, -0.47767387466931355, 0.16214296569705178, 0.5823880992782436, 0.25216485418150475, -0.20296020868834888, -0.2192129970950479, 0.17030431633623205, -0.0671229405021847, 0.18688725800902428, 0.7920531247529781, 0.7375473876405266, -1.0060756772688386, 0.4412853162093292, 0.8335121383298336, -0.2684759763216694, 0.3520072112850174, -0.40328918937844294, -1.097901613999882, -0.7768671500814326, -0.5311007728342145, 0.6514371908622456, 1.1027613516530712, -0.14362411826490878, 0.11742297616950807, -1.2184482902390203, 0.15077522684118, -0.7548310226806018, -0.27406387358303264, 0.5295745885214044, -0.13882462049948296, 0.2079624158974214, 0.72054706530376, 0.7209376721215341, -1.322133463476563, 0.9271595540940547, 0.8703799489561979, -0.9064671715277446, -0.9747890558555584, 1.0538871227490751, -0.36251164430666566, 0.3123920642759324, -0.6774868427105883, -1.0515673137869355, -0.24484876292042038, 0.939332512041511, 0.41816056038706956, 1.114055923693998, -0.3817416454099831, 0.2983014418257664, -0.9096728579987919, -0.8598090910574202, 0.47577320329495554, -0.5746757778984438, -0.36134352236811407, -1.01801245613009, 0.03189726626869963, -0.04347459912966075, 0.22362179779568264, -1.3170371692909553, 0.4760072285165871, 0.20834431515115673, -0.41731113448524304, -0.3260695252841017},
    {-0.11426797786380465, -0.4640468924477211, 0.48792821323938407, 0.2240137180963438, 1.1092821455574955, 0.9737138901170501, 1.0453616064001612, 0.04607050246420533, 0.8611650176730006, 0.4877630304146693, -0.5860701252853435, 0.8701966152099175, 1.133204451844523, -0.9674939395331696, 0.05412836415738687, -0.9313433316806617, -0.07837541243552293, 0.1320166701476547, -0.5814216922506626, 0.028139543474845655, -0.9211107544951339, 0.671144850648038, -0.6518576974840985, 0.5347433429007963, -0.4970264422769475, -0.17120884546420972, -0.5244338049368932, 1.1811423143611224, -0.3694287369613103, -0.034587838223679127, -0.029891737946509025, -0.222301023421386, -1.2350621823568637, 0.26197081987222, -0.8333938988156638, 0.23787957882595268, -1.0512542900972028, 0.8860599826301193, 0.8470628088565487, 0.9092833609455576, 0.8597532618511304, 0.5012844984492942, -0.6713023101978572, 0.12289212409366324, 0.654050727700544, 0.8980225735646254, -0.512257928627907, -1.1880388129279145, -0.06198605357359143, 1.01599688394786, -0.08030003969542984, -0.33004423643688835, -0.4707436293690438, -0.6681562845903034, 0.9422276266589221, 0.6116904519220666, 0.08768990401075843, -0.5102873745360926, 0.20669560324733402, -0.8578221049994402, 0.2304221246436817, -0.20214920223736993, -0.24677834970185475, 0.45532005871317893},
    {-0.8963921434076031, -0.3247409587331789, 1.058191073246164, 1.194406597311909, -0.8450469708028554, -0.10372647758049866, 0.7755272775870901, 0.5990082136542617, -0.5566986839486753, 1.014802345563763, -0.6902353301432551, -0.7156012084735739, 0.026294467016091304, -0.7322429126446639, -0.081068998408995, 0.03111720119838942, -0.5820187958006353, -0.1482547716032113, 1.0356135556808224, -1.1007228307584747, -0.5415027908827095, -0.6129128396066662, -0.5983794577903792, 0.6408359476829905, -0.38150279835341444, -0.009036706189462614, -0.4008740517878206, 0.22154175603268547, -0.020008677538546998, -0.596171772739687, 0.8175603981308469, -1.1027273488218352, 0.3659815244564459, -0.44074293170663825, 0.18983025351837107, 0.9446894732199531, -0.428083709557317, -0.47912396868902535, -0.34765696871651963, -0.5632325969761376, 1.0344725515535993, 0.8048513730970525, 0.1293088597110864, 1.05970751826573, 0.5763481064743499, 0.8557354926987434, -0.7260759100860548, 0.2631563598674943, -0.1531280638153428, 0.8484170503051389, 0.439794725169383, 0.1080438353974811, 0.17956913744235825, 1.0497364265055393, -0.22280129382126523, 0.27737488034323493, -0.32050159541670287, -0.049563480653346294, -0.7004565471328823, -0.744807330122049, 0.8270996718361147, -0.2040576323714446, 0.929974166068612, 1.192792513567239},
    {0.19310940254966974, 0.8496248978250116, 0.7077104580416895, -0.48419736020291754, -0.8139935490947987, 1.0346514180641697, 0.5155901748524676, -0.2694356307334897, -0.8467573757525094, 0.2625522826788492, 0.5413598698706893, 0.48832598397153526, 0.7488811601724317, 0.6406004109146244, -1.0642174654798124, 0.5840725769911855, -0.9367449815825151, -0.2091671124843973, 0.20869707635300583, -0.5640039714812712, 0.6961007087128415, -0.7932517763049025, -0.6167599322453627, -0.6826031415782715, 0.09397015715258836, -0.07788848034764492, -0.0844838909407254, -0.16812159541535637, -0.43979178816104736, 0.5597576067195986, 0.31901642332026087, -1.1391181871826683, 0.4152172780926952, -1.2387028745024689, -0.9085723527367268, -0.48018004994278507, -0.19218831282094076, -0.5419807297559976, -0.15336136834317945, -0.06830177064624748, 0.3521442110330409, 0.1578761987261509, 0.4973171832336708, 0.0586978624057426, -0.7601517219334846, 0.6470560752798318, -1.1936652120027542, 0.3914993886943868, -0.3623398555418841, -1.322314863759354, -0.6246697624702455, -0.8094003613887882, 1.1016681891384597, -0.8289403806673494, 0.47305411343532006, -0.10088060296881007, -0.5172645965521209, 1.1416497409957524, -0.6926295443482314, 0.5696424001145728, 0.27866146719059076, 0.03915182617843228, 0.576068164597761, -0.508410289430955},
    {1.028280793279932, -0.9194416388699065, 0.3061646500962015, 0.3182819153548036, 0.8374190250760213, 1.0087778825871052, 0.24358233245066852, -0.7672424884838469, -0.34286774964253525, 0.2918900709351593, 0.8651579125002732, 0.9419289909215011, 0.632469849135603, 0.1044685353270456, 0.8992129063115941, 1.0347948960800184, 0.2335411131912582, 1.2236422014250659, 0.8790106443985924, -0.9710048383780775, -0.8613476114079266, 0.7089281082184752, 0.06529876898575375, 0.6786544415351745, 0.46106328876407754, 0.40372505272813963, 0.08419550258251052, -0.769482508639093, -1.026671724325597, 0.9250849000559985, -0.6441733832576307, 0.0016504038901935377, 0.5190797395403113, -0.6989677590852407, -0.888585506219949, -0.7587359829537268, 0.9998034832199388, 0.10412821904997893, -0.36422476148009275, 0.6339474885540247, 0.01506970704833959, -0.8182345790546982, -0.001283268647404148, -0.9956516089399292, 1.0295884924890457, -1.1832594226401436, 0.4572731029501313, -0.8454003590193997, -0.6621778954829997, 0.9336968779359276, 0.9589084423368175, -0.5526388307509414, -1.1433862686473215, 0.11396874350754713, -0.2377598797663762, -0.27761675958219045, 0.15270810204546295, -0.335056000901509, -0.9244031335310795, 1.0048362685274448, -0.09916273206121312, -0.9483778914652503, -0.1951729773924197, 0.35739997279470925},
    {0.31779141805592237, 1.0406073237655469, -0.9970997272477137, 0.9200708166894579, 0.2658583437014685, -0.5619576606593168, -0.9393602096180143, 0.6453610380041587, 0.4244977862141623, 0.4003189893887622, -0.5128087175048484, -0.514286716530395, 0.914707652969062, 0.9980868362909328, 0.8639347930205434, -0.9515403346021905, 0.6884873764433109, 0.9905817015044829, 0.9344560626457927, -1.3435099571388265, -1.3550831282903868, 0.36728409863403116, 0.5968552084679262, -0.35295221976472346, 0.23399665522700544, 0.06670748894043356, -1.069704418938453, -0.1417800226943421, -0.7905839991138748, 1.0032828371264055, -0.3008745756390857, -0.8389448761872956, -1.2473816665175825, -0.9012906043668591, -1.0848204048878596, 0.5468178360437675, 1.0483103961540317, -0.5071959546489336, -0.10866241671301705, 0.535373306738512, -0.18434594900517598, -1.073279782762582, 0.6830112254261049, 0.5152049296682689, -1.070795917463536, 0.30240425769169893, -0.02775882368863304, 0.34827906955116833, -0.026435053814616548, -0.006804047144920721, 1.1854133713402322, -0.05623352341636351, -0.2738377376755294, 0.9386098606136489, -0.4536276429055878, -0.6333537624187895, -1.0240368325495801, 1.0085571341580846, -0.3263562919395767, -0.3103882684225421, -0.5516135604139261, -0.6628643484677136, 0.2647136499957708, 0.7169502235968765},
    {-1.0840444457430374, 0.9291277209557713, 0.6797009109764818, -0.44730185399715544, 0.24504847950047465, -0.9514063672125651, -0.6915143165657354, 0.18777568232890404, -1.0613831937908578, -0.7010047292274973, -0.3144690832958163, 0.5166595726126034, 0.25009222130481457, -0.310782452923313, 0.19821962340742766, -1.0455115049461725, 0.06341738360345626, 0.8735786539445136, 0.18446479393029105, 0.14057923378490866, -1.1456911644844998, -0.6158166616617032, 1.042593260698739, 0.32096761618851966, 0.6075488760269715, -0.8753132454006142, 0.6549242097206047, -0.45244718806696255, 0.3141687053066723, -0.5033768004488223, 0.8419183760912781, 0.12400776884004548, -1.1240448186650749, 0.6383869394101065, 1.0010962897873348, 0.9434059454843056, -0.5069209972908035, 0.1485559266328664, 0.8916493451549675, -0.0863996676071951, -0.9684029166069807, 0.5699331760417602, 1.0045220928632281, -0.9223218188322244, -0.3237035632675108, -0.32512248218176265, 0.7850364671161475, 0.7671323541531966, 0.47833541946183794, 0.24985548863263943, -0.3591850935438665, -0.6397036127999518, -0.41147336869138673, 0.9352196499436014, 1.0962483754330632, 0.6045904367122906, -0.40317456407086677, 0.5610659700710813, -0.46514021576909903, -0.1314373006211475, 0.6438181366240945, -0.4572343125768307, 0.5275773287476129, 0.6505622742043736},
    {-0.7195598556601264, 0.9799618881061131, -0.526401877689216, -0.9544818796324593, -1.1326684351704372, -0.5936478328444231, -0.4789196285987876, 0.4319878679613313, -0.0233523373251316, -1.131935114963584, -0.030339952368364384, -1.2129308778422998, 0.6200650262034009, 0.8318274571490332, 0.9668415964050221, 0.22869390565387185, 0.6964702421649134, -0.7375508950572334, 0.49423371958528134, 1.0632769815123941, -0.39186514182006366, -0.4057106718469004, 0.891656620577796, -0.7311105774357791, -0.42420622328033186, 0.22901049442261132, -0.13102696700250355, -0.105671100287076, -0.009447204652074834, -0.3469970419525157, 0.4085124964143193, -0.6001249432408772, 0.19438359398275018, 0.5643762087781294, -0.04297781606202066, -0.5335712569241408, -0.2998862784198964, 0.011613297537667192, -1.141795321051983, 0.3897093197170203, 0.3422650435806749, 0.8572444752177454, -0.9772667820700167, -0.6628015520113925, -0.7346753358625498, 0.26632159507694725, -0.512466041577797, 0.35702409601662216, 0.32959717621639784, -0.04700060528354667, -1.022004196212049, 0.17863466880011133, -0.12940284770638197, 0.7869661426425125, 0.909126390739872, -0.8794999456877043, -1.0152846490150575, 0.953502589391007, 0.5613321590548175, 0.0388374206852774, -0.5885394259710103, 0.9631336717608047, 1.223150631600984, 1.0411046734440004},
    {-0.17816945932216346, -0.6958366251495219, 0.6448198666563083, 0.08230838812465242, -0.40370330119043124, 0.06850197029924955, -0.02227767090250159, 0.4868019718632593, 0.2780579466357488, -0.587997534685517, 0.5069153201252733, -0.82864068462472, 0.8554704646918699, -0.31919367029075196, -0.31450379814785173, 0.08816733665508664, -0.8769706300427241, 0.1235835940339145, 1.0988725277400415, 0.08834225598071722, -0.0030288918916434233, 0.6888676166001519, -1.1686190672829186, 0.8512517228034261, -0.936437222251872, -0.7944917208711757, -0.4596223759611124, -0.6562000207662073, 1.0789178565126667, -0.5681405627195809, 0.42462406853062185, -0.6383171552070055, 0.9806470949695596, -0.23384772490573116, 0.04538647361387704, -0.5768853558368596, 0.30031496505698163, -0.09448252151676059, -0.9860231486266342, -1.0247478651234345, -0.527499583018835, -0.05256447823627521, -0.8775641933731924, 0.7654734927198963, -0.008967139435583487, 0.6844309022984721, -0.38910941316383196, 0.48634370093908824, -0.46327574834589297, -0.963938324078239, -0.8073817417006375, 1.2298550388157539, 0.8494052708717937, 0.3863372029820621, 0.7451857956307162, 0.16273377875159634, -0.19018640512771212, 0.12237225784835887, -0.2720099511286797, -0.7773376895003016, 1.1139950265439063, 0.5771749281391781, 0.12367661023988301, -0.7057992142471824},
    {-1.0431976985592424, 0.3590903229714605, -1.0910502238768098, -0.7274789705138339, 0.5313721898477746, -0.9136970998131378, 0.6525376479478102, -0.09265697220124744, -0.13382944712505085, 0.2686935427913294, -0.33130187779443343, 0.3453876849198281, 0.1694850390074888, -0.40697971445014003, 1.0589839159292904, 0.7585372559052672, -0.4845618284958428, -0.11795679095717813, 0.6945733123279266, 0.4143895341010066, 1.1197015359237708, -0.5094366319508524, 1.2037495115644263, -0.10470572143957617, 0.478685784810673, 0.9520979477143907, 0.6693017474804892, -0.9885437408168255, -0.9979060634218403, 0.49709395934931855, 1.0460934132971755, 0.9180352550506304, -0.32897487854415486, -0.4394971261027466, 0.32975644110811664, 0.33219191106198875, 0.2036771028679144, 0.3080477766684784, -0.20618072795764297, 0.13541838050935806, -0.32876609602683643, -0.9417900031713432, -1.1282745228194315, -0.9166478952078747, 0.08878538661445495, 1.0383950105046669, 0.07603119363590426, -0.8061628338336448, -1.0619699576549504, 0.5471083876845941, 0.5949866395735262, -0.13749539448602, -1.2091442476165666, -0.3297785785209713, -0.312515795128855, 0.45275848621111947, -0.48469759464703804, 0.8954706190732417, -0.38788399333337203, 0.4904830040947657, 0.9869074111118067, 0.893597049252965, -0.24239592754231828, -1.0783833274705397}
};

static const float b1[64] = {1.1924747442918706, 1.0171049219169004, 0.5741297693415904, 0.6111155928511294, 1.2279077400941554, 1.2972221808889717, 1.1457184499457997, 0.9663417388833823, 0.9039068065628579, 0.7581796735374502, 1.0249556577554126, 1.0714321717030442, 1.1291445807535687, 0.7515895635618651, 1.0734625972070815, 1.2137129757906704, 1.1601506469083271, 1.064517372529136, 0.8341210286980881, 1.1277534996824428, 1.2447329012349582, 0.6616919355788033, 1.2929842069532618, 0.40864332820576166, 0.03005251515347408, 1.2231648823813568, 1.2139413344830736, 1.2464689301786454, 1.1905987692717057, 1.1318227773778042, 0.7276479790171623, 1.143482345475146, 1.237432323649325, 1.0290461987788402, 1.1193668402326367, 0.889186183365896, 1.2407289472056007, 1.1783464077913455, 1.254743458486872, 1.1595919079335408, 1.2141116351956012, 0.8943849093876862, 1.082497951236936, 0.9834158179081394, 1.2469628768092447, 1.31022706176228, 1.100556704663926, 0.996653880805384, 0.870705911402323, 1.0405802880428012, 0.6069506900352843, 1.1048906951393098, 1.1960157850437179, 1.259095378827611, 1.274279843054066, 1.1633745771774884, 1.0340457424146439, 1.1146169713296468, 1.1082687775128912, 1.146169493518738, 1.15749316185501, 0.8989623534613409, 1.061909324996368, 0.9562809559613968};

static const float w2[64][32] = {
    {1.3393562046547152, 0.9934359121793098, 1.3851286162094236, -0.27637492078964915, -1.0526485634241158, 0.8839559678153013, 1.3812047376374668, 1.191920936004581, 1.8912305687700315, 0.75268373190775, -0.22481872489709062, 1.7497608721993925, 0.14597276155010938, 0.2505087949606687, 0.6631693210096792, 0.638188237818019, 0.5039673892736585, 1.0001807530641404, 0.05529094404655612, -0.4847483334582763, 1.6408709000955426, 0.38711525149846654, 1.6528683888137916, 0.8087156960826706, 0.5726906691504817, 1.5234425748111378, 0.4342674848982067, -0.2435701539890978, 0.30640856268108657, 0.06609700117010066, -0.89674852988696, -0.22998361900095046},
    {0.16520304428678095, 0.6864415797877799, 0.31311475007603, -0.6380796120567649, 0.2723022206877066, 1.294190168274193, 1.1311022982739631, 0.5925003775818285, 1.052050759941836, -0.3872429934321146, -0.3549146173536345, 1.7070560166140207, 1.3070858841308612, 0.6074479712318129, 1.4552234235354489, 0.429135322539414, 0.6473483332301749, 0.4742442703505699, 0.8506043972625033, -0.0648954944507256, 1.1747814903188751, 0.2158143598378631, 1.0603783347519373, 0.007133968619754186, 0.7024093012772162, 1.5775713497322654, 1.5540444087072443, 0.12270594577336653, 0.7391435790815883, 1.0034517232980826, 0.4866776234000799, 1.129873389178743},
    {1.0569037763825884, 0.44430784266268897, 1.5910183102189068, 1.1285592760441983, -0.739224857819364, 1.1829558417253638, 0.1147751508768876, 0.11001392902639254, 0.7463066607924573, 0.5101367157803356, -0.9962109768122737, -0.05142649412390363, 0.3355846170168927, 0.6965951280915205, 0.46383677347660046, -0.24186800806160585, -0.7877227974228833, 1.334644591495893, 0.4588088233293317, -0.39025159679680654, -0.1549872604031713, 0.4255541433049047, 0.6119829824256049, 1.296828512662856, 0.2747757460687748, 1.4891401711000674, 0.9936596053324188, 0.22718952916680274, 0.4376544075184572, 0.07376954530060445, -0.24023798736710292, 0.1489483493920279},
    {0.11708525223602263, 1.280606747227867, 0.7639771182048307, -0.47022556678846056, -0.5966877157575595, 0.8516549185729426, 0.06315292439946019, 0.445740135031423, 0.47551423341900007, 0.49720864999791187, 0.06412735242143902, 0.3897755412651878, 0.8998529720325913, 1.3526982971051973, 0.6017072503164972, 1.5745437478701434, 0.41904812914412265, 0.6311573339072123, 1.0884612207078868, -0.3254232747780642, 0.37331644121096236, 0.4371917992718527, 0.6979249492670551, 0.7573874419007164, 0.4805094311035959, 0.09752086196026272, 0.9491844938394605, 0.5537632436373336, 0.06685138121999976, 0.15041113607803058, -0.015690987241477546, 1.574813655959938},
    {1.8948263428229248, 0.40764497766077196, 1.0796333325916665, 0.42560219148273254, -0.8827731122298146, 0.5849222148897505, 0.14403964421151808, -0.2688756260104578, 1.881546819926814, 1.1775449219627643, -0.01224070815537956, 0.797790544357392, -0.4622786078590491, 0.5859221472412653, 1.4945021430099703, 0.13649139208882494, -0.28390799249403986, 1.5350390544136323, 1.4864766189774044, -0.39165139858527964, 0.9786964137689298, 0.08298604537367801, 1.5906805976553262, 0.5370143914991237, 0.7146431461960807, 0.7048551245759238, 0.06675765273777072, -0.07454428690771275, 1.1442403413406677, 0.0440312783219839, 0.3476008865193568, 1.1162918447222712},
    {1.7177777390715905, 1.0981459790967254, 1.7874685601352944, -0.31794502401409624, -0.4652691428349098, 1.2084021248468355, 0.8387314716275076, 1.3231529799919899, 0.26392385402617496, 1.218515562951658, -0.44944004394446824, 1.2349685381896285, -0.16566060754163556, 1.7969141218176647, 0.6259185410584484, 1.1426647092573305, -0.2172665249939957, 1.6467599314804573, 1.8016540496654614, 0.24703017183161452, 1.3141479531362532, -1.160178455095112, 0.9609033669813273, 0.6415986405057801, 0.9005849586777994, 1.3994638430970068, -0.01998910405976268, -0.2520284939745219, 1.2006787310935336, 1.634376108880633, -0.795804940456355, 1.094218272087563},
    {0.8302816577392919, 1.2456189586725421, 0.20988861657980035, 0.4515852016303421, -1.011306399970808, 0.9233274940801665, 1.328180080817408, 0.38411536844224375, 0.924513077756545, -0.012281809119117503, -0.2197774113383503, 0.8792342930053821, -0.1490806438696691, 1.6035907347053417, 1.7054446274065924, 0.591369075385129, -0.5458969697599777, 1.5319594018239375, 1.3324946029163909, 0.7031233714104991, 0.23816271028097646, 0.5122641274222282, 0.19866886704515918, 0.41050229574037295, 1.3155290455298108, 0.27473854871368614, -0.1845544201288294, 0.720722663029928, 1.5513168099474368, 0.4354551375456915, -0.707575741340295, 1.2115729610040629},
    {1.906817018101261, 0.1362298625133027, 0.8983561641019211, 0.9551404882796627, -0.6972198732062536, 0.635075456240217, 1.195326112226043, 0.8916032142994795, 0.2712810569393179, 0.9174138960668065, 0.18938003066434497, 0.5226693205315003, -0.38177334415739667, 1.400877692829428, -0.12935079755013962, 1.1974135570551863, -0.943773400634299, 1.5873986408249778, -0.08723886407041431, 0.6891966996482286, 0.17343218444918826, 0.025201891265950994, 0.3823804941880405, -0.014473174579092264, 0.7405251150787664, 0.6917808051679741, 0.5520743865647002, 1.4854981285661217, 0.25513964144056933, 0.6353254451732533, -0.14125436924783627, 0.869885775719935},
    {1.130014352599823, 0.9825939704500981, 1.3779960180957198, 0.7936363356943293, -0.7273453616442618, 0.6258040311872924, 0.9609576225376224, 1.3295055914175307, 0.6880990542028721, -0.03807903137896448, -0.9508966286142593, 0.27033826447730325, 0.5542915744677964, 0.3115879993178362, 1.467034964636543, 1.4991924341699383, 0.3362681788203516, 0.36850325025128655, 1.7047198792530114, 0.6346928881661607, 0.5867876898676434, 0.047832165390054665, -0.09782169724300178, 0.17323407707581964, -0.04448076592824913, -0.1480958992233961, 0.8939739354900864, 0.08624573737437342, 1.6240976037837844, 0.6691846902805464, -0.8308802285209453, 0.929240579398328},
    {1.6536990567901484, 0.3345387838503329, -0.15739666579790454, -0.5839611845053377, 0.5901341268713712, 1.5003506504668451, 1.3041921394445006, -0.5183185729400501, 1.6804985819158984, 0.10003399811096998, -0.8369045892005789, 0.08468066418597216, -0.4753514995859155, 0.27301674658652664, 1.1387618213152786, 0.13926858039354964, 0.6480214596671362, -0.08894709450538645, -0.09325426041610596, 0.944548229161024, -0.06581856667430308, -0.9929577821736192, -0.09567853301809194, 1.2650040109686849, 0.3321284845807737, -0.07218070453903438, -0.13668739688108714, 0.6997631248747913, -0.20321664514616197, 0.4351237043249896, 0.6049244476665389, 1.254258935572712},
    {0.8265548131156479, 0.3785184848008251, 0.6809635039044183, 1.2383277695754773, -0.6216291504371138, 0.5109874749932014, 0.5512117311294558, -0.5009855301648425, 0.650468887238832, -0.46480471659002953, -0.3498027441527451, 1.4347845991294617, 1.3298556238056003, 1.023206099935948, 0.47221225254138255, 1.4924706954762257, -0.8792509393174361, 0.5797805235355862, 1.738767799924655, 0.2628119945292606, 0.6133352682174371, -1.1401294108453823, 0.717009448657024, 0.957403638800471, 1.668108383052285, -0.07882599869279044, 0.07090196659974851, 1.5139065810963979, 0.30151140108974933, 0.02249350213281635, -0.08220963457751267, 1.3955408756631749},
    {1.3933974969690668, 1.2302973533358397, 1.3582040492602145, 0.479214813176049, -0.719019379866177, 0.7925847167357009, 0.08404208177506663, 1.1531391194303038, 0.0803547724038136, -0.27153332994459206, -0.27050966781802654, 1.2797243847095516, -0.6272229205076134, 0.5235447835354473, 1.6072448709925227, 0.5368754951173805, -0.30860384148494685, 1.8157120951871613, 1.3541229200546037, 0.8663988645825744, -0.2087217735404096, -1.0889191289379507, 0.9961556730710582, 1.0292038496695533, 0.522227496505113, 1.2682910882395324, 0.6896532118153258, 1.342348602922746, 1.6628097693935713, 1.923527519262512, 0.626763904398242, 0.9446133458831545},
    {0.38607339305505833, 0.8904784218713993, 0.21295933289555305, 0.5994438310512349, 0.5321905535126817, 1.0029888487201386, 1.3899882661582652, 1.0670458708878003, 1.9945434519609642, -0.2994382184695054, 0.657866126658278, 0.23776569221376007, -0.24756957658499673, 1.9636015998791456, 1.2434674765517713, 1.080965070518319, 0.01061145692177562, 0.30314459121684634, 0.1644458753269876, -0.10844518684890574, 0.3129166238886459, 0.38324860739113054, 0.057648846049022304, 0.07982110044834745, 0.6452126236362519, -0.010570554642505767, 0.2625823457156491, 1.0749554392723004, 1.3142203396909165, 1.587744184002019, 0.1652431893770287, 0.9651651895396299},
    {0.06979220942200202, 0.6298019107051259, 0.46963505867626054, 0.023624731397235282, 0.5799015442460417, 0.358375535975486, 0.708062147480763, -0.019838598001044226, 0.20411308615926588, 0.6510355042357918, -1.0523581155649835, 1.2044376284886136, 1.1244968389165593, 1.0004341315429175, 1.6325454700361695, -0.06342957640452555, 0.28959438639875273, 1.1245016218008899, 1.7130352357187701, -0.3298596336172593, 1.5393989121939977, -1.0491700372187256, 0.3750378674919218, 1.0867840241489044, 1.1516821323703579, 0.6354355090964947, 0.6267296754859528, 1.388420823638064, 0.6802794666071417, 0.3486946937187474, 0.3527102001069571, 0.3130609685062533},
    {0.8399656346423291, 1.833709815839349, 1.6832507021349565, 1.2702464908380198, -1.0098658718064302, -0.0030871706159349946, 1.564844215445788, 0.05369559035702513, 0.5934982277870745, 0.7741359524218464, -0.9003021721171396, 1.7315193039981709, 0.8535501899508492, 0.7118138294843235, 1.0706218505491327, 0.4428671646967842, -0.13327254048111897, 1.7210351597560676, 0.14559223669437865, 1.1865136965781413, 1.6163953174178947, -0.12369385748654699, 0.8997109723958402, 0.1756450799997738, 0.7351518315380335, 0.2593283943825035, 0.3408230531854132, 0.9043100998146459, 0.1726499303354938, 0.6721337392932162, -0.05825789813286125, 0.3793267031346178},
    {1.2429559020328633, 1.2828284883664525, 0.3299214858107272, -0.3414698108511613, 0.6132777882751823, 0.04004935036573219, 0.1595394160840117, 1.2920693172911002, 1.4342414505493377, -0.43981155670771704, 0.40720830685126785, 1.5460429088850702, 0.9787141055494243, 1.1068716036138802, 1.3169296600286502, 0.5416440147790441, -0.9605987047775674, 0.24635737160053503, 1.5356579862277941, -0.2611711917351733, 0.38242600490432666, 0.7242067137263257, 0.5475154447374432, 0.6951391901759052, 1.3254440614376952, -0.20131830290499558, 1.1013797464300914, -0.34392950026045527, 0.8070769317514062, 0.7238739170691776, 0.5471253820975135, 1.4712022122437085},
    {1.56914147991706, 0.7783696418208936, 0.21318528053066615, 0.31313653197662683, 0.1693285935417877, -0.11209982149508851, 1.3413680718393877, 0.6479680469748499, 1.0721127679387688, 0.06267117678626735, -0.825957072356314, 1.4412506314159104, -0.19100053703731948, 0.7169187975981509, 1.188252104953767, 0.14618133312890003, 0.1986757359424962, 1.673248888149455, 1.7439956747111929, 0.48247062613537456, 0.7185733993354865, 0.544488323710968, 0.0994641956379937, 0.926809066302664, 1.8219652242410538, 0.19654833555491744, 0.12367547150634031, 1.177164007108811, 0.5826788333140783, 0.13808782458572313, 0.021093709113095636, -0.17196045671107935},
    {0.3615567331388205, 1.767621838963639, 0.6748459912792488, 0.24463799665458932, -1.0145018860080308, 0.4947229562642752, 1.0637851707015116, 0.5718651101785921, 1.0554262279872786, 1.3414855835940174, 0.07839864444438285, 1.8749172279418862, -0.07978766368373064, 1.5765012813887296, 0.090970767896168, 0.7719892677083395, 0.1578001056335738, 0.019122819145750217, 1.7202905424177377, 0.881139670248677, 0.15782631245201523, 0.5966299687518621, 0.7955920075004251, 0.8743853951035497, 0.5155522225756295, 0.9669040400626902, 0.4762916647123491, 1.334835234150849, 0.10923289352451397, 0.756613591981883, -0.3955705081237001, -0.005627519845423241},
    {0.8216282151918436, 0.10563408545609715, -0.0767905404291317, 0.7566947987633039, 0.5459740403493115, 0.6948690532849476, 0.38703358499926105, -0.1169857526941919, 1.1451265041218575, 0.5290081765329961, 0.21986082732907639, 1.0365019110960032, 0.7836799021442029, 0.9539608225322024, 0.1644877727881942, 1.5147859684607041, -0.14995386668582664, -0.0022550875895231584, 0.9387995710661549, -0.15684592167426156, 0.9584117654549662, 0.593925699832026, 1.0641349845236705, 1.560894189652547, 0.1760414268884311, -0.1658679010735886, 0.9627685281656625, 1.244270478059705, 0.6608855302587078, 1.3396071203838444, 0.5158897401326556, 0.42140852741531787},
    {1.7097950070835763, 0.3296133319738769, 0.002461944998945244, 0.34213876665948667, -0.7249850576026207, 0.9449902843457796, -0.0957906911124044, 1.1992616668069551, 1.0237948299335393, 0.5106262437694583, -0.7367731001604498, 1.3862440877850093, -0.469390204634317, 1.0159690392161858, 1.74735920926373, 1.5501086644088908, -0.6208627739783064, 0.15294821686163454, 0.5743480921908889, 1.360297956257256, 1.5473858060486712, 0.13863072851253638, 1.676568294719027, 0.10454388131447775, 0.5918958682754619, 0.7564323912457301, 0.1338424278521029, 1.0732119989193407, 0.7484333337384295, 1.8128140837166333, 0.2869009788839874, 0.2518256089979126},
    {1.473460620773557, 0.9506846787572831, 0.01172150791593648, 0.709214934364961, 0.7074321486831179, 0.7329864859899081, 0.7440872437728118, 0.6721951289014685, 0.796763946760655, -0.03297211219640409, -0.06925188221825385, 1.0536013098837285, -0.03088215891934035, 1.2712164721835266, 0.4406251970455616, 0.7336460492923855, -0.8403643702139798, 1.0236012151973826, 0.05660381085450148, 0.39666829849616725, 1.1149433197816858, -0.47208043151158435, 1.0328614422272968, 0.9347348373057339, 0.7579713287885345, 0.5296806424348081, 0.3402944012673008, 0.30380433797093265, 1.0626562012758143, 1.9395126183464975, -0.4755266756990377, 0.16691692551237403},
    {1.6123027945497919, 0.24837487333309105, 1.1766070384923828, 0.5395568073493713, -0.3535465859868007, -0.2880312568693077, 1.212527517806357, 1.1735808918356283, 0.18915890182301112, 0.5479595686957228, 0.2135003718059431, -0.04587321468688387, 1.2582473032044663, 0.16021846611721316, 1.2501862594008313, -0.11598064906783172, -0.7424441538114014, 0.533461588266356, 0.020114481932249014, 0.18867191270300837, 0.2181642295119363, 0.40409122112586504, -0.2538803866155102, -0.297857311423398, 0.4282197239262453, 0.13552597654489215, 1.3526423365045985, -0.025741196383754713, 1.7029921784592028, 1.4360823096857132, 0.679270295201311, -0.3220254473049994},
    {1.8452865901932762, 1.2489418082665367, 0.45941306911873137, 0.34204358520971334, -0.691982621509252, 1.2467290514973066, 0.37743703961785696, 0.9505334548864941, 1.679327741761567, 0.5664441327250586, -0.686815076484801, 1.70931774280414, -0.4852187681203161, 1.4822365498692527, 1.5148164784535396, 0.40764125928865563, -0.9136100597502875, 0.187240756941266, 1.1288398771572128, 0.011507910951583997, 1.4025489654099674, -0.48986343230663504, 0.41441447831639, 0.8690155432285058, 0.03655049458131207, 0.5670503200118208, -0.035891077663989086, 0.691733764962548, 0.9073043113007271, 0.13213367273293206, -0.09181840143025902, 0.5213418303715103},
    {0.48303524657801067, 0.185256281934614, 0.7119384119518659, -0.1066033759680835, 0.4968219691880503, 1.4839580475805714, 0.867419751797697, 0.8131247489915008, 1.0410924826906947, 1.0582696806396625, -0.2973137400258144, -0.10942854293903101, -0.603364575264245, -0.12354935779458234, 0.5332888009499961, 0.9947205953932278, -0.19953657157418192, 0.11380248274727887, 1.5650408670567342, 0.8776345480647036, -0.1355033416458846, -0.42913773228264723, 0.6758385726123955, 1.2893791936039738, 0.06380098068611444, 1.0320045469366987, -0.1847742467190777, 0.24731182831463225, 1.0771600939780872, 0.2264120494254752, -0.578824946435844, 1.193164129968307},
    {0.05791276758645406, 0.2140438917047659, 0.3089329532768146, 1.2208063399223825, -0.18901557898891336, 1.4157278799764945, -0.04496486123093644, 0.7629615635269184, -0.03387535517542583, -0.056872725022584204, -0.7668602318762184, -0.06431644304666147, -0.07105765401985864, 1.3277579603617382, 0.4536613821726275, 0.669145983768079, 0.2773686334251639, 0.30736775023137003, 0.25369382809762603, 0.7765472831683048, 1.0789432871637223, -0.19231410470314944, 0.6169315801946581, 0.8712478321334188, 0.2047772469305771, 0.4394658380012748, 1.411425796900316, 1.1240808962406774, 0.46963330983232887, 0.021994917238594133, 0.025645423988821796, -0.3193848042691522},
    {1.7678805378144185, 1.47956224014003, 1.1915474930817744, 1.0974996714513536, -0.9652632487450281, -0.3104810237357867, 1.2009408105599035, 0.840887827735357, 0.9479916097491049, 0.24054512395202068, -0.12607188421405838, 1.5733109119944655, 0.3320711948159455, 1.05824392845793, 1.7272253522139036, 0.38986137965718726, -0.11075097447197625, 0.6390699012364022, 0.18496942087341275, 0.0068122842966858565, 0.44264413416829307, 0.2671962294972018, 0.32183545398824087, 0.04047100394619021, 1.8794547845564458, 1.5395076451313014, 1.2593197139895413, 0.5973366045676136, 0.444553053081832, 0.6804145580960788, -0.023362711688898943, 0.8984954819440314},
    {1.1606597427972125, 0.32829020491454386, 0.5910232989804719, 1.2758638206977053, -0.42143140402485996, 1.1027782705334734, 0.6803460062657269, 0.4382446214745578, 0.6998975465970831, 0.7254310490573831, -0.8037025934206892, 1.0180035371081275, 0.9202149258034062, 1.4234471736670784, 1.695830752083146, 0.3628558699383336, -0.1395589671448152, 1.5056690830691337, 1.5476460452502157, 0.2604282671905109, 0.6333964460717274, -0.1319500314329356, 1.5288886838225022, 0.27202585800062573, 0.6244131219094029, 1.2925208703628954, 0.2926301554605914, 1.6058567789586182, 1.6975346640842117, 1.539716225599004, -1.1466439615490494, -0.14539979547399667},
    {1.51508051956605, 1.4696055919266755, 1.5816879339239123, -0.40967778121709236, 0.1648204293457201, 0.7454731726389173, 1.1541051392557362, -0.3755405369988647, 1.1885685379573638, 1.3542994260091743, -0.8371353108064544, 0.6772294648907788, 0.32029534190288694, 1.0262343228217625, 1.4738486197703404, 0.14413716454978773, -0.19611686536853518, 1.0416976659684736, 1.4814704757270936, 0.16557853068030481, 0.016576145843712427, -0.03681897375528059, 0.5168931629474945, -0.11711474961602383, 0.24545965247890913, -0.10972737769904525, 0.5780511981099288, 0.5148837906981757, 1.5919131294205973, 0.14109963732612893, -0.14445939924722245, 1.0207976073926606},
    {1.234632916403198, 1.8054242396111333, 0.08880463136308142, 0.3516573492816409, -0.8116988441083268, -0.22017257456831893, 0.43603506348390986, -0.2366146008922336, 1.660035489286863, -0.3192690400273715, -0.24353346448019642, 0.7434026319558933, 0.3447533060368817, 0.7206486417520389, 0.7652371007903016, 1.4321255404911344, 0.6545485005234704, -0.0705692459357003, 0.21094471202082907, 0.01976807658840748, 0.14751504874375215, 0.5115016349910276, 0.5253299611529773, 0.7870069539638641, 1.7532360693941882, -0.16882043865495835, 1.0950774305196695, 0.36668402202189576, 0.04914130026539496, 1.1482098888080658, -0.15314462584608668, -0.18484664607600587},
    {0.7368324352276574, 1.2063559768715937, 0.2865493861008627, 0.5725710074200788, 0.3414145099652718, 0.5379996294825523, -0.36928890484426286, -0.06071483520472093, 1.4312600662795434, -0.19712939778938365, 0.2875124354655637, 1.1233253944639994, 1.2561012935892506, 0.003944757753676292, 1.1469426944765477, -0.1899808808201895, -0.3081433157177673, 1.6825734690580367, 0.9357464317134144, -0.12864844395306668, 1.619645233232753, 0.6835047904586391, 0.5065789387025968, 0.8319407210436514, 0.31319193204577045, -0.002077072468013801, -0.21068633541366338, -0.06522102198363776, -0.08356023935760408, 0.555900953039263, -0.30434442916434573, 1.355643925601302},
    {0.7964768717616009, 0.8007371520798356, 1.6688781618221942, 0.47684426379700473, -0.5375060188013677, 0.5623037894222722, -0.34407878395550995, 1.1966166983030266, 0.2651492788133115, 1.093838014260187, -0.035014045878052825, -0.09409324858335169, 0.3853232357581798, -0.04388292922014497, 0.7347869548195822, 1.3584204804770108, -0.2162710754157046, 1.62924171602464, 1.6029759530794294, 0.47967575509710625, 0.9647876641131647, -0.44862775706420344, 1.008724120111923, 1.307580359766862, 1.3048582670803281, 0.06404302630058632, 0.6775522487485658, 0.6257328712020069, 1.6344298476352908, 0.442642456641167, 0.004553088086377731, 0.15216689987206378},
    {1.272638816211976, 1.7799603585842723, 0.9259477751631108, 1.1029157144646726, -0.9947054346787376, -0.13684715755098376, 1.3996146691882938, 0.3042233440607131, 1.9401794918300959, 1.0926459568992468, 0.42115423273060876, 0.4303066629126944, 0.5426268591940759, -0.059868942056870836, 0.6759695639674466, 1.3390369240704683, -0.9258304082027387, 1.0742183179061255, 0.2293939068003578, 0.888239061384529, 0.25800657096561896, 0.04299597110126848, 0.12233830262908188, 0.4849343132322248, 0.6723680563603615, 0.4484913095541916, 0.4255356417768325, 0.10874500011661072, 1.1099577203822262, 0.8311042580937592, 0.5701453531871375, 0.9301540199316317},
    {1.7723894911252096, 1.734026588440276, 0.2524873943797801, 0.1261617466319755, -0.9116992186559024, 1.3452086245829054, 1.146553167650595, 1.3019873025199944, 0.42854458289136405, -0.26421141069586046, -0.5990446809456416, 1.228600287631112, 0.6377769984460708, 1.3829888405051816, 1.4746625575875068, 1.2005139298344352, 0.16073641000941122, 0.40826095094269416, 0.7477050254567754, -0.448791855214081, 1.7151658796455522, -0.1887046066943977, 1.7589046136692568, 0.6249277296657032, 1.7181630489395363, 0.5464445831286969, 0.32411045338214567, -0.028185659629747763, 0.3696056436470228, 0.09945435850281951, 0.032447425572153986, 1.1077816553074387},
    {0.2642101613063368, 1.6672705165001571, 1.050863250906765, 0.3708048060419872, -0.2849473618087513, -0.24388023094822045, -0.1860592538737595, 0.9475668999251613, 1.3728180522450368, 1.2000501696639174, -0.7691168906855129, 0.5446280222061975, 0.11720423621137194, 0.9040202756140621, 0.551833242647536, 0.8706826399461818, -0.5545986302422244, -0.019421866095033494, 0.35973997000648367, -0.09996296065380761, 0.11631321454035662, 0.722488506759472, 0.81544176335777, 0.3130379779165458, 1.647810185886694, 1.1271117756767395, 0.14061863386590823, 0.31500045282207884, 0.9812749257970852, 0.3545068503569106, -0.03902935447217746, 1.5530679868607606},
    {0.5079866675162044, 1.4865469312772712, 1.6564034807507753, 1.024856737895224, -0.3595852705039021, 0.2326823577652047, 1.4294976791973986, 0.9571381643417632, 1.3034639606031848, -0.03602250272849295, 0.8076633858380424, 1.3930665246899143, 0.617078748219213, 0.9911590824565537, 0.9148419390248538, 0.4148423921185163, 0.8705392300175238, 1.7315123238831618, 0.35943915894371997, 0.3734836270107317, -0.11811975373569508, -0.9598709342957172, 1.6135135838908667, 1.4317917379007818, 0.07583014204300076, -0.08778792839285342, 0.34661758240263146, 1.16302304568832, 0.5774561091336331, 1.7861530755102843, -0.09484959637335727, 1.2410752076795166},
    {1.0380881886647297, 1.071902876888391, -0.03761795971014975, 0.6971353357298694, -0.6512009564380759, -0.09959258131111082, 1.4783484230670478, 0.7058509059228366, 0.3181406761744385, -0.48980789346926634, -0.5178173808603428, 0.7320483433383027, 0.36095380237925934, 1.1937674806510512, -0.029753190148512826, 0.0976917705652118, -0.8294749130192778, 0.8511819747735484, 1.183282790683308, -0.3813032621680774, 0.2762156758950618, 0.4585233689926823, 0.9940671494488948, 1.1161874365388968, 0.28528500039807914, -0.32738632253114225, 1.5252737263464915, 0.03935147954718953, 1.3704193054725498, 0.8532951717656814, -1.1742017627673134, -0.16568278757832838},
    {1.5529714482237602, 0.4108720039422363, -0.17499759977006302, 0.4461513503683535, -0.2494935315300992, 0.9519932059368259, 1.1271291596967492, 0.9216469471931298, 1.9363652345701203, -0.4895695903899826, 0.5424368461239379, 0.9237809584766874, 1.0992951659312005, 1.9485236790392575, 1.0783055666605774, 0.025750978769088627, 0.7918959035134151, 0.7435141703554324, 0.46693961753396346, -0.3750673206644659, 0.42405084085211364, -0.15539914346133724, 1.0929595600484967, 0.0447124272421044, 0.8786603746088701, 0.04573409530280035, 1.4094328210507137, 0.8060446953524861, -0.11110868385567818, 1.3016745324878545, -0.16628830122608293, -0.25242845849257073},
    {0.23047145976688646, 1.302561552574878, 0.3074893418900555, 0.5826261532485, -0.6009909796190832, 1.5120432807863728, 0.20979816322819086, 0.8363260166360551, 1.5404816525031435, 0.5857542862859672, -1.0335055433065012, 1.113551345455422, -0.39737279241708184, 1.7921839423248103, 0.7046579484528651, -0.02980413675410375, -0.7022375901317307, 0.49987948262604004, 1.7708103990510609, -0.13239500798849493, 1.1449305787645188, 0.585352104994168, 0.697281594169862, 1.3070526834364156, 0.026963910625764198, 0.040878082868111766, 0.8192132931468915, 1.035848240664465, 0.3173372782364486, 1.186529069845769, -0.05229654405714867, 0.8667500784581272},
    {1.5566058975495325, 1.5680165672066773, 0.848853621616748, 0.19496046965682193, 0.6755710486786389, 0.37071245209032844, -0.09715572174587463, -0.4056146173362784, 1.0982252073910705, 0.5940672699408833, -0.42084251874226336, 0.13507091666062476, 0.5744464464930356, 1.0288994175974941, 0.5709637974088566, 0.09964064976671183, -0.43492883962933776, 0.9016282143917898, 0.7669959099426652, -0.17041102215059517, 0.791100871256318, -0.9519021577270002, 0.7174109373683554, 1.4996503707176796, 0.3708690262026789, 1.1289001525422304, 0.16774220772218354, 0.1441117369211571, 0.7366084835592117, 0.8841729096893305, 0.6205123720428636, 0.9655265850512236},
    {1.710721793392311, 1.474252200832538, 0.6629379861131971, 0.0958093445988367, -0.11502075182664347, 0.6125101774237505, 1.1668593496677004, -0.24885186520795974, 0.32817358403652647, 1.160670847102223, -0.42190168245254717, 1.6092199732055843, 0.38147723551597806, 0.4650756157485658, -0.026335407762143895, 1.3092403433778355, -0.6779145296787011, 1.0541147848327126, 0.32111688656252263, 0.5148046258138401, 0.35568670297128996, -0.96314151212155, 1.2829879432039182, 0.19177216835581534, 1.7334754933286867, -0.12348566040336151, 1.0678810189206807, -0.09584065693520516, 1.072922586309366, 1.912308405690969, 0.322382787648772, 1.013430151097077},
    {1.5902315308240316, 0.8823686102450699, 0.5513325480335969, 0.3148449066599552, -0.6906985875706396, 0.6556977992909698, 0.40556173831495074, 0.19168898461230968, 0.3905425348930733, -0.34964745684265164, 0.3714875905651909, 1.5769881394533467, 0.6761778385153628, 0.8451518546950163, 0.8998729675520307, 1.3636803648952402, 0.20145878573730747, 1.544635021455568, 1.6248612550627024, 0.6863090958384755, 1.6037607333162947, 0.4180051351726272, 0.12725654240761955, -0.39737982721354737, 1.233325271885903, -0.29303079883028943, 1.5553575230196823, 0.738984620060857, 1.5520658771301814, 1.1343906041748282, -0.8855232017413959, 0.4507968797888054},
    {1.6075011440624654, 0.7557849652422792, 0.0740701239961748, 0.2003849993761927, 0.5913743655961677, -0.35183796348714974, 0.9459902984606388, 1.1295536471167102, 0.3813338941324907, 1.1428667520814138, -0.03682693945458053, 0.6724799968352232, 1.1769822711340225, 0.3926071521786617, 0.35224075243233993, 1.0525365709311125, 0.1803745481635578, 0.7235265840040315, 1.7114884374856512, 0.3712977918764841, 0.018414101664204693, -0.9352900348654349, 0.7291015890017406, 0.3670951036985877, 1.1593028551318876, 0.28851224614263954, 0.26221930726822845, 1.171718517145946, 0.7438001517198992, 0.23058609490209897, 0.45217922050864295, -0.34722665597326857},
    {0.8953440850577449, -0.06815557800647457, -0.11057545269540328, -0.1298783349549097, 0.8050746003453328, -0.09385234514741522, 1.1430093273239073, 0.0358357191235785, 1.380023571027447, 0.45910900263288146, -0.8854430782147407, 1.6435804155965061, 1.1639564225987935, 1.1826919833423797, -0.06124399157621817, 1.360424867542095, 0.538959195167369, 0.8417395128829633, 0.6099817946739021, 0.9436935668500809, 1.1717796579623456, -0.2197692315184339, 0.8133712378415155, 1.282931492674315, 0.42885214226570656, 0.10687249243485918, 1.1488803844578788, 0.46425405456023594, 0.08380217358825376, 1.0118672512103826, -0.3025429053063803, 0.5112894680003321},
    {1.0453136274080685, 1.5292007776043235, 0.7413941181217829, 0.8753562213588884, 0.20042455899910844, 1.0142026877409633, 1.1140953147914652, -0.019110442410846546, 0.16272188895034798, 0.8633921982420847, 0.2696501686212, 1.1273133695625177, -0.42436677562972197, 0.20695135738410678, 1.4430494849129858, 0.09181928185366943, 0.16657447503857542, 0.3002234912394752, 1.2420525378733631, 0.1984325577101624, 0.5937396264488147, -0.6709881579666557, 0.9272075547962536, 1.2105223937098057, 1.6699638281147828, 1.1622781687857524, 0.41306995361403653, 0.6559816396828856, 0.6087768943376426, 1.5215355715805685, -0.21066100422255812, -0.20258201433157974},
    {1.9484834768637513, 0.5890559942092629, 0.21972300578334802, -0.43633823262159277, 0.3616239944716129, 0.17237185578695682, 0.26083963056521364, 0.10461177817800109, 0.6915727500106954, 0.010565294342647514, 0.3401933683714604, 1.647261987236989, 0.9122938627534254, 0.9340644376713197, -0.02589690404991259, 1.5803415430344163, 0.08398565699985039, 1.8650416085609445, 0.7138911469057054, 1.0392332560047122, 0.15441276022200454, -1.0030300584904117, 1.1880758279312411, -0.19422421950120625, 0.7939204441844204, 0.013421243953475534, 0.8693249033816675, 0.6989879140071872, 0.38629415421550695, 1.7873292405942802, -0.5770382519266483, -0.04660692513700825},
    {1.5341515128416052, 1.2122887988656397, 0.3045429165236978, 0.819751343215212, 0.007367214059182552, 0.06774061217683121, 0.9852166569940827, 0.27363845725782643, 1.3149860412554393, 0.7727676911271486, 0.16772301161119352, 0.6596110109674015, 0.45719436878682873, 0.5553706279059896, 0.9990927641578838, 0.2921459091449458, -0.9964181229679494, 1.2811915394905231, 0.6841234350405073, 0.7623465396751334, 0.32975525872410005, -1.0502879646211074, 0.15837288581953265, -0.04322931373829257, 1.6619856453380673, 1.477188788810061, 1.170993177472986, 0.07309046431590353, 0.6303498511251528, 1.8402361323616085, -0.6622067154677177, 1.2051052644269524},
    {1.8935869340528497, 1.0471589957772252, 0.751607557379427, -0.4721212512062254, -0.2766906383018244, 0.5891073884983021, -0.30939702598537155, 1.1226754724397552, 0.15188342631234664, 1.3837602457406681, -0.19088963185544935, 0.022792831913550998, 0.37561915818987895, 1.7752465868547525, 1.3423646315075433, 0.602190708095697, -0.15964375279654858, 0.40517773209809926, 0.3353619088726597, 0.5635796910193286, 1.5328523797799043, 0.07185688027314684, -0.04509212516470455, -0.11960379649337587, 1.8087546398069911, 0.2969263443673641, 1.3737783889372743, 1.4288866353633245, -0.18482120154693157, 0.12099704458392614, -1.0275660703615976, 0.0799704366708278},
    {0.24928785376457602, 1.0498236393803546, 1.1632615023722135, 0.7141216756449089, -0.4528774997780766, 0.07472200340920246, 0.49065712273706535, -0.3698504399456769, 0.5099130648602018, 1.0752806591742454, -0.6013233561549268, 1.8534345808036523, -0.39298144912824257, 1.2964576803538759, 1.4394529035938712, 0.16861153522118597, -0.8610957607050462, 1.8424473285237761, 1.0441726584814002, 0.8410475731843557, 0.7210580419407497, 0.7473600112990867, -0.09510858636293243, 0.49080415784306874, 1.4859531030761157, -0.026218007010362122, 0.18604929136009155, 1.3166908390062493, 0.8351436259786434, 1.7115312369485554, 0.599882698358979, 0.08218792231725018},
    {0.5368641134362666, 1.126119576146819, 0.8858386083783273, 0.1394218093001805, 0.2778050284352769, 0.10232229195961214, 0.545739745710078, 0.21642245117982875, 0.7632332937055313, 0.29792944652262804, 0.7702768581046057, 0.8593164091233357, -0.047876131791825524, 0.7877506539059614, 0.44147367203386023, 1.3911502159473752, 0.9049153101263039, 0.6271282428473024, 0.6531237286493101, 1.2407223541335597, 0.9523670745636487, 0.6976962371566177, 1.0171652611631792, 1.3824697690946925, 0.8642845858885915, 0.941746123726053, 0.9284625965887784, 0.1540256677065097, 1.3435414360769977, 0.37592728441730633, -1.0352544350764457, 0.421728367403693},
    {0.6452269744837724, 0.9544464365655277, 0.09366235757359945, 0.9087707810359539, -0.08705398111585284, 1.1175462869077086, 1.4199688508833814, 0.09484190772498446, 0.5300257615830418, 1.2314345221444158, -0.9250334061909576, 0.951072149383109, 0.3361706301166698, 1.8568340397606549, 0.15087989856993086, 0.8637972509110511, -0.8929704898955662, 1.7304858105124181, 1.2013701837864772, 0.5657072372839177, 1.5369112006806023, -1.1430727497965485, 0.9600257994640934, 1.1635977493328848, 0.8522922234361239, 0.9512760776232188, 1.1574040224232018, 0.7064917446700787, 0.0422289046652769, 0.16076477459449864, -0.15213576998661565, 0.24243441471774838},
    {0.15782970987619488, 0.9370433936039678, 0.41535794735204923, 0.22155923206074274, -0.03964097565577269, 0.2075206953658379, 1.32354489230693, -0.13476472535267736, 0.2914935370599122, 1.2182238210652836, 0.12081447338407449, 0.5201040507245549, -0.4610037887950561, 1.626912717174277, 0.465252576620823, 0.9488173458598484, -0.6874567213823614, 1.3020600913448288, 0.6007900606817572, 0.02006575557498363, 1.280441186894817, 0.1919996022077725, 0.7138097915972801, 0.115152570411979, 0.6346337027690836, 0.4489751793671524, 1.0151338719577223, 0.26455307169189696, 0.4839925265885472, 0.0035075168364861655, 0.4123155056388288, 1.3214840521050562},
    {0.7913199384552303, 1.4146470967407017, 0.5553903636997597, 0.4569731261657106, 0.3841084729791792, 0.5978529652004632, 0.8370402591679563, 0.757782818632865, 0.2442429781755687, -0.46696732047226147, -0.7627922944803622, 1.0383974397908746, 0.14525587680429933, 1.7733733941745566, -0.004433274736827509, 1.1895868354007908, -0.027438722362545735, 1.3649933835507837, 1.7169479465297766, 0.12574519464864803, 0.8801238203615459, -0.8110900982195091, 0.17075124451856674, 0.5064399294376828, 0.771956555704922, -0.20176549173367367, 1.285426996485635, 1.3658924592733892, 1.1655497002047452, 0.3491310680334327, -1.0522089462220485, 1.4532302694164705},
    {1.6904952817709524, 0.45415122731090357, 0.8815928708666024, 0.4466398292151493, -0.0004743115877588348, 1.099727710744256, 0.4518031204005969, 1.237659546839117, 1.3667797465803486, 0.9754097352720892, 0.18423667977267458, 1.854837169883292, -0.12768376654613037, 1.5874600503743526, -0.06634274345082322, -0.14372651096655145, 0.4722798406452154, 0.8010930726771692, 1.4353537876958604, 0.7155007894640152, 0.04431964201188966, -0.2201365962581246, 1.452595752294733, 0.5983449654048386, 0.07178381015720292, 1.1003639497103186, 1.183809765883828, -0.03590062739542769, -0.13030220278734633, 1.7300906472488142, 0.41516436214924257, 1.1590175319007612},
    {1.3707039933626468, 0.3727098974177071, 0.38053947362004215, 0.4827289093960573, -0.32566413428264884, -0.06028665761202822, 1.074565176520747, 0.2939577336953538, 1.1192830964158507, 0.36376362063886986, -0.44733269228720635, 1.4994688453896547, -0.21736386621604037, 1.7872305526546022, 0.056447793756857816, -0.046045760915710214, -0.5310614998745768, 0.8625405394537464, 0.7215377539743784, 0.9679223224473275, 1.1863542719286968, -0.38405123458667734, 0.35266882293450563, 0.5181103351342329, 1.1480505391542277, -0.0786868315240658, 0.431848174480394, -0.2858055359397775, 0.7767670071116981, 0.3540113990663294, -1.1930987205308459, 0.023704800912045264},
    {0.8316548406878549, 1.478183071445821, 0.12078834795813166, -0.576062351249963, 0.6493479987218377, 1.1370111834394714, 0.06121502257877597, 0.645831365306692, 1.3172544229439855, 0.991622907447516, 0.799025241346813, 1.858949083964604, -0.08859262017041113, 1.573926076887304, 1.680398080967914, -0.0024781537768732436, 0.5066847676371521, 0.5161045068371511, 0.16212931894407512, -0.059952371036841, 1.5328391481823826, -0.9304279720045325, 0.8358276080397234, 1.3294756609330733, 0.48556533175583433, 1.2676194695124698, 0.8357947162015237, 1.5872456931376415, 0.26289163981909847, 1.0988512941339852, -1.1617680056740252, 1.2391487058411492},
    {1.5067077531229334, 1.555891047626415, 0.5667259223780625, 1.177689450709794, -0.9350128517584758, 0.21341416636562474, -0.32094676094511343, 0.181673955373564, 1.4739991998762247, 0.7866292120526038, -0.8243202190227854, 1.1527111748033183, 0.3458873121964474, 1.3962213113788031, 0.8563526614152018, 1.5724497178787484, -0.03800049480717143, 1.617376308749755, 0.3169893779666607, 1.139168562067013, -0.1939607129309737, 0.3349529510550435, 0.4619084623071479, 0.9476661742634538, 0.29371909704448884, 0.9221067183964058, -0.22066102864241904, 1.2281380604284247, 0.8886393707321936, 0.31681909748757037, 0.4047232133953757, -0.1539950379065457},
    {0.4302297873747137, 0.5714578906786282, 1.519770993455203, -0.44712242979848177, 0.21157676446594276, 0.02078201905747812, 0.16066549592723198, 0.124248254869563, 0.8202115858615842, 0.8012577280668048, 0.6833019818885597, 1.626028248936493, -0.5439807563720308, 1.4573712375995218, 0.969639379225321, 1.4021704225718343, 0.12297648188121728, 0.7773672655271776, -0.12969574177022916, 1.1866287116351206, -0.1388707335809569, 0.6733376543713598, 1.5990430032340344, 0.09730908378347365, 1.1462542883546374, 0.2741603957789702, -0.09005562960741623, 0.09509869353222504, 0.7889900709489093, 1.4428890536130008, -0.02522013307164971, 1.550376763591086},
    {0.10152753115921649, 1.687929751916866, 1.5175538088800242, 0.7172399868722311, -1.0573582423596708, 0.4046969585849191, 0.7713821487232667, 0.4604294065824927, 1.197033889012019, 1.2975880836848566, 0.639695485282684, 0.506269530578184, 0.9428919494522643, 1.6192218774687346, 0.3373437134879804, -0.08729506333370322, -0.7447988349683139, 0.8924824948133555, 0.3062168592850974, 0.8177012893193047, 0.03848208121275505, -0.028862294378008503, 1.512335883147181, 1.2321233051829614, 1.742715124808967, 0.10849920801684644, 0.7820520818275395, 1.3706177966880617, 0.4473657716293926, 0.5812456526688553, -1.0236224988075093, 0.8074102280524175},
    {0.521786792744065, -0.017613349366882167, 0.5975658788703299, 1.2517384165646324, 0.8700665834321127, -0.19917283068489813, 0.8830369508487728, 0.43850469140513915, 1.7306898306150384, 1.155669795573897, -0.5014686910297286, 1.1798167604794483, 0.04608585283341716, 0.5651898502918763, 1.326687028589028, 1.134752018211804, -0.8010663575188949, 0.6432360305062429, -0.05130751013699665, -0.34349388547762766, 0.9205194296901482, -1.128193106217187, 1.6956929154527036, -0.3782335525062499, 1.6337939196333384, 0.6903989728853531, 0.03525409832236347, -0.12580839096989, -0.18666790883667667, 0.5527064779306439, -0.35943240871154564, 0.2844858502995513},
    {0.1354458210648928, 0.4097050873580849, 0.2960732561960155, 0.16112871423797673, -0.3364529741755064, 1.2365304726032569, -0.013891010973616787, 0.8079888457479509, 1.731651927200996, 0.6239427384928192, 0.30327280295627806, 0.3458987097962211, 0.8873580811462004, 1.3877786007669362, 1.004614251451408, 0.2797634591786699, -0.33203701456477774, 0.06866244136914058, 0.45262762646784277, 0.6885324915388594, 1.6712325593514543, 0.14209248009248412, 0.5773553172127855, 0.4127832037573211, 1.3236255981309197, 0.8967312231823686, 0.9125166786375035, 0.4373266468908161, 0.030019286527541475, 1.0239945702759277, -0.665643513770655, 1.4976677448132818},
    {0.41173305812650735, 0.3320861560951966, 0.3227710600849674, 1.0305543762402667, 0.10973181410249841, 0.49670157748785737, 0.5555257449770543, 0.42104303808060767, 1.5819382672500677, 0.6921724232703035, 0.6499726418004063, 1.157140052774687, 1.0203587301556356, 1.6572400943345607, 0.11838030391458275, 1.7354520012980872, -0.8539475749718941, 0.21838677407195836, 1.6397835994681391, 0.8148790103305609, 0.9910622596579515, 0.1474020802002327, 1.4722878526773786, 0.4022257056491204, 0.4855944914074533, 0.5396090483288153, 1.028422420191896, 0.8948516285791666, 1.8784198281089546, 1.6304813795766218, -0.590928220913989, 0.41277497885625913},
    {0.3184600454790103, 0.5750044505565196, 0.7692463147360264, 0.9730986065813687, -0.17286041590182463, 0.43859398883630923, -0.009119904347801426, -0.36852925067324194, 1.428616035940945, 0.43434365165006084, -0.10870452677809894, 0.83228652855307, 1.0075928239136764, 0.40079231928690184, 0.88116106978564, 0.24123591952246565, -0.12190452185565814, 1.577873533615021, 0.08347083884413144, 0.7948224297265567, 0.12410165157871143, 0.47755790252012686, 1.34398598266632, 1.4892582018522547, 1.0728437676816336, 1.285075023294554, 1.3321153787293845, 1.5800423112641446, 0.41045203888160153, 0.4201450522175257, -0.021615364560119546, 1.1198209794276934},
    {1.5275646281283333, 1.4354051718865515, 1.2015474094670773, 0.8140430545625535, 0.2568131693151662, 0.06272984178910285, 1.3482701740907697, -0.3689936748973511, 0.3100899375442141, 0.13101035994039748, -0.999711836213003, 0.9299173015735329, 0.4008477645101609, 0.27227067622002, 1.304866486542919, 1.5869219032136708, -0.7134508717401603, 1.5022249121491908, 1.2358192511447388, 1.2675645575130523, -0.04320736638968648, 0.05432413917360604, 1.3129168659118315, 0.8824122968064855, 1.1784953659691482, 0.11661063416736643, 1.1758099574919065, -0.38198650375970256, 0.06607468952382521, 1.1838479979424907, -0.18437565777550813, 0.3437108970125894},
    {1.0747080179051636, 0.10965463335565986, 1.49250776165275, 0.5223568153674668, -0.26207496593117574, 0.6678884149675169, 0.2622287183764569, 0.246678919201695, 1.7113056067025076, 0.9393444539887554, -0.9704292113045847, 0.1502229133190681, 0.32841180021862726, 0.2731581556417138, 0.8349112093922129, 1.4513735582027134, -0.6856955113373738, 1.0041663947209587, -0.20802041402584748, 0.7924492085271253, 0.6697820332104605, -0.12022618353698344, -0.22202643110520537, 0.7878401197147743, 0.6316643561746221, 0.3394373779500709, 0.7430085659240901, 0.742710967382917, 0.5131259947280717, 0.3205041311985283, 0.27084969993072644, 0.7862604833704935}
};

static const float b2[32] = {1.2430357818646318, 1.1046768024510318, 0.9629119164337043, 0.4504106436595763, -0.13858985049213635, 0.834518460923111, 0.7458765931162051, 0.5153487191145185, 1.2810924658639067, 0.5295032665901996, -0.15255205138775696, 1.1823625036454426, 0.5711765569541812, 1.1755187436753816, 1.0059450431110275, 0.9366174532660229, -0.04762621615462012, 1.1395744174138933, 1.0327488595232535, 0.5118502968339546, 1.0093880174017862, -0.3276508411874165, 0.9959738909302627, 0.756758627750128, 1.1844268619087217, 0.7797074150219373, 0.9238431105264752, 0.7838361826446361, 1.0303796081462182, 1.1784142810928624, -0.3396528518378351, 0.8401700937261829};

static const float w3[32][16] = {
    {-0.829091386901651, 2.2014232041902964, 0.8418554413015013, 0.710407068943737, 0.6158662094897361, -0.5928266868588826, 0.4953007664373093, 0.0005608314120210177, 1.9198800492075259, -0.4402697425189633, 0.19157774597344465, 1.5661727164853607, 1.0554259530719283, 1.902140110089848, 0.4199521944946052, 0.6530065669117718},
    {-0.1664469366601006, 2.2201863248522136, 0.2538627161381562, -0.008920482993628732, -0.5987440329880742, -0.48809026883159484, -0.2473000153454584, 0.33223396443863423, 0.6777942405310057, -0.8450777350241275, -0.7383376241942025, 0.7859889501933823, 1.3559923494867598, 1.7732117514694996, -0.1225922475291149, -0.14532711204139467},
    {-0.2939325497638364, 1.395318122300559, 1.7504155598076108, 1.3073550779470486, 0.8917680892812689, -1.0185531537565278, -0.472685544536447, -0.3499296409668834, 0.18710040487094962, 0.6222136644227421, -0.7612871839052825, 1.6969843711768895, 1.8543634670755484, 0.9606831777351283, 0.040920443151807165, -0.16231599697969307},
    {0.05512732917018174, 0.729429419206024, 0.7484655272868501, 0.8829305786102366, 0.04052930610378333, 0.805386804328221, 0.05548579874272325, 0.3380751588718441, 0.5272406147257453, -0.5831530601117337, 0.3186318818137932, 1.2843027978684247, 0.5529813029039032, 0.3523209084847126, -0.43687150495424454, 0.6146447141682746},
    {-0.9436168921856343, -0.4439372151155173, -0.09892333190398366, 0.8806027375022165, -0.8211953706679699, 0.4223259062389953, -0.9897737227234378, -0.3078863198396651, -0.8016268909035388, 0.2037726419015952, -0.8110895960683296, -0.6321407894837747, -0.4940112753473531, 0.7476193179758256, 0.27138784779021063, -0.34125369429413466},
    {-0.3292857591305154, 1.9680776566519274, 1.1848700270217483, 0.8931447219140736, 0.7429503751033971, -0.4394574486358442, -0.2982294862017403, 0.762459093674226, 0.14012483338086132, -0.8810408298154148, -0.36395968194749434, 0.07196333503409921, 0.5108893621192641, 1.8738521841435867, 0.1404118716084856, 0.6626282624872912},
    {-0.8828427944440831, 0.3764039277873268, 1.182204809202131, 0.416362287863376, -0.06052738860151202, 0.6281081420772642, 0.8701972534388448, 0.7277600620744878, 1.6176999112618096, 0.7352286999967321, 0.44855745994277313, 1.6536962574995235, 0.23797050266011743, 1.4048692501710978, 0.30407063553137587, -0.43652346464303965},
    {-0.41990894711947135, 0.6402555698849204, 0.8280159213812093, 1.3610261504201613, -0.3969750120179422, 0.13526202859875278, 0.18015033139908387, 0.4069159346089788, 0.47005822900200667, -0.789008685466521, 0.8934723039442491, 0.7728126394562231, 0.7150212256169146, 0.4789850895191836, -0.7340698234466806, -0.15163496162499207},
    {-0.25787359398665655, 2.238553123712967, 2.141994855976861, 1.6676333688186515, 0.5426533104671867, -0.6395278707438499, -0.8378584726101429, -0.10247183871650557, 1.407371794277083, -0.8775877801500969, -0.5898152316649504, 1.459221215944848, 1.5371211304306625, 1.647811222662256, -1.0268140090016726, -0.7800904993669796},
    {-0.6417034081286782, 0.6148721443088404, 1.4121815305687437, 0.5613679685693667, 0.920814021307146, 0.7130918932316461, 0.15623192403951577, -0.9492981649084611, 1.7262291905851774, 0.06790977415474796, -1.051928000554619, 0.21081769590153632, 0.2654113972672287, 0.057204615562543165, 0.8376717180965046, 0.3456984335467978},
    {-1.002628050194164, -0.7337448854045506, -0.16975526603575475, -0.715375883032932, -0.4095771559760974, -0.776195771339576, -0.1504563724777293, 0.7904575243165176, -0.6492159352174391, 0.290488469300092, 0.13625639989372818, -0.14309676375073943, -0.7396617025221252, 0.7553470685649607, -0.028272899673381594, -0.17939225915535711},
    {-0.5814865883603045, 1.0307523813222648, 1.8118065626407367, 1.325759105950533, -0.6432947116061981, -0.29434917954555934, 0.7419557807641567, -0.5453704740748873, 0.8753327217717782, -0.5034721131842393, -0.7005366709411286, 0.7077805876350051, 1.9466012766766716, 1.443369576497986, -0.7127547039760771, -0.6236784054521562},
    {-0.9534148910487504, 1.737571998275997, 1.3541621555755243, 0.42806384477271725, 0.8179785838399466, 0.050172141577275335, -1.0162985657357666, 0.21268045841355515, 0.23324117326313057, 0.8050729033238011, 0.3919764028151913, 0.4560637133770866, -0.02837631946460565, 0.43836857624208064, 0.2761686742246372, 0.2762239071630157},
    {0.4317901489852239, 1.2404012676185787, 1.2106913373706134, 0.8070019310642743, -0.6466625665555946, -0.8929082214608203, -1.0816507090250358, 0.2757536384909146, 1.24324522319096, 0.40319419852052674, -0.5229739808384086, 1.8429379455547124, 2.0107141391422636, 1.5315254308909785, -0.05748328130441713, -0.30162987291591814},
    {0.4311381751311654, 1.2000360621491741, 1.879486250508674, -0.0031564118416354437, -0.49934328534642064, -0.7780027095149497, -0.3310036993077648, 0.8992417963856351, 0.8101909323490243, -0.36708025134618466, 0.5397498698782394, 1.0456254062916095, 1.5660832388234487, 1.7238295929611427, -0.8664858784527788, 0.581481140162382},
    {0.7069647272902011, 1.0304244573902073, 1.6861621859025275, 0.06681864054264278, 0.9028802235277745, -0.37657278737571553, 0.1462600570028609, 0.3373017719353443, 1.414871118149535, -0.15328315790938551, -0.27002233213765364, 1.801211483184545, 1.0647075846516512, 1.9082255521148555, -0.2751396962701243, -0.7436787149671784},
    {-0.6913529090808045, -0.7791370260850911, 0.12079131689310504, -0.7929988782566337, 0.8947338348418848, 0.17221746210162958, -0.4555222433161899, -0.07151024242192404, 0.8186947246268655, -0.7859026695402994, -0.4237963575855656, -0.5794492277813248, 0.007470068541459977, 0.4875802927982364, 0.6527808770074015, 0.4794175435812083},
    {0.531861714231163, 1.5328218194717167, 1.4696337191946744, 1.5518952772245231, -0.9999135730870451, -0.4886020491870034, -0.5910480333074004, 0.24761522638868838, 1.5205982536509473, 0.6574518962331563, -0.1616573363896319, 0.719073401376812, 0.1603580425101776, 1.2074874705820233, -0.3483987723069856, -0.33121841154021053},
    {0.14922541124841748, 1.0723885420177544, 0.9991071037049528, 0.11498840332151916, 0.5895191117799872, -0.5243496909514017, 0.18487423851314552, -0.9766799428980398, 1.1147093069500416, -0.17616374578581723, 0.1513189322641376, 1.6599601373067325, 1.9272177603174212, 1.5104656841817394, -0.35798478912724696, -0.028149295616157897},
    {0.5090187538922999, 1.0705056591236704, 0.6552440943907648, 0.4607309440643502, 0.7514717665724869, -0.16806774454573623, 0.6459373007945477, 0.5912752860357665, 0.24688657284429538, -0.13269168310679572, -0.5052021933104273, 0.7393113296523243, -0.005914996223670944, 1.6190446542372952, -0.48257520762958295, -0.16469274846587564},
    {-0.08849798245746938, 1.5482874953097243, 0.6680095944186143, 1.6513171696470015, 0.6146248291683603, 0.6960231989392099, 0.40533898904970667, -0.4912327001094629, 0.8043896960476686, 0.22276351085631801, 0.6323587433123462, 1.4499483694761892, 1.1680556503141546, 0.9765071159695285, 0.2034823070403991, -0.11069321210908992},
    {0.26776341036529394, -0.6038179262945786, 0.4746952845189755, -0.10332479992311104, -0.4908999860452597, -0.22962916467741123, -1.0705080090490942, -0.2872789503418256, 0.6411103615774518, 0.8497333050388826, 0.3797451284053149, -0.6545260898444654, -0.09434856974591639, -0.46405673117938095, 0.6688043455248824, -0.4458738096436418},
    {-0.6448027301790331, 0.753007904395647, 2.1398979500696584, 1.729516931483404, -0.8511736138137902, 0.18194101836868004, 0.708088125449505, -0.9721699793021482, 1.9572696357072192, 0.12590636881281492, -0.4450952276539757, 0.43483356987011756, 1.4154677514443375, 0.696612163610229, 0.005765617126645451, -0.410978521418771},
    {0.5321213929259505, 0.49614171840533144, 0.264035531075723, 1.5551899558264295, -0.3012924230605114, 0.8328021320314909, 0.42635423324387056, -0.8846022581441487, 1.1792030550818715, -0.49434876918759935, -0.05552371119120458, 1.6879479818086496, 1.493875143714052, 1.3279674185759203, 0.2707397864206006, 0.2460449746997256},
    {0.27766566263398984, 1.950419760399558, 1.4853707377296699, 1.8581468428510703, -0.6258633090563179, -0.2785923624781702, -0.0904737439832004, -0.05990874988044639, 1.7204483880781205, -0.13890086699388046, 0.3897801643398724, 1.1753926907042929, 1.321906196367057, 0.7436205831853568, -0.03808865624283283, 0.06603476714347915},
    {0.6422308588535232, 1.3121844803003935, 0.3352679699070148, 1.0315757124564673, -0.281123253474515, 0.4156416293165953, -0.5122470437545348, 0.704233384716721, 0.3445428816760534, -0.43812167527236484, -0.8660747594820194, 1.0090790039895983, 1.7547548020224526, 0.9165435143532462, -0.7603896799256457, -0.9634801746060322},
    {-0.13856249656476832, 1.8811138690379714, 0.37886930764536375, 1.7064808109497638, -0.7710144177756258, 0.7283174612528375, -0.830485857732781, 0.5988198886251459, 1.829852787912151, 0.5620446762036927, -0.12981380362937026, 1.7749269727531571, 1.3729675105740107, 0.14197971944830687, -0.22394732238973203, 0.6173356870253911},
    {-0.36233052439430874, 0.37743215743324077, 1.6234525768153292, 0.4862532420431218, 0.5594505664086938, 0.0590767540081077, 0.25286727733605424, -0.1497577217383515, 1.40281529719489, -0.685275931709014, 0.9249553428274854, 1.2035216276218974, 0.8190424934013877, 0.8113853075052956, 0.9540153140953765, 0.6078573293390057},
    {-0.09649624053839069, 1.7106588325300511, 1.2649343242266085, 1.889309691007276, 0.6399680983635898, -0.9034722533473557, 0.32447736324099935, 0.878729003730264, 1.8649178446873216, -0.017903227083880317, 0.8323377313343282, 1.901066789800939, 1.0534857104414075, 0.7522026193264496, 0.5662550687689214, 0.8391632415094782},
    {0.7535215027913974, 1.67866964827038, 1.549342194896838, 1.2493677418388047, -0.7760762271756724, -0.3127457642723415, -0.16573916418547063, -0.7618481117488681, 2.0902469137299877, -0.4911769024641615, -0.11107200521113086, 0.520591299340394, 2.0975054707144216, 1.3947739350119368, -0.7747316772130615, 0.1468661340776291},
    {0.844370301839011, -0.45369768608947436, -0.316081844447096, -0.43525862543914684, 0.8161734058739185, -0.14297648444131128, -0.9242280519930504, -0.38238301877174763, 0.020199350276404723, -0.19328529391038396, 0.10682015318676812, -0.702498490676958, -0.4863388174961028, -0.21298732044552626, 0.106523464465821, -0.5359958309659552},
    {-1.0188254670344534, 0.5653351539803538, 2.0095769135223356, 1.5763192451079762, 0.923876817324311, -0.7936158310112728, -0.12368284179718275, 0.41387433910724214, 1.4414839626614415, -0.6235759294211903, -0.07689097109126994, 0.16724184854069027, 0.8823848651713522, 0.5570160195529061, 0.12520796659144903, -0.8733503428100461}
};

static const float b3[16] = {-0.18130997348892325, 0.928561152720063, 0.9238934345379378, 0.5893728391735252, -0.03095039254233056, -0.07787194306907506, -0.12804987554698466, -0.10735417571391767, 0.7231817804284308, -0.06886468808813215, -0.04939598206707304, 0.8616622798056223, 0.8223995389277934, 0.8295797746142523, -0.060339833875536694, -0.09980103506933392};

static const float w4[16][12] = {
    {0.46765493550580833, 0.3708645829376348, -0.10496071099092553, -0.3092610191348218, -0.9563106442106158, -0.8706714125869601, 0.1716511654355506, -0.7287364875244169, 0.5060863873940178, 0.815550843597889, 0.3383964842350554, -0.2157376215791096},
    {-1.8477896807553127, -1.2358480038784179, -0.6128339412449243, -0.5628186548115477, -0.6585258354901264, -1.4622447981260043, -1.6878793031504697, -1.215256796025569, -0.36121108681371816, -1.4224444642050371, -1.2672189730474952, -0.4918834961508685},
    {-1.004764894626399, -1.3915140464932025, -1.4717509285159787, -1.4002535313904376, -1.1480731603016276, -0.8345505060145743, -0.5194385981168995, -0.9674230849976455, -0.04360267138522759, -1.6190952050505056, -0.9183847289578321, -1.3183679188320037},
    {-1.8921838976131131, -1.152718896328512, -0.8362426105280489, -0.2346301161743729, -0.4382133113056389, -1.2476245692123817, -0.880560055167352, -0.1664440988278949, -1.1702010403630136, 0.13874216797655872, -0.36226729593277696, -1.1262481321755464},
    {0.18057570205978454, 0.500389950419871, -0.7416640978540673, -0.9370726654168762, -0.8927165839062894, -0.475668530976061, 0.7589538500208552, 0.35084426856515, -0.5242969273899707, 0.2712468557863216, -0.02829968664536293, -0.05247231695492406},
    {0.6721812343206397, 0.6033358264052188, 0.46190448303057197, 0.08678230117905748, -0.5008246286243255, 0.9225645799841515, 0.33981803077431605, -0.40270352939078896, -0.9699762413247165, 0.4782358276926566, 0.5194736029081664, -0.16979743170829817},
    {0.41390864635065017, 0.8685077704412989, -0.37396595703037094, -0.9692321522925159, -1.1078666162081852, -0.9686523802843237, 0.7884862065091196, -0.7620334299680475, -0.9283882419416611, 0.6327756788185371, 0.2023992179321395, 0.5295126409306372},
    {-0.5109794173215243, 0.8658194588941827, 0.07217478911744396, -0.2906086547525114, -0.7076831791713956, -0.5518254668055868, 0.6165663465055236, 0.4943689326021736, -0.144237813697688, 0.41122297657222656, 0.4917193063522517, -0.3254265043788979},
    {-0.24953886587863308, -0.24108314021984245, -2.016246856632196, -1.40228046156704, -1.3053871749449202, -1.3770392127419122, -0.407150347726386, -0.15653757241815855, -1.6707960171007556, -0.5999965154620314, -1.7975745477683507, -0.874155698232193},
    {-0.6522134938080123, 0.5205114046197604, 0.47393930418567964, 0.029303116110602212, 0.15235590052979708, 0.1690641978727393, 0.8082429289901631, -0.14101223337068997, -0.47150630364564755, -0.21782927521384565, 0.21568351712545766, -0.5241133424466308},
    {0.31203930541976554, 0.6296786252711319, 0.19258014455786557, -0.12237794508433861, -0.9158054964636406, -0.8094592136480758, -0.8156028109649743, 0.6051014114542164, 0.8673634711869149, -0.3758115100797552, -0.9153659569491821, 0.6625194453062215},
    {-1.0133766668196886, -0.9023078222593626, -0.25627219456224987, -1.346809533043242, -1.5172077330959293, -0.10725828855990774, -1.296520484473168, -1.6668719330957928, -0.7337400417204538, -1.5060356178534517, -1.1727293539295514, -1.0956760280641866},
    {-0.7053909160343954, -0.7975906399420041, -0.3724656155522847, -1.0385881264301062, -1.5403751109478696, -1.102390306066139, -1.2034875222652974, -1.1834908514961173, -1.4308050363913256, -0.28049072773210476, -1.2921985863007825, -1.108168156347777},
    {-0.4649494460643608, -1.2884245780442638, -1.5504693648938481, -1.0768216140209952, -0.547718542257461, -0.8957801079068588, -1.0850752565358508, -1.6481746857524116, -1.8480736285123731, -1.5970618998176238, -0.19973366044010904, -1.1744798809264079},
    {-0.23454950524410217, -0.10415911027163523, 0.5624994985440297, 0.2331927690639732, 0.4911826386055724, -0.7371900448683609, 0.41892689018874163, -1.0351395124227796, 0.052463837854987046, -0.9429008066883026, -0.11365278526384354, -0.5944736809739973},
    {-0.6958127002065859, -0.40401560834091166, 0.19116496226814433, 0.28911733778164844, 0.6105260737863849, 0.6736468242588778, -0.6704229481925152, 0.5587337331984822, 0.5225293625100995, 0.90748664125319, -0.4500657741374494, -0.13630007821065698}
};

static const float b4[12] = {-0.4679917436905778, -0.3591455127836869, -0.6229548262482645, -0.5439095493032037, -0.4667983984102672, -0.4904933743027738, -0.41170654963684916, -0.41995812879627475, -0.5093079083617573, -0.3859446147018674, -0.5032777631683039, -0.3674181225840138};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
