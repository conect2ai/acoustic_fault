#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.7716389666202388, -0.7894658603788802, 0.6068710413111986, 0.06001825602712483, 0.10416507834453037, -0.7792336378264619, -0.44452505738002734, 0.3249140920566999, -0.6892809991258827, 0.22964760911710644, 0.4532388170290145, 0.6732789569695643, -0.2997543405360385, -0.5203958097896373, -0.6090175524773923, -0.8276415564052749, 0.27789741535044926, -0.9629323968491523, 0.1876965625361684, 0.5466898569777294, -0.7906756475559372, 0.14427032950257684, 0.44729523606500593, -0.718225364496145, -0.5551540332668097, 0.4211437291917451, -0.694276092945918, -0.6705488819037694, 0.5432903773895723, -0.9528192947953781, -0.6805242688319793, 0.5288755070474477, 0.19153215004643206, 0.15606765829025124, -0.7147456637969017, 0.01744478739434771, -0.3932804212968267, -0.817916447192518, -0.23204250818486302, -0.6491241879066114, 0.36852615656850357, -0.6815795699097768, -0.957685725940741, 0.228230134822514, -0.2530457151590586, -0.5449463025793694, 0.19218241191982235, 0.03693401977636926, -0.15602408835563178, 0.02772769171335958, -0.44937207812896934, 0.4858618591164765, -0.7405295246201966, -0.35184879130103336, -0.47126413645395676, -0.3635440947970944, -0.5546810429949816, 0.33679313761451435, -0.0383539655689187, -0.36906794245226354, -0.012823622466085859, -0.42552812329184153, -0.5627565150773408, -0.7439498522084769},
    {0.13745119820803905, -0.0583981010157778, -0.4604908100015013, 0.597602671233987, 0.09645389632863752, -0.15317279050102128, 0.1467318250993122, -0.13664573847608094, -0.13591029602030388, -0.47385883083993297, -0.6697698736285207, 0.037107165908698184, -0.0640057488913696, -0.5199359188909246, 0.41000468362649495, 0.45156029278656357, -0.45256994406405426, 0.06690213824762263, -0.4013859736275608, -0.7782946538545391, 0.7486164562982522, -0.3800964177508281, -0.36930532125324433, 0.2943953213376569, 0.003704036348554037, -0.5098690790827971, -0.035997714139356755, 0.13013317675234462, -0.465164981039097, 0.7095027235398622, 0.007096605024752715, 0.4070172414960845, -0.5043543188721897, -0.06782602498456514, -0.08005376920249808, -0.6107249585728397, -0.1114910726802509, -0.18048517247288526, -0.8369407157126578, 0.7747862120847484, -0.20157531896398617, -0.21276229292328222, 0.41889268936135565, -0.3610349651819204, -0.5163984832566106, -0.37098376383780074, -0.15054907038320964, -0.7368008151213792, -0.11388532741170489, -0.3851503522506119, 0.1348365160835782, -0.6666919853580737, 0.2667202193186077, -0.007192863670107315, 0.47667824591053554, -0.7035663434767723, -0.15074368140014227, -0.8775395108121214, -0.5833674593289058, 0.32282948810374434, -1.025722308339832, -0.36913937798139873, 0.01759926424621748, -0.14364392693656308},
    {0.22021023625147382, 0.5812917255298148, 0.5329236144897315, 0.005813886078859348, 0.31379759896363923, 0.6308042693560515, 0.7427086782497484, 0.13012023096392078, 0.7613699351469175, 0.43215188677413763, 0.3862702065869175, -0.07385563536326299, 0.4914289617013805, 0.6692591095901901, 0.003634212697938824, 0.5546765497136055, -0.24806836455561357, 0.818488260591872, -0.1298355136432209, 0.4576403198492686, 0.512543241685995, -0.10186686029705418, 0.11369876785359458, 0.5479693840135161, 0.7891860264447513, 0.05407838540306589, 0.7843259803280783, 0.4244205015629171, 0.7054998966302588, 0.499958833916525, 0.7476572957606151, 0.022591115281540695, 0.53990886061308, 0.48504509966348797, 0.4536841738899304, 0.5654326694344626, 0.8406106352585352, 0.6634210058256322, 0.6420686495939957, -0.03376097603917049, 0.44947907825060435, 0.3368871910130472, -0.12621673121097368, 0.3156404130267389, 0.49416119885784954, 0.6763686863502708, 0.1662600675891622, 0.6056190869401828, 0.555390815601987, 0.6039057323982543, 0.5955482338550429, 0.21819074258975102, 0.6545166530652919, 0.7306076199860659, 0.40587868523396803, 0.6286777930027769, 0.7444389034309872, 0.23686933030510463, 0.2169886068559816, 0.7172745007904846, -0.024205074638793216, -0.04114023900162903, 0.421365877064167, 0.38275536329756954},
    {0.5271490319997612, 0.586337687010402, 0.6390922468418366, -0.6776793119375081, 0.3337961086243025, 0.7037698135959644, 0.919336590952051, 0.02605797110675769, 0.4210166282215499, 0.7678377535387588, 0.6374702637594958, 0.37899869632577504, 0.3348971962488039, 0.7570715691667279, 0.08682736265485538, 0.40205252184731466, 0.504335108851285, 0.17625981209405864, 0.39042510551555704, 0.8440404603098068, 0.46497598552279557, 0.2863672679324281, 0.5937106030283639, 0.3239307062265223, 0.3300673359583908, 0.4104881598349015, 0.42764058622185064, -0.07263046964772103, 0.850907131761973, -0.00807184493051927, 0.5666034417007958, -0.22337552191868504, 0.5153306986280651, 0.9260692755044528, 0.4208659855697716, 0.5804326086810023, 0.3940258168692607, 0.8023447818706175, 0.8545153086075573, -0.5932003517092227, 0.7239183612113468, 0.024411110576672192, -0.3530276324759048, 0.7004857082016289, 0.46099200712242755, 0.5828591504373586, 0.7478592750328142, 0.7829204879894301, 0.40507326235387514, 0.48934525848035193, 0.13726240874681417, 0.2176161462141468, 0.5510996330362508, 0.6472182629498392, 0.09908903532270881, 0.7250558125907339, 0.8132101073854476, 0.4678725124359076, -0.11343283935686982, 0.5240512732709632, 0.5177024704142167, -0.12487943022676677, 0.29588209872580873, 0.42738437545304225},
    {0.42939400085504237, 0.7048951203653372, 0.1804920597543176, -0.037544583871284065, -0.09047010649244497, 0.8541626729399774, 0.8375463413775921, -0.3130111872048226, 0.8827207875490618, -0.046528186031834826, 0.5811339725827731, -0.1047471347730187, 0.4746959612177048, 0.41120129487448975, 0.36565008136263, 0.8028922535305444, 0.09016940263992478, 0.6956622601579661, -0.11480923534435264, 0.561846150175186, 0.6442846379490024, 0.3756805390034123, 0.17917436347192606, 0.6595722061865491, 0.7713000803090733, -0.17659241685084948, 0.8078724581489763, 0.708600525637021, 0.4126563604051042, 0.43986055559787945, 0.9124991030271472, -0.25033666069255844, 0.06413152519012015, 0.8685540070706034, 1.0239679322619542, 0.44545420273091296, 0.744774487377932, 0.6157488666262203, 0.5138012292857744, -0.22340108869345593, 0.5534695596606728, 0.5446256316276998, 0.6188717868020145, 0.5160226663188016, 0.5270768557004729, 0.5963651672274701, 0.11575599604416241, 0.868710327700285, 0.7069273208967102, 0.5245362221719673, 0.6230712990626301, -0.09590909344581375, 0.6780615457104012, 0.5519563335980635, 0.73073879143159, 0.9447329888787692, 0.5402418589853637, 0.031074907386758662, 0.46032300877692695, 0.5865661530752794, 0.17437076754288455, 0.8225926222975496, 0.428117124947911, 0.6875869165585883},
    {0.6706523319290562, 0.995935174890745, 0.15260408226191918, -0.31732130192752656, -0.5092922298543273, 0.8874260995233226, 0.5200768494511495, -0.531718782619924, 0.7679620754669015, 0.0762501951324188, 0.30784249136822545, -0.48472280032828546, 0.6275249113037278, 0.37962594068119365, 0.11587879578900263, 1.1395474509828025, -0.6023017014174558, 0.7105254901578046, -0.27514171943933574, 0.2002108910323232, 0.4146973945722905, -0.08530860341130116, 0.3705059840354246, 0.610446193874224, 0.9262155760934544, 0.12432921364737766, 0.7562779400063192, 0.2798931899649858, -0.13355389895165976, 0.44065100141180114, 0.7947685733242886, -0.3082296788422641, 0.30510749434046475, 0.815266534675888, 0.3865590098027208, 0.44046297562085285, 0.7407622168147648, 0.5068017787068547, 0.880344798355969, 0.07949226773179678, -0.22449904173294657, 0.5399291792732979, 0.6192192185148871, 0.15473185062529954, 0.7381963671135475, 1.0030102986669034, -0.43823152966391077, 0.1477182032033258, -0.2699116000812217, 0.4981423700417092, 0.6226571593276605, -0.35731359500112275, 0.5636467979123343, 0.7086080949395677, 0.8539169056595818, 0.8003395361544888, 0.8337362271886876, 0.16018774344372008, 0.04635350849844967, 0.49426807626750274, 0.7758372591189012, 0.5072852911423185, 0.7816778881326913, 0.2145540067325544},
    {0.6769780393116004, 0.6728633528737045, 0.5907984589825518, -0.45252336036748736, -0.17709775856073148, 0.5231713723039237, 0.6231855909121017, -0.14233136467843652, 0.8455913385334843, 0.19559913410812124, 0.7499065421994341, -0.6970319879192323, 0.4604047191787162, 0.5378134604912103, 0.33314520647201695, 0.6858917797841325, -0.5726138294408032, 0.7542112444659105, 0.013993020920158618, 0.6550942499894682, 0.5427934581825057, 0.2071062073240395, 0.3340389825302879, 0.6905417354318485, 0.8082922048614682, 0.5032326197546269, 0.6186894712765537, 0.04169250842201476, 0.006360195591293776, 0.3284749578082335, 0.7512992761469783, -0.18806382482059247, 0.5566137523680077, 0.6056480813090832, 0.7281229530787616, 0.3800280077847603, 0.9044981539978463, 0.8993306216409462, 1.1635420966235412, -0.2808371463665091, -0.24209211578080214, 0.46986736578191995, 0.7825966431778105, 0.40901336218342205, 1.113719859277123, 0.7949633166173203, -0.30670547380733526, 0.5017767223503057, -0.005138104672251808, 0.727736535305749, 0.594703821545355, -0.19409809131583328, 0.6569928507804171, 0.7117998153162829, 0.3548553403202359, 0.868501848612343, 0.8398926931366144, 0.07279338861756177, 0.13839407734739717, 0.8606665678213236, 0.9194448050942511, 0.437615158771276, 0.4564313617678954, 0.3299353425727901},
    {-0.1153539731695301, 0.5696418582226171, -0.07280291927588917, 0.05566859802571179, 0.22979032497586693, 0.2624678776337739, 0.42583767425505714, -0.1378042924748023, 0.3290346000952249, 0.044165732168104085, -0.2818173802297406, -0.0034305253020749725, 0.4195346680103958, -0.10372465930389581, 0.48392186859961883, 0.576770232486409, -0.7797653765240059, 0.5601839564125416, -0.14740300911293006, 0.17841023564145905, 0.6663348169851643, 0.19894013861056398, -0.11098499910979724, 0.5150591986241678, 0.7034731601247943, -0.06443772965948079, 0.2856963213237143, 0.043156536321877256, 0.13191337445926482, 0.34412906897558204, 0.29370277536711786, -0.02904877655540219, 0.006724015921017443, 0.5309180717283958, 0.4871480528688684, -0.06273246712759015, 0.10864489751792114, -0.37490179297489057, 0.21149501818979705, 0.2038712696739546, -0.14709406078973575, 0.013849128997807481, 0.44751158757804516, 0.17149142760056005, 0.10959603061700002, 0.5481177498742184, -0.2186770657985031, 0.04477728026266407, 0.3028931328733933, -0.25401632756043674, -0.10605107732542039, 0.26931128720783903, 0.5955653151447522, 0.5364594059279302, 0.41823045236631146, 0.3660142457320302, -0.017950114450759443, 0.0041228577352995215, -0.15651761345068835, 0.5739990075771904, -0.1516428745473011, 0.15620073929331843, 0.21999766900690454, 0.4942200950905093},
    {0.37720264516684404, 0.5991361413869174, 0.48084230888410345, -0.02432803547064003, 0.3707398747842798, 0.40980125612764595, 0.710142860695325, -0.5965629132748196, 0.07449705182814327, 0.21099496256279252, 0.02502989737116055, -0.25104407359468384, 0.5071060214990721, -0.09730962175568228, 0.14296378898514006, 0.1463279573929447, -0.7761229022134623, -0.021502505353828815, 0.06316167633014055, 0.043784504080242745, 0.14340955530195174, -0.2513339103673426, 0.19218166572348377, 0.4368149497645254, 0.5527630521671043, -0.280785136594553, 0.11750804666208434, 0.13734579812762823, -0.5163813196908981, 0.6983131554832869, 0.5302139471142923, -0.02742539795592607, 0.001213170552597348, 0.4075111585078832, 0.30131983563449083, -0.3347018850716638, 0.1048485962295187, 0.28306701827018205, 0.3985577610467476, 0.47653744815711035, 0.2716436883758554, 0.05082309902915354, 0.13178709092956967, -0.051726177562520105, -0.503377047734584, 0.20575630524854752, 0.006689725776224475, 0.35482203096667847, 0.22431847607279887, -0.33585854780369123, 0.46021908218996127, -0.10792797199561059, 0.3476079211948589, 0.6852107061026784, 0.22861490456938954, 0.5574402644708247, 0.8020034444531847, -0.38443600760254243, -0.8486277278648682, 0.29419916735445706, -0.13041137320420512, -0.31547676325214785, 0.22314357791918404, -0.22296381104333515},
    {-0.07386481314739303, -0.0021706680479176184, -0.44073742204897637, 0.7924496121922044, -0.03585791209616315, -0.8491400896663996, -0.6978906319576198, 0.19878412886114732, -0.3983733225958426, -0.7498189223935958, -0.8221469819633656, 0.13968939150859774, -0.5763311909066952, -0.34439283055791925, 0.30512456453411346, -0.2941300987374852, 0.3529781642909122, -0.24231753492239738, 0.40629806440225036, -0.8561210674438836, 0.2544681711786119, -0.2713559200260672, -0.723170438046309, -0.02650548528483497, -0.4984538961058705, -0.09170435848294596, -0.6152576410552981, -0.26518257014177543, -0.5289869313456276, 0.14232558091159084, -0.46700472103813023, 0.05424907599348374, -0.2720672227208004, -0.349761771239063, -0.19096785936254318, -0.6691289580327636, -0.4898377680347166, -0.4042298654255172, -0.6522186539130992, 0.6501456224611835, -0.34683392264999074, -0.7409813213620238, 0.9118750738363192, -0.19503131409970284, -0.5942471499974216, -0.7245651849311229, -0.14629610856081335, -0.6615829853567451, -0.22076678298696048, -0.22827564497565006, -0.5368937217673551, -0.27550477347499003, -0.3107717725110548, -0.48874812076016383, 0.4228458873678337, -0.7164258490104826, -0.4352910495665282, -0.47815481879233723, -0.29437114658885666, -0.38123546930055807, -0.33614493059987355, -0.6259237973401303, -0.17455960990459612, 0.012990872678440218},
    {-0.13073728880024268, -0.32144885384598726, -0.18331604229045576, -0.07546943720714222, -0.5382160745624223, 0.03245757598377378, -0.5871017683070565, 0.09089490968489934, -0.09292165636335388, -0.1867539216189053, -0.3853561720393344, -0.1342831784644912, -0.4425769135712411, -0.11428818179289915, 0.43384821629396814, 0.0846748140642482, 0.35197604276937133, 0.08595278805063583, 0.37468455193382816, -0.32067813970466214, -0.09377486400469065, 0.22399165742231503, -0.5852594720009958, -0.27916651480936, -0.19108514248987726, 0.7002064794203426, -0.004726547379142641, -0.3427098050065678, -0.8301337644092145, -0.5753639550509454, -0.3274954883498431, -0.439337071724515, -0.04865305208212915, -0.7759655385373698, 0.014107156393889302, -0.24383712353807155, -0.3839787340473396, 0.2955721281015587, -0.5061805549270972, -0.402118782061684, -0.1648504880140803, 0.016262610478343282, 0.057552184854133825, -0.16573165633752587, 0.47166504931273245, -0.32077671236752137, 0.04362659164798314, -0.34772853762095973, -0.4694361390991885, -0.07102839894456021, -0.16735514014768466, -0.7031751955928733, 0.03156633307242329, -0.2730236309432279, -0.4235643558792876, -0.12693116373662883, 0.04264389398545887, 0.01782789411027928, -0.37859709132045, -0.2747919611504173, -0.2714290429955522, -0.3488175144880741, 0.1563983766684195, 0.3693930778313933},
    {0.3906272777500254, 0.3253013481887453, 0.07039774341639012, 0.13159481917075883, 0.4909690783209659, 0.24813208580997034, 0.7094379267969864, -0.13448772417204236, 0.004341479063439214, 0.543404436753399, 0.04396604674622365, -0.02538708346678516, -0.3315147004267528, 0.09175490819556693, 0.09567235278317657, 0.2335310440941156, 0.08572649805897237, 0.06863181162319973, 0.39618636703152843, 0.34066440089020106, -0.2800182774142508, 0.003909563206942023, 0.17586807283392047, -0.003849293902012605, 0.05212351424663801, 0.38486365758683133, 0.009756096513704371, -0.3967323505972382, 0.24374747717382425, 0.2972130775072949, 0.3593747386595434, -0.03197132494049765, 0.7092798797779039, -0.42822114731343713, 0.08574341597778982, -0.08430840868932811, 0.023397491283904483, 0.0679994327893825, -0.03936926857491729, 0.6307833429661184, 0.44629073777379524, 0.2554697657812781, -0.7772784725778354, 0.08875057671569955, -0.1937654065950378, -0.3727579208361703, 0.5009266093326253, 0.2918749343336957, 0.3793890361233423, 0.394763432899181, 0.19296145134448744, 0.18878197398955449, 0.4872087026272176, 0.2887816216616619, 0.1652982108711172, 0.3555763372230925, 0.40395772070610747, 0.30583837428691757, -0.11492919496137788, 0.19175112559638463, -0.22380913322387977, 0.03495914927932831, -0.19180250072530902, -0.07825594465319274},
    {-0.15263354743569502, 0.09986411122621722, -0.3921301544626061, -0.015445813765063326, -0.685365664472296, -0.6024846808021563, -0.6421556268800259, -0.509195961385447, -0.3043321737281728, -0.4767911089062091, -0.6714646640719575, -1.0936457900000836, -0.4072630601128804, -0.18801610865320614, -0.3452355643236927, -0.09812821714920496, -0.7901455804451579, 0.29245506399802446, -0.7065562884017483, -0.7289301170721557, -0.3099585618930089, -0.7995243595882648, -0.6982772839133939, -0.04026242066516717, 0.03208963037905341, -0.3519634415518015, -0.07255213094049798, -0.04558264027245957, -0.6266632307389127, 0.2705436003067275, 0.02338494583571728, 0.28636543607323867, -0.45368886353857224, -0.6976486095765212, 0.1713722212737286, -0.5423144904244981, 0.3390873045382839, -0.30809862080251615, -0.29878140758669025, 0.6898631333972068, -0.693554026432836, -0.3762296194701494, 0.47260808980524394, -0.32501156334537085, -0.15231861528386081, -0.3791890759725221, -0.5700362409945767, -0.7539841005479284, -0.1844072580760299, -0.2966462337061255, 0.25409138138900833, -0.48447976364235645, -0.06999532380018807, -0.4218388578895569, 0.17207761790094903, -0.6421428086702801, -0.050929066218743185, -0.4048701216756964, -0.0919207054649301, -0.1835927584622767, -0.43148419829789075, 0.38834220673217645, -0.022056244723673117, -0.4017705263999554},
    {0.04704297469449871, 0.13104848151829807, 0.4684399200102277, -1.1620074918602321, 0.12802789793339767, 0.2418766869423339, 0.5181298790457369, -0.03142334952298627, -0.4863426007300034, 0.21356133451299691, 0.6484462752813357, -0.39583124925741997, -0.4668933503930067, 0.8852512699145019, 0.11918235084269373, 0.47017130982699795, 0.49465870793876404, -0.529657821317768, -0.059565030474319054, 0.8411978585406071, -0.47802748089027325, 0.035264852693796575, 0.14403191049712155, -0.6447054904250029, -0.2702245911770908, 0.04314697007293507, -0.19211496801984732, -0.4418852502405489, -0.40697621441058396, -0.2521141361076721, -0.32348096298491774, -0.6046164894851968, -0.04931568945025584, -0.38478770886617797, -0.2852859366793615, -0.09903063207168336, -0.6162570097867549, 0.08986159552539544, 0.5559149808453336, -0.6245792804523114, -0.1686793059158686, 0.2461635252089286, -0.16139769064703255, -0.13033765781301782, 0.4464892069078011, 0.7125936178390765, -0.09512344589240322, 0.48712317861087034, -0.1359412812981301, 0.28974068388577773, -0.05698713826922361, -0.24315539069251146, -0.4175646764514113, -0.29011548189221326, -0.7913930666078519, 0.5595879547759822, 0.50872848370443, 0.14244821407813524, -0.14364899540913878, 0.46289119386751565, 1.0668835406530401, -0.6625186126899176, -0.03294684061717097, -0.14684024477657837},
    {-0.16891522181991162, 0.23021953111921684, 0.1710764056432272, -0.8750106900198241, -0.42673217806279784, 0.2762231709218178, -0.09980760474942516, -0.5046424909119965, -0.32426300499965854, 0.33510512323719055, 1.2668399798971497, -0.6212878350760371, -0.3378159437209951, 0.5905472427320083, -0.3329959511813783, -0.1269027185328765, 0.05722218200404659, -0.5850936052539208, -0.5291344136085131, 0.5971662958509643, -0.700050720591641, -0.13722306498753203, 0.32651954974861863, -0.6338479038663728, -0.12259501540238486, -0.5909145274451783, 0.03235757864223654, -0.4223179537006799, -0.07695199968981352, -0.849349052115507, -0.4938732263547048, -0.6239708523681915, -0.3028373135185986, -0.6261880701055431, -0.7020957373839348, 0.10768550615784046, -0.16071139292775763, 0.11437053235873902, 0.7566982665812368, -0.7188086584958527, -0.33874641177556536, 0.4358234405126993, -0.6172749901075281, -0.36944080809271557, 0.6928115378901311, 0.8531159876334002, 0.10137933463656595, 0.27007562740585944, -0.45715766556126086, -0.13820146967445107, -0.17297530959471405, -0.12806496707644624, -0.582667131768978, -0.5687632022115907, -0.9242510895473449, 0.6713831085861953, 0.1510066827713194, 0.06486745768812081, -0.09206874343859059, 0.20022790785795122, 1.0510542679567498, -0.5061941610418933, -0.6023295646427678, -0.6550954953393049},
    {-0.6487661184425249, 0.004693321031401475, -0.2269579730409963, -0.31252049400003995, -0.5921565504563628, -0.3640108338436779, -0.12755380591654036, -0.47641482408628066, -0.6284732945348841, -0.07541356881399813, -0.048774913459475135, -0.4635612329650875, -0.6674441186217074, -0.1901011155060252, -0.4357180688990339, -0.36760357614444605, -0.6106028656813781, -0.5290665114609676, -0.6715027816172612, -0.43338710411139636, -0.9544709883894251, -0.49729924007835363, -0.4323236967988346, -0.38097213997727447, -0.06574923493889014, -0.6469379302916426, -0.30237577817484207, -0.07868525666962235, -0.7225801550464183, 0.22294198145527852, -0.404729817686962, -0.28311706669874537, -0.589763118083803, -0.7573559499361745, -0.583689020401425, -0.5842212675497787, -0.6767751944728758, -0.6341917066158532, 0.14103080417215355, 0.026002556084905405, -0.6520153781593262, 0.0745809109043733, -0.008149242121133628, -0.48075083700075766, 0.4188494029761745, 0.41012501928511824, -0.6399294907399652, -0.22650204917197533, -0.5184441418361186, -0.9190379629383012, -0.19653959111221161, -0.4558981721841735, -0.8020921763620179, -0.3173015051974705, -0.637159105925441, -0.13706531039303016, 0.0957512497899924, -0.6173460513303876, -0.2834107556106566, -0.5136903570296679, 0.7620751281743023, -0.3316782100630332, -0.23393051191148506, -0.8685965895273886},
    {0.6245474874039941, 0.26518656564854276, 0.2904181983285263, -0.9493757685145553, -0.09600104662794223, 0.20539762579280554, 0.1180867075280281, -0.4067504840281904, -0.402493966086408, 0.31587122929758865, 0.8460442184072817, -0.7805183939439735, -0.379571893826098, 0.6323312083766458, 0.08366210535308184, 0.4711726768550123, 0.35597104518079686, -0.8317981889393995, 0.029435651549350045, 0.39305297184351434, -0.15543404918045242, 0.1312441517837545, 0.16114353184439728, -0.6337764817071849, 0.015587237983813767, -0.062342974921923186, -0.33998514966765003, 0.05054033517231842, -0.37225662705330187, -0.2849273306690049, 0.2061124406123238, -0.5598337686882565, 0.17400836356192417, -0.143258629239587, -0.43674585955562895, 0.2818630377764123, -0.3477421172608975, 0.5967499847221842, 1.0470750741223036, -0.5318977142989292, 0.04991074911810265, 0.2878584916562599, -0.12081598162604422, -0.30408702720648806, 0.9212101183314721, 0.7516958381450703, 0.1466134863496243, 0.13714202650233712, -0.39539118047615024, 0.19793874211770301, -0.4083540345454374, 0.2099174757467947, -0.3886213619499761, -0.06276185391524822, -0.5988657424639142, 0.1758966592746908, 0.6895003970183665, 0.06926262196023826, -0.30533251137015405, 0.4127674144483639, 0.8923455691269097, -0.9593208297177804, -0.058266315241655355, -0.4592152091687038},
    {0.0673086491689274, 0.23233833376184979, 0.09411099899040841, -0.7499068284875399, -0.26465181295206014, 0.24846683062267735, 0.07663477898826017, -0.5164306523868892, 0.1328522964203645, 0.3327042383337389, 0.7327198426705009, -0.6877775629117995, -0.5655388641239252, 0.2968606706559231, -0.4855193393279402, 0.45979259407772793, 0.022671160031342764, -0.5539091146827224, -0.4364774291052184, -0.1495197323740707, -0.6351788570644806, -0.3315533852890476, 0.18148821207690408, -0.5192486315151708, 0.0016635949999034808, 0.007863384468072509, 0.27211118169433557, -0.5631355631270571, -0.41439542235519816, -0.16389034675116274, -0.22655328810952535, -0.7431649914710463, -0.10700568102781875, -0.3233896825599265, -0.5907183034673883, -0.18231402531824265, -0.001459161404687156, 0.12386099052584752, 0.9091695018879881, -0.13358914283037412, -0.2601147399426997, -0.1100669800316017, 0.2620953501314062, -0.593769998400704, 0.93079049516238, 0.5428481513719859, 0.012570029524706622, -0.10880103885857154, -0.1597545009971761, -0.047161330735078236, -0.10741582688571927, -0.24814078945043277, 0.025694777731882966, 0.006041646192009978, -0.43772697236081876, 0.5701377592903027, 0.43334469071020276, -0.5004173498397514, -0.5831677789590751, 0.5138242839614959, 0.7317994284357575, -0.8528727205738291, 0.051719464917648526, -0.2840537258199853},
    {0.7628204848764621, -0.05747117625206376, 0.512227819684612, -0.32889946316808644, 0.3712530567891609, 0.7634493184219826, 0.6442731446446524, -0.578707879055503, -0.08651474524726471, 0.7837269106399745, 0.6550183681938142, -0.07546364340101074, 0.0964410258697816, 0.686446509929733, -0.3669281830991382, 0.2857311140196662, 0.10761645227263199, -0.27055185222143213, -0.3765910543444344, 0.21306779198162834, -0.20165531738404457, 0.03205198638767406, 0.23189299985850265, 0.043039982251530204, 0.30162998482412, -0.19741176327322912, 0.48230016531185477, 0.20963111756180489, 0.14828772614113545, 0.5310497921480596, 0.5781327148240119, -0.5670091238714035, 0.4306630319420826, 0.38778400168756516, -0.40539894584657044, 0.12662933182031438, 0.4503153725388916, 0.24497450925568917, 0.7797941721165522, -0.14787547629620343, 0.19312329217332513, -0.034555309273969013, -0.3254180407914613, 0.3990929183892665, 0.549476192921343, 0.703955388071777, 0.026110068142440067, -0.22184747031139512, 0.24818623395555187, 0.24592598050431247, 0.015855772487120466, -0.07288602452958616, 0.1897414564335701, 0.12255745471252812, 0.05136215253071929, 0.21803867558861112, 0.7899551516854225, -0.15030825585799804, -0.03759241883241817, 0.34077109762023705, 0.26231908248620617, 0.20747757102585965, -0.14908116828706025, 0.0597532543608534},
    {0.8897026776564613, -0.1487419240069111, 0.3025814467979794, -0.1751644216050236, 0.31166997614415437, -0.4638371918898325, 0.153211953399489, 0.37133668580210544, -0.04227690992421799, 0.5289174691678525, 0.02053095366967681, 0.2319877389874135, -0.0348824730924966, 0.2547173791227805, 0.4528730872916521, 0.4009993841491751, 0.3887745673532622, -0.28518786103207266, 0.45328977229124484, 0.3267563590418144, -0.24681258895708158, 0.38632093224964703, -0.22129029482387813, -0.31835614003308194, -0.4065795382817561, 0.6972896033768559, -0.5160243831086182, 0.13632481295960155, 0.1209252473892136, -0.2572077042045889, -0.21390380039428078, -0.3650461280752204, 0.18044651333200346, -0.2437966979258789, 0.3024243098021784, -0.19753747598295043, 0.2152103312528441, -0.014866148242665746, 0.27354425478869765, -0.30657068006722343, 0.12595537624151842, -0.38701778016664995, 0.0361978737844075, 0.45964097934458986, 0.326962728606827, -0.3080506639410921, 0.6885444322281882, 0.2677462413403113, -0.04697041417759334, 0.611448946374516, -0.11194076868425945, 0.3353871421293713, -0.028051948487150292, -0.231380852064643, -0.07662974742633376, 0.10969624735981817, -0.10921619300247624, 0.5457354354491346, 0.2773244466030549, 0.2217658232592463, 0.1434455740503923, 0.05134347526386922, 0.03564846930000486, 0.40735410522227883},
    {0.3652797683725165, -0.02851721246621932, 0.9006275328983663, -0.49982703803806455, 0.30750170372367513, 0.45517599169494494, 0.07895980461476525, 0.36012060559796605, -0.29672991609568444, 1.0154382339948909, 0.795886121144825, 0.01117156689629919, 0.06005500308154148, 0.5795329005456981, 0.002977367689309927, -0.5025012887362851, 0.24466895916029668, -0.25590755648327396, 0.32110448754560217, 0.7745300683613815, 0.35068204982113854, 0.06821005516752301, 0.5000887324861484, -0.7051794637350494, -0.6059036317443806, 0.29559337731987917, -0.20366407404006032, 0.11507131371172276, 0.13039431338357216, -0.4216646881087971, -0.2960285508726006, -0.5101585468354292, 0.24243080525103172, -0.2843136065903815, 0.23782334277406264, 0.12477959370279994, -0.690795547263164, 0.15231621278904556, 0.2762418846537822, -0.34088761602507767, 0.1227021207402055, -0.2758189930207812, -0.47633142415954555, 0.29829041186710903, 0.23507588457288364, 0.4308133735857025, 0.423542220715903, 0.31160424254193353, -0.047728460720125515, 0.25646873498238465, -0.8242109077729716, 0.5447142942883646, -0.023623876755526504, -0.12225412039403037, -0.7176392348338696, 0.17288065035649514, -0.25647821715490304, 0.7560003168139691, -0.05616273480054172, 0.6696672116407703, 0.5343956722320263, -0.2378920153298799, -0.4433862104148966, -0.18313370955708497},
    {0.17935323040850767, -0.20691430179308135, 0.4086964609463825, -0.759801372490815, 0.13799795784846292, -0.11332219361514621, -0.3525803657758064, 0.2016743233453253, -0.40940633437454965, 0.18115167464742657, 0.6758992604001959, -0.24152109318931908, -0.722739364176306, 0.5090369961967617, 0.6284534929478434, -0.22769335316882353, 0.6540957661069564, -1.146869304502569, 0.5323289043612632, 0.493381325658909, -0.45631712679473724, 0.3767251736071742, -0.3184588366328956, -0.76916612463381, -0.4309527564258145, 0.25598695454708587, -0.67201880655015, -0.02010391178168932, -0.3307930612058438, -0.7709881491103294, -0.7376965810180645, -0.763737323750749, -0.1879231992741929, -0.03091544795530131, 0.1629564775517779, 0.34945546790710336, -0.7261321090403009, 0.13482831055815742, -0.02175382070710006, -0.6424179166309053, -0.3244374696061289, -0.06902448778376445, -0.3607075813363484, 0.530105801972678, 0.6489826378029163, 0.4913159864995005, 0.0816529739583596, 0.11424939319726221, -0.17835844681259358, -0.13561824030061134, -0.4540150350562603, 0.3645145842643523, -0.32197735444598546, -0.4467861826647768, -0.7478514045493666, 0.09471780850632408, -0.3049570007519863, 0.39069062782801983, 0.404250319151463, -0.07205985595994728, 0.4644145112389475, -0.5611695430647382, -0.15683601485869245, -0.17656912707685424},
    {0.05007811317330681, -0.04682589682590202, 0.22922501923458796, -0.372485145132679, 0.6385662123348201, -0.12217257735037992, 0.013818156433487066, 0.00030092168103556226, -0.47056653091663225, 0.9513606975310496, 0.6062013572383107, 0.38361242051609223, -0.7404678125565255, 0.6519905711304315, 0.34941812110082177, -0.383926106408696, -0.051641852151615875, -0.6365240015281944, 0.22423036317390083, 0.5865775265087223, -0.3186050330488197, 0.8107700355862301, 0.14182327678563483, -0.5365801021333386, -0.4450190092859048, 0.27715669301736484, -0.581552186043989, 0.2713477395575975, 0.3754750406535734, -0.6818177649280179, -0.4226125853068926, -0.19788597733943653, 0.2557365996513058, -0.296969553841361, 0.03551060802714727, 0.6028836803519491, -0.577458427492346, -0.38333407891090304, 0.06856869142504546, -0.41239023920688095, 0.17328069910862268, 0.42518674936057416, -0.5945415015498727, 0.014057866986691734, 0.21667132621016177, 0.2585317218658936, 0.5255238524213176, 0.3465019484112832, -0.27992510651485003, -0.1199581612115937, -0.3791417817271165, 0.251965185354751, -0.3932793620427874, -0.32606655618321084, -0.5611905205097704, 0.13745228504384308, -0.40940385658293366, 0.5428113261222086, 0.13200691027260428, 0.4110371333307409, 0.45689089734910904, -0.1487140973406787, -0.6044863660860134, 0.2765256847376731},
    {0.6482593643216444, -0.41121049138200444, 0.18292413015512213, 0.012735851630783128, 0.7613227892309361, 0.08389719292926162, -0.1535406481290158, 0.7689850636179605, -0.6775866695953862, 0.2230598720326426, 0.06679234377921864, 0.5857506814145399, -0.12106858038625093, 0.5125734200606044, 0.8160127753512553, -0.23302310401060025, 0.6294243665913994, -0.18146307232051193, 0.5851657164261114, -0.35054528015278, 0.2311705130827479, 0.7327058306469515, 0.021359598037863317, -0.08143283608207823, -0.512978370304494, 0.14789722155401586, -0.39685167538238103, 0.2549877086377239, 0.2729021904262262, -1.0952933327032162, -0.47714103280166886, -0.15331905768505985, 0.26726895018919367, 0.31749419938666695, 0.2727367876213588, 0.5919974814011538, -0.5136664364829526, -0.23993651274930056, -0.3292882965738114, 0.025820595636334365, -0.08117125415325938, -0.13465003075258059, 0.05105816429769529, 0.5234117406568509, -0.42300853948354, 0.03352074311150543, 0.4033588691009069, 0.15336847974498374, -0.16250107837637956, 0.30647198808574083, -0.7176277353927951, 0.6965166313401573, -0.12314708137332461, -0.5993556139367935, -0.17408546355891893, -0.089821229193569, -0.6052066612106664, 0.6207257868179451, 0.8897799786434487, -0.3136093466821083, -0.4689005227551151, 0.16589965551407357, -0.24360759938745857, 0.6015630665563716},
    {0.3089200395657785, -0.011479143591426997, 0.6539037436991602, -0.42404710508578414, 0.9018672783062887, -0.12284580386976265, 0.43809741426923676, 0.7563017607659376, 0.24466375862112724, 0.7291614672533285, 0.24187714375513533, 0.37930132769574315, 0.02091112811829848, 0.3410934645443473, 0.6534083315083917, -0.1728490892005555, 0.5695171590125581, -0.22338632045546833, 0.7820102429269179, 0.0671088699255394, 0.24186786515851513, 0.7228193778281915, 0.6579638758633432, 0.03937964293094189, -0.5473637141236293, 0.4041686293447028, -0.2952463715138495, 0.0761157403916738, 0.5376944294495382, -0.42214456271710554, 0.00014416167144816835, 0.11003765881531698, 0.8055046003640253, 0.7036090860990786, 0.6740573554587179, 0.6164202465967652, -0.23779242983821763, 0.18984723813604767, 0.11420723697074148, -0.8265646116820002, 0.5206006176918156, 0.03302277940415138, -0.20811416289187032, 0.8999820199654781, -0.044985894535125005, 0.24626726627749596, 0.7699768774492408, 0.7371389593955522, 0.42598673224477585, 0.7243323734989152, -0.13257725713940705, 0.6894554552880321, 0.30605200851756575, -0.1345771044171757, -0.05779519622895325, 0.4642337751094594, -0.08457911705504587, 0.8845277802322858, 0.43942503587674564, 0.2988410598811668, 0.15220338871521272, 0.03091766950941666, 0.18329003260083082, 0.7529870335119864},
    {0.7456244372739831, -0.5270335190676004, 0.80119634799556, -0.28153129654351955, 0.7055584696829913, 0.2380681404352956, 0.17026902095163593, 0.6829439156944502, -0.327816449671748, 0.5921390792983791, 0.1227412628126829, 0.8713893681412471, -0.3237079142015176, 0.577580417524641, 0.3408025284339261, -0.5894122928777595, 0.8323066432231299, -0.2490265135462921, 0.5229203473275336, 0.09338406731043812, 0.6567265554319143, 0.4781954828986956, 0.47627156402492066, 0.17971763968380564, -0.3683383635586698, 0.6197005358697336, -0.24932808855895627, 0.08183561162515667, 0.9135515688741073, -0.4806656615883864, 0.1464608448659463, 0.14168705236945286, 0.6193557745670063, 0.74532107057534, 0.3689642304021575, 0.8713784526068952, -0.734997720713044, -0.1748765218901894, -0.43567552153440514, -0.43092002966388454, 0.6449423195541528, -0.0660109649183201, -0.25909333084833136, 0.7592903843750656, -0.43094294122712773, -0.11720091390221311, 0.7930826055434657, 0.8030313809424087, 0.33064179396822285, 0.6987306634413346, -0.06296223436384499, 0.7432194900500464, 0.033125991077686476, -0.3060756318413617, 0.31101604024887924, -0.13076040758981589, -0.9079483149760406, 0.8424030178317079, 0.48143787196127885, 0.35901250581149513, -0.39057349339019687, 0.4700094183206465, 0.3187369779029742, 0.822077825126779},
    {0.3953904046766085, -0.6720355520116765, -0.05350647005938194, -0.40989401388736413, 0.3065108729134048, -0.557374476534815, -0.2848007688331911, 0.52997704340816, -0.6460123272957465, 0.1019031103958672, 0.04396610611963911, 0.6334301412802006, -0.6468839453229053, 0.6112680415854361, 0.44682909392872683, -0.7683064893705731, 0.5762150297787183, -0.7708639638039891, 0.5159182980296013, -0.14962474482897611, 0.25415191116799973, 0.5098737455456814, 0.021804613887906776, -0.8019383792448408, -0.8811871781355592, 0.5522035955316184, -0.6470380516408614, -0.15126886096519324, 0.3622315859419647, -0.6538033415869322, -0.743019939199881, -0.3184021974669958, -0.08205641457375464, 0.002236714271397258, -0.09240697031051177, 0.3155952815847615, -0.7424837374530473, -0.4495496826789927, -0.7174133470504921, -0.7075919385918878, -0.08442346392983364, -0.0005615193212583359, -0.36530771965907866, 0.21862011032520196, -0.5275355677968657, -0.5196045112426232, 0.6687352835621543, 0.5436117140528203, -0.40583468690324404, 0.19971086631000964, -0.5201148025911403, 0.6652171001458305, -0.5421296822487311, -0.8800329018999646, -0.7625246656603363, -0.4708916884152738, -0.645977423998177, 0.8174473293557454, 0.13576752533960232, -0.31076127284861577, 0.07735859673484896, 0.15695619683692288, -0.2889600312950422, 0.3444540776636191},
    {0.8473997137184667, 0.0612454311388556, 0.1293471799129792, 0.5099967823740528, 0.41286135854153266, -0.16391956991576892, 0.48768148115228116, 0.4156435956905567, 0.7176529022658188, 0.2788042632312492, 0.01283551866528422, 0.3203034596477362, 0.26588475871275163, 0.4850510087726759, 0.6818906789583012, -0.10989586602914085, 0.5403499193894159, 0.31928172441616326, 0.32992448819684006, 0.32015906853590553, 0.5336769696595483, 0.5442177622683397, 0.722521005689793, 0.24929037369793747, 0.06755059744228768, 0.6482340486766173, 0.36296474597228523, 0.20515127486940143, 0.5567302708999354, 0.19511312353961532, -0.23108801107951654, 0.6303679032560328, 0.35163908850047415, 0.5922518916527385, 0.6523001774583541, 0.5285262885374175, 0.038825083738623783, 0.10641403756603042, 0.10762224776179108, 0.14409980314354823, 0.22128506105740853, 0.4285166806279636, 0.2994103350577806, 0.6501555653431242, -0.28603126278554897, 0.15015688889868894, 0.7092465340996472, 0.6958626370913528, 0.5734522161897607, 0.6882469674304756, 0.8454395164706188, 0.7366864248843477, 0.8531902078073044, -0.0208558828053061, 0.46180238364372334, -2.674383804539833e-06, -0.3939270656011536, 0.8395878343379226, 0.8166509629985005, 0.09366936688980203, 0.03133577971620787, 0.7830397012482638, 0.11420617429030722, 0.906287520358682},
    {0.28724569393151933, -0.38305074280515866, 0.4872827648021257, -0.7145036934410439, 0.7865687716421232, 0.07578176633203605, 0.30768297075931345, 0.7208225390712665, -0.10121244646242826, 0.5068811172397428, 0.26444389168137433, 0.5327339659231347, -0.30492359070800773, 0.9833996918100938, 0.36294888562927985, 0.037618383445959816, 0.8838431679999063, -0.8582137774990197, 0.6466197341623581, 0.31428363619729877, 0.04282819448300629, 0.5915343920813079, 0.300356907423498, -0.6533200575888902, -0.4095517123647631, 0.8071363378296904, -0.2860667249119128, -0.3724338742184742, 0.6849331660775305, -0.5408431823296411, 0.2974583713704605, -0.7217386474621622, 0.6245088450087511, -0.04378881751947298, 0.39834937258016717, 0.5369350274019687, -0.7204262643908407, 0.22663080876968017, -0.17548855844303754, -0.8499093404144875, 0.36870571207584696, -0.02373590277704018, -0.7225108198090687, 0.46146605283962905, 0.18325737701018258, 0.5079868260542801, 0.9271118649815119, 0.4470123993920317, 0.18515961420745244, 0.6783576891104656, -0.39346841511105346, 0.8799653065575663, 0.12299976152807614, -0.11125830740017721, -0.46984046899971593, 0.3126759007913483, -0.2675920760535635, 0.9720487138323852, 0.3674483528186694, 0.17004127314948092, 0.038589103654523976, -0.12803714184574175, 0.19452147262329855, 0.8165222613950058},
    {0.7983822369491034, 0.17981622379378417, 0.22488342879132472, -0.6519212853073524, 0.5729973993323266, 0.30191047511493535, 0.5682778978156566, -0.1789584331304513, 0.383878785845951, -0.015927847273315046, 0.5004379080449952, -0.17576976646597198, 0.09444710065840609, 0.769120749828396, 0.1981304726307198, 0.03144202911430836, 0.3828580303268524, -0.38625822755937694, 0.2644694678091593, 0.2243741765677931, 0.11078358722964946, 0.5207071765599736, 0.4304056476877726, -0.16924557778151464, 0.08775719623531188, 0.365688547536835, 0.07835086040728892, -0.31200159709205894, 0.27688040613693427, -0.3226793669380707, 0.3079717220251951, -0.11705298730372347, 0.5440126569166456, -0.17239846970412595, 0.5071956938009616, 0.5740500284129806, -0.3964573034971838, 0.4654206292151767, 0.3615169155926243, -0.3781896099291091, 0.37589097948021916, 0.4706757251199172, -0.014379901693867143, 0.2719275284338165, 0.2942410501429143, 0.6242170092371078, 0.1212700059953242, 0.5658001062937748, 0.2852918568397445, 0.5727304777789722, 0.7572745644766753, 0.28109412426500846, 0.702517039253894, -0.5769366428506219, 0.1303641968525855, 0.5377550601485153, -0.08378500418160846, 0.4908319028654988, 0.4207988465479263, 0.26224636222247666, 0.3399287164254127, 0.42223848814843495, -0.10041948642896223, 0.6233298643712584},
    {-0.2752751741741329, -0.8563516701677785, 0.35495919090078, -0.6021417613863846, 0.4741972086481364, -0.7310764587332983, -0.9164462409079485, 0.3134486345858663, -0.7618800209425305, 0.07165476657163973, 0.04894742000692967, 0.33934525626796525, -0.6348977023868942, -0.7019793293626984, -0.9026548190050597, -0.7645881165058822, 0.16720232612456812, -0.7979462255603437, 0.34825490601235354, 0.39038410070281016, -0.7794647190919538, 0.34403499527499465, 0.31865772769215084, -0.5688037679612382, -0.9057307100858952, 0.4891374186257327, -0.7653642986129181, -1.1668700063213604, 0.34876043495929165, -0.8779285305315718, -0.11485804915762919, -0.02997691935608498, 0.360787962476008, -0.010238168178679407, -0.5829994280967693, -0.3203188006073231, -0.8659239808348588, -0.5446077244390055, -0.7645573530945977, -1.051093987485396, 0.21305703567883205, -0.9822242680964557, -0.5497463992542866, 0.3053444434788894, -0.3972865822861959, -0.586184829710088, 0.5261864574011537, -0.055111618796859274, -1.2182496425024318, -0.12951273315625617, -0.8274276193016231, 0.5398483121893091, -0.7085912040706177, -1.0855042845176377, -0.5703258085769585, -0.7178528071500166, -0.8351204900678803, 0.4140720212643247, 0.04138540053036621, 0.0032115063532400148, 0.5042219417297693, -0.8466666281531949, 0.04965235652848893, -0.7197388744857139},
    {-0.44341227905092656, -0.736926572445763, 0.7466055234435279, -0.500255587874838, 0.35390120319073476, -0.608655272740217, 0.21453726624997185, 0.6139593726228821, -0.6262195483809166, 0.35766669800975553, 0.031204857411173206, 0.46434374432117437, -0.40062307545316794, 0.17606410588128762, -0.6489093615093158, -0.6197430402459, 0.5881991711025757, -0.5501947544657381, 0.6279650558692081, 0.5160951458767598, -0.5559448009511818, 0.46086140850180946, 0.4551614113694759, -0.42873869751600474, -0.7923245565765643, 0.6816531375423405, -0.5722776363895888, -0.6752783106727637, 0.5824521066177594, -0.5769284936584249, 0.14408383217077697, -0.1801760836196413, 0.920317507998182, 0.33662872815102485, -0.1555061830856191, 0.28593588476256065, -0.36479695430265013, -0.7260888388473761, -0.06638953492723786, -0.8966697184804078, 0.4818145901645259, -0.7714574839446077, -0.9941406399812092, 0.3387109674123502, -0.45907901296227954, -0.6010347955025951, 0.7534821377848704, 0.5113177485757794, -0.7567341934242484, 0.1371287186403188, -0.9488462618845205, 0.4357829401153236, -0.8004090585062779, -0.48715122700310703, -0.27960776323164427, -0.38603960981283153, -0.6442312000350172, 0.8185385530564977, 0.1309405034792958, 0.11786523270208538, 0.2643145193850375, -0.43114486348821995, 0.46050041091172245, -0.4466959286890132},
    {-0.3376507325157438, -0.7283675740312605, 0.16937816151289734, -0.016358293921972404, 0.37062895893488773, -0.9412757809649165, -0.6715372566662803, 0.650014191704683, -0.1996574694306023, 0.2493872032006891, 0.2038391439688234, 0.4002108466521772, -0.5607821928552514, -0.2834437619617601, -0.23844392818437005, -0.7125485980130958, 0.23314476479150628, -0.4314904487368228, 0.4676956525487678, 0.40913089056402535, -0.6189150016702128, 0.4531865040638957, 0.3727442925926514, -0.37290708977944637, -0.8754631592726275, 0.21299556566404837, -0.7932540515428098, -0.6513732561485631, 0.18170010211123325, -0.95145366111636, -0.15203139885551095, 0.18428356964611337, 0.6982315602875189, 0.19244914117704834, -0.4636665568437355, -0.30512778208552377, 0.29517689828352006, -0.5754585564850194, 0.07209232406457332, -0.4571470950408422, 0.46620720014653194, -0.7623892150770667, -0.6382331565249189, 0.2838722461771675, -0.4781286103987146, -0.24527283185992457, 0.6585032501437197, 0.06374246581031823, -0.4009708974218028, 0.1503449417634548, -0.32461069719225827, 0.47889449320722954, -0.2966543433120646, -0.38191020993349195, 0.06004861901091009, -0.24595193833712034, -0.2878738192776985, 0.534203313987899, 0.12789766816295345, 0.08875421631637888, 0.2964634180222312, -0.21483120376743312, 0.3554459115042232, -0.7579119532287238},
    {-0.11890314355059736, -0.8020724695396757, 0.10366134708451401, -0.09089946490705383, 0.7419409021319588, -0.7381956274660771, 0.2386571297409513, 0.39761004123902244, 0.003390013528520897, 0.6499349193957606, -0.5282513365770192, 0.2180102464404659, -0.06287477952935461, -0.6748670217730793, -0.8295179394931084, -0.6726752572214579, 0.211979728502321, -0.2881585702421084, 0.6685577138923555, 0.10742108950314455, -0.6151327479414985, 0.21703689051749675, 0.6616097721310057, 0.12995279627033016, -0.8813022311618163, 0.6866950557449106, -0.13596853825406321, 0.1673930826242649, 0.3636504597644932, 0.21285823256500103, -0.11564466913052444, -0.07586953445253092, 0.5391528974226059, 0.3223840996168899, 0.41833052259856984, 0.220964081983685, -0.23947502855883485, -0.801663488464205, -0.37259528446627926, -0.8409038453279167, 0.2387530969138698, -0.6630147282984757, -0.5434787890536554, -0.18551499827276646, -0.30315621836465906, -0.16018991382064388, 0.4350097721049405, -0.3688125574395011, -0.19745889058195631, -0.09326669617354166, -0.021859718578576676, 0.41001415815745546, 0.2548796647759468, -0.27073973793474104, 0.10080790404083682, 0.3746480781183893, -0.14229022468704852, 0.5770031524896576, 0.2497523737003767, -0.3041249189086669, -0.11650502707582881, -0.1019179214304538, 0.4986071758347991, -0.8472747216214869},
    {0.17487932158991662, -0.1541725300107763, 0.4396735361331951, 0.2010589554315195, 0.39271695078418867, -0.42348456711406385, 0.05367487838639634, 0.6370840752017435, -0.232060227882522, 0.5113776006930567, 0.13546362435771117, 0.6984556913018679, -0.36505447142506453, -0.03949998478359716, 0.0010437281083364495, -0.48848688470576135, 0.22547868521166511, 0.3309209618749854, 0.2691717268949723, 0.39170207559470627, -0.10881710579039848, 0.31350808419058845, 0.3751584244901732, -0.0997664380752196, -0.5664088555385222, 0.5012908102777834, 0.0283657194354158, -0.5174370137582552, 0.20321240796142886, -0.961571410453055, 0.1897095130521156, -0.2292160440861027, 0.8258373178399095, 0.6518220601091391, -0.06982374674581672, 0.9412564562104313, -0.2659252645876459, -0.4174246839164738, -0.01918894063549695, -0.6380481462159341, 0.1672512346257831, -0.6154807976872856, -0.4171368824240998, 0.33366510141611855, -0.517220708630036, -0.3163469117324155, 0.39605277736371175, 0.4979072601923169, -0.4119871635520588, 0.10990934682278376, -0.15976164639162382, 0.7221264172294645, -0.3240499427497404, 0.15232171656980906, 0.7365805738360329, 0.16975296263116704, -0.36423862902400755, 0.5229592696395586, 0.3571382497338609, -0.5001707056710011, -0.14818359582399127, -0.17745635701705498, 0.5544631115520843, 0.13604624467922716},
    {0.0008058015965662997, -0.4604505452345203, 0.27906871049595083, 0.5273912453601779, 0.4351476243174544, -0.08463724090297718, -0.012524764634843205, 0.614099413249568, 0.15509821658880982, 0.2410348801560558, -0.7308747770501617, 0.1555367719179915, -0.19270207971708253, -0.030825766812181767, -0.4852368476525439, -0.3770875007210682, 0.5029484799955575, 0.009772933027587674, 0.5554970572678896, 0.2823677597872113, -0.07406388911457151, 0.5697406622633356, 0.4321235601502218, -0.1188077387654229, -0.8441881923750846, 0.5039318493073289, 0.1077840755592269, -0.4503594440649033, 0.4381967071360634, -0.3750158286364207, -0.19485203991052885, 0.02666765960356301, 0.6617697665526298, 0.45169653443649527, -0.5831615426936113, -0.06621199797570271, 0.12145231921603085, 0.12922641071288374, -0.30270891409644846, -0.4322048121712796, -0.053478605455710274, -0.8605070056516256, -0.25593371004140525, -0.13925363953634376, -0.46801176430282143, -0.46672635909425836, 0.49780243779824673, 0.3101001190207075, -0.27921418436202156, 0.18116322545443483, -0.022174273937518744, 0.8722494380446322, -0.5032532151689593, -0.38813981992694024, 0.23509487184215283, -0.2865822214162649, -0.5945296433908479, 0.4191965534182488, 0.027951423256001286, 0.05488389241413724, -0.5540930983302154, 0.06809844154842282, 0.5234274953894966, -0.307887198091134},
    {-0.008106969679777207, -0.3509280452778631, -0.16975563641970914, -0.15999537880541345, -0.027867809013038335, -0.24174918061715808, 0.17137433277315225, 0.23390707496318572, 0.4324468678121984, 0.019747844629606454, -0.4953747247209424, 0.11038230213196716, -0.04706663290772175, -0.3966200883057016, -0.6200464503560456, -0.8306362361266508, -0.09318953640651376, 0.2852672218942586, 0.04277269078830687, 0.09829465618413454, -0.8319682027229728, 0.6775081241345776, 0.26000452393341394, -0.7137658079476414, -0.6123915388547921, 0.646608703336957, 0.4175481697317556, -0.09571329395242069, 0.5289391126805593, -0.25891613088033016, -0.11637786353501456, 0.4444054663781388, 0.7842722145145279, 0.2608703677359061, 0.21109850130866356, 0.44990165383334546, 0.11168243847737248, -0.1451774083988823, -0.08340071057099292, -0.32246503079640976, 0.3978128830760312, -0.2383884173925584, -0.14196933042738355, 0.3720100518261361, -0.27146674092146145, 0.29169935027524474, 0.46913545086890907, 0.49234679819718113, -0.3442614867767549, 0.5421962184942679, 0.06608951571121385, 0.15142012972899857, 0.4303991110474071, -0.16781082446579756, 0.2376754459434285, -0.18159647095370912, 0.4268293715325675, 0.10897305613697414, 0.06102416304160742, 0.204630762445358, -0.19891886088242244, 0.15328863501099643, 0.15319139825660924, 0.03657563370500973},
    {-0.751956016687242, 0.1659231438680262, 0.39216170835409847, -0.04278129510505123, 0.4740832399449081, 0.0935728155128448, 0.5178844318714184, -0.008176117728611015, 0.3220500894385709, -0.025955881900388934, 0.4011894543918912, 0.12194325647332084, 0.11606902415233278, 0.1376573875765599, -0.0048166873887723, -0.8590396962872786, 0.45664331983960116, -0.18034569982466253, 0.4242970073548411, 0.510438629398967, -0.41989616081015, -0.12558673017859676, 0.5818777718107467, 0.011619268967913465, -0.17676822915054438, 0.03584354025338494, 0.3076557321747671, -0.09774322031448152, 0.06415046337562527, -0.3619643829142344, -0.18712954793115932, -0.11362048585018374, 0.5847862187727045, 0.24757160735585704, 0.19714347236087884, 0.46230476682021265, -0.3226631694956476, 0.22034504012125947, 0.28478492975996667, 0.015292237766045663, 0.00388312538300686, 0.6168366737274695, -0.05425959258850332, -0.16599960122495555, 0.2535781905739322, 0.254741173973667, 0.49598392076994885, 0.33681154245165734, 0.23402225963873816, -0.15238335051038893, -0.15926130783193357, 0.2412098235206159, -0.33898208734679397, -0.2094310469101829, -0.007636617891182907, 0.6011394098668638, -0.15247544606155577, 0.26191648354427594, 0.2043573902232308, -0.2752303684544482, 0.5972275826608695, -0.3639116682523565, 0.17804744802655167, -0.16689368839471946},
    {0.050200384857120625, -0.5371899854847904, -0.24479298535152874, -0.44118065413723606, 0.4937933941019633, -0.2042453351411877, 0.02829766373386963, 0.17786677976840193, -0.3399072747061398, 0.2512063609777586, 0.5158859616606714, 0.10771412471096424, -0.5806725814152459, 0.027346241333733267, -0.6368637632682048, 0.0877744821428734, 0.05445738595957823, 0.20523850118397072, 0.7037290986224642, -0.31993756491829206, -0.49067128609352856, 0.2738699317966626, 0.34644271734072096, 0.028198126171348578, -0.6323808687834224, 0.46307086089502103, -0.270809487266255, 0.12192684190233308, 0.26066115257495714, 0.04656896950752017, 0.1973043516345091, -0.2188682194673839, 0.525518548306951, 0.6088228714327526, 0.30856532292223265, 0.4626333977931837, -0.6294134863643572, -0.3737642220484075, 0.13065441215895293, -0.5607685565643455, 0.46334331626821385, -0.4377937971494449, -0.5002226659492114, 0.4636831040814113, 0.29753762048181126, -0.021393318811250738, 0.07514454051163476, 0.4429925204997358, 0.1387531828609116, -0.10737141082776126, -0.3040708226503526, 0.42058128529678884, -0.4331360551328194, -0.34035766954371777, 0.18503094074728385, 0.447634786574694, -0.22529039736486586, 0.593843965976606, 0.1465231264680327, 0.4878480831599358, 0.26070457524300383, -0.3864316990632567, 0.3519103421670181, -0.18487394264350118},
    {0.5758393805359827, -0.1473889353082186, 0.007784748039189337, 0.07079220722752366, -0.02287956692481646, -0.5100127871062479, 0.2717193066001786, 0.4987898136892932, -0.39923134213930334, 0.20069762679112396, -0.23430592817654755, -0.11046348639305559, -0.33602689835820454, -0.3603563670631595, 0.4520999604018949, -0.5104307235742984, 0.613749728436776, 0.21596150773662268, 0.37191244189588996, 0.048967287962183886, -0.562689672529883, 0.16874327513435797, 0.009784618968596124, 0.09159336175079968, -0.2283470846575049, 0.46491073647337516, -0.3195804923166618, -0.34663443263036386, 0.5280121414929009, -0.07492516452230107, -0.5021872740434791, 0.26465567918802413, 0.08446618326022878, 0.028175567591447636, 0.035884319767867434, -0.12543204262124627, -0.17004308218694356, -0.4447641372069602, 0.0030172196978532307, 0.012148471872228431, 0.21047103998498048, -0.3221466864575216, -0.01501397751662429, -0.135437957748207, -0.0994102344181154, -0.04497471430195598, 0.04265293433211094, 0.18564615710329102, -0.024078547047083756, -0.5054876371035266, -0.30196154247815754, -0.47597342714971935, -0.26351641388866925, -0.7387266285210057, 0.29634579809828343, 0.005454357290669216, -0.5811672507738569, 0.311763180678694, 0.10704613481082532, -0.4537301521164331, 0.2226705758793641, -0.14474657592753706, 0.726690165926195, 0.043365717366831875},
    {-0.18657686378922472, -0.051183601997925696, -0.26421500796418546, 0.6247600678069711, 0.011395855518106367, -0.569734568648908, 0.22169682051864886, 0.09555318271540097, 0.41297511937301296, 0.18457287029166128, 0.10205533336668555, -0.053210803442009104, 0.11379386294142167, -0.4541441735259356, 0.09685807922421505, -0.5893809580731443, 0.054659894899229684, -0.2664243827792721, 0.14761380047987155, 0.32830752322117684, -0.029069475158763094, -0.1455364828057909, -0.12870789004802152, -0.05976390665534118, -0.3228688885730381, 0.688170316828471, -0.2698264619992229, -0.20716394498788715, 0.32372252594481843, -0.20314489744174963, 0.10643699651247493, 0.2876996298837761, 0.0643335720303326, -0.5521495301178919, 0.308335657159282, -0.5501421684647461, -0.19337612965496082, -0.27366371630813313, -0.2892552059753559, 0.14030343333096892, 0.6102233147177226, -0.27468223644153195, -0.2253156000132869, -0.15939923202708442, 0.04818504818267313, 0.09087236645029385, 0.3602316295119563, -0.05964454889527219, 0.09075811856684868, -0.004238638697044818, 0.2731717548650072, 0.16545146592761298, -0.48236225739430066, 0.3140820003178238, 0.2992230400641181, 0.004250983662889672, 0.30627866991447883, 0.16199951235059068, 0.26910373496705914, -0.15121869706948157, 0.13901881562876758, -0.23073575684325914, 0.09477012052896897, -0.2785552710542801},
    {0.24148430495273235, -0.25057200587955775, -0.14949039007204565, -0.0038151701211488437, 0.4868830172596177, 0.1850281910876264, 0.10609931570325407, 0.4941318893232191, -0.048608921862026436, 0.44291268270246975, -0.2570259083088826, -0.3294114691142642, -0.41224399872042, 0.3221377189143155, 0.35310691448096454, -0.22133544692912813, 0.32253357300990226, -0.15013038208507964, 0.6189220727427144, 0.17326882804543942, 0.3796617222455828, -0.2394200286770666, 0.24562812640358916, 0.5694864467288432, -0.48280001277270584, 0.15126010283614788, 0.03909431443460545, 0.026272482202436234, 0.13292631474049268, 0.17605472096481153, -0.12726520414505443, -0.6777023416133457, 0.15119069890714906, 0.25486511276624585, 0.41687806080316614, 0.16080325862792538, 0.053622357189420836, 0.45828554454663556, 0.17294440917167608, 0.10853101177137663, 0.24228758119105503, -0.215921885354927, 0.3324598665874723, 0.16106552585969747, -0.07638721948727435, 0.04936770003616344, 0.5531252772464264, -0.1494384071172275, -0.5916321712152026, -0.3861401435481355, 0.17369807173553337, 0.17903106027053356, -0.6402537569522723, -0.40864308875247257, 0.19764888405786485, 0.2402328828215095, -0.03215471620799481, 0.36554746982366537, 0.894892047967459, -0.7553665843579742, -0.4890650714798834, -0.17134860153389056, -0.5732996341933245, 0.13130102722008932},
    {-0.28756898470015224, -0.2710329549000725, 0.1159283336386634, 0.31897038887648266, 0.06507386163638289, 0.07719691365820978, 0.4476369710012414, 0.5518878406232625, 0.5004187819216405, 0.7991508528457306, 0.52261645371425, 0.52957732978816, 0.26455184688262434, -0.2951300057419245, 0.21436311909137826, 0.11081829186594429, 0.17096999070007243, -0.3863222597042121, 0.724264333963503, 0.48743151766667736, -0.1552453303315347, 0.13937580408752379, 0.6922568439166696, 0.4576823901211433, -0.18861066188508002, 0.09524285420336023, -0.38487115081323026, 0.2692712558612357, 0.4101448071980926, -0.30821616138350005, -0.014608181325384743, -0.2686566220674706, 0.09871520312302327, -0.039654398562120864, -0.14567007536909524, -0.3193254817843663, -0.35689174132509194, -0.07080287299662558, 0.09846720676915456, -0.4120635807122305, -0.004163004606632938, 0.5738703625112827, 0.1133806853907829, 0.20652083396415746, -0.14748009893689307, 0.2597069467538516, 0.4013538178676001, 0.2697394959268571, -0.03784360172932715, 0.4568005414494265, -0.06263288335898998, 0.08613744180412734, -0.05650822522473287, 0.36152385496296974, -0.6947158443350063, 0.6597876620831038, 0.29093763048780047, 0.19755219235694016, -0.3960514384933783, -0.02576716964623803, 0.30814743672757766, -0.7683125714491195, 0.05080046653714678, 0.2044686973063974},
    {-0.22234513627892855, -0.7098262436659593, 0.0702177444181491, -0.11223357434837218, -0.27727876753281766, -0.267336328878525, -0.22321198679792853, 0.3058092188912407, 0.03559224466047781, -0.20008499706938512, -0.3987404125298066, 0.4995893484230409, -0.6180793968881345, -0.5150539321636036, -0.19263895599250966, -0.22405364140740178, 0.10660596096553894, -0.27855660441090235, 0.1871780625524124, 0.2731868529565501, -0.2852142639417923, 0.09934848234918293, 0.1446298455162485, 0.40537406928043807, -0.09092952673577269, 0.0022863829588551502, -0.38155537792665145, 0.40297425217494354, 0.17300840719886762, -0.5097208308628363, 0.6769670642610358, 0.09840708542030346, 0.1249968468730633, -0.2909698709857354, 0.5348571794777933, 0.3851996283981804, -0.23130750841303843, -0.4914389494600914, 0.07203734688703142, 0.13073125438965094, 0.2081994044838497, -0.17661614226086736, -0.35931602895061193, 0.5605521089119383, 0.18129416778399804, 0.4873549078272938, 0.18229340724590778, 0.06615293307917157, 0.5191657607432696, -0.22952033287194382, -0.600542712334907, 0.18896087072465595, -0.021309878385053868, -0.2831430184349367, 0.33584780595150643, 0.190541523078447, -0.023803421129830093, 0.20864104959018812, 0.494680009136161, 0.044759397754690664, -0.6451870141449527, -0.5376397022861206, 0.44766814340894195, -0.5229835696481796},
    {0.49333748194180616, -0.031221315367071154, 0.761897828352794, 0.1514189881327171, 0.37884184313135094, 0.1915730255917923, 0.3308370975165145, 0.344682143716421, 0.5249054708294753, 0.2822631782368776, 0.23989815913422946, -0.18789121705612868, 0.007546835638647593, 0.09408060742072973, -0.2648278995731467, 0.36744279897007853, 0.07725003994287784, 0.48584489217230725, -0.17524324082061926, 0.203332791085594, 0.26788008968699023, -0.22296997648144382, 0.32472023904575703, 0.5008586858516508, 0.19665342213401568, 0.38120606052659994, -0.30093203821417397, 0.37039012896644763, 0.3785326304600668, 0.1266418944011105, 0.25691436663134665, -0.66223569104544, 0.7565438995824875, 0.2560592367597587, 0.45179403075095936, 0.48685164162318617, -0.1250848968644851, -0.18236774117230117, -0.02458366464341815, 0.12272891550968502, 0.025237673724433016, -0.21394904540048476, 0.45073429912132623, -0.17696583370697594, 0.43098848784432436, -0.12512353334566512, 0.09694333118100153, -0.19663982886269277, 0.27663714164082814, 0.7721988585223603, -0.28636259378211765, 0.3922400331771637, 0.23926538292347546, 0.022775890948315294, 0.3790083480007575, 0.09968139896761494, -0.21797315728109892, 0.20747996588776443, 0.7441055144878773, 0.16663702579137785, -0.3117017006292693, 0.3227910838203926, -0.01028704986986654, -0.30338311523420464},
    {-0.03407169207105651, -0.20374788186582593, 0.342500405272065, -0.32611837329646537, 0.3042355946009448, -0.5836013040708693, -0.2756294376244816, 0.42916011874518306, -0.20218086006211544, 0.3261240758665333, 0.006777449983272578, 0.8865709395545255, 0.2828885983231973, 0.03105944398561537, -0.310268091799765, -0.20655638335714852, 0.3676143881241264, -0.26402245470409236, 0.3222720517024816, 0.37436746447817915, 0.46624270190967165, 0.17698638575643083, 0.2266424014200811, -0.22007492288219896, -0.39786532492430654, 0.7136141353255282, 0.10658720444149208, -0.596496590009724, 0.012727686279840972, -0.6352176583203755, -0.6354115077761713, -0.4411774252095992, 0.006717820048187727, 0.12508427256934906, 0.05981623950376939, 0.4022664084996326, -0.39125586273227636, -0.13638059134172578, -0.17286398443148085, 0.008706968055334522, 0.470396861637609, -0.12224349746069246, 0.006021957349711797, 0.056174204125521196, -0.5840629793909727, -0.3045600566325355, -0.3486160293886079, -0.0037173596519113916, -0.038484917220730996, -0.3708500189364717, -0.2558020293989334, 0.38851649033526847, 0.2761223157609813, -0.16935176877848201, 0.10437685649259754, 0.17058340224560645, 0.06797739141028347, 0.2980413241282898, 0.44467832527184853, 0.22734791897684242, -0.5853123254115207, -0.4159494968854073, 0.12891293263440812, 0.39300238741471055},
    {-0.5428081942270478, -0.22954635818837185, 0.1714397739660885, -0.27972319305536, 0.06777856750114744, 0.462852645173888, -0.021440808203256022, 0.26793249150038057, 0.009759219634491598, 0.24110230715312123, 0.34583820614446475, -0.008923182885242506, 0.21052983152959887, -0.15979364587059722, 0.14522087484576943, -0.08888631007726794, 0.23695313819710964, 0.17481597696191506, -0.2197759362851744, 0.45710959260295075, -0.11462383454446767, -0.082307055209861, 0.3741531329063724, -0.2021724613342992, -0.037989510360922366, -0.04784744552145376, -0.3389267895461281, -0.158561933972737, -0.17075767624904634, -0.20947399800429106, 0.1546173742019325, 0.07864824949985427, -0.1677374606045747, 0.1325879059633507, 0.030437097806903537, -0.42587267792639744, -0.44191218407214644, -0.1573883248148576, -0.29787894245164853, -0.43993582142969334, 0.37035780685448644, -0.05878612386503038, -0.42166435596505236, -0.5814022493475786, -0.19837785716645143, 0.1919825664937214, -0.5439827575092756, -0.23020003506187034, 0.6517264918720673, -0.6310124386966647, 0.4622861506143652, -0.019434841383858276, 0.13950605791289677, -0.08041045079816343, 0.004396526606011583, 0.25655462287755965, 0.46129865448188595, 0.29384672113263194, -0.3068414475482006, 0.04510196357947439, -0.08049198752942509, 0.06364811539517862, 0.3689886878514694, 0.02354478779065913},
    {0.1868905717424888, -0.36836433834586074, 0.1121979024490488, 0.505128444266568, 0.12428585790752884, -0.527532475212603, 0.5146487841461851, 0.34848668086574663, 0.21217757182607158, 0.1878834416059961, -0.13748289025691515, 0.14571805311984587, 0.41801973467016657, -0.20486561472840717, 0.24082642591358971, -0.11253907479919657, -0.37770108927494134, 0.4032071839383602, -0.36766299320896706, 0.08742205824265793, 0.06825465510860583, -0.22378770463876535, 0.6042129310633079, 0.2528073212210746, -0.17297268237294328, 0.003028439768862282, 0.09232555147834155, -0.26264983274265785, 0.2838740464079076, -0.19471418027844883, 0.27402029424050706, 0.29939066229972594, -0.13532484652856672, 0.19866586079862059, -0.03986495928035799, -0.6740878922468755, 0.046554573794768954, 0.09625488350084101, 0.16602231810317822, -0.4074492596890237, 0.7032020026501621, -0.35822818664119105, -0.23855028403060144, -0.22667823942077764, -0.27984363756331015, -0.15715834585187427, 0.18901671125828545, -0.07325325957702014, 0.43870308104154776, -0.33280599508752723, -0.1914365390895083, 0.004308830143448171, 0.4516502846671896, 0.04949839624104199, -0.28683588255558934, -0.15462675650049132, -0.23243104609027657, 0.1501998358963362, -0.15110592590378005, 0.10855969425264134, -0.16813745328495716, -0.694180579533291, 0.2850717978311998, -0.32152037906538056},
    {-0.5710344749972766, 0.46727706153443266, -0.12532413233158274, 0.2992759325175029, -0.09883315854920821, 0.03132263166565008, -0.002059988321102209, 0.6354383957847077, 0.051738830746646626, 0.3278176018641207, -0.07889623059274706, -0.006190974380757669, 0.3544679815807145, -0.2360562863820622, 0.24134963755937322, -0.09006423773121024, -0.5813464905988437, 0.705487343018085, 0.19421097846211344, -0.21655711136614847, 0.44555681463822766, -0.3690349994240394, 0.15301355307631742, 0.21738794833033956, 0.2854667211820836, -0.08249437569408385, -0.33854192211377987, -0.15153864018982155, 0.5179899220972032, 0.10622471597849438, -0.02544191621216467, 0.3875235830598341, 0.260797765761937, 0.21438590801792023, -0.02976082760837071, -0.19685467655933672, 0.10527885432311815, 0.046111936046161456, 0.026369730239058826, -0.173474883613263, 0.5069243573407441, 0.09129797487226378, 0.4335806978810468, -0.5913584730806204, 0.28023067162623116, -0.001924843281003289, 0.2940561057543902, 0.2603582274452717, -0.02598479655563016, -0.3104520729511274, 0.7455743384070858, -0.2011666135131048, 0.21322480496986668, -0.27877494568657335, 0.2300124869507835, 0.32296366715846797, 0.7094101465700514, -0.05182952780966212, -0.0315356681980881, -0.08696482055780301, -0.38928174494334317, -0.14025507300406106, -0.2790611180891874, -0.07189658012134242},
    {0.008239970662510683, -0.04566611842847517, -0.2193514149322464, 0.26243248275029135, 0.2101247122361889, 0.494283450514988, 0.3550974386044356, 0.5294728023331078, -0.5503415074395142, 0.2591771254964936, -0.7120221159093183, 0.5280276354817505, 0.4922631125463884, -0.19900633518099903, 0.1551656198079361, 0.25692441330421345, 0.19296993131089937, 0.6070881971824135, -0.023704516748488558, 0.17159597132823204, 0.4861285684692161, -0.3800702831759946, -0.03395089503280856, 0.03116797860146226, 0.02522951742349723, -0.14618851251482964, 0.34994793890231707, 0.576537916270402, 0.1936152356635385, 0.12383337289039617, 0.5434358880492199, 0.48986325541602016, -0.4904289434241008, 0.019096239332470233, 0.11413679114490315, -0.598278942668239, -0.1182868228214144, 0.2368700226810521, 0.051587024886002135, 0.1528865621305534, 0.19668645376251875, -0.15002114101425448, -0.46170137413997697, 0.4958130038257917, 0.5062130516857201, -0.44678428847586066, 0.17903214655583283, -0.06868290547563777, 0.09210293945025763, 0.4310634437835144, 0.6051438948907648, 0.11634386738217949, 0.13443861654413075, 0.37374785548355155, 0.4034575813639866, 0.12025180182195519, -0.049574591243244016, -0.21316897530137188, 0.3265175780735029, 0.32898554483001147, -0.24914695155400196, -0.05294521182617596, 0.3108621645256421, -0.31006825629707613},
    {-0.19582017344908753, -0.12151289023975942, 0.7094881775649206, 0.2035517970232095, 0.735444652016008, 0.874008395589589, 0.8588436658013205, 0.27854957187235024, 0.24341154772557685, 0.3902292923037621, -0.3403509861169641, -0.1210064112861333, 0.24227086674374512, 0.21509255669058924, -0.29091029842994537, 0.42341303649759915, -0.09617438643368094, 0.4358089029771324, -0.037165139121216585, -0.018983656740386417, 0.2648823375444069, -0.35070876446089216, 0.1149242744938277, 0.4358900064577914, -0.5504035207160146, 0.08939309458761006, 0.7280278219974139, 0.12569122159187127, 0.13321527314426734, 0.3104765963138383, 0.5618508007119484, -0.5912232069345601, -0.5864052476247605, 0.2705768030113965, 0.49569641016276, -0.12899940891728617, 0.5105915003269016, 0.08057867224299801, 0.21582377229050764, 0.025802619617535914, 0.29085101410045566, 0.005756268340835906, -0.34064124625631415, -0.22095152681134092, -0.47342248560030004, 0.2658364379460828, -0.5516298600267836, 0.3015706482962562, 0.8688697726229211, -0.34500651256861115, 0.31816350559469975, 0.06716769379178017, 0.6281918772397874, 0.27557296843918416, 0.26590202306029403, -0.08837692758635204, 0.16176068676819788, 0.09906292885943949, -0.11278402725837854, 0.1869197333168559, -0.3888163805108768, -0.0071160315468608215, 0.2537438375612721, 0.5199046082218715},
    {0.2750174536024585, -0.030327766316120316, -0.2614171317268974, -0.01250254083859185, 0.7654312092966424, 0.11701714352613643, 0.5426119471376101, 0.6493367496289466, -0.0794662252697645, 0.517014919643634, -0.16704740726049014, 0.25315864134602956, 0.3457135574535821, 0.22078056679642535, -0.05571870199695004, 0.06564331800620311, -0.23165828746674846, -0.05779320849097455, 0.0568803463705816, -0.870334158220102, 0.016128054445392403, 0.22324545074505867, 0.41355529974740496, 0.16480050138728825, -0.386366258334805, -0.31955741306906393, 0.26061668478164507, 0.39390028358932866, -0.3839764469691991, 0.3404111826041582, 0.5229202821436766, -0.23446948504466067, 0.5734400960248416, -0.022419666625705745, -0.29752832352841196, -0.2512407705107305, 0.24918959860785936, 0.2730466630591903, 0.032497119117313025, -0.342020191501961, 0.48286930695244534, -0.7082222964732584, 0.12291508833530199, 0.14273726534283343, 0.37238164791936607, 0.18619514426800732, 0.530402784726277, 0.05795675451148811, -0.026557860518882995, 0.16815081624591968, -0.09732245098270789, 0.23212498483527944, 0.16879902134998634, 0.16310497648974456, 0.5345045940759334, 0.573860504675829, 0.21554469606196927, -0.08220361157241872, -0.28874025583064805, -0.24488431957571144, -0.045326738350931935, -0.5468955506587976, 0.7224248624189341, -0.269226677940389},
    {-0.17146932977924326, -0.023289523912309484, 0.10046967241029546, -0.017446898671600784, 0.35824946480404557, 0.05358891234506533, 0.6000403926524552, 0.500747911722539, 0.500087085075119, 0.5762442640847076, -0.020415530860914438, 0.21303348342420855, -0.2066009057041507, 0.36949998965766173, 0.30305708691511474, 0.18958319756671724, 0.35706361681358617, 0.08327317563799634, -0.006028278285661036, 0.054722690970541325, 0.06640846394706226, -0.1106490665406048, -0.03641867222175895, 0.4209598769339275, 0.08944915688106199, 0.4067275070908862, 0.42970134275937805, -0.2322838828598273, 0.27024496672405146, -0.5239560615329381, -0.045766596720665915, -0.14521749793758276, 0.8074912048224978, -0.13951921005305118, 0.5181921467139864, -0.6257547697629607, 0.04676275258754887, -0.2849620160248772, 0.0037369017868678143, -0.5066531272139099, 0.26504985573783224, 0.1465729057148487, -0.15658680875308256, -0.2649053206548505, 0.04352601452915608, 0.16131868238147717, 0.3460046466928192, 0.4177067139727688, 0.3079089214907671, 0.19251111055111578, 0.15773400712964897, -0.06744451109598575, -0.1321651888863102, 0.06941771059008281, 0.036299720178086, 0.4674727968094976, -0.162020143448676, 0.4649722827045651, -0.14806924273660896, -0.1480752405982028, -0.10065898449756165, -0.38554542448718404, 0.22034243235194115, -0.22337220003477182},
    {0.026262902674977686, -0.3060832825326228, 0.4779597537012489, -0.073023833337351, 0.20253038266772838, -0.3500880777381397, 0.4494930231835694, -0.4312185132635027, -0.4226640110785258, 0.15429199211526426, -0.007740473288283286, -0.14160463124636405, -0.517633310497862, 0.3762716826117154, -0.35304110426548535, 0.23182916396475842, 0.6576086532803253, -0.06850069962401686, -0.20684111819451895, -0.38007201019599846, -0.7217337120808904, -0.45823560861613444, -0.5556079267646957, -0.30963315655029094, 0.10480249527887986, 0.9706807964583785, -0.417161306355786, -0.4263706984967611, 0.12789557032044266, -0.06640589171782563, -0.3934028953078803, -0.5626069408911663, 0.48587910817578384, 0.4584641182546174, -0.511024615941219, 0.420257967355157, 0.10742120229857786, -0.27997120798642594, -0.22901003508327777, 0.27078299403888345, -0.30738893905698234, 0.31956318912859616, 0.1167059728519282, -0.32277225218573974, -0.04948972844446124, 0.3868329140756321, -0.1386695358101973, -0.1598012648639702, -0.039442233072679855, 0.3444452370609849, 0.257582950714167, 0.23896702464876693, -0.6422305283289795, -0.5322648275509064, -0.30664971484104336, -0.6939320479382757, 0.007828009801439993, 0.33119149862904523, 0.23663375137593817, -0.5602731199990054, -0.6108067413628013, 0.22111134092323984, 0.1321181076089702, -0.029759748331270732},
    {-0.1755370121608115, 0.053356367996856266, -0.1677136997236408, -0.2926027558133696, 0.6215050402866185, -0.005475798364346703, -0.0984500893501575, -0.06386013452887544, 0.18923950687105062, -0.2161930713154995, -0.11611998654723817, -0.030236817967480227, -0.2506817269597157, 0.10756875212895271, -0.4715254628007853, -0.049644384561113974, 0.3206477116076123, 0.1447738522202057, -0.1300662118663863, -0.04100980303932565, -0.3620601357296164, 0.18674921867223396, -0.15484517416533503, -0.10376390181039839, -0.40260354941858806, -0.5453299113931116, -0.3300264762129081, 0.5275468320104141, -0.22647437379651109, 0.2811373736491161, 0.3056185066784534, -0.701975110835866, 0.10874511205933272, -0.5081956472735731, -0.24147749507016844, -0.07950150819581038, -0.638170734213194, 0.0348048237915069, 0.24679759499476614, -0.12180594765419282, -0.32808586280911944, -0.0952254016194379, -0.1293519301242612, 0.24516394699165198, -0.28316197434479373, 0.3825179073238078, 0.4727812405966213, 0.2635590147753785, 0.18548535768644817, -0.07799897969623769, 0.22080425577828042, 0.02731908771504494, -0.44551138995341805, -0.19293590893475449, -0.40563476775670076, 0.03893272917599192, 0.27675744452377743, -0.12940868570246875, 0.0005164905290931163, -0.03253499115736869, 0.30686664532275304, 0.02879636476028761, 0.06776930802054422, -0.1672308397784276},
    {-0.2481145586696066, -0.06944822626202193, 0.33243518720269566, -0.15700134023011436, -0.19579722672178462, -0.04528981779624793, 0.2955375585591854, 0.30876776271308787, 0.3706342976026486, 0.3961208929120545, 0.14794518659568665, -0.2298312564781933, 0.09618918316558948, 0.1646041618398124, 0.05072876076911986, 0.12757962064316383, 0.57083548036843, -0.6022272359513027, 0.5252713959332258, 0.08062657592576288, -0.11765141564113919, -0.3951708867517991, -0.04602085909670204, 0.0837184383013315, 0.29370547273739994, 0.7224682477083815, 0.5035497555780256, -0.20758983488028918, 0.4019396512190366, -0.11306434049222579, 0.5367997167558003, 0.27318798837136893, -0.24388690878861732, 0.5221768314698368, 0.12753118409263306, -0.24941148134748592, -0.14960946339099448, 0.9507576561522117, -0.0952884835260474, -0.38313538743869474, -0.021764350517672386, -0.12354756766377331, 0.3773225039230874, 0.0065832318113082785, 0.007796719361997634, 0.24109511653223686, 0.33010889530882853, 0.0760545887153523, 0.7378348717696095, -0.5531081044380466, 0.2882876444488088, 0.25544187407193386, -0.17173200160126686, 0.3555861672748162, 0.3006339446407179, 0.5709244709372743, 0.36219456465225397, 0.16101613311607033, 0.28657301213412306, -0.026168009603917415, 0.20675648592202578, 0.22023999252933557, -0.10794917392882084, 0.08534607949783371},
    {0.0505138681302477, 0.14475351208256435, -0.017004949860676032, -0.29777623887825677, -0.10126393024257696, -0.016068471467208197, -0.15846745474631374, -0.39587185739530534, 0.07953223315379343, -0.4368911307917828, 0.30338329263050207, 0.23675928793544573, -0.2602025425694547, 0.26561741662800953, -0.4225030179937117, 0.14308245718921392, 0.3078177109465062, -0.06923975118874752, -0.14060990703446413, 0.009889299497036496, -0.7928079709894612, 0.11905211276415714, 0.23361864539173682, 0.31237875950447347, -0.3806032466236443, -0.01304979532064358, 0.0390218350408729, 0.17432530714069142, 0.2984954553287921, -0.059128847227775234, -0.18345042628125025, -0.35539681216047114, -0.4012468886580045, -0.0029361460616587976, -0.06660978484984252, -0.39338321342185995, -0.08063717178088577, -0.502657387499621, 0.2738081852212394, 0.5919125276383096, 0.2396337492348711, 0.29508882441225814, 0.052143458096567154, 0.09987703641294396, -0.3744644567650303, 0.3753692586617361, 0.3441422203555399, -0.28222140567308623, 0.25167970522732735, 0.37551530068961647, 0.4389070470416372, -0.29271522889734286, -0.0467410654763646, -0.021226041878695426, 0.012022888006038084, 0.2450938029555861, -0.0014302049053848847, -0.33192952416936167, 0.4840257326238747, 0.011403200860554465, -0.401412125248881, 0.03016819567028827, 0.17371887485373821, 0.26614085015951777},
    {0.023990710914504675, 0.23949570949022453, 0.008543250495834437, 0.2751348491136501, 0.2256209379317339, 0.3249944625787399, 0.4931135435039934, 0.05116991097285634, 0.05858598664209555, -0.15922570114768353, -0.13395018889505214, -0.30056697934343807, -0.14834415839683254, 0.2197677907968288, 0.4207471415233793, 0.2964770169460208, 0.18754431304159613, 0.08801677425904116, 0.2067219059553704, -0.14621739102395576, -0.0672194939219321, -0.5741939635082292, -0.004668811008919175, -0.5016181219422599, -0.3991258952999419, 0.19665866268961651, 0.4797583168806177, -0.2133979312709824, 0.3837638146902237, -0.19646063817846818, -0.06565122878150283, 0.10529267026121522, -0.5264714553106754, 0.4039430581160641, 0.40361898048330874, 0.22160814679209775, -0.19067369767534725, -0.01733232551317839, -0.35661323980053733, -0.42085676733076655, 0.29773617090739396, 0.4921189192959504, -0.5281720002613207, 0.3612306921759024, -0.3240746195815142, 0.23511438476805632, 0.13633600866161966, 0.16275559959982755, 0.021111916458928324, 0.7011876943509759, 0.863558732672834, 0.22243462785176124, -0.2883256996550469, -1.1202962502259546, 0.28969935858710977, 0.0448010440090796, -0.28364115087856234, 0.858403339215991, -0.1272811724211509, 0.04437944891669245, 0.11289789077362435, -0.060661321862821124, -0.13960924804188296, -0.082849542827205},
    {0.4789564490794869, 0.3929159592268603, 0.7718214241123421, -0.3290113800663993, 0.5568078022078353, -0.04903279520924704, 0.04073184675340187, -0.35382971734306723, -0.3358349842917063, 0.5443992036982112, 0.06667033723025591, -0.2450607362695663, 0.12416525248572556, 0.7376149996793371, -0.47978316426049483, 0.5287682149971119, 0.579026804494801, -0.3666580342969569, 0.28415027024727296, -0.21483803836508245, -0.36852052405304725, 0.08863012232723227, 0.5483846556417824, 0.08622770059765246, 0.13991951161831767, 0.1285923983172765, -0.23165011527572968, -0.45214655011579064, 0.19072412800086122, 0.26647001441956863, 0.5998137233918581, -0.32119004298031634, 0.627167918158408, 0.337040868938039, 0.07250741628343925, 0.8416935792857945, 0.06541702592170293, 0.2801258222079957, -0.015740438002750434, 0.13965805262579653, 0.4588539046625193, 0.6748090770406355, -0.5962479321514054, 0.11090248336801178, -0.31957589576713236, 0.6081944747932821, 0.3076963928147092, 0.4949948043438, 0.33369227781629535, 0.321393640592726, -0.11762909379512682, 0.5173090678642185, 0.03512467391720149, 0.15754388668097055, 0.38597807892925823, 0.35848303188501457, 0.18884594800165583, 0.7403145046068087, -0.18649739552771621, 0.6022770232369891, -0.3713521367782854, -0.6081198104547316, -0.2900916290653093, -0.30947945569305924},
    {0.3520775766249896, 0.30475770404643016, 0.2551864725090848, -0.08327477185119429, 0.31962401577764854, 0.26148249282602287, 0.05198175858860181, -0.23375561059006922, 0.2060724108170918, 0.5837987915949212, 0.5158728019173667, -0.1075633656512173, 0.1718242037069587, 0.30828065748666206, -0.10897885197049577, 0.5410537890869597, 0.006128548473506943, -0.2616118543419426, 0.07421527705685013, 0.4387154015262892, -0.046556697716572365, -0.012550887728273745, 0.4965951188064461, 0.355514979976377, -0.33444414168637904, -0.12998590486064188, -0.7072591106091431, -0.06051508065306635, 0.28428524386372367, 0.13655729121699833, -0.01593471247549781, 0.1477131892275116, 0.42541028603871067, -0.347172248302856, -0.23226361571070941, -0.07300007082748183, -0.8301901967091131, -0.04032644327702544, 0.31733784044691077, -0.36971439928216654, 0.5015572396312702, 0.5047628922591593, -0.04090693372571246, -0.1774065596707285, -0.2811676016270743, 0.4230113784009799, -0.2058324656981176, -0.39763920549559845, -0.3598155239862148, -0.1276913063323909, -0.45197355372086767, 0.06542145817980366, -0.16807424885247535, 0.4737723785578273, 0.9113901501455598, 0.36068969221030067, -0.03453397822337507, 0.4300419588688256, -0.6578888756052618, 0.41030413701332913, 0.043703673990823845, 0.1447184595993686, -0.25771953795988306, 0.10720922840390525},
    {-0.06549434100923385, 0.19026673705904576, -0.36520646900147674, 0.3422557561598218, -0.04433214332463991, 0.02833094229179005, 0.43982163771566696, 0.05144984964048289, -0.12866885147494506, 0.1488905046304491, 0.38900674558847925, -0.009868810019259933, 0.4842125282972783, 0.20813175136784423, 0.0672458759250341, 0.24758010010943288, 0.06499374459296925, -0.0027755660335684845, -0.6200577179390874, 0.004855224506954264, -0.4232119852831788, 0.40844876130567276, -0.44143515129407795, 0.38283861372616357, 0.010791172478922424, -0.1971886532330404, -0.3642587112001972, 0.41421857055352457, -0.3231110166665395, 0.4577028395043892, -0.39797863623726, 0.21618768329717028, 0.05821550982821062, -0.07159087618992048, -0.1536354277735169, 0.4939470937195815, -0.0024108598869993655, 0.25523450216050164, 0.11229905060189924, 0.3616202267608501, -0.2847786298373208, 0.3706089031416252, 0.47690352677656556, 0.15751253028868895, 0.030967782856736858, 0.41705328568151373, -0.05352321685658262, 0.0301264503838919, 0.4474548067180045, 0.4005299431149878, 0.116584377113553, -0.08272696778961906, -0.06910679412779411, 0.36112934450244366, -0.04545827033518507, -0.13037575774347795, 0.3100064778495554, -0.41799942526410383, 0.16330694199470558, 0.2977052458373866, -0.34664040129208823, 0.313702053996006, 0.09128133592329368, -0.17941064655901012},
    {-0.04313717643133533, -0.06877405393040073, 0.37660984885028725, -0.325544571751227, 0.28309262579842503, -0.33689833705932637, 0.18813001825200273, 0.2254185529988226, 0.6299875001929314, 0.03811614457087006, 0.03923998737009961, 0.2715064156701918, -0.14188856723321452, 0.5469769633936895, -0.7399615600426145, -0.04033929425685528, 0.07037733780719929, -0.32611809256099106, -0.06342132829039297, -0.022584582699181045, 0.41440395364613203, 0.11510795954732952, -0.13285156989677024, 0.2826365606895208, 0.33013929752162213, 0.08962797511935171, 0.35670671282672345, -0.10700385952517256, 0.151990511902817, 0.0775664489782889, 0.061122776189029705, 0.30020365534328153, 0.09101069299720006, -0.2781401578936209, 0.09434559355964506, 0.16035331505061703, -0.22856255954265553, -0.07837712988381215, 0.11053949294591114, 0.5060480609478117, 0.2884767802652942, -0.4860466509749982, -0.009027155221004075, 0.04472008220499296, 0.4780075682172699, 0.09733719053157423, 0.02643260646805979, -0.12785061279612278, 0.2927098958946195, -0.45997206647111066, 0.0368394890905175, -0.054618631193695956, 0.07197090141332463, 0.19979451401436962, 0.2777760240825943, -0.2071674776703848, -0.2689555812189416, 0.0010906350451995327, -0.23074716095724385, 0.08566594968989147, -0.036818080550583554, 0.40452152906043415, -0.14246751279743658, -0.5260540831455894},
    {0.4802889802127641, 0.2438230792168378, 0.2787668819253359, 0.3334878856728678, -0.6168118001340702, 0.12731277222573403, -0.08733252207429756, -0.3956048548893614, 0.2792936102564189, 0.06264946196293063, -0.09496735052876096, 0.1833726128602835, -0.5548969972837418, 0.12953635103747302, 0.26519196379168886, -0.04676131321747356, -0.05169747802989945, 0.10493589455064295, 0.335781911296178, -0.08473176219706359, -0.27082950142611106, -0.49362984720841774, -0.24766182538630693, 0.042664963581279435, 0.1543634607203906, 0.07965528801198916, 0.37401796890053274, -0.4201348924932475, -0.32104604249942587, -0.31820454256976716, 0.24054131566310344, -0.13301489440950612, -0.3258398286523539, 0.19178358533845655, -0.04449388578259383, -0.542633832315393, 0.006014178184174802, 0.06594437489383659, -0.0029399231777943024, 0.07658149161237802, -0.02664024329310916, -0.3455544511823595, -0.03214701589969781, -0.033152840779487915, -0.5679359031566531, 0.18198947054176717, 0.4527762085606468, 0.12044487879288716, -0.11952728026686871, 0.02022037324322417, 0.38188021564694813, 0.03400913384237336, -0.25740251528510133, -0.27173788480527494, 0.22856898728897582, 0.16975781164090772, 0.3794953558503881, 0.01584363597535479, -0.4543405232268208, -0.13719619510027303, 0.2111735303467717, 0.1818787820066887, -0.5426196784373778, -0.025023863647675622},
    {0.22053257433201956, 0.12188722798830119, 0.22342139963806953, 0.1887842139645951, -0.23832181448885725, 0.6915607076936303, -0.36913529234226633, -0.5093079237497457, -0.07880174585524415, -0.16536393224981466, -0.14504036985550323, -0.1841474048262498, 0.18786950815248124, 0.19271279404454766, 0.22343840582534288, 0.48292593825095254, -0.2508462009835093, 0.315311598557645, 0.32406630471729964, 0.11030702520628703, -0.2605647113421887, -0.028046313863562697, 0.5199134879182913, -0.2604189652256374, 0.22892984132227134, -0.3722662505178662, -0.41820817581641007, 0.21269908919208333, 0.10049654166767025, -0.21383831077612872, 0.08497724186972408, -0.40535408135816225, -0.2578961199993158, 0.17530234592709493, -0.09522235896130035, -0.5536035941083853, -0.0670602904448533, 0.13067461961105997, -0.27956064306208683, -0.43986584421511393, -0.021828948479545147, -0.06440091194863021, 0.05947272357545019, 0.23593019009260358, -0.21077167998818122, -0.3801786037115218, 0.040968992545214744, 0.09293277731160061, -0.38429792926541007, 0.5269814185474436, -0.09652471561476016, -0.008621264010029769, -0.14904782067048097, -0.2751329791043041, 0.15098035992024697, 0.04815613501241621, -0.46875236137367454, 0.3065073919199142, -0.08969234712632373, -0.3591512706775072, 0.3954346123893203, -0.6428165606950315, -0.1538150071304065, 0.278240285537032},
    {-0.2172428404765078, -0.08678954343137714, -0.7138489472004881, 0.07234389691224284, -0.01227789775869144, 0.12789636436772103, 0.23952133492141353, -0.2869100263671154, 0.48755621163385143, -0.1323710769283653, -0.11238349166753624, -0.2880002892384862, -0.10122559737435181, -0.1869417826027271, -0.17226165951435268, 0.701183288051621, -0.08786399953865381, -0.10882762047275965, -0.1244688231606079, 0.02269646788904729, 0.4454983141235034, 0.013454431291193324, 0.14571664165044304, -0.3896973161412692, -0.4800568232379302, -0.32719102395696564, -0.42776010302719414, 0.289587549062575, 0.31574965099583086, 0.05803953103490785, 0.364435591357292, -0.008981393732880587, 0.05021263077863773, 0.2598537292761128, 0.27573396523456745, -0.0379015851517262, -0.2696687906199115, 0.28491071904293247, -0.026712535949411326, -0.2957595861419104, -0.042388974224101345, 0.274104501030223, -0.1715240230734084, -0.21181135085701733, 0.07404480302552605, -0.40586971561138985, 0.15745022512005, -0.17699459948294818, -0.055989227411550394, -0.19147672550454342, -0.2628025347820662, 0.519464959416706, 0.15719011827107005, 0.07135480612873862, 0.1804174715687888, -0.009087944104947721, -0.06392378073700099, -0.08923495336819799, 0.16552765458305735, 0.2834537209662226, 0.5476219048936005, -0.8821315833669279, -0.3940121851436134, -0.00614794485592015},
    {-0.41534013961011895, -0.287393631724157, -0.20962477046468597, 0.1780687433169535, 0.2288441839748423, 0.45894718547858404, 0.6332704182444175, 0.29289961889654337, -0.000672422904745979, 0.29959233955672504, -0.3482062890037475, 0.23062329505994894, 0.709961613614445, -0.15609319107361758, -0.38518520766670017, 0.46907697986201147, -0.3146933333513734, 0.4048253870176946, 0.1563211268238498, 0.0502196098269114, 0.25895058049674474, -0.07705035414417744, -0.44108563647567456, -0.2812927636447603, -0.027354821648545562, 0.07982468165935039, 0.3743553412603535, 0.05713424415669079, 0.4563394226444631, 0.46628321533614014, -0.08653912644448604, -0.035269598886086, 0.2480489588129994, 0.40770135139438013, -0.2965761399612184, 0.18879132360021234, -0.24898689782007138, 0.3604384167902244, -0.27954425626142826, 0.16182769736260236, -0.22689406347227822, -0.36059355377065666, -0.28258111630403643, -0.4168494235423416, 0.27857710863061036, 0.048783955714380094, 0.08292693524199542, 0.010648797632077382, -0.2610303621715814, 0.2988915939957067, -0.44534970659474027, -0.044247916500247515, 0.4543009710789302, -0.28493166414121623, 0.33126437786193147, -0.3813424979359233, -0.16766097487847165, 0.19576321671365157, 0.4288547025361383, 0.4117264910994412, -0.49386817840683384, -0.031352603817678466, 0.11067576071466205, 0.3503571871794555},
    {-0.0372812671701076, -0.4868482045140881, -0.24559070222154997, 0.2659544326219536, 0.4481315014849994, -0.1053069663903136, -0.11076406626164671, 0.5534630366092903, -0.021820643349646528, 0.0049836805901112505, 0.05079824965375867, 0.22787207453026254, 0.46308232707014924, -0.3383935092422802, 0.1070489848529563, -0.1061336545063623, -0.4003519367751171, 0.25942357179093767, 0.28010528783722305, -0.04773956231155242, 0.011708596142094347, 0.21656966650277987, 0.11242740701077385, 0.06906796760149994, -0.08052885780241298, 0.20491982164087053, 0.15070229697908033, -0.029466061424952124, 0.1293641091006512, -0.10926707560145679, 0.3896795987917611, 0.42683327871687216, 0.42430143361594325, 0.2683467881864556, -0.21938720997740543, 0.4818749893678503, -0.13967644318187913, 0.0680253742715743, -0.17790927809712032, 0.16300440141811853, 0.03537306710679432, -0.19991969058015413, -0.04941719152595552, -0.6377043034283164, -0.14064394296400243, 0.3629314475735446, 0.21308821032530673, -0.15719288146994578, -0.15053308620486783, 0.06800648358414906, -0.387159487658119, -0.3522934918767255, 0.14379686393041327, 0.03219313725244136, -0.030488150863966168, 0.14772967931638184, -0.025925488136669693, 0.17739670126765342, 0.6006734681860413, -0.1514837741694338, -0.03784427481779354, 0.10406602654819416, 0.5078300607453543, 0.09319618336468774},
    {-0.24174019579858783, -0.08635712675513478, -0.301844786099884, -0.2700332441312849, -0.2203685575519599, 0.1239958765301185, -0.2508565832397264, -0.2229316451973046, -0.19091249138906066, -0.13326554828612816, -0.3656384820660613, -0.3175389677898882, -0.19722899821271905, 0.01971983984711871, 0.108395585391376, 0.031192850101396417, 0.13125092380863337, -0.17428125545036396, 0.30609211394287694, -0.23458932179683872, -0.11799721374358102, 0.13132480363859486, -0.33854447580934743, 0.09633793842800559, -0.08623559684845947, -0.11226117893228728, -0.5914632880220768, 0.1438790876667093, 0.1058071677172453, -0.18675194356245672, 0.5027231809497587, 0.40797289487680705, -0.15325163040528475, 0.08052727636261724, -0.3950510662349918, -0.2166551152293969, 0.1752193359108263, -0.48538324104405517, 0.12138518897805056, -0.07920422816334578, 0.45456524463199954, -0.501898660622072, -0.3849260463681463, 0.2679388943270387, -0.4644580715175995, -0.31151030083910275, 0.09947008962899948, 0.15892314741464686, -0.08573891008245696, -0.6180606714500114, -0.03592153670207534, 0.07539434494779967, 0.06565342680236567, -0.022508758765857974, -0.3213045126275332, -0.11789695953109115, -0.03084767950095402, -0.2213041067566461, -0.41327321183495824, -0.42656976189823453, 0.22895468472560462, -0.3185958564230892, -0.48768779494689946, 0.09227556209247996},
    {0.15148831416892683, 0.14619753850316577, -0.1802793552828738, 0.3480029898285049, -0.41120651192958957, -0.271720094058995, -0.20943291858631216, -0.049298617995266296, -0.07894167521204093, -0.11863808118210586, -0.05911547727699716, -0.5213869695447708, 0.0556264562971941, 0.12417274252948252, -0.25662301149714695, -0.2983340251169456, 0.49807775873948207, 0.13913995821720898, 0.27357595769016285, 0.1318657011401998, -0.31539308664079146, -0.26833104479261183, -0.006209683223004091, -0.671519401368332, 0.24564682266402812, 0.5330644139043514, -0.15561376548060693, -0.17227306788507102, -0.08456039221699092, -0.2040351062733975, -0.38800684919455913, -0.4490169278996949, -0.12140599742163716, -0.10783941356922468, -0.2308820476535983, -0.5244726230847525, -0.16420282797433905, -0.3310266019405926, -0.22095763195836557, -0.48882043570155376, -0.31080567309257334, -0.2950585282663021, -0.3866514403675522, 0.3920073024547895, 0.06165850390511774, 0.009530017746821771, 0.36334985616612375, 0.2938924357070366, 0.05769532838463362, -0.06124093532093243, 0.03636826970388701, 0.26772778181873896, -0.1411905357254889, 0.4071552380711417, -0.729276071239847, 0.23079606772764882, -0.4714131913384791, -0.04753928332926829, -0.2766106333329534, -0.3006557944850721, 0.16397590763463762, -0.5672410451937262, -0.2696826600471898, 0.4611694455686914},
    {-0.3654160841944052, 0.023364441323463367, 0.2945407946425766, -0.29744550588461455, -0.49037634999302937, -0.36200035489173654, -0.22304733328774004, 0.2265143751828149, 0.1641004448712775, 0.025781933427689564, -0.25832364315647455, -0.21535856287040223, -0.11862450143458249, -0.30311439255226885, -0.29447840188655755, -0.5130562331494424, 0.3253811350119541, 0.20862475991379836, -0.15561610988358843, -0.7462405752105189, -0.015723262437021785, 0.04245129650235556, 0.20871447434027926, -0.3573144576470595, -0.15915285440815424, 0.25087567991709836, 0.2518234440168089, 0.4821680494099938, -0.5426880031797185, -0.3895338466511672, -0.2973349496491127, -0.2639872042153156, -0.45847574068782726, 0.3603337704242009, -0.11461303292980332, -0.3566145031688575, 0.05155738365475015, -0.23962402035950195, -0.41648012911502924, 0.07323759497199542, -0.5885635538799683, -0.21801479137134092, 0.5313269478225502, 0.21523664864962677, 0.06941060822086176, -0.10051333394993611, 0.12055502921841435, -0.02183076781807139, -0.2158969719638741, 0.4331833134099247, -0.11860418122743425, 0.023675228021612118, 0.08570635314336593, -0.3750091103984453, -0.15396173103666977, 0.4032390788618548, -0.18108358252799794, 0.11480058185262036, -0.47847973988372894, -0.24620409842843152, -0.23466902010434956, -0.17828587531633774, 0.382449582421241, 0.1278197145324687},
    {-0.6013862575414182, -0.07189079436167922, -0.03279347054899378, -0.13386712204709605, -0.0022448119677762773, -0.10412064686840854, -0.05207684942214554, 0.2092346587718898, 0.06303634331333677, -0.23231010906384272, -0.2930132262613111, 0.059229102715439054, 0.16599543008277826, -0.05981592059270096, 0.13576285854603895, -0.4865362413203475, 0.07885965773180469, 0.12629195106460817, -0.3821035275470256, -0.31937728638807156, 0.22917709510278048, 0.230038129948815, 0.18408051861039942, 0.1769026411111329, 0.2246632429068118, 0.021738234111332237, 0.12347651996296947, -0.3177925694052626, -0.1147201601097214, 0.1165225657007959, 0.14660258491738332, 0.049642430033336474, -0.4752251972964005, -0.051035896810558666, 0.02926796949355822, -0.11816436268405323, 0.12705312484897674, -0.35120389517707934, -0.1163664239231065, 0.174582715290925, -0.2500885430314481, -0.1536326414549906, 0.31885997235372543, -0.010748635416194943, -0.10289933138197366, -0.10732193524575455, -0.12905156756573674, -0.12311068985565647, 0.2492314295659417, -0.023825400130272963, 0.20914097719811447, 0.14875552939995884, 0.1348822652605446, -0.007045494653705814, -0.15581009127869358, -0.01273275511211107, -0.032318795494217546, 0.05037158256841271, 0.2817320638821495, -0.05204644814351126, 0.05874869619048493, 0.24674930038937753, 0.5694110854644657, 0.20779625835428536},
    {-0.08319102722167537, -0.040036236389521376, -0.3160186241496299, 0.4860819574307524, 0.25203316833553846, 0.03966733674302367, 0.01541792779570727, -0.35930671945200676, -0.2422455010577718, -0.5577457514057871, 0.41317686099709594, -0.017064101643141, 0.1966899112822588, -0.10870832933929761, 0.1975765204356158, 0.3100791373339183, 0.11805105881851476, 0.1455046812298375, 0.26550376116992086, 0.3286398310341007, 0.10908810716152519, 0.2000359242461142, -0.1617012234876419, 0.26255189670540496, 0.12748428432830042, 0.029461440298134724, -0.047275392520591285, 0.07410081082721875, 0.5602350908436667, 0.22207765941146002, -0.28099973920940474, -0.3255172249785685, 0.054771171667997616, -0.10893493480484553, 0.4112258409808723, -0.18338195566299945, 0.3537240129449472, -0.11047246826697027, -0.08042587641514407, -0.20771936228089996, -0.22958688464239985, -0.3480976870266254, -0.6378668479252919, -0.22670762800411248, -0.24942857710488092, -0.33978494406877685, -0.3144675961767037, 0.08119248531926783, -0.33463219782979686, -0.3305322857272802, -0.03720734941771923, -0.05320394065584893, 0.4548085738179186, 0.4210978627232518, 0.1361129834787173, 0.37197236039050807, 0.3060793035238729, -0.23597777834477, 0.16015163309001054, -0.2058788504705718, -0.04084035250004414, -0.29082329744639906, 0.2694345636808209, 0.39735493363437174},
    {0.8799315118519533, -0.2447686953757876, -0.3257820903739208, 0.13949351626060838, -0.070543724649104, 0.24369513900513126, 0.3350470308263514, -0.09783679172438817, 0.30874214023126234, -0.15525187283410044, 0.5728721878818325, 0.2202061499419121, 0.36943957605964495, 0.609189569807232, 0.26647027624396336, 0.34851630084325114, 0.0968557437348015, 0.19354852794074914, -0.027315047115743438, 0.2634795164294684, -0.015626741946206477, 0.13785263027945815, -0.16478171473062336, 0.33342522453373824, -0.07008654442657457, 0.18078965224441634, -0.014565502900828201, -0.25759869360455, 0.1547807902449902, 0.2770606275075558, -0.5578663083863448, -0.025452201778580996, -0.14459728292010507, -0.048497246828349466, 0.6438469786900073, -0.1261042881480302, 0.3882772730660078, -0.5948629871257859, 0.4223717362589154, -0.1138108022054773, 0.614030988124104, 0.2889503000702277, 0.016484773231229457, 0.39737125411710955, 0.6807980062631851, -0.10409488992140753, 0.10206283449918269, 0.089534297780697, 0.08393065641375488, 0.16542183354707932, 0.24843470455957162, -0.4994466972068026, 0.4637886598202758, 0.18407671670553505, -0.3013796335874166, -0.25402539603050067, 0.24657413723686755, 0.06746125529015495, -0.15548375527421085, 0.029288579922022925, -0.30942038562138063, 0.07291246109252822, -0.25557306378662215, 0.3233170904548948},
    {0.31539891424902816, -0.09722248696295566, -0.15985687180799255, 0.29788616206016927, -0.29561094340656957, -0.21382358308285992, -0.3455854338210908, 0.09058516570951101, -0.0407575761178015, 0.4351659413416965, 0.3926570249714747, -0.12863754430404092, 0.018367317502148536, 0.22224283712927725, -0.01104874680084695, -0.2598773319681492, -0.3074244299287652, 0.1274979041225575, -0.0097214387304306, -0.20105735476375416, 0.3788323091536908, -0.40781184843040924, 0.28754465557366765, 0.13476545949148205, -0.26274635513776967, -0.09850331698576294, 0.2741658771944477, 0.5096193492748091, -0.39586868314949025, 0.08465011453385063, 0.3208059377292801, 0.16942851033123033, 0.19383840101520233, -0.2045548164266054, -0.07035866122553375, 0.2837724891061428, -0.1947986064814253, -0.5136712579254411, 0.14939220592783564, -0.21894847502085263, 0.8655574389510361, 0.6611722058364289, -0.0058222494308957755, -0.29812077065041986, 0.055756129211038695, -0.22309444374449444, 0.4976871158546071, -0.392217909462085, 0.37294985341472003, 0.07051965561582488, -0.36541559294013737, 0.15544803146007347, -0.1069549050574239, -0.29414468804300636, 0.13397863113940386, -0.04028423829245683, 0.22776111761511542, 0.23528669950441586, -0.3972834203809398, -0.24771534487534475, -0.04503019258846611, -0.13750105733527232, -0.124314010079822, -0.5311563616239},
    {0.1645955978719786, 0.28637465778210863, 0.5395148982060687, -0.1631220418422485, 0.28510650582325786, 0.5208996825881882, -0.3683496890308238, -0.32119111866413724, 0.5362962788321753, 0.1632705069613721, 0.03313077804021469, -0.09545458797659923, 0.22090002462600314, -0.1776492956569644, 0.08902086832664562, 0.09875900904983805, -0.015698482594092428, -0.31364763544807767, -0.2092413712757757, 0.02908774026680742, 0.5142165061124152, -0.20874555843692996, 0.37135275526237044, -0.18814443653321686, 0.6470508566520038, -0.7117317905742925, 0.7727392530110184, 0.35822572927448065, -0.3934764226632911, 0.15933035286586208, 0.609103898126313, -0.25588551091250555, -0.3715411377250913, -0.3667833352313142, -0.11166259865956227, 0.5086532483466882, 0.37558098084798636, -0.0005677241127420029, -0.31579059494188505, 0.12850305233845108, 0.09044991755781039, 0.5111663844058526, -0.44406691837038953, 0.1862987096791975, -0.09489753308939448, 0.373616226659453, 0.2769437866881002, 0.15204733810286208, 0.41579045258879055, 0.21481799906168278, 0.0630210394338337, -0.12496708352116458, 0.1272318303991959, 0.18129796657730524, 0.5692540889637876, -0.11015945017878698, 0.3598804425054913, -0.13845198769579026, 0.24018596852813237, 0.2580633058923989, 0.19040516109391797, 0.3115916007057944, 0.3112492866511512, -0.11609394093113196},
    {0.0023301324806056377, 0.06068476139327242, 0.06035090889174677, -0.16848174041736833, 0.3994978289013474, 0.06747143198842266, -0.49961040879825974, -0.029774834287995103, 0.2753208015714839, 0.47810458373177145, -0.3888072511761572, -0.09621955224079098, -0.03012194278814235, 0.00270009980661312, 0.35763883365448196, -0.0069442404948502345, 0.05007908335748626, -0.04964223692605243, 0.39564940531273834, 0.24471491629121817, 0.17452173109351016, -0.274747592041654, 0.47519739464761174, -0.47389696795216507, -0.01687476393123373, -0.3244078112287628, 0.246506435870288, -0.08191746258166545, -0.02619768260094653, 0.035119019610540154, 0.21821219743283105, -0.2792053826359855, 0.09176264408122836, -0.4229493798642701, 0.15306466576127972, -0.35908992567782894, 0.091318508041997, 0.3135206594161119, 0.0651835204772758, 0.014507975412436822, 0.34323602924148333, -0.3890316000646532, -0.23971121168312698, 0.4440837518468414, -0.16487537145043654, 0.1408240767013408, 0.37159833921936564, 0.22432098993841354, 0.3554473480101974, 0.015738095631906198, 0.22918233383348535, 0.2625951059208519, -0.0841957474650668, 0.3142813453460172, -0.48958977484358124, 0.01214532306090119, 0.16524736123606498, -0.028913659407542917, 0.42106049108166016, 0.2195282501067057, 0.22924232943433273, 0.3564093087313692, 0.3716296575150443, -0.219316324293352},
    {-0.39580527428403917, 0.08110924598025188, 0.2319098234322777, 0.0074572899587664766, 0.12205186612423516, 0.004392740673078175, -0.12370981625696693, -0.2728791759173224, 0.255091138032692, 0.32681752231870403, 0.03757383405165327, -0.2962508512823778, -0.25703967106471964, -0.26107779348662047, -0.32093241152726415, 0.20557471905892308, 0.18816212398886364, -0.015909873216608094, -0.4239434812793553, 0.17117391570509763, -0.36734579351148383, -0.20532286054364204, -0.4846734500130157, 0.19436180243927517, -0.467255814164208, 0.30214502848509067, -0.07278763287659322, -0.22544424935651405, 0.11250497937133457, -0.31315868146955755, 0.26020047987375655, -0.4980602152995359, -0.1762777846084836, -0.024448465359631737, -0.3050583611457362, -0.06684202416980706, -0.25386738414878757, 0.5690284884349904, 0.1777722945356534, 0.12281867458595187, -0.17471277935089263, -0.10267255452231462, 0.5340172901765906, 0.41400878138384756, -0.021874433370381422, -0.3008120122356565, 0.27808637631980687, -0.2780068280682012, -0.3550226380563802, -0.017841327386053464, 0.05909610211882076, 0.2627081662418559, -0.5616362806113299, 0.14094330260778812, -0.43769911636496617, -0.5548756851953827, 0.07977288419619584, 0.2278747726901215, 0.5625095092486074, 0.2853099885661747, -0.07542041653623198, 0.5884923947597274, -0.23683315146889572, 0.06897605884884943},
    {-0.04686304420140311, 0.19472416359366412, 0.3397600280875473, -0.19204477194263472, 0.22089072534125015, -0.3796950753874277, 0.030296448537177813, -0.012031839673521231, -0.15372837078164883, -0.010706154066762846, -0.013651323548641401, 0.29506417536237906, -0.13045220106048544, 0.4932265076270713, -0.7302988687315449, 0.050374368174955754, 0.3968307285080463, -0.11480015633119238, -0.3226285164422617, -0.3076205181001887, 0.07446302089303689, 0.23969165956527574, -0.20204051142676063, -0.34184928517942653, -0.1443291723837709, 0.1265309756200223, 0.4583899783975775, -0.2578250973032223, 0.07054523576373292, -0.09534784594220122, 0.09544640251628066, 0.09228499173738515, 0.16640377205120413, 0.3065245739823462, -0.06415144211103935, 0.32156023516625293, -0.3620661618414992, 0.49483835091145867, 0.24241024496482347, 0.06571208068540092, -0.3733447628918913, -0.2602419548387503, 0.6123452720849866, -0.24186223687056133, -0.07529106276585443, -0.06752948179529447, -0.5222844381047927, -0.40941526623944496, 0.1502163007209204, 0.004506244994918337, -0.5925494964243035, -0.1020488011208077, -0.13453352576767072, 0.12277147184834121, -0.1950453849888567, 0.18113332526292691, -0.06285528973473747, -0.3418057835401647, 0.27276306255345034, -0.17334409940562479, 0.02776393596229888, 0.1957704197337626, -0.21478857767898, 0.357575331220971},
    {-0.6862368566902116, 0.11293254536287681, 0.307743443672951, -0.18150680421614315, -0.2651944648782996, -0.19849511164347244, 0.32277759226065433, -0.17422403605302517, -0.19488789874455284, -0.1434153845030198, 0.04640030278321943, 0.09727570436844676, -0.32511888992888577, -0.1852250680640961, 0.16408400547369265, 0.13015184551719944, -0.10960821486027028, 0.3543969619957235, 0.11613461938678742, -0.09383271950363416, -0.027685214829245033, -0.294461782225539, -0.41874370937913324, 0.5283833280382647, -0.030864209256102604, -0.12231453890637946, 0.05223169007099418, -0.18602363430209679, -0.12064596018537278, -0.30544217960718056, -0.4207422834904058, 0.09689452342040748, 0.006953841440313274, 0.15278407948528827, 0.3422469024237436, 0.11127626732387766, -0.03423133383139615, 0.18650309996983072, 0.18308224701105982, -0.12199463544989647, 0.0019504698281630347, 0.17204656166801466, 0.28056137579498824, 0.255898397030334, 0.019979353488692644, 0.21201831807379373, -0.47275515027270915, 0.36811597254558953, -0.6420387420347498, 0.44504590651007414, -0.22040421037474378, 0.17964087537296125, -0.37933897228674895, -0.3769723983175874, 0.14784643149856197, 0.2944874328282301, 0.36887391421836313, -0.20435427841957327, -0.07766235147716777, 0.21326888132986743, 0.2070642899129345, 0.3450205878058105, 0.11007175085365574, 0.038030848459537435},
    {0.14935944180694177, 0.05817361775905842, -0.0435222908111736, 0.9247428330270413, 0.16487971394178227, -0.18337026317725785, 0.19230616091484645, 0.3126733641656749, 0.04340097626509343, 0.028236683301015704, -0.031232356854346333, -0.043196253623879514, -0.32246224403361046, -0.38383804116527076, -0.07234515770502963, -0.030185613378837618, -0.09193332024111939, -0.04861804586376906, 0.12267508237006702, -0.0011659595369416893, 0.02527013147537198, -0.38106383180344644, 0.12546238570171378, 0.11017183420965705, -0.19517974848952777, 0.07567029897363152, -0.34769455266851773, 0.05735150656798257, 0.014797012355090502, 0.008412145796575265, -0.486692355869521, -0.21286764180612283, 0.02884822206108207, -0.26042213950613624, -0.13848076827946357, 0.06112906762823147, 0.0016135645612832838, -0.528461720219606, -0.03805833964132366, -0.2798835964922435, 0.25546692111279, 0.4067029218175082, -0.0349326299704032, 0.4024763540417385, -0.11017604264762922, -0.026509472804348486, -0.26740506067120967, 0.10598348049479957, -0.3394438869756485, 0.6760051530801195, 0.2644203013976961, 0.06187395056063929, -0.6302377217279355, -0.03981616325861842, -0.0030077996958111884, -0.13956080476472596, 0.15287964837290194, 0.08247142569744913, -0.04053377557778668, -0.29357252297632436, -0.09262288100224067, -0.20464039884206095, 0.08186331918196443, -0.20888276956741234},
    {-0.042960338613069186, -0.0641977547954709, -0.11792389868535219, 0.023127251517414585, -0.3982640911517127, 0.2748947700598174, -0.09995244436085131, -0.16127183729097, -0.16120074562840778, -0.4273807876533772, -0.14087404073274704, -0.020211196901939354, 0.024625509151336173, -0.2522406512103309, 0.322267807892819, -0.3591151430416436, 0.07468640324531395, 0.05638196559311485, -0.024991796246548265, -0.4259531592311602, -0.25420016898163883, 0.45376510319451946, 0.2057619604467167, 0.5654289183556085, 0.3597893566270489, -0.35909635656167704, -0.4337037619120208, 0.7387792149528548, -0.01175241766353944, -0.13739945295247175, -0.16992409472561396, -0.2567087917706507, 0.2660245131038627, 0.11534296481117935, 0.13706801243686362, 0.07002471237390523, 0.07567256243099185, -0.6057061195641081, 0.015575367959354838, -0.2760090904341232, -0.4450370178052239, 0.08282009289844508, -0.08841426372727308, 0.10664027584857448, -0.3764229795964415, -0.09293823916585117, -0.09217915064146756, -0.2601934030427915, 0.07972046397504147, -0.11022114950029628, 0.516749417976682, -0.040223978241464536, -0.2771285899877991, -0.18914579985698365, -0.09653323541426498, 0.0653294818506002, -0.47554571934647705, -0.093206473626198, -0.19942973938989486, -0.1738355969037618, -0.31315295767323664, -0.5880759772141422, 0.5667476950912758, 0.18081325264019454},
    {0.17056013234323766, 0.024191389173157565, -0.47039677630343985, 0.225100317335672, -0.004864484880022721, -0.27180665198266935, 0.30858075938611923, 0.10491594983336712, -0.5345414972511087, -0.061659648233458854, -0.10242511140681426, -0.05613450005861458, -0.11243987080940324, -0.29524007772723126, 0.081531612071292, -0.269619592393834, -0.348295152039504, -0.1391005458515676, -0.03571467324862397, 0.6647816366536401, -0.03615091681983281, 0.010912528339046967, -0.2145637298649964, 0.06947002810742152, 0.0957748776004698, -0.4549026029613092, -0.2654833663348346, 0.4185215698495366, 0.21090474097297252, -0.04955950607247312, 0.38064779540669563, -0.15272115668835512, -0.12811819458575327, -0.17379219937427928, 0.17109734823095213, 0.15364299899774278, 0.13428204010906553, -0.22746019022956263, 0.3448042528001881, 0.001980686376223292, -0.6410152414314326, 0.19626709614447682, -0.039114047398524136, -0.018503872450670394, 0.15435528550475947, 0.023937988654530812, -0.46227805231190194, -0.1843598087393471, -0.1898808005704094, -0.08366632382263275, 0.5651763384653141, 0.12259373362416494, -0.19096048899342322, 0.4295464141116793, 0.24344290225876247, 0.1020622912775153, 0.02907048264646316, 0.034757539396427756, -0.251017316045857, -0.19838682843443642, 0.14553328906005086, -0.08454293644835265, 0.5715228020575227, -0.08396721530249164},
    {0.16679421857664775, 0.2695961818070194, 0.1294858557271145, 0.014631003679833152, -0.1036722532090084, -0.2650236465246203, -0.12330456959737736, 0.16803352809040772, -0.3100248215885394, -0.05638956702861139, -0.07289201518468175, 0.05785590798756338, 0.044447365608475675, -0.1916608603707787, -0.3215922714606473, 0.08176542109177143, 0.3094144711478494, -0.09551283167223326, 0.5731085106475599, -0.20644951447866042, 0.7453433574959821, -0.478538947685963, -0.07621573064866605, -0.11069598878339633, -0.1219373252494292, 0.09999499942960363, -0.35705504504840135, -0.4272745593629886, 0.37164520945863105, -0.13838799922086634, -0.1576328097835638, 0.20453509083564786, -0.20960439568652534, -0.4708371435005734, -0.12914516873705928, 0.5666321823292458, -0.2015134044432726, 0.23259309803719555, -0.5535223570049599, -0.010214756033052151, 0.43204110686734143, -0.4341316379160535, 0.01786044298201101, 0.31322123599545176, 0.3584271340774663, -0.0822991479751156, 0.09745998235109403, 0.18667350091076557, -0.0656103879597486, -0.1112301872614863, -0.2124707627329046, -0.3039697555281898, -0.032551026275945055, 0.19951813301910246, 0.10596828495336386, -0.20734023787248373, 0.06787044082170343, 0.137715395292726, -0.20926374615166166, -0.39783472373782924, 0.08781000901731206, -0.06250418496525886, -0.01908597453597669, 0.27917564515772536},
    {-0.09858140404313813, -0.09926678463119008, -0.31427485757139595, 0.17490583910101468, -0.2979023781869452, 0.06639535805348869, -0.029238436352839903, -0.0283707251778536, 0.04372935791604875, 0.11158140432447429, 0.47530750990671866, 0.16057917726554077, 0.3134600588436783, 0.06883555722560247, 0.2403512698435665, -0.23021571122363998, 0.11106471979869531, 0.24376970578320017, 0.5951379863325746, -0.07312539925597748, 0.28646262794227106, -0.17923704549646038, 0.3411802059821092, 0.09335876349414611, 0.1580269555199439, 0.043959734920565284, -0.07263498037090275, -0.7033506112941162, 0.1076090196328902, -0.07892070638130899, 0.017128387108776413, 0.33854124618940556, 0.08152152436979454, -0.08752909590431415, -0.20357451305001972, -0.0663651561543854, 0.04146330652013611, 0.13251829823221384, 0.10557014216305634, -0.19465330964879277, 0.3741827252016889, -0.11319959176983636, 0.1828588838124677, -0.26400991020756254, 0.4204267376186895, 0.32331592976424034, -0.21606001994656207, -0.31745454396683975, 0.6985441357420539, -0.27353700798659425, 0.29415646387322475, -0.04290259593348182, -0.3599067758734017, -0.03721300233195509, 0.03131412133993222, -0.23918027624666546, -0.25720441074504347, 0.18108591199607452, 0.1094994414761889, 0.24089469632795363, -0.0022708537487308687, -0.46108775471861846, -0.39303280812097946, -0.178201142266984},
    {-0.4986905738634716, -0.4134171467738355, -0.6296352936857055, -0.18540492883448745, 0.12273601995545909, -0.09681282832753003, 0.015846460379578233, -0.10076979037054509, -0.42079900621802035, -0.13296377928291173, 0.3156992839416085, -0.2535422306458521, -0.19223900231105748, 0.1415084108001378, 0.11858467528394548, 0.07346865388121787, -0.07637533649542996, -0.18705292076215796, 0.08241790654784423, 0.1102598857771984, 0.1991948522784678, -0.038358758797458516, 0.12001563344054547, 0.3922798585466313, -0.6558567737825818, 0.6859555667115955, 0.10557714445846501, -0.12079333468080752, -0.24905910154070446, 0.14948415537529824, 0.16337211402969637, -0.05881310905977722, -0.4173605002854535, -0.5274549025580801, -0.32815115616785295, -0.28116790492529276, 0.183974429597486, -0.28273113946862133, -0.12366200298206792, -0.27909057920544716, -0.45731715371039905, -0.0694679654732335, 0.3489066576415261, -0.7281734090811423, 0.11981879874167023, 0.052499030349714926, -0.31647756644955055, -0.04129533473778209, -0.16740251726175565, -0.09133306514301469, -0.6245221421116193, -0.10667467264878638, -0.5050828457222286, -0.16533915396326707, 0.18601819176895637, 0.08440659913299521, -0.18822614316721875, -0.09772460471281272, -0.542674568369894, 0.36015791560336985, 0.1333068781262812, -0.1477406738154553, -0.0692384401255467, -0.11941488087068901},
    {0.40028693245681757, -0.17105031852556893, -0.5034332552437107, 0.12696876487382794, -0.3716693778798812, -0.28715048666879994, 0.3098316447743621, 0.1751331912250176, 0.5882259203931869, -0.021620813675497726, 0.12668760747214655, -0.05408046125938409, -0.1532797670002857, 0.03250771684301462, -0.23102806087418787, -0.47425730378223024, 0.29531387395483794, 0.2551523720447347, -0.12612388292827123, -0.20975131274569847, 0.057907947749042545, 0.2126959026649565, 0.45944990285653137, 0.08034066848590667, -0.20438134868998667, 0.35082343467506616, 0.0051073041854058235, -0.08436044313618253, -0.2512894872981675, -0.2233325329628475, 0.06293933867068487, 0.4202935794900294, -0.07936925725751244, 0.3969643364446108, -0.29648974636044867, 0.13416654051410284, -0.37462389410355773, 0.13240049632873793, 0.014673890574294217, -0.31810488391996045, -0.283456622798789, 0.09470009799338418, 0.46143971571449827, -0.5317995748550343, 0.09666039541807593, 0.30732730703686684, 0.32221964455685603, 0.10932502215903414, 0.12957425478099607, 0.36296328335613226, 0.09126494751592018, 0.04473949249235708, 0.09593689299751804, -0.372865385138071, -0.1390355369140504, 0.20737109411456534, -0.16862739401851737, -0.031305532283130696, -0.31053180628672145, 0.24548368228745637, 0.09004559975702302, 0.5572647418653038, 0.7356290687685789, -0.006421774318818279},
    {0.24751305591020145, 0.40494420792138164, 0.016778411908354645, 0.442714067519307, 0.09293326487327172, 0.009189629859583348, 0.11636510846726934, 0.6760787285125014, -0.1270000948560369, -0.20621785055601613, -0.0994385253101383, -0.017555379877738045, -0.11987087290498963, 0.16959516376258407, -0.07619812943222126, -0.14934251396830142, 0.34298176625159343, 0.11422528307043893, -0.36303514160685596, -0.07383325260768503, -0.0992556447450922, -0.21427632723606194, 0.6384557944550987, -0.13466552442904522, -0.17833198701259279, -0.20412541598402112, 0.016581419910679174, -0.6023529492773874, 0.4285384843227792, -0.12493183936940658, 0.45528918112374345, -0.14321649743863413, 0.15432781336403809, 0.3680625466661893, 0.36483435949907417, 0.2789693557285611, -0.18030372810336653, 0.04046741537044742, -0.14820221626762375, -0.05139082610354007, 0.04152531170712445, 0.2305012538766598, 0.4403031704664069, -0.4284750339433279, -0.25095457909525315, -0.029792757254100275, -0.1689109203298966, 0.11756342129527937, -0.38719863940999494, 0.2778160585549711, 0.044879877201528404, 0.1075524902683803, -0.26785198790592374, -0.26025920969086996, -0.03955437389359452, -0.013306550974681391, -0.6672661297859938, 0.41265659963633555, 0.24568901302909807, 0.12840580065729232, 0.018189959646706784, 0.025506540960166482, 0.5107580014643714, -0.3550491959120444},
    {-0.2356277078041827, 0.16871437642081225, 0.4816514384984644, -0.3970236297813838, 0.7216361938944718, -0.08706972027015299, -0.1796827019918395, -0.14864606954705806, 0.09222726310076183, 0.4144520902768806, -0.3329320512002724, -0.5836527006304177, -0.1925359530014661, -0.11308547461231244, -0.026254001121614568, -0.19193816904111993, -0.05366118789008585, -0.08274877518170438, 0.04990278824767232, 0.40778821703974416, 0.1612589045422321, 0.425066217815039, -0.43234623296644775, -0.035314005483348926, -0.34805037629241076, -0.08501861400531953, 0.004597819853698026, -0.3127616189164241, -0.3401749376561769, -0.24588835404644754, -0.1924068011807814, 0.046354496487202634, 0.15361805970160905, 0.013347810852178576, 0.40893452033926597, 0.09568828366888209, 0.2605459443406283, -0.48573745701995624, -0.053114906130687575, 0.45558020107353703, 0.5057563237702638, 0.02536290310579594, -0.3546412538297679, -0.12538573833516822, 0.5690270368410525, -0.04443695609456119, 0.04771653384602418, -0.3785560072471858, 0.13179588738055867, -0.25392971940847503, -0.31463919050943434, -0.04797807444359947, -0.06390159105888672, -0.38903409624884944, 0.2402037933658075, 0.2876797597266805, -0.2283246600794003, 0.4875590865493864, 0.650173483513336, 0.08297964261546306, -0.157964808813352, 0.4192151573474826, -0.53963282847044, 0.15203257553740696},
    {-0.4263603963784681, -0.391890610446521, 0.2642676010733217, -0.5485833585184056, -0.07125032754361578, 0.198212452601329, -0.572456170748781, 0.08098488448089174, -0.0307952474457468, -0.013000674888365558, -0.3606303515067286, -0.3953958428490259, 0.2525229354020807, 0.015494007910021628, -0.6439795434753535, -0.1429559932643645, 0.2603936130382103, -0.3389269780134041, 0.02052283044008214, -0.9433999400900749, -0.21412658273407487, 0.45709907556319634, -0.05972316858859419, 0.2802023908650276, 0.3110951706777363, -0.19197546661682843, 0.07858043759444153, -0.10684760715274777, -0.11788272605259208, -0.12485234486725827, -0.1058645535092611, 0.07557207536509798, -0.0985335570423015, -0.034214614575219134, -0.310530436414624, -0.5621333611732675, -0.3645240354825258, -0.49697379131850206, -0.1864325599068127, -0.14249180266531059, 0.0037166595213916588, -0.6527569225474144, -0.28597893614680364, 0.2913270801352605, 0.4172910771659544, -0.2935054056425939, -0.3495198929140797, -0.6367736349832932, -0.20135152378394802, -0.2801884604180009, -0.13114805199573976, 0.2181714261033768, -0.089386136308832, 0.15599024942631598, -0.19080240834344, -0.06507827198731668, 0.208165259515016, -0.20358303294555252, -0.1611718734174807, -0.5835380106591684, 0.5520884274352719, -0.4976885477708857, -0.2504507776759989, 0.44413952496813563},
    {0.1048607370716912, -0.3151324546908152, -0.016111237570582432, -0.08988169725354266, 0.03238192801141608, 0.36036670336744564, 0.26205131162275674, -0.00869228866400006, 0.030235736423532715, -0.04714122807603715, 0.12183119977756761, 0.2393386155329451, 0.04771042969434855, 0.3059107458872018, -0.2676107306308931, 0.2034839806599008, -0.009872003603675489, -0.006606797243017944, 0.6896986600282726, 0.14808422531607707, -0.020557593042713727, -0.2895999250711143, 0.13085226217864182, -0.038824016596305314, 0.1379061048688414, -0.06466655275509302, 0.48882829861905175, 0.01991969285839305, 0.3679961695631554, 0.16764386797864247, -0.06650184240732221, -0.4941808901786686, 0.11891753435048456, 0.22306004023153075, -0.6341546534935277, -0.46270190994204013, 0.6350061586539826, 0.16798930825077057, -0.09602837707264361, -0.10346482372125601, -0.105466057620609, 0.2788374446912511, -0.20531839123895365, 0.7779228710829726, -0.16870724692081657, -0.13303133927387922, 0.32350401489605907, 0.11765454222233203, 0.08735445184656798, -0.04632286622549981, 0.24487318801217792, 0.29280214250496955, 0.3687006878401685, 0.08192136047508358, -0.014882460898862906, 0.2812851198170471, 0.22082460857577318, -0.412436365454367, -0.0709666501983772, 0.3030751127058516, 0.34121380410569635, 0.061172849475658965, -0.2982863557786476, -0.30868243162995623},
    {-0.09350962660817683, -0.7418242260037431, 0.05224738058707975, -0.4286639967932385, 0.21395522388956273, -0.6206211104586129, -0.8583349809883611, 0.7872778104870227, -0.785500356002509, 0.25615240087668256, -0.25872363042710506, 0.3243915250550237, -0.4299955519896131, -0.5499375819600152, -0.41799715230075696, -0.6370870861590904, 0.3542655407270936, -0.5863285679905217, 0.402443425003212, 0.05774980470380936, -0.4988762637408823, 0.624612579038323, 0.5047229351800172, -0.7162303533595314, -0.5441780685912272, 0.5382119260605029, -0.25370101380574483, -1.0111498802532948, 0.378787571012151, -0.9667293325353917, 0.19999303862801635, -0.20190546096224782, 0.2969885625164247, 0.3054034586126245, -0.4157310940529842, -0.2812284021492648, -0.7120720802753491, -0.5042156708514196, -0.8510406635010803, -1.0161631178573198, 0.5309531114264519, -0.8894286805096224, -0.6197663935675966, 0.1699740256478863, -0.19894659396599898, -0.8993458976810537, 0.5960052914111732, -0.054132078053003185, -0.9898871792862122, -0.37836490673728584, -0.9398720030599101, 0.4363961105074508, -0.4581619398412035, -1.0144878646188504, -0.47553297828022006, -0.9868623143456724, -0.7923396654409666, 0.40845517724891917, 0.05773914202692855, -0.42715677492072623, 0.10330979318358482, -0.36806050059795437, 0.04980681674285922, -0.4435110239380639},
    {0.13171994982567872, -0.617495470260448, 0.23686751990593305, -0.6365416123979496, 0.6220115422678552, -0.6488663196924533, 0.3588957072732773, 0.7436034048525855, -1.0768826501295314, 0.012049353608790737, 0.2175279758262007, 0.3646775836702613, -0.5250005969195366, 0.0119551205007322, -0.3054646550192286, -0.7099324078822982, 0.5066775961590876, -0.5807105926221303, 0.7470485182158176, 0.1878849609304412, -0.5147900606777411, 0.42109861793589937, 0.40510061614782017, -0.39804038356500265, -0.6804435881859077, 0.6111274664299496, -0.6483373380449792, -0.3232624645190491, 0.37544109299545697, -0.8899444232662043, -0.050004533638710415, -0.2740074470027069, 0.32018500609798317, 0.07778550102663731, -0.5047875968138301, 0.1878362191414514, -0.7538027987440921, -0.7175360076999604, -0.4488213999738138, -0.8282544511346346, 0.5048051739036292, -0.8025509905248863, -0.8330053774439335, 0.3744523560964221, -0.5356628614874662, -0.5552806092049127, 0.6397841772273214, 0.1684710844691013, -0.5521217011566719, 0.004550909324116984, -0.9433302310261683, 0.45461840515134133, -0.9696186860765373, -0.6430536669831589, -0.029451670915353723, -0.37506635893480716, -0.4256947186890791, 0.7020193128001497, -0.13527401876792855, -0.0975114183155455, -0.02806893093516682, -0.5296747651021791, 0.3651793314793904, -0.4475646893642439},
    {-0.2515402033409348, -0.24310593004145317, 0.3107149323082899, -0.09237294523355438, 0.5297057468142102, -0.47449176641537616, -0.819857044481671, 0.3955451859429184, -0.5810405908639393, 0.3651990226983179, -0.40341330257468644, 0.3229457463678464, -0.5124130947104993, 0.19727968417452763, 0.133403382331623, -0.4890231094609524, 0.10512590074633701, -0.2739911588529527, 0.5251282986629676, 0.473039977375535, -0.8136310904047368, 0.4256071668143267, 0.4056165337005031, -0.2377908949961509, -0.00412898613785847, 0.5195000616879342, -0.377303743314868, -0.5620853203591849, 0.18896983082445673, -0.39551409495643713, -0.4402936679194, 0.1842146965058634, 0.17965638871833842, 0.11395419522764569, -0.5079725383298211, 0.1660576116197598, 0.0048753256938678, -0.3432043365066314, -0.22759342763487364, -0.521038610228171, -0.2175297115262665, -0.7209505678310142, -0.5917481546148305, 0.07327310216021786, -0.267699427862078, 0.10362223136149967, 0.12205466553390737, -0.2598919392956632, -0.48425579671651875, -0.2858332533070402, -0.3421607231398904, 0.6567926880891534, -0.3893645443561933, -0.6813235476631719, 0.09491591136495718, -0.4443437214517532, -0.2653281660642505, 0.5752198744260972, 0.04716274269210314, -0.06640982346738716, 0.18568683142218212, -0.48094687684112253, -0.05414396471099866, -0.7260361522819827},
    {0.02551319279767946, -0.3710326193148773, 0.05048657225376461, 0.23096055285371292, 0.574416134920103, -0.6017725931827748, -0.06502525381518433, 0.7103044394945199, -0.07483546035915378, 0.38384321826219064, -0.8540435621036652, 0.11922085732722901, 0.30002775317259106, -0.3884842059503556, -0.6516171854269248, -0.43797616438505577, 0.4092149800590906, -0.197012843347232, 0.41126127942309004, 0.032331306851896405, -0.4522927662126091, 0.44561419822347437, 0.7444537512245905, -0.2390092964577808, -0.7433896054782702, 0.48528798092801834, 0.009941348793388623, 0.10206391148812585, 0.25515948500294905, 0.04258658618864072, -0.017295456987147368, 0.40183623396246126, 0.744572653677314, 0.46610006476354376, -0.04732311366529175, 0.14396261511306863, 0.05903744828481122, -0.563345109636694, -0.4480582711112877, -0.5269273477478456, 0.17471906240683507, -0.7517442866997508, -0.21880861130630933, -0.05597728456725463, -0.28793127125485596, -0.3985452561604816, 0.12551145924122303, -0.34879909170095774, 0.002394890540432303, -0.405122960749579, 0.06540915929474281, 0.5737059674878818, 0.5246995091310744, 0.0532376333252705, 0.18779052167803822, 0.12024183310104306, -0.38762835592437583, 0.2846080248367187, 0.29088501186983823, -0.3859466700867069, -0.24308207969988158, 0.13469129702417043, 0.8359607952948419, -0.4424702811148455},
    {0.1670907639366489, -0.05679945832002047, 0.20153316471140673, 0.6362801199959227, 0.5462555171453688, -0.7758282545796236, 0.07988473889067986, 0.7197480015101432, -0.4079334127073448, 0.5505404154675357, 0.2109978557429138, 0.7759581567290526, -0.5857111658736559, -0.17810025263702428, -0.1549846340927831, -0.7204341389206288, -0.08625788850232857, 0.2829081032014429, 0.18960031954318576, 0.04835135168493984, -0.05802938426537232, 0.1310801173496919, 0.32300392495975877, 0.06993837680835903, -0.566214095337736, 0.30441249654333546, -0.23750087107217638, -0.15095687219336415, 0.5195972215573195, -0.6705379638957357, 0.2347438249394497, -0.04271909925737711, 0.5419709382165041, 0.5833700137819886, 0.17320731089733873, 0.572916790105668, -0.5801802126112005, -0.5155293362709554, 0.07656976153162232, -0.2537421607134643, 0.03170957767864715, 0.002262236620771356, -0.21741878900357944, 0.437490031419008, -0.11588559619974152, -0.21234885864490416, 0.20929002353937284, 0.5123208246874397, -0.5850077151643728, -0.2658458169744471, -0.3489864866824302, 0.2547349982553644, -0.2926264838268125, -0.024291553938634792, 0.3176014823862446, -0.007501887242396647, -0.44341979783840124, 0.20760233508676992, -0.06608505223987338, -0.23205055238698993, -0.22375979692151723, -0.3045035316164432, -0.11613450738962708, 0.106249094782861},
    {0.2277219092765706, -0.5531061259549606, 0.7035690856511332, 0.1763165707340417, 0.4744273828646394, -0.6861133326318349, -0.047051750649901095, 0.2654665484069278, -0.07466553738538692, -0.3906316252154598, -0.747683687490805, -0.1893692280278567, -0.13918540491468834, -0.12978855131056052, -0.47743652050384433, -0.3072623951653511, 0.5729604920807893, -0.19749375456826965, 0.25266079208262354, 0.06770383964023592, -0.47617750935222825, 0.28894004178629434, 0.4017580240617101, -0.14616388813455636, -0.7284871191840872, 0.6438440960330921, -0.6175849350308866, 0.03440034327615948, 0.19998444225528975, -0.5909067653801193, -0.32586102951064444, 0.17515966989628495, 0.6980035339785141, 0.09574515645530965, -0.8667710170987568, -0.38752671965718066, -0.2541944966090383, 0.15500573343262386, -0.05364372587540962, -0.5574146282736243, 0.13028809308612563, -0.7667057072084301, -0.34608130628134376, -0.10937517576679244, -0.5866924465037497, -0.42778995716736073, 0.794780072477813, -0.012405552780625691, -0.7161802160527737, 0.13496444392042564, -0.4950637581175368, 0.5227338622855404, -0.7098482306399546, -0.3653430060951496, 0.22190875240302166, -0.0009755593207844712, -0.516948509665316, 0.5027523229872203, -0.07641524110224403, 0.0439457944911944, -0.44814795981787997, -0.3361619460763048, 0.2611677616617826, -0.5745878607652928},
    {0.4419150039554712, -0.2578552590660908, -0.05181986185216849, 0.00491341413439793, 0.11532515829917687, -0.6092655013388022, 0.2699224723966733, 0.3688294745695667, -0.15309117915694262, 0.32298528395261816, -0.3831855638322197, 0.2682571523319986, -0.5763344975665161, -0.12816101051985027, -0.6463813884482361, -0.27695044794462675, -0.09278592007567943, -0.164379163523234, -0.056913117406400655, 0.05603966839228167, -0.49887568700123314, 0.44302936054780767, 0.21496701262429552, -1.0132127580317674, -0.5495923827051628, 0.06501948019956515, 0.15907979516632773, 0.31242747685560424, 0.687062051967387, -0.5854643691634492, 0.03070948494065571, -0.1115718450974307, 0.20023753088629975, -0.021180843390381957, 0.17917063800941452, 0.10715976085453584, 0.22053200170757536, 0.031041270594834223, 0.1527266116773358, -0.32788908204340933, -0.031033932939448193, -0.4259516087727201, -0.06644495475969492, 0.04158043091917558, -0.2101953440703744, 0.22038935720213282, 0.2628090355849205, 0.3548534576050697, -0.4583429461310066, 0.49534009710731736, -0.06417375676725436, 0.307805737076788, 0.3971495165677507, -0.18022152961068003, 0.0009092069601944013, -0.07208635217957049, 0.029789888448611426, 0.03608211003201937, 0.04875038472971033, 0.41782186241153785, 0.0174258451228943, 0.15289372747606156, -0.03037076464722474, 0.20739662019462565},
    {-0.6142460520825659, -0.0595861459792629, 0.48757601372816745, -0.014338267724436683, 0.4269625918764617, -0.47940346404009127, 0.30424141606647626, 0.45653643538995176, 0.6434664741298826, 0.16979191818775094, 0.14581128594895826, 0.12557806385755627, 0.6474095290682371, -0.19302216946441417, 0.130205011278193, -0.6211032599209771, 0.3701425411944479, -0.3067630577594338, 0.1833153067158353, 0.543748251496174, -0.22085823693676535, -0.09147142066562024, 0.4062008823609729, -0.1841802158025759, -0.036493577266967815, 0.15508193124349967, -0.17712833195678565, -0.30847132819887235, 0.49255292315428245, -0.354604645918788, -0.183887761222682, -0.009274942254933298, 0.2919528023162805, 0.3514597025976559, 0.03250091898840574, 0.032471198267823013, -0.36461357821760787, -0.1358277066917734, 0.5804746910209425, 0.2783487658938318, -0.03855146566060164, 0.5290641567662082, 0.12067355893476772, -0.5993150488272686, 0.027721873859598956, -0.08114817775623188, 0.7980890248836913, 0.3788808247471425, 0.30631748057648545, -0.4704093332835166, -0.2870415689226051, 0.056727366311134744, -0.4812533963757804, -0.17720999532317835, -0.37398435560692905, 0.43050302234403237, -0.015068015307113804, 0.5632805846010633, -0.42236350654978905, -0.12852696051214813, 0.510816799968693, -0.4106643300207801, 0.05735554099568702, -0.3674510942282492},
    {-0.1834431163192322, -0.3989259076204953, -0.0455945576917078, 0.1828380003543053, 0.04068016968552815, -0.14123212628580445, -0.06127385732968611, 0.5338263802412992, -0.5071024108602632, 0.3012216955295991, 0.33394539207523455, 0.13245717314426822, -0.23319119167239374, 0.1311733456236713, 0.02657580485499492, 0.17410597171474737, 0.4857112114213335, -0.1860088675954597, 0.764803659932288, -0.21285858317993067, -0.4303638022211043, 0.5312981515849641, 0.5951610155799724, 0.04183314279599345, -0.5125499495066316, 0.1995821296226756, -0.5490816133239427, -0.09057789604416851, -0.03310538535470632, 0.14577908002221032, 0.19191549852136083, -0.2046602345204622, 0.25359860160602304, 0.25593285622610273, 0.46619076022817013, -0.03685384486460967, -0.17847122251759598, -0.5344852829062636, 0.21570984823683417, -0.7618736297335199, 0.2513207920396826, -0.23599637549072425, -0.6157041698926544, 0.0971926184922119, -0.14188236189298628, 0.20186907969843307, 0.4682280313071505, 0.2731571124337102, 0.3604683234890578, -0.21007576454762233, -0.11277450908045082, 0.33829668289316306, -0.3497101418346865, -0.4560327682242843, -0.05324011792931473, 0.36848793000103786, -0.2321155900523492, -0.026214706838304406, -0.02813870281951038, 0.5140562796512571, -0.024591160738388563, -0.4266083831859199, 0.25648995557203386, -0.2567394003738065},
    {0.40734488099743665, 0.28640061402414263, -0.04997883844728412, 0.20776332846667153, 0.00695590721066239, -0.7758096340608394, 0.44482451633908665, 0.27379057538996154, -0.4552617992974532, -0.34922922935263145, -0.09834388319135134, -0.09469599330448539, -0.18773322188741406, -0.6774959187041104, 0.16522048410119952, -0.6361317902059891, 0.08960296027762135, 0.035053062463928156, 0.28186429727406254, 0.028545629636880253, -0.12920046558305187, 0.21578527947031015, -0.014983464879785016, 0.3179153241401512, -0.23893943322120142, 0.4986505930367232, -0.23256828477948296, -0.3504156069483605, 0.3266591214018258, -0.21949102708357945, -0.5498483159684733, 0.5043979486503755, -0.11924751894632477, -0.1586029382423665, -0.40776610880876935, -0.327489045335425, -0.42878161423039274, -0.4774770247864648, 0.2697951814009029, 0.09224176989984344, 0.21749559046405315, -0.12303248722427636, -0.22022595261944264, -0.25840752162656483, 0.08719483542221527, 0.20498425902019246, 0.08103846456027033, 0.2584000183705892, -0.15291772149448593, -0.4476578692355686, 0.10395511851861136, -0.19947587604612835, -0.4725059100636138, -0.3327093864065141, 0.8230007730510469, 0.30469405989249715, -0.1147393960779049, 0.010877138264929276, -0.08628676417148659, -0.2880345460758392, 0.29473607282469033, -0.09493643981617796, 0.6466930688010302, -0.3231985121560113},
    {-0.1830713355671512, 0.018698243302784523, -0.4906700589712287, 0.46901999319103593, -0.035800925657733365, -0.40430039959464203, -0.45748573755344124, 0.6022631205320533, 0.194516756179372, 0.3318670737680313, 0.5139292195046372, 0.06549194568893538, 0.42619230248097545, -0.34263694618910606, 0.325000324938678, -0.22687140788023222, 0.24903131874551523, -0.4466547993642103, 0.22020833010273477, -0.16970717891879455, -0.36068102690142756, 0.3500937646617947, -0.37780465982368205, 0.09855935530914399, -0.4776688114651048, 0.3918436027676025, -0.11456915399742157, -0.36354188603697457, 0.31913862031043755, -0.717965650819035, -0.24567308429390344, 0.1347728980589953, 0.03485708723224824, -0.2497727412858841, -0.12001423815919413, -0.4011178307815082, 0.010139965790066442, -0.2786413861250208, -0.677482166201958, 0.3806603744890087, 0.6767816475157651, -0.5718887970984797, -0.40774605610337206, 0.2630726599020941, 0.011538550985681795, 0.24331869466563288, 0.4059577438903321, 0.3516982000432931, -0.13634976057280723, 0.2919272065882888, 0.04693332795324745, 0.053301208551434234, -0.3366670370798557, 0.21061124654140181, 0.2011454596622692, -0.1157984540659237, 0.4097930811799577, 0.5805160214985045, 0.1573789013475144, 0.05580108155359293, -0.10354023105924577, -0.00016368978206390478, 0.3617259361850212, -0.18210817518467726},
    {0.13968756705855326, -0.5155903074985597, -0.28623731014368486, -0.11571354796285147, 0.6236117416515331, -0.3253437907976549, 0.14997550125714595, 0.647446316910206, 0.1931407901396381, 0.7151481916717402, -0.30624257278563477, 0.010890961042522893, -0.4778985526660465, 0.3483682924042275, -0.2643999369157187, -0.2900856990955267, 0.5808992923366325, 0.12665405318023246, 0.31360298449116797, 0.022880580410055855, 0.45624504330896704, 0.1202595680383978, 0.36122259616947866, 0.6651285090022194, -0.2942185940650656, 0.007583947412936814, 0.021724320604480457, 0.08965994291473438, 0.22728016814692625, 0.23652779218871417, 0.04777627515606822, -0.5787462411288009, 0.26948877401525223, 0.0901118768311324, 0.40881200037685916, 0.4137405677195542, -0.18963695880915088, 0.08180304148568789, 0.09564161933362736, 0.05436567196710903, 0.2399896850726461, -0.16720411484004627, 0.43330420404027475, 0.1191947331964274, 0.2424969602269559, 0.09665396688401236, 0.3501161726898332, -0.2196656483304249, -0.45247730960884797, -0.23047033858940508, 0.04270616497702669, -0.12499397760938918, -0.2824421550047732, 0.18742720456049064, 0.19089137639908277, 0.15994641678979113, 0.14677758356720066, 0.10655021283090664, 0.6699204923182317, -0.7243685920387126, -0.6243192882186439, -0.021576627503249086, -0.4757930641483461, 0.08564991410071},
    {-0.1528494080010043, -0.45264586538322593, -0.03519175302667389, 0.2495581436612964, -0.16051436637784092, 0.27859869076006016, 0.3583186153053058, 0.36738991585290204, 0.531564798959885, 0.3288060963813831, 0.022004336995984364, 0.4147950407977239, 0.3664072972769264, -0.24311066763645367, -0.11604486411017667, -0.08137348009833459, 0.06223757417801357, -0.1361722205307055, 0.6725527019946703, 0.8083578239395782, -0.12795788354436705, -0.23042603056394, 0.6031273698769176, 0.29409619767753226, -0.037985042956830146, 0.45545044358889925, -0.06682670659735039, 0.43592411677125603, 0.40683930831253834, -0.13584738556082016, 0.01742307754263204, -0.42440072417845726, 0.1065953930372485, -0.2691266428068715, -0.4005631863841365, -0.5896835062143243, 0.006845121922228433, 0.006772808185155621, 0.05691953525710115, -0.2655855113776575, 0.21976976545840582, 0.6254755913286775, -0.06410339427248818, -0.011740132484490223, -0.531735107205457, -0.014752094156312796, 0.6349700935564091, -0.16931674603236568, -0.29701311483954485, 0.4309526891967227, 0.012319652230428581, 0.08572835335012458, 0.03905462754703102, 0.0690025928162844, -0.5859404018743115, 0.7037500478757042, 0.5140128391807508, 0.45819358352966894, -0.6423184133457546, -0.1715015548914582, 0.4118713439667751, -0.7807784944163216, -0.41706456006501375, -0.1427820857288126},
    {-0.31769358884653415, -0.49096994055712906, -0.041493650181086965, -0.47507836008174203, -0.2704034198804163, -0.047525554931732855, -0.3806192551589783, -0.030655390032058222, -0.10090957541690788, 0.146484550281716, -0.45184560826401976, 0.3538932162063508, -0.4662504166224597, -0.5988273142180106, -0.21271013501135394, -0.31924273175881207, 0.18590951266733383, 0.007269184795977183, 0.298501214924584, -0.008554192254643416, -0.04106814617838735, 0.09128600938306947, 0.10610595621030303, 0.28713373429550093, -0.34291341579344853, -0.3030297990017844, -0.2766294016546503, -0.06187490424752463, 0.17584409205009416, -0.5272409161821667, 0.42839152898627286, 0.3090116725253425, 0.2810747129014834, -0.4779214070215006, 0.8811845715871726, -0.05130657175730014, -0.13340374285957496, -0.4312140049522612, -0.08294568437898812, 0.3339685016931358, 0.4614554732369941, -0.2849303124945727, -0.3121379391911269, 0.516656578014334, 0.2233955475653963, 0.1871009971788961, -0.027342603459295758, 0.5981311625157484, 0.6042853329779426, -0.4566836925226601, -0.27720782579934183, 0.35408941073509104, 0.2068613723582229, -0.30686853614956827, 0.1648388406938628, -0.42574903838108685, -0.5159786522106485, 0.3872568233869758, 0.5245288635434227, 0.025600747935662797, -0.5563863188409626, -0.48677906922729314, 0.42128803024845246, -0.6096584519610405},
    {0.4379704268846446, -0.22125530825933593, 0.3064568963656145, 0.09727037738783366, 0.3476767916175562, -0.04897064420253457, 0.10258615164053347, 0.557250189837489, -0.18385306245479452, 0.24107676102910577, 0.20285863624255726, -0.16196956248626226, -0.13496364423915994, -0.01478442758176866, -0.34450028785303494, -0.11639511251097852, 0.19522412481566612, 0.346853504972861, -0.18554947122924786, 0.6334400857036515, -0.02976600302559022, -0.2647157288609201, 0.1550614489630965, 0.17093589117725005, -0.2843048394841486, 0.1626700403977994, -0.16559245424385302, -0.027779593955888544, -0.01865623864945378, 0.08181212153325022, 0.15790071880164672, -0.7047871359079109, 0.20536154718448263, -0.07109121543757198, -0.20468430327273715, 0.42914181764919956, -0.06852176535681015, -0.4773971500730476, 0.014531381729549767, -0.05111734801507846, -0.14233344041119322, -0.5586088078749069, 0.14155477334658048, -0.5739278609761063, 0.5617264160972149, -0.33621726762345194, 0.09836596591246423, -0.16076384777458466, 0.2899513932949988, 0.5525621262395836, -0.5696643336742796, 0.32666673426510767, 0.15650852480431154, -0.038113907570322916, 0.09790982540553521, -0.06430869033104013, -0.4095028818440747, -0.19853645602476858, 0.41498413838612047, 0.04645822076795802, -0.7693232263870223, 0.4718591760213639, -0.15730166503236112, -0.40207232731786097},
    {-0.22249254985769978, -0.3900463253474391, 0.5852601530699457, -0.36617480408057757, 0.35002979882820956, -0.29615851614792804, -0.36873400948737783, 0.44884780899076837, -0.5291533418831977, 0.006811320365217968, 0.11987993930478719, 0.7122479613017514, 0.3250577272078064, -0.14130660742536766, -0.21441410020591575, -0.07584700885321384, -0.018040184577425546, -0.41154444021472897, 0.3386755400538931, 0.44398621849846265, 0.4949773408751613, -0.11932250043389957, -0.007442257700541596, -0.16835567274092506, -0.5612429304001453, 0.6030196061430032, -0.17139107055761973, -0.10651600945897105, 0.10658428268917844, -0.4109574063846578, -0.43980050554616956, -0.19749535511311764, -0.18342026293564836, -0.024789603624999622, 0.1095844137745092, 0.47034315323324455, -0.47087832762983917, -0.005010713008121131, -0.11811079323731345, -0.0030015483907710598, 0.3567224153596421, -0.20114801804263815, -0.03686486709605209, -0.0028740335414852527, -0.7134270450044302, -0.5021846915450114, -0.6952959793900192, -0.0684006106817109, 0.23231125938074199, -0.17978978560810185, -0.4161249816098062, -0.005692455585626878, 0.18227728856641692, -0.21493235470075753, -0.17192909536481316, 0.1564258593010067, -0.4692830820099546, 0.17674599286096868, 0.40672487484294156, 0.022813117709019812, -0.5521115395517731, -0.7421199575614288, 0.2353220826396386, -0.100341465383632},
    {-0.06915022683805129, -0.07474318588676238, -0.1649375372740656, 0.17313685185587185, -0.5666460665285231, -0.02228452865356329, 0.00489316756770537, 0.14038796206055373, -0.36081219648789187, -0.27617564852336746, 0.1908710210381198, -0.008201927987569507, 0.11535439999886989, -0.4589033282088761, -0.028837573052097144, -0.5584217650204126, 0.7698109522166928, 0.408744132200938, -0.3422241254578563, 0.0977185097440894, -0.08659126984658468, -0.14891507590855335, 0.5455421649670259, -0.4467129741830732, -0.2764329026909571, 0.09157755452223473, -0.4313153565559044, -0.11994111853182628, -0.29864294376298944, -0.3477228768865496, -0.45037996770963995, -0.2970961480847806, 0.07765025353194177, 0.41555658929954087, -0.163529278831863, -0.025544098186226074, -0.7500110730978973, -0.31530839093127283, -0.18503677464217044, -0.04019510880804817, 0.024389441361233596, -0.29822781513657093, -0.6466543594725559, -0.385574065517014, -0.5054790766267274, -0.1973612790291844, -0.3206898578999766, -0.2962824244247677, 0.07745624212852217, -0.773296485861628, 0.27185178957698575, 0.2736429180660393, -0.5229933926682264, -0.37354761660976904, 0.2707393148860123, 0.08290045219041722, -0.02532301641364384, 0.1175789028999215, -0.10707848274644241, 0.06780062282193162, -0.45561785695326784, -0.2830554713325956, 0.251741446586864, -0.19385960516237458},
    {0.39953603428724505, -0.4646337576159469, -0.13246311348853435, 0.6972541561110809, -0.06867071108465418, -0.7344508729247119, -0.009885313465768816, 0.11902010104377149, -0.2470727480527399, 0.2786933926607561, -0.1366284813316772, 0.03992780506135313, -0.20988435947690126, 0.05985271692385184, 0.37766277635668766, -0.5111034494947388, -0.24079291479776427, 0.23882869092406, 0.01220890984046586, 0.09027866264324834, -0.1236357871486589, -0.23490520168123122, 0.47613540133133847, 0.2190772661409174, -0.29940918275705647, 0.21432411818277866, -0.3863577424078374, -0.3423546772443755, 0.28887683016680044, -0.07177596031937154, 0.18581223980756445, 0.26484927665512936, -0.2907266919395445, -0.11699974666055227, -0.4490516454667229, -0.4033688161471186, 0.11187095352609878, -0.2590692926863242, -0.20079296864770238, -0.33003246262829095, 0.4722687036076106, -0.585584056892699, -0.2905564567691491, -0.15292058977505055, -0.7284848103960693, -0.042481642097551744, -0.1043801706649838, -0.23462516711504783, -0.09122185150513397, -0.4001243518253819, -0.22746055363910575, -0.09666582605527409, 0.3734064373997514, 0.20862863247744942, -0.3112495499138246, -0.3124363176759248, -0.5091761517537716, 0.09537469880810054, -0.07605889392380956, -0.01003600371881291, -0.0011185453280479793, -0.6732341812224819, -0.531863434039834, -0.4130803930445493},
    {-0.9312995109949959, 0.4598412463028619, -0.18302421814007305, 0.216991692116428, 0.32774308595025137, -0.423972547159563, -0.09625652735963929, 0.5835045708569696, -0.051934608705938065, -0.08835860792150908, 0.13178286857544882, 0.19071772401734385, 0.3939552911680681, -0.29695527334233146, 0.3140656113943645, -0.44781878662032604, -0.09789513838494648, 0.2727622579574141, 0.3369804090378994, -0.3230197466640337, 0.5116922020579064, -0.39127667640081537, 0.16531673938003238, 0.2127367922738705, 0.16686327631428496, -0.20453533551209885, -0.30375990752488774, -0.3385793788788018, 0.3269578178251239, -0.27957151187405094, 0.11383527210292974, 0.35752637265251547, 0.34222464871672076, 0.013188740614921823, 0.29882264692236443, -0.6421501729891776, 0.14621296313027757, -0.27694221595217583, -0.19179177630590713, -0.08430386406361569, 0.8321221728322161, 0.12977159461187035, 0.2389707994263836, -0.6931525980280233, -0.11931142778883623, -0.05636236411458246, 0.1729292641783445, 0.39828927954812965, 0.3039368814035075, -0.6796664144356386, 0.4662313733438791, -0.18764145885788985, 0.29603996222356393, -0.34482290492789613, 0.19370733521917075, -0.0831097431695077, 0.31012586674874376, 0.3213441923271337, -0.006981577966922702, -0.2790473115928983, -0.4358875868248717, -0.24524419234360892, -0.16877237829032418, -0.08822545917673538},
    {0.21156433635015548, -0.07501168502154326, 0.08204348138723774, 0.31248143147235974, -0.24146479673761048, 0.18252636601790226, 0.43021904815324885, 0.5217121251023973, -0.601991554975608, 0.35717275228552614, -0.22137703344424048, 0.6773070845362825, 0.24140218577838918, -0.2826269916137119, -0.14907646159208485, -0.42538016623033725, 0.35493975533755806, 0.3633922768716102, 0.4138600372307875, -0.07551468873989008, 0.3863514354186964, -0.4070749537584545, -0.0008960125472399049, -0.09006410893405535, -0.32020163215297115, -0.15704481030059247, 0.2446108092611785, 0.7206312825387817, 0.13633685880381233, 0.01898196159267318, 0.4382337057727344, 0.2882102600626466, -0.43896584932379556, -0.05504080722609372, 0.10580694116064387, -0.4205398731419013, -0.11263809128930012, 0.2642527984038899, -0.1636243279633604, -0.11571741503937025, 0.002868061579819545, 0.008846354907004838, -0.3341523199498531, 0.2427539161674897, 0.12299439664790365, -0.08805072302198567, 0.5601639830147311, 0.02888904871764435, -0.14397719990080415, 0.069942734708155, 0.40543811997614315, 0.33077288316569237, 0.08545044422082443, 0.019149233734598356, 0.10112007153457084, -0.028563665238005607, 0.11352828424573162, 0.18506734864288352, 0.02316188390849939, 0.15805622008441114, 0.0221581073352043, -0.4364734084282915, 0.33261931389287697, -0.03931926635924084},
    {-0.294589475632655, -0.4471094836153408, 0.854718961052924, 0.07396281087935144, 0.702124400217742, 0.3426197811128646, 0.18265788779253123, 0.3155132046853557, -0.05843628500103566, 0.31483330978044677, -0.843767467801289, -0.055069251210091534, 0.02014339511777532, -0.03677191627187259, -0.11806007722711268, 0.474280498556973, 0.2676500771348087, 0.4927654937258426, -0.015069842902941482, -0.06057276641323503, 0.45605126622068287, 0.12589911471690582, 0.1631918190100459, 0.20202769095099413, -0.7212952408375313, 0.046731388654224125, 0.4257813571297244, 0.10139965913974386, 0.12935319763689623, 0.3460945749319265, -0.21486176293179893, -0.1078472210678545, -0.41351826664016345, 0.5891501254461343, 0.191060893966184, 0.13137946404647013, -0.21544901039039172, -0.31172366841718796, -0.3186117623110568, -0.25662933910607083, 0.2286265678017296, -0.4284828044155966, -0.1412278942053973, -0.08368322654902056, -0.5671563577302036, -0.5217225802189881, 0.22421333567347798, 0.36678983864112086, 0.52667382916589, 0.003922287385253355, 0.11792539508120806, 0.21458500368958844, 0.25461602712482273, 0.13703541523249782, -0.04212429645512928, -0.10045645065426957, -0.14887890597524997, 0.16321408775317703, 0.1289735954527604, -0.1982982488533111, -0.4795523162295784, 0.2658659662252309, 0.36271946118542797, 0.2445731783553735},
    {0.24046821143016398, 0.33280212720897184, -0.44427028994470763, 0.2848678351117551, 0.2721514297778431, 0.11235053098065828, -0.03640955858401168, 0.5063075189611342, -0.14596574807285753, 0.21225843924607804, -0.2464195823611683, 0.44985967842983215, 0.2826225198178086, 0.16179498963779537, -0.1543566504479093, 0.21027433903926462, 0.1874864924432857, -0.05707212512304129, 0.6976650120906571, -0.7918814281391504, -0.0021629315826594054, 0.36988921696557, 0.12013282432433749, 0.06730851042781223, -0.3926923420471264, 0.2874616144372197, 0.5635283403413877, 0.32873257410619566, -0.2347267516631079, 0.49618702085531413, 0.6620819943129163, 0.08670669594929582, 0.7623506628157452, -0.04421399649440169, 0.0396051534479079, -0.05339541727011783, 0.2424351281932982, 0.1339595562929768, 0.021155425836177327, -0.3554214802579978, 0.4341633515706532, -0.6028447829991643, 0.4278143001261223, 0.2684918824318053, 0.4236268147004634, -0.4409998853220411, 0.5599043006365106, 0.5637068075701174, 0.3385488761022414, -0.19488323758321235, 0.20128633877443114, 0.08707972314954088, 0.1944842969690342, -0.19378558104195445, 0.6532195777070298, 0.40825890594695585, 0.07559695446080254, -0.12504865303393395, 0.026892194238894686, -0.12724498958976013, 0.23989998404534565, -0.49032166953078027, 0.6733166791786604, -0.12003962681347621},
    {-0.3377340262890689, 0.26020412698642326, 0.48303198900840005, -0.04354714099667177, 0.07982095724340849, 0.11056624931424229, 0.5539599335213029, 0.3735568384311704, 0.23779981009681758, 0.11589392931434363, -0.08141051520137732, -0.13899153236411504, 0.12190948874120391, 0.19662035007400208, -0.30622908898193124, 0.30697318303936494, 0.2680754726228587, -0.028062746500744803, 0.4532388630398022, 0.14002383291226453, 0.430919874024245, -0.04595147335282909, -0.24222406821286516, 0.5386421485500742, 0.2190594078057658, -0.04317815765049183, 0.24416308739531783, -0.5025184644463137, 0.05642409546527346, -0.46358537262844485, -0.032485664133949474, -0.15008039557787597, 0.851358672801033, 0.007595411486900944, 0.15001442440772939, -0.38389053544060475, 0.23114240791154672, -0.3439568188178386, -0.05111201020131772, -0.3407761397004237, 0.019158648498776524, -0.08181611746287092, -0.554147564165615, -0.5068735091184173, 0.18551519573452407, -0.16879991658741042, 0.6194480571216051, -0.04066872758871738, 0.664688830245235, 0.18522165863218568, 0.18560858932732807, 0.54912912458004, 0.052775248562400456, 0.02961848489515392, 0.15278022114188605, -0.099128901187915, -0.40081008418657105, 0.1736648877245244, -0.17532859470787546, -0.19280203966245477, -0.14465709327581955, -0.6236457018202428, 0.07124547819543418, -0.34337777569905803},
    {0.1347074831853928, -0.2996291479809149, 0.41425816370666624, 0.33410423486731466, -0.1844245674217228, -0.023295631056498487, 0.054741326032646385, -0.4437337993627585, -0.0643374341241642, 0.15893309196453687, -0.3093831812439881, -0.1362956796188208, -0.8146689953485584, -0.04463183402827085, 0.3001532293086131, -0.005899370789126102, 0.3358119182769999, -0.08685108206033401, 0.1287672993756043, -0.2870878341862063, -0.4908162936049596, -0.30755045425782784, -0.32334777755894734, -0.34564892695970995, 0.17666369449063885, 0.6650563812565711, -0.29880899737834293, -0.5230391012557744, 0.022683519140096968, -0.23931120261294933, -0.3435955686142113, -0.5133350133963832, 0.7829580494220871, -0.0495558152098575, -0.2626001181093348, -0.11069109935701531, 0.25035320859711324, -0.5256308841299786, -0.021865707461172085, -0.0846719625882528, -0.18346118633334663, 0.42864850595568693, -0.0825939488099682, -0.09617252743761041, -0.14151769603095418, 0.12489460873681912, -0.0018225098400568266, 0.20981210207059492, 0.07467730985127059, 0.6186849192934137, 7.3800695624572235e-06, 0.01253567829497803, -0.2730056421912486, -0.47750126065819787, 0.3512388682259737, -0.7045338027958281, -0.17938771560804045, 0.24571439922935115, 0.2640552665362042, -0.49459219909502894, -0.6691242889227127, -0.12317857876795257, 0.12436895128198339, 0.13798456406298282},
    {-0.5123657391228108, -0.07447879546367406, -0.07595679044152219, -0.14281413104712348, 0.24026161690440426, -0.10553570248634149, -0.3232401089568481, 0.14981808000598607, -0.2112942396047816, 0.0067013157888628685, -0.19068257886751866, 0.024975549423312475, -0.16072684120758482, -0.20659644552887005, -0.2310648903967109, -0.28965338862785023, 0.23896162859115216, 0.17548100446328252, -0.07083531028307266, -0.18902485274710143, -0.2874692285577829, 0.5234247290909948, -0.39235640766051155, -0.07928555084811775, 0.03445320726543781, -0.32332186735626545, -0.37400179461992206, 0.04832419105232432, -0.2630265243663405, 0.3354658315343363, -0.013198235043605958, -0.6702230513548693, 0.11426534634228981, -0.7649768402238227, -0.566446086266425, -0.13321772929449885, -0.46076844782862325, 0.04976370327654357, 0.45781378140597456, 0.10504774381592877, -0.3145180046494651, -0.37635178376424094, 0.3434179461566679, 0.3357322060419139, -0.07846664044858422, 0.09399965409547976, 0.35554599598816383, -0.013122077517621518, 0.461374994362635, -0.4453605727111171, 0.04335618563986362, -0.3284567131360236, -0.30238668108326966, -0.14692996590336768, -0.1644089604076465, 0.09768911744665941, -0.03403448899061653, -0.17578645113630853, 0.48260581191461255, -0.0786189467176994, 0.056719703576540687, -0.006100724905792548, -0.16325853477592558, -0.23747395625953854},
    {-0.1418974572742993, -0.14218568037983922, 0.16477419608423763, 0.009791423819544573, -0.3309700976056903, -0.18406432070986642, -0.04796465488191272, 0.16551301367882446, -0.22396466537431298, 0.422470767591137, 0.01276285124019915, 0.016843063938891675, 0.1378275405262755, -0.535453385154883, -0.017532199452536888, 0.012531121371992164, 0.6103734026366645, -0.2780761784030353, 0.2064237822566721, 0.4726152884812055, -0.18257681263363804, -0.19997378366441537, 0.25563736095708245, -0.14863860931869247, 0.2502453556481643, 0.7494518351484298, 0.2373902620714639, -0.25697149644201855, -0.023136505923373022, -0.10023578326911732, -0.002300563592693187, 0.20772229360792918, -0.13255147138068302, 0.0809430059446638, -0.2050112836096364, -0.06327586754761808, -0.12069547410111654, 0.21943411427542628, 0.009072128855642276, -0.2769889857496106, 0.3393175138625115, 0.0794738492640235, 0.5646491987384579, -0.2759125277444556, -0.2447959946176952, 0.2026263452757058, 0.3489768199456879, 0.026374428811688444, 0.5532044989916488, -0.5429010941556655, 0.35073632186651743, 0.03240370273144944, 0.08714104419238496, 0.18918805896149324, 0.3767023548952544, 0.025759959728697653, 0.1722975425776741, -0.02379163522099857, -0.259366690604983, 0.14790582758132523, 0.24164567973979584, 0.16804105972173483, -0.4023627428503197, 0.18228692896953405},
    {0.031258869617188496, 0.1971185471051934, -0.332285823783586, -0.2148508729241257, -0.08499838818903573, -0.29450737759700124, -0.54292313345897, -0.17388412169153591, -0.15898837838867422, -0.7250045127361816, -0.0433678699238629, 0.02180766136244467, -0.3277501178458215, 0.26130145496589396, -0.08158450323786967, -0.14212549147097187, 0.1501374753115691, 0.19116667906570226, -0.16925410692897527, -0.1961418884427508, -0.7806995198619858, 0.32454161287867606, -0.19727167482201047, -0.4523715422677481, -0.3321131950547526, -0.11467821301792712, 0.05064658787113704, -0.10282903502460525, 0.10537597598337406, -0.638579047422643, -0.43450183388452474, -0.37705167451434946, -0.517653055201811, -0.20583325857652254, 0.16054357606684969, -0.3790074926062605, -0.2807485762239323, -0.2340078239411807, -0.4184302362129794, 0.5001552544710364, -0.04797989409027416, -0.2029555231367704, 0.22198457658265391, -0.17482652720783226, -0.49300033481996625, 0.2579109098741694, 0.5173068208854718, -0.42869622936246116, 0.4449096892051524, 4.586641939480839e-06, -0.6588012662666165, -0.44407229359789574, -0.06823759766854232, -0.31537644378962953, -0.19383396730070063, 0.325649306739285, -0.2979067626188375, -0.45710427565770684, 0.009786924513768273, -0.45355879119383097, -0.2996052474101222, -0.05741192684637067, -0.3243124749812769, 0.18691421350997278},
    {0.20007330719139976, 0.0013640652249892367, 0.14475578556366756, 0.5104113017437305, -0.09808474995401288, 0.3118476870140665, 0.7098337829689455, 0.23234788730932834, -0.031978624755267145, -0.2700166723113715, -0.4939185280119159, 0.14914827561451513, -0.6173088486006176, 0.041355398788220275, 0.3636915966131369, 0.519180416828265, 0.29461861949239826, -0.001926371375851817, 0.17354122834623936, -0.056501032556816155, 0.17938444609229198, -0.5458724845595955, -0.23401561698434598, -0.6723043190155856, -0.49004993984666007, 0.20022519427751795, 0.5142461465887366, 0.1403551068182064, 0.2862459104615914, -0.23119375003556186, 0.08021046498373842, 0.7530561106958672, -0.5239979254276678, -0.0385353409999865, 0.17421386267918715, 0.21041227251403224, -0.21094609979268275, 0.15170059670327105, -0.033532969686073416, -0.02289621366571598, 0.4304274167263369, 0.17209415464884573, -0.3580827776985365, 0.3040088655828025, -0.4769293953232809, -0.09995006328190312, 0.12150911520060866, 0.4190170916309628, 0.419304235287407, 0.1431883517033961, 0.9786418061374293, 0.149465161672831, 0.04283032473401725, -0.6036262280577374, 0.5064611008679047, -0.44158830583537223, -0.12690482306247705, 0.6971284580745087, 0.18715567987243947, 0.35469620158702536, -0.16605948320011124, 0.4284175031668665, -0.06670704904406367, 0.1054999365232526},
    {0.43820983931375834, 0.11871680419168149, 0.5186880332648687, -0.25350742570680035, 0.6645343844563714, 0.09766250219472145, 0.03426899211024738, -0.11521953213400647, -0.04792957514699844, -0.1141896662594648, 0.25323219065257174, -0.3207178426166247, -0.10999826777501259, 0.13839671102803378, -0.8568591512827348, 0.36196189748454016, 0.3640528471076316, -0.40581083809378277, 0.507351710341278, -0.0474624175679202, -0.4897985061167341, 0.2553110112694414, 0.05232202144998269, 0.42125372818223217, 0.11322874044400187, -0.27682369279385904, -0.4597766093768163, -0.5433483198237808, 0.17743817467180847, 0.21712418286393725, 0.37172003459077324, -0.0743139744136219, 0.7023569077944833, 0.03879337373827196, -0.28087018001402597, 0.4223826637984943, 0.22958810777487462, 0.04172262693360766, 0.2649266013385269, 0.2735252022702694, 0.7662168308028123, 0.3672953586456086, -0.6385002248927623, -0.3106872087080218, 0.04426665911251131, 0.5702536599611991, 0.774469411199833, 0.357840917337316, 0.32954455336845556, 0.33953502410587033, -0.28232474291326526, 0.5161530554600482, -0.05627386466662813, 0.2606516749032191, 0.44538905867194467, -0.02248126060687934, 0.6136891911575993, 0.4033681512324846, 0.1427693304790879, 0.5054797188831154, -0.5115930082438117, -0.562218863432383, -0.45563728400182046, -0.3147371772536027},
    {0.37769176092921614, 0.41823956978999444, 0.2880176600570304, -0.2117968691365345, 0.04768284151235145, 0.6201464208269543, -0.17288192810084466, -0.26337183193354463, 0.10576535035310129, 0.3381692251215864, -0.22926674067185648, -0.4200382251924113, 0.24729635609283895, -0.25730557995770165, -0.39336357141216133, 0.17608571054743363, -0.08589465134160737, -0.687321085081709, -0.07755558593678964, 0.0976718168216181, -0.19602043500024055, -0.11339869671393361, 0.3301788959482124, 0.41928106081949174, -0.0628000141437561, 0.14712684992995992, -0.28195615373707394, -0.10956927940311981, -0.0771896970098837, 0.28140260156824665, -0.41877300521548744, 0.007173116584013944, 0.22413773645353746, -0.45917027302673175, -0.013732575985653736, -0.48346136680800644, -0.16060698914588734, 0.013528032299739439, 0.08892487912262914, -0.10869118079354625, 0.6653895347508811, 0.3534935082286683, -0.1406884602929675, -0.26817323221935485, -0.4119208632197054, -0.4054344574326726, -0.5777871626779773, -0.3852018043058906, -0.4447990417733393, -0.38819883026772267, -0.22229025855990547, 0.10158280856571755, -0.4940213939359464, 0.17355129688868232, 0.39142581001602517, -0.1469418541108997, -0.1236175910006374, 0.03753707875993631, -0.5152795963369264, 0.4647177714965038, 0.029824048434564047, 0.09272823081244969, -0.09033134063392159, 0.12096050113208527}
};

static const float b1[64] = {1.0653316262233807, 0.8112449718099175, 1.0160046756560126, 0.9694974405153322, 1.0606599084383246, 0.9655519743003571, 1.076677205443676, 0.9271981203150804, 0.9853510865223889, 1.0029110652005135, 1.065251691878032, 0.8934790506213449, 0.9768820233420025, 0.9714079921531729, 1.016998558892234, 1.0571068347615744, 0.8246275126029909, 0.9612123344223172, 0.9250813209612125, 1.0299851615729763, 1.066671270869599, 0.8145455457075327, 0.9426327860251127, 1.0517688831870677, 0.9925250817301717, 1.0373283859473856, 1.0095344206222285, 0.9820766035475362, 1.0490301779100977, 1.0022533737242345, 0.9824344941800764, 0.9942031113775442, 1.0539394208911623, 0.9747677606292452, 0.9803269965041151, 1.0392827716676223, 0.9640989864980517, 0.9218174012070076, 0.8740387810942934, 1.0279325927511755, 0.9289527646714761, 1.0236703579937527, 1.0712967622604912, 1.0169649508957332, 0.9908857245269181, 0.8840614051151089, 1.0771252644950489, 0.9281496942223306, 1.0433211049556943, 1.0633459076960399, 1.0551564845212626, 0.8496920623970955, 1.0578029300999747, 0.982046642108813, 1.02381948329851, 0.9315711615434542, 0.9346769245725445, 1.0524259634373982, 1.0126813211237526, 0.7868087748605431, 1.072024532086112, 1.0332173145441534, 1.0787527884066779, 0.9833521332656526};

static const float w2[64][32] = {
    {0.8591430263146792, 0.9625402605485586, 0.7974904106819833, 0.9873991939360962, 0.5822373288774388, 0.6470468860566626, 1.2456325200059857, 0.9743816410794128, 0.7069521389088381, 0.5619477625534816, 0.9379686342260037, 1.200078230085959, 0.554645792802133, 0.6626752118582532, 0.0523844746545117, 1.1290378687357745, 0.32538849819094934, 0.8426538659324283, 0.8963547291889498, 0.8831008071187013, 0.9201649635152327, 0.9250381983574577, 0.6497383799016384, 0.8513252704783045, 0.8234532185747977, 0.4670659646005475, 0.5438160560134238, 0.6561621470230962, 1.0719052503475293, 1.0710776866280534, -0.08026321108415153, 1.1638740274128998},
    {1.1027683383197837, 0.7384669107929445, 0.9086173737692647, 0.881066004335706, 0.6972231550993879, 1.1319703654552113, 0.7206634578820778, 1.169176634560476, 0.6946915283123446, 0.8162289211898649, 1.1276541628598482, 0.8947117224982274, 0.83709669320031, 0.5360808268256115, 0.06945122837717932, 0.8339077961305984, 0.15850246894016642, 0.6621200507152198, 0.7931547054189123, 0.8143596921134766, 1.093866046123584, 0.46907102054224675, 0.31734721210645583, 0.7380737449730407, 0.8310677140643439, 0.6286012710500181, 0.8060444437791596, 0.780022298028359, 0.8388456696727921, 0.807227543078944, 0.0713000766700684, 0.6922126474094664},
    {1.1524020713543217, 1.133186049545865, 0.8613804217339185, 0.8481436310737756, 0.7953642464016261, 1.006948014252414, 0.9043785258176519, 1.0008361606493326, 0.7277485603211372, 0.5541628014983013, 1.0413422874114897, 0.7412162627157244, 0.943988016066865, 0.7474378421704626, -0.19041467019013347, 0.819879358410191, 0.5977673235586133, 0.8531425503858244, 0.7521796284398063, 0.9596859127748647, 0.9478216795693455, 0.5725849392640686, 0.541390007807128, 0.9827738020041283, 0.8161294163984413, 0.9656455222676904, 0.5264546489523217, 0.8492854947876288, 1.2228372932293836, 0.9748163264765886, -0.22527077560522785, 0.8470792631282595},
    {0.7972511219177512, 0.986619456111242, 1.2670310514867473, 0.7574358259882125, 1.1166833175495265, 0.9146190074761709, 0.9369460866334497, 0.5902054603910015, 0.5901756603328674, 0.7300219810904518, 0.763219767648042, 0.8680566284422068, 1.1337992590254238, 0.5404119276663462, -0.32618467479176244, 1.156932307429572, 0.5047512097012072, 0.8616291663625668, 1.0108386646226672, 1.0072265220185017, 1.0969763659095837, 0.9085143282756585, 0.5398026319715481, 1.1857101027151509, 1.0706119038390411, 0.830514681397613, 0.6590742104077623, 0.83357209199064, 0.8095606080877883, 0.8761317993792185, 0.2647036200220875, 0.9341394195429527},
    {0.6309159280032589, 0.6122973785507214, 0.7752730766455949, 0.9688310081942183, 0.9004943315529911, 0.7707334262368654, 0.9352906978124536, 1.038953950487277, 0.8788899848980579, 1.0729678045539959, 1.2237359357726303, 1.213283065409337, 0.5979798614312228, 0.5474430502124606, -0.09229194619878357, 0.993775373838938, 0.4241174869148828, 0.542754612511892, 0.7457343665101512, 0.6677604777728905, 0.7522132785409462, 0.6217904997628084, 0.4303047357715714, 0.7735399210186309, 1.0649391368809817, 1.0073623232089424, 0.3606391658578119, 0.6768867628781533, 0.9239140357774698, 0.5637828434609483, -0.1715525044485358, 0.9728092364068043},
    {0.8188754645470789, 1.0720838497621001, 1.1406839974435243, 1.0749462726487247, 1.010214495457941, 0.739182083380726, 1.0965896439644909, 0.7954776500846057, 0.8692065503448122, 1.0124117258440517, 1.2897974947578397, 1.063444873784729, 0.7148526206838512, 0.7598411080729739, -0.20689713394114767, 0.9422475844605753, 0.24312500614514376, 0.3832935332349652, 1.4227006166097056, 0.9111080855842824, 0.6686579079339712, 1.0382339028751477, 0.986538155001102, 1.1902840938921713, 0.9441190323821872, 1.0075486798524502, 0.5418351614468218, 0.9986280125872954, 0.5947751555403831, 0.9552707882646191, 0.375899373444524, 1.102905843132347},
    {0.8213314966501458, 1.14737137057541, 1.0547553758881743, 1.0144098318098815, 0.5839380228694726, 0.6457798765088585, 1.1461667850677995, 0.9443148024449114, 0.8356007967171232, 1.02609019613694, 0.8906393008367272, 1.0050414488900032, 0.7725368838429326, 0.4147277316244184, -0.14841418230950043, 1.0412608132931085, 0.4090259797565693, 0.8497339395136665, 1.0355316573630042, 1.0059966513640166, 0.9577707152415669, 0.4923124446701685, 0.5801000808845432, 0.9040403470177948, 0.8985339154602716, 1.047890721307298, 0.6481563849335297, 1.1917540352612295, 1.2335640011387663, 0.7099036546857109, -0.053410469709266294, 0.9610783387835468},
    {0.6745880213292054, 0.8793345762408767, 1.1569307105229518, 0.9800562890122458, 0.7470144771533771, 0.9491893046191663, 1.1698821477272239, 0.8222617633036763, 0.8901168355061034, 0.96753934240221, 1.0162750503656597, 0.9838264907159554, 0.57641840050675, 0.42552662930228674, 0.2007823187698897, 1.1322106380042687, 0.6392963547395194, 0.9091828335593863, 0.8169166093874745, 0.8145138683234061, 0.8206918272070499, 0.49508471625259526, 0.07985308024172594, 0.7630837711867876, 0.8310187344461932, 0.7680983936765896, 0.5936195430146425, 0.6635457863858725, 0.8530951996201687, 0.7681923485167819, 0.10868403506218705, 1.0211484830779995},
    {1.1305265008138001, 0.6170860838181774, 0.7556100759981944, 0.9085957503582494, 0.839305865475827, 0.5202596157835133, 1.101550470532201, 0.997099226417286, 0.5032590004931117, 1.0774962910221983, 1.0354046749662473, 1.0524062063942259, 0.9899432285357953, 0.4660198239734423, 0.03881548005356766, 0.9644907681579853, 0.3487789165198597, 0.904900260824447, 0.8869438287619942, 0.6986408513654043, 1.1922873342278917, 0.8979175289605933, 0.16132137501414287, 0.8994096297373234, 0.7811655401716016, 0.790525252171381, 0.8958505907475608, 0.8901966092215635, 0.9871511357718624, 0.8491016017858469, -0.4225394043870968, 0.6966420783571522},
    {1.0400996728643221, 0.7462829754610579, 0.7596863204308555, 0.8562985820752824, 0.749874129404986, 0.8738098176514228, 1.0781928007050838, 0.796553548184333, 0.6158245070439085, 0.9245666013703927, 1.1681615947009725, 0.9234673858623362, 0.6628480770934737, 0.37709339281051996, -0.0864830144861497, 0.8625304348498078, 0.16433566514678796, 1.0603487534329452, 0.9877072903036705, 0.65843877103636, 0.6560269367871523, 0.7461570414979518, 0.6391367201532309, 0.8937556740937483, 1.210133260673925, 0.7477649730694219, 0.4127786209885219, 0.9961326351344301, 0.669877331928194, 0.974662448281233, 0.18370319715384612, 0.7974422059650511},
    {0.9479140350268481, 1.0296276294808056, 0.7991037290754459, 0.8619603685278966, 1.1962552518029013, 0.5498072359097408, 1.0768613277589423, 0.9477372177812238, 0.9180129969306657, 0.6535373866958195, 0.7664463114268377, 1.1159776393021206, 0.9040776258735854, 0.3992064956875194, 0.2508277288087334, 0.8731834122313366, 0.5323552581936316, 0.9265984550006379, 0.76249021966615, 1.1824417592317151, 0.7152641028767591, 0.6727433548292269, 0.6772309520723189, 0.774367378132685, 0.8210734106181884, 0.7644002942393223, 0.7218339760483772, 0.9554754373453522, 1.187972258024758, 0.7195228521839329, -0.08529644730046954, 1.0614991030113115},
    {0.8975654295888217, 0.8542199680873582, 0.5708263049571961, 0.7972671896321164, 0.9961999664806189, 0.9657221973524991, 0.9028828645393506, 0.7616043065682898, 0.9289812727482701, 0.653439430000922, 0.8977481046583943, 0.7851020542858104, 0.8765127402562339, 0.7296047288267531, 0.045369939391299616, 0.994498821330444, 0.49135057715659436, 0.9180346319418271, 0.8182627568622403, 1.0650944463766272, 1.0598656985468333, 0.6137391328047237, 0.4048490952592109, 1.219544214567465, 0.7535065469610911, 0.6519398766565977, 0.6037506959106397, 1.1274143609247826, 0.7452115080641186, 0.9201617699249216, 0.2265367331644344, 0.6813895709671324},
    {1.0515552912937287, 0.9669621857838989, 0.7199733175273665, 0.9294313324852393, 0.7673535388307985, 0.9407255412751864, 0.7045486092296419, 0.9599266622756848, 0.8259693583167367, 1.2146361075573182, 0.6218974866510839, 0.8179903965375078, 0.6519814192125833, 0.5296331947008441, -0.19579940397916543, 0.7877066869373169, 0.28548144162573824, 0.9352230378966333, 0.9636478874515672, 0.8038634351580334, 0.9097842589193235, 0.6355173387862547, 0.5839859066281234, 0.9504104546727095, 0.8867346580321366, 0.6767551171860584, 0.5170551465538181, 0.6614088615329162, 1.1419633045058544, 0.6156843843338305, -0.31643204854195, 1.1152594845132844},
    {1.1175813835690174, 0.8669874059366774, 0.8499709662493173, 0.601186396472035, 0.8341699595692913, 0.9269935129119028, 1.0230486861190737, 0.746289855630489, 0.9223463937120028, 0.7946878003653518, 0.8722284712312867, 1.182488989773279, 0.511816081539187, 0.31316330256056485, -0.43451038364791417, 0.9149294674867752, 0.5528106535581105, 0.5746617581045463, 0.5698370460059987, 0.6820076101377046, 0.8835301537864451, 0.6680315734171163, 0.2520162523575717, 1.124311584530438, 1.0522312844271824, 0.7583593570317472, 0.7967369252752251, 1.278283242685161, 0.8760865372714345, 0.9294097037455085, 0.10539520351629378, 0.5502321334907339},
    {0.742035251579158, 1.1246916644849145, 1.0016581398631315, 1.0717256176932852, 0.8372927636198855, 0.9063890371094139, 1.219394219577936, 1.2311776337285063, 0.5655703846187717, 0.7354188430982634, 1.0244991345860925, 1.2060505197143245, 0.8671035108049072, 0.6491363095193924, -0.17577059793137714, 1.058193656342279, 0.5342392875381302, 0.9160179311560672, 0.9558453578331575, 0.6020119391531739, 1.0449452860141042, 0.8507924277200024, 0.4996187083230717, 0.7055748098539866, 1.0862221058839052, 0.7209432355555194, 0.6635869730807022, 0.6659896440208619, 0.8554292737620884, 1.1197483221428506, -0.19474126726975877, 0.774214100216809},
    {0.9815331582821796, 0.8977154941021334, 0.7972887038393703, 0.955053831241569, 1.0074510668189833, 0.8828441778472977, 1.1361309777355038, 1.2553414766220077, 0.30647906102757394, 0.49816883582004173, 0.7192657304539158, 0.942104474114957, 1.0203875014165846, 0.6123938430998406, -0.022282752499462426, 0.6064201362297258, 0.30640377444008554, 0.8483050298935391, 1.3419300081371788, 0.5548644178106252, 1.057891919163053, 0.7582965040475115, 0.668102873681526, 0.9495509473125767, 0.8121526960702726, 0.4949114929821727, 0.5587296636062722, 1.0424970973690777, 0.9035511333655457, 0.8274322135095569, -0.1398099831261592, 1.0483018359432765},
    {0.6678018821882237, 0.8749979076859391, 0.9338680312802954, 0.6856846325444332, 0.8792390347940074, 1.138184934717807, 0.9137297321546296, 0.5419039081376397, 0.8690356295757582, 0.7582537786046065, 0.9110539215778473, 1.0123754915212908, 0.7456269397642776, 0.8747136083724201, -0.07694395833644754, 0.9939565410338652, 0.4955044092305082, 1.205722344824795, 0.7712662179432218, 0.6100126324662135, 0.9484179858944446, 0.6880842646797957, 0.5185171121202594, 0.9684540810579862, 0.7321298306335441, 0.7063329305624304, 0.6360159904852318, 0.938483638882769, 0.8621737966182139, 0.7632343126545744, 0.20304818603086477, 0.635449228947678},
    {1.196001153835122, 0.8267724823007906, 0.9767643145446844, 0.9032521740984188, 1.0773023988715498, 0.841145456299328, 0.9101278521455318, 1.0124825358078242, 0.6927312351833047, 0.6185854031590279, 0.9014035158134026, 1.1494278384915222, 0.6351324140370674, 0.43412962631743546, -0.049012132475271954, 0.7885845059270021, 0.49909665734306335, 1.0867163405386615, 0.5939905216985908, 1.0522471848005432, 0.8770063020939226, 0.6213676004949467, 0.7405731409794782, 0.5864501908866723, 0.8707145227060458, 1.183507435377739, 0.7342964603480486, 1.004264630466717, 0.9010694709626177, 0.6090187442083976, -0.19380569414136709, 1.0200856852422748},
    {0.8076246159177654, 0.9724494262504315, 0.8490577424392245, 0.8836499586847943, 0.8019378785411387, 1.2882983682578426, 0.596352360646148, 1.0482524641182056, 0.8525683365805303, 0.7263039217836197, 0.8413055224998474, 1.096629837848754, 1.0725017452408434, 0.4926618434074739, -0.3146752971209618, 0.9699896888342849, 0.2788456501162577, 0.9341268512659286, 0.9906921998165149, 1.0725932700323086, 0.9672728968840892, 0.8995520188875415, 0.566446317296323, 0.8498774565329015, 0.7870204548823015, 1.1470493073894072, 0.7746196166003438, 0.49698727225986794, 0.906391376816005, 0.7487050730335797, -0.1462720402303383, 1.0287795914098798},
    {1.1373182108741844, 0.9415114586994303, 0.8089979753554285, 1.036762904107984, 0.8718974944665194, 1.0974187123442105, 1.0944029253478726, 1.033007612140114, 0.7408852757897116, 0.9621071839590066, 0.9194158478437728, 0.8553275722296239, 0.5962287365168022, 0.36514308093287895, 0.08818684699533094, 0.7882566129134531, 0.24667049130033258, 1.0223605915466907, 0.9956685690727886, 1.2148084251571032, 0.7404965218963395, 0.6076222984370007, 0.4675200474006203, 0.7245054046320043, 0.8778686878836953, 1.1371698937374664, 0.6354554554430898, 0.872776064874068, 1.29302351710844, 0.4304598607024766, 0.07875481107850295, 1.1583843008031613},
    {0.9617992709231229, 1.0750387961905865, 1.0630663919149526, 0.7488777064124054, 0.9893950632497663, 0.8760035561422352, 1.0566573731964686, 1.17248185989897, 0.7143986332291657, 0.5746374391486196, 0.9078830150983764, 0.6947610452473125, 0.6939257232819845, 0.41068605829372434, 0.08006798479721562, 1.0800159385041432, 0.44406487072767786, 0.5803398639236048, 0.8741968533764225, 0.8003819007474273, 0.779367445436418, 0.8313922608032568, 0.3417019031029308, 1.1937035717219928, 0.9669153131413913, 0.887294562304055, 0.5718858507242626, 0.9792426120168829, 1.2050092836079085, 0.6680036031608029, -0.029753296118788606, 1.1605684638600726},
    {0.8563014681632566, 1.1936675460351294, 0.6366367784464145, 1.0591307351594939, 0.7968158720874541, 1.025406618416277, 0.7923132884608562, 0.5610093751960451, 0.6451818897270334, 0.8346749156959142, 0.816407669561309, 1.008035904871014, 0.8909569976866525, 0.9253423323499911, -0.05821316531885733, 0.8315253220360352, 0.695082889886375, 0.8179356413375629, 1.188437948616206, 1.0816394144362207, 0.6744034213782917, 0.6159253395098718, 0.8392143476203049, 0.7665654030341711, 0.7837588338885975, 0.7094996988482466, 0.5357468239474681, 0.6105820375131514, 0.8942722637663993, 0.7601290849990539, 0.27059625512573326, 0.9826863741028203},
    {0.9421132333519958, 0.6473236296026471, 0.9548954243256998, 0.9640889175034367, 0.8962969757273219, 0.9900096023237719, 0.9567993128065416, 1.0548343504812345, 0.9460440673484203, 1.0433624594943347, 0.7901024350283059, 0.6345999088965032, 0.6416017607954444, 0.622828390147939, -0.13070990056122553, 0.9431718548831232, 0.6324705386155042, 0.5315401500039384, 0.6135359819095639, 1.031496110341003, 1.0596878817832698, 0.5543838331061928, 0.22821246510876791, 0.9479854085823123, 0.8272805944145314, 0.696224811392936, 0.6525943365524969, 0.8102606067839403, 0.8927233702334374, 0.6481297216774277, -0.018335942899654335, 1.1565655380263211},
    {0.745386315251189, 1.0843173783886288, 0.956152854037436, 0.8901896306829764, 1.0894741971352193, 0.9942401871067833, 0.7806603368612816, 1.011470382366031, 0.7406908575922287, 0.7325545167592781, 0.8452073624327947, 0.9559292816417954, 0.8370730670896229, 0.413488202658212, -0.24018862384858, 0.6798502551098826, 0.15917326864748657, 1.0982098809530627, 1.198637240491691, 0.6344155089528665, 0.697249859622894, 0.7624385043485574, 0.3527699442792888, 0.9721755522286902, 0.8090625964141026, 0.8406898593807164, 0.7758019033438106, 1.22349909506502, 1.1724235216243222, 0.9929385849824724, 0.1531521612245712, 1.0243787971923255},
    {0.9263256482248897, 1.0720894830676815, 0.7297899158527349, 0.8529010045180972, 1.1605214498270338, 1.029096874228606, 1.0320136889228597, 0.9616948902116333, 0.9020303515529456, 1.0852342297007243, 1.1671106462973242, 0.9717121237810694, 1.2849929762124093, 0.5379579102299954, -0.0999688142671935, 0.6788629463974949, 0.3122295131512963, 1.0235866649542813, 1.033471313640905, 1.0375224048730942, 0.9290508684486126, 0.819299837673124, 0.5188487298810396, 1.1119998904746524, 1.0830749009706802, 0.6211373225673804, 0.5061165535724723, 1.396843457293369, 0.9988693466149005, 1.1427415998014907, 0.13512073403219976, 0.7978283452535453},
    {0.9556868234787146, 0.6910811104980236, 1.019823765969958, 1.096533706319444, 0.715150234405007, 1.12301070086743, 0.9705603123386369, 0.9310447936887961, 0.6900489313411966, 0.9978645752500204, 0.9139019093921489, 1.1667531462290546, 0.7780647542915207, 0.6764754092215464, -0.1787679042984194, 0.9749186984905944, 0.35286261469657754, 1.0039485022382006, 0.8953206915214459, 1.125894160340484, 1.0299279384586217, 0.674942453886801, -0.19756345484828974, 0.8598723432640435, 0.9182340753832751, 1.1685166875184445, 0.6922007608951756, 0.7216014021871184, 0.8648055985057591, 1.0327379911223638, -0.1693409796770125, 1.241804214234006},
    {0.6602558454354387, 0.8099300056502646, 0.9380155802374981, 0.9735620421695318, 0.8444938507189536, 1.0754492166436216, 1.0444430291556, 0.8926542605821642, 0.9806618563171625, 0.8258351253236585, 1.1028060634862682, 1.095869256987421, 1.188937729505072, 0.4803825999468072, -0.41002417266234126, 0.7134433354689502, 0.3767091387782558, 0.9792084103400398, 0.8099097081012748, 0.6047088575806389, 0.7051386217907054, 0.5558088914214887, 0.49691335644560863, 0.8299401880536643, 1.2652005184687898, 0.5576534180520982, 0.7030143579277982, 1.0580631456961593, 1.1411071082604263, 0.882260845763041, -0.141126537247045, 0.9680291605607739},
    {0.9728161739590105, 1.2111069347500025, 0.8673939498817627, 0.8965319474841384, 0.9121024920533344, 0.9296313245923727, 0.5193453240506706, 0.8395436318934342, 0.5882647288755841, 0.6749400735063209, 1.1812935909882603, 0.9556592867422413, 0.8052908391806017, 0.7873015124484211, 0.033077497818805146, 0.9804175552454011, 0.27741015152447024, 1.2257152796390467, 1.1840542955783333, 0.8412920475684729, 0.6708103601286343, 1.0434369574149358, 0.6129646793187269, 0.9264073927331499, 0.924363806548238, 1.0487974311221229, 0.7270798085242617, 0.6158130134244366, 1.0720882479111062, 0.9941596160830319, 0.03817269965594809, 0.8467594715584813},
    {0.9510068169066248, 0.6711757906191937, 0.9582946941094207, 0.8515130046120652, 1.0842425265043811, 0.6341920947929602, 1.028176972010487, 0.7441885732479788, 0.6381834240927113, 0.8115822465557629, 0.7380562568412733, 1.0067850494430401, 0.6141072017362111, 0.6559041623942586, -0.22612900017509366, 0.9214840674126392, 0.19582798408137755, 1.0450780976008465, 0.8181677483565242, 0.8182953886884354, 0.6399756135011969, 0.4388807240708687, 0.48368844069362715, 0.9492978318837896, 0.8178755219723225, 0.6989538064915829, 0.5674368076230095, 0.9973608808431872, 1.0777169489434437, 1.1793718278205854, -0.04177659618040479, 0.9315849898889336},
    {0.9438779354721345, 1.2200808566876014, 1.1680928465915004, 0.8583390902044241, 0.6678567587052594, 0.7926872381363459, 0.6861133487833215, 0.8366417132714282, 0.7570962975045142, 0.7203611008583345, 0.9950587607094422, 0.8773907557423163, 1.0589414965655357, 0.5578758187003429, 0.028149517898468746, 1.032095940475513, 0.4728551196784614, 0.7747401180307891, 1.2063799932218333, 0.8453994072002177, 1.134689542338913, 0.8110796612723254, 0.5959084055795915, 0.9520602535098496, 1.0427303163795107, 0.7234381519672337, 0.5901006808420256, 0.8059821362308389, 0.7598382706646987, 0.7492293543652615, -0.03342701874042031, 1.1382666900113974},
    {0.7079023802961857, 0.7408233739732137, 0.9489687846153042, 0.9738214123371414, 0.8909226546883976, 0.6282193450801378, 0.9823638500779349, 0.8813696983608414, 0.6300155783998085, 1.2390350604110978, 0.9509320188472742, 0.7476208334333717, 0.958099559951484, 0.6974185006014818, -0.0734490427928801, 0.991787022035568, 0.4982641183116523, 0.980502189527697, 0.8845084291766702, 0.6102959252352377, 0.8274666521008004, 0.9682138231139998, 0.7629676019607167, 0.6205432958880006, 0.9775441314674738, 0.5352533689148521, 0.583925242786426, 0.6833961387170956, 0.9611461009166016, 1.0234987025955213, 0.2370811589652723, 1.2547470815377604},
    {1.1066365900587263, 1.0816503319705904, 0.8244673928375433, 0.8348840557418713, 1.0712018184582164, 0.7955341199357111, 0.8305879777318947, 0.9951331809834376, 0.9036232632814264, 1.1620604408291302, 1.068617442251905, 0.9690856183101342, 0.7778326647036617, 0.7606206105044259, -0.3977097001935375, 0.8831841548051174, 0.6575403112738407, 1.0592462286415312, 0.869113953553321, 1.2292628170863091, 0.8635661533458582, 0.783403594356101, 0.8205623662889203, 1.0166994736171184, 1.0870677760825884, 1.0694207906121562, 0.7807972076295184, 1.13762355417288, 0.9334424561755472, 0.5568716918316822, 0.3026674155898832, 0.6278387531466008},
    {1.1660212010296853, 1.067382424663834, 0.9510250421146884, 0.86733906659724, 0.9182653191803941, 0.789239894454713, 1.2616221047518006, 0.9896603076841133, 0.7905079347037697, 0.6102758976079646, 1.0653484482029327, 1.061316460616819, 0.9322569990391911, 0.6871306630582141, -0.040229945209916844, 0.5375459509174566, 0.3545190932398297, 0.7498644137775645, 0.660827211605984, 0.9303469370160826, 0.7298058962443367, 0.6929538681551999, 0.5785631797127684, 0.7931117910039717, 1.0654926712968, 0.5288183714098522, 0.8296098570902505, 0.9154936758201153, 0.9976465942241126, 0.879929551169006, -0.25353325605322324, 0.9481767614811473},
    {0.8861534824629282, 0.6583943673174474, 1.083586324047118, 0.9876398787631218, 0.4883151267661179, 0.7173908856171153, 0.8516605691280356, 1.0556298981972208, 0.6490071824225574, 0.9974200699800283, 1.180421162288189, 1.1024554900220678, 0.8392600008417815, 0.5706438833305513, 0.12340788513468096, 1.00815303920478, 0.3428303194733188, 0.7734219454628226, 0.6535713270807302, 0.8720202222722742, 0.7958315343703508, 0.546209247631175, 0.4491705036000703, 1.0809280071680827, 1.0040801001294561, 0.7411775442162412, 0.5340902185861098, 0.7607694963599242, 0.8225662831933376, 0.8610916593213825, -0.19458273492207384, 0.8406675549845557},
    {1.0985374980799902, 0.7712932079405169, 0.9618257394533059, 0.643537299313238, 0.6078930430820632, 0.9180316891936704, 0.8473906669432923, 1.0696378746741064, 1.2343472447860457, 0.933880659652071, 1.1556020766759558, 0.882756595576156, 0.7965403926905774, 0.8416443948132655, 0.0710690255854004, 0.9311481712949502, 0.5145615461408773, 0.6811472786987803, 0.8962509424858099, 1.2109720095372989, 0.664826356447939, 0.5788985631595416, 0.3932168815733712, 0.8640287443183944, 0.9654518376373339, 0.7015592696498547, 0.5678099465345254, 1.1225724845776222, 0.8429316821019451, 0.8268913963153065, 0.09294767259651156, 0.8010880259506169},
    {0.9150869008274408, 1.106230937829188, 0.8585672662964816, 0.2685072059384773, 0.742335672024824, 0.866423760060402, 1.004042905513999, 0.9119866534775252, 0.6919350499909347, 1.0279836961386242, 1.1804457621324482, 1.1805363515519411, 0.9669990749892294, 0.21485683805094744, -0.07353015609686046, 1.0414544311867235, 0.3862239875493032, 0.8630304481978706, 0.6801918863100014, 0.8002925818815788, 0.5901741530578181, 0.9100431384582808, 0.25593079378019634, 1.1171007379533662, 1.067167464710281, 0.8348196065277113, 0.6870506812442282, 0.9302750340597233, 1.040255483390629, 0.867261365447184, -0.22297954767737074, 1.0682207617780282},
    {0.8538062778183259, 1.1654505197803258, 0.7020875595044598, 0.7755119316818324, 0.8270211495867694, 0.7896226675228797, 0.8619936221828711, 0.8105355243963298, 0.6376371773171641, 0.6467176034630424, 0.9892862145721907, 0.7513433132604341, 0.7863178026548846, 0.6016991095797489, 0.29746416947562837, 0.6462037243881057, 0.20568136410445226, 0.9618152818570845, 0.7927841784243791, 0.7423445985081601, 1.064331201106946, 0.5036581742948991, 0.6354578026880364, 1.0101538810304258, 0.9868681214798068, 0.9504949159151667, 0.7233500357619116, 1.294841352908664, 0.9017870551141217, 0.5238232790229563, 0.09713909900625245, 0.951630064394427},
    {1.0166829370179558, 0.5980809370223727, 0.8784971527703747, 0.7735237517223658, 0.9592319870213246, 0.8940874982338216, 0.7772393983612732, 0.7898049949653969, 0.8988979289693455, 0.8267901974893597, 0.6996434676869784, 1.0137466871419896, 0.9659365532111082, 0.549264922156872, -0.03889786937694986, 0.6608845771738503, 0.462033971423594, 0.9187728870298888, 1.0576713755615985, 1.0278509357831447, 0.5215019013537723, 0.5532434444980083, 0.1378781268394358, 1.032210239523214, 0.6880841407460103, 0.5757654762377892, 0.7752554420664495, 0.9172777417868883, 1.1157780997079298, 0.7221154028790542, -0.09795080934438422, 1.0477970703202004},
    {0.9613830103260217, 1.1595883968134395, 1.118706258658186, 1.0484256427686345, 0.7317080010093185, 1.0970189332525966, 0.9015334759086597, 0.8950095001642635, 0.5878149526114829, 0.7344753351072248, 0.8369631682724539, 1.074866452867297, 0.8930588982222092, 0.48500024808642456, 0.2233619655933161, 0.7926948431811138, 0.47098576888923716, 0.6782788794780286, 0.8038211054842326, 0.5991027370367913, 1.0925110373603122, 0.7705639161599815, 0.772008218917069, 1.1205863622213377, 0.6617069032769773, 0.6519818635240148, 0.7577139708802147, 0.9811643450828159, 0.8945710100503937, 0.7453766633216815, -0.09352219399572065, 0.7453287413560149},
    {1.0504889345756592, 0.8908400790043114, 0.8440247522156666, 1.0402180186332066, 0.8684557625503521, 1.030187368735842, 1.0142128281080411, 1.0147522968404303, 0.6444061804722712, 0.9209372933839881, 1.1750576621318962, 0.9669807711504935, 0.9797042020744068, 0.7792733527748923, -0.0635780577308905, 0.8715243576919964, 0.1987676812497716, 1.4416852594649092, 0.8449147054573614, 1.0237156469700355, 0.8332152945142562, 0.6794058349743398, 0.6307511671239203, 1.0647768399467554, 1.0729087515018763, 0.720253022862931, 0.4186906261712882, 1.331476691210367, 1.00915647589197, 0.9981586004259898, 0.23428953977688166, 0.7738568634436139},
    {0.9372242139282412, 0.7431307656336984, 0.8139924575396361, 0.6709167997777539, 1.0994000435228541, 0.8456737994461145, 0.9021823857859935, 1.0336243780204872, 0.5041874064948652, 1.0318732504050923, 0.7598892635271947, 0.9534612627287851, 1.09025777554655, 0.5025120225225077, 0.2614038957566407, 1.1827374705237044, 0.7922824905865781, 0.6786367285248267, 0.7392197148181338, 0.8143130448545222, 0.9235291226619029, 0.5722538059856224, 0.536458216444841, 0.8369807525026013, 0.9815983862749633, 0.8171162790990891, 0.3846017552498133, 0.8755670527390564, 0.9498383144672774, 0.30783413322440456, 0.21679027805367815, 0.9160910035180848},
    {0.8114616249287482, 0.7763184607878293, 0.9488101018307113, 0.7925871599168619, 0.8914158294624341, 0.836973143818212, 1.155956979295394, 1.2914537042354117, 0.7429885592344244, 1.0335493446087067, 0.45078006766767664, 0.6534344061837508, 0.7134114855310499, 0.66948038483339, -0.4527357863002776, 1.2664585422253625, 0.7355092540999395, 0.8101404176798079, 0.8153537714585573, 0.7202064939315336, 0.8326589049457443, 0.5850311254048095, 0.22369468188805317, 1.1070765004929752, 1.1027448472707555, 0.7926749834024673, 0.8394321490396006, 1.106348122527002, 0.8656703858095444, 0.8023514517341747, 0.08080220608544056, 1.0927612933533433},
    {1.0107101138113723, 1.0458657637538782, 0.8627092456060413, 1.135901873391043, 0.8085415413659707, 0.8637715994686045, 0.9587735349241063, 0.8155319138548356, 0.5678274802378305, 0.8265818068633038, 1.2827303646736654, 1.3162989206427635, 0.6819582377638711, 0.5399173250371143, 0.061086791858429586, 0.8156333720527869, 0.3185415714647696, 1.0231319605049556, 0.8231933340543957, 0.8197367813013259, 0.7155871886808678, 0.6580583148712392, 0.41400392200259645, 1.187987097053143, 1.1490980631268588, 1.0254493387526604, 0.5002509286918773, 0.8870125263618676, 1.1432470012279028, 0.8135039122220658, -0.025763609299125804, 1.078515442861739},
    {0.8669659565768293, 1.1762198205831593, 1.1027089889903077, 0.8634666928912788, 1.0361327239907976, 0.9220766538083162, 0.7104423181535264, 0.9932634199982777, 0.678251596092828, 0.9237549606251062, 0.8213262703763844, 1.1999648625619324, 0.8299958947753544, 0.34167649360180524, -0.28397602300163255, 0.9100943233581759, 0.7048533102720257, 1.0884853458694006, 1.1520270738458236, 1.0410263659762395, 1.0859919191546576, 0.8135707187759876, 0.6169889259963677, 1.027175337066399, 0.7731560700001331, 0.7691128205420991, 0.7465958149056053, 1.0341123011610514, 0.7635478121583295, 0.7168095022932368, -0.17569898478013649, 1.0944350392428015},
    {0.8924688873806511, 1.0340420649587823, 0.8608395066927923, 1.139399428440485, 0.499558457667775, 0.8002337400274498, 1.0313119450031396, 0.8873411616241097, 0.8513609028420006, 0.6153687201628352, 1.0619707875350153, 0.8552619530518378, 0.8133710986483481, 0.6347396224330694, -0.1319323516420462, 0.5831941352089047, 0.4684563667846689, 0.9053365807107043, 0.8849396337009066, 0.6213943431453477, 0.8094705021304855, 0.3828683151283825, -0.023472449637529622, 1.011813094009225, 0.9330204313981961, 1.1076600637063458, 0.5024861882763322, 0.8942475857723108, 0.6474239550524503, 0.7890035142149421, -0.2500178146087277, 1.0438980030094325},
    {0.9382072272896025, 0.8979243613810376, 0.8835682721973093, 0.9151198263529106, 0.7233895959035188, 1.1809843148401211, 0.97219819848725, 0.7775867907381698, 0.6783584179668752, 0.8838806825851745, 0.8567799217035219, 1.2725605297431943, 0.7299425993290579, 0.7909293216804683, -0.12541838595771737, 0.7693528823730746, 0.362796613352539, 0.9185607852381498, 0.8406051786568731, 0.564360623464872, 0.8998474565640701, 0.6528832649274555, 0.4712402428727817, 1.1751679442956757, 0.5977359328466815, 0.9499684218186806, 0.6520365601347629, 0.9978619328031163, 0.8484096598790065, 1.1246374816637623, 0.04635213190308595, 0.9712692260666171},
    {0.6452648016453795, 1.1231813614556858, 0.8450609449429235, 0.9752934168955677, 0.8362607453277122, 1.2063216427851158, 1.2019377479666906, 0.8353756887219214, 0.8334296531099848, 0.9023916719016114, 0.9069107410549012, 1.0069880978501031, 1.1791939396430164, 0.6817876036558042, -0.2880907068623417, 0.9258799666661874, 0.3804630375037174, 1.0997866457299261, 0.9582630117013113, 1.2489877749260787, 0.6383856912806193, 0.5724094633307752, 0.2777667613222581, 0.8845160222973915, 1.059136241577398, 0.9639081805150034, 0.43579310043817093, 0.9045617675064672, 0.9270093332515089, 0.5600895568365538, -0.031928683239602164, 0.9368608689060947},
    {0.5207470247647995, 0.8159491306730039, 0.9548518773685557, 0.9331580924791991, 0.7957760603660964, 0.6695096899916463, 0.8416862324157217, 1.0891011837245559, 1.0821098029004448, 1.1421238899467434, 1.0120840027741362, 0.7585499780500495, 0.6784649722981843, 0.5298699677101587, 0.07753452683010773, 0.9429099680061243, 0.34822893730618815, 0.6241051418014014, 0.7267201811453046, 0.9366887521196999, 0.8430150817767874, 0.7448162979986087, 0.6532529995436259, 1.171448944759072, 0.949175445947394, 1.1187718003190263, 0.4362016605533512, 0.9405683620523049, 0.9325066057931939, 0.7754587688588699, -0.04994530027254237, 0.7149688491187177},
    {0.795504480468547, 0.5759627602724524, 0.8708243520973552, 1.11144936403015, 1.0146501615748083, 0.9666321790792254, 1.0527905747512631, 0.8679952948307189, 0.6910147372015508, 0.6808843923483567, 0.9768381365204626, 0.8593016131691873, 0.47134758410180566, 0.40016198479877385, -0.2670465154551321, 0.8106012718535353, 0.0715760213949823, 0.7395719383602772, 0.7031523075448706, 0.8046534409151613, 0.6598313128315163, 0.6636869249505574, 0.8144327888565432, 1.243979623471659, 0.9519036960121736, 0.6593579842979984, 0.6312106614475241, 0.9699685203024289, 1.0749802262587078, 0.6122560528817491, 0.0435978955394241, 0.9047915696868855},
    {0.9417493426284305, 0.9000458660821989, 0.9096424358213488, 0.7347168663582405, 0.6625569085686818, 0.7515200843934517, 0.7325222870730672, 0.9549549408078951, 0.38330504492688344, 0.7144207695629732, 0.8904284361321325, 0.8621309147985299, 0.7393666659452798, 0.633909685082427, -0.33657122246441895, 1.1617648182625735, 0.34204311594039216, 0.8396356543957824, 1.082586383966393, 0.9567311560407832, 0.6120637402388871, 0.8383701908957362, 0.5407317510892885, 0.9870826843641756, 1.0436739330869556, 0.8493992091683561, 0.6701741950024002, 1.0559503373996528, 1.0658421743327855, 0.9388603016882118, 0.30071315454772235, 1.0997588679722599},
    {0.9840494881528075, 1.0183938737935627, 0.9246246347536649, 0.7075697790250883, 0.8443552274130351, 0.9273296571972867, 0.9089200140837695, 0.8838693950971808, 0.6473909311731696, 0.7406640244522292, 0.7644037056478172, 0.913783984601897, 0.791461252738447, 0.5537611695185815, 0.16686768967790322, 0.9695544824299999, 0.37980629191834286, 0.9071012288408015, 1.0327046731833942, 0.8408267645778683, 0.8025411467802293, 0.806583156877144, 0.5757654648037186, 0.882631656812859, 0.9716310022879657, 0.9015332077800355, 0.6898638589880074, 0.5480173894317473, 1.4602733863989261, 0.8886831549254245, 0.00033090795460004926, 1.0410855280876459},
    {1.2735659695035801, 0.9444916306645214, 0.7729596391918411, 0.7670495109627997, 0.943766421387405, 0.8837032522907012, 0.8908618775052831, 0.6265335812222158, 0.8529219849326339, 0.7929272786862143, 0.7444703186213799, 0.9892841309834032, 0.5261790830357408, 0.6806835140547621, 0.23003009654444018, 0.9550190492174597, 0.7192340361103038, 0.7191741647908737, 0.9360130149647532, 0.7800744725504175, 0.5899201826641249, 0.27290672627135487, 0.7196203848836773, 0.9851749438224395, 0.7491247872615722, 1.0029476281280891, 0.7431919853432208, 0.85815676845301, 0.8676678964843947, 0.6156839835789526, 0.23593942024379264, 0.9677076696819159},
    {0.8487127742979813, 0.8121398414938734, 0.7141636092390974, 0.6463908347236845, 1.0426932174050068, 0.9168212813702118, 1.1053995740385654, 1.332837412171278, 0.6958350355913268, 0.8054958907780695, 0.6082125579662914, 0.9605050794122802, 0.85744601565382, 0.5681400233141679, -0.01205682155862268, 0.8351427165155694, 0.510650035917549, 0.9810244001873107, 0.8808648211789337, 1.2338220278020984, 0.6746046737263678, 0.8366203217637642, 0.5757319020026572, 1.0681965064509746, 0.9279428317047801, 1.2542189941904514, 0.3734771841889067, 0.8068571909974642, 1.0627039524675352, 0.7213902462306335, -0.16523685989925038, 1.1855334564610427},
    {0.9024808895564232, 0.6608393136790427, 0.7919691794197238, 0.7553505410250205, 0.9592875373325901, 0.7616965369967593, 0.8314084508438422, 0.9493896201567674, 0.5603868343006786, 1.0884386176435954, 0.9934027663201185, 1.0486858909181282, 0.9198900226093231, 0.8205115207270006, 0.04567250720117182, 0.8365231276326526, 0.17879520576297767, 0.9726579861462871, 0.960673463645893, 0.9784673863341967, 0.9780395664883432, 1.0703182833237923, 0.3968180807211562, 0.9410334994583024, 1.1246928843999704, 0.9732583946568397, 0.644080944296826, 0.988588010860425, 0.8373484323468493, 1.0689913510853668, -0.051013664547559116, 0.9485810120464909},
    {1.1955516240599047, 0.9770056879816136, 0.7366491739571791, 0.7646518526373621, 0.5765760686127044, 0.9837827917600361, 1.1150426853443178, 1.0954908193976796, 0.4920992910257157, 0.9172175177935186, 1.0349185286099085, 0.5029928461907207, 0.5670261234793447, 0.5113547115555463, 0.031123336563139106, 1.124826598926748, 0.40573781272751686, 1.1116444687636873, 0.7917168675982759, 0.9273927772023552, 1.2459469876816966, 0.5717162187086303, 0.5789209198245723, 0.7055964348388083, 0.819833061506996, 0.8192060394538319, 0.46122028569101425, 0.9493716806758075, 0.9355127291111613, 0.7123039060323063, -0.2376431129915927, 0.8461115056550038},
    {0.7322432101255025, 0.9884366870947974, 0.7525001157385717, 0.6578752268593214, 0.7109239949812655, 0.9994361674300171, 0.9927116007186613, 0.49535233314630145, 0.5089749288854855, 0.8647107954544773, 0.901849766166086, 0.9146691815632443, 0.9129070315687142, 0.35315307255485084, -0.06734541232810991, 1.1491900396791408, 0.829516649181362, 0.8332917237274393, 0.9459532462126394, 1.123787631838597, 0.9325056858595637, 0.8381927424212897, 0.4577483083988082, 1.1966689618902193, 0.868647209902867, 0.6562005136074739, 0.6955078549024887, 1.0437401112973201, 1.1365058674132542, 1.0386210408026602, 0.18654127684216967, 0.9279579392157387},
    {0.7213627332387208, 0.6169456676671295, 1.0432954856122654, 1.043760967295661, 0.9879558487367103, 0.9999750308266061, 0.9136572855275799, 1.12145905882758, 0.7872090477527958, 0.9097007853176099, 0.9960403540291067, 0.9445801232968951, 0.9308957814426984, 0.7150353502169104, -0.05066649640620949, 0.7371244246039474, 0.22485262788000146, 1.0194424796382238, 0.8704611807938443, 0.7644962444825258, 0.7663041997823136, 0.7751428664724674, 0.5683262510925757, 0.7883976991629319, 0.6973651354986565, 0.6916763526498463, 0.4408604531686045, 1.1459448437653976, 0.8940954380283046, 1.1753064286574624, -0.021173828720217874, 0.7584557979096738},
    {1.0009698757986836, 0.7681875131896647, 0.7453422994105624, 0.6044876818611049, 0.4885571219706503, 0.7799361702290597, 1.1902524483340473, 0.7331633183671312, 0.799613499781435, 0.6205070825717018, 0.955351917144547, 1.0658762303070235, 0.8979106757562675, 0.6891933220499619, 0.1787834498801288, 0.8267822572410336, 0.39106513123151126, 0.9180695777010475, 0.7567524440614926, 0.5229810430313848, 0.6766084897500173, 0.7601145486569201, 0.7065684593143263, 0.9211465370162764, 0.8209611679296621, 0.4530582924854153, 0.44832410527421573, 0.832897768859779, 0.9490770454835437, 0.6989248994306957, -0.1953247855127496, 1.1474376807977233},
    {0.745306432612166, 1.3184515278888465, 0.778540221709935, 0.5824660014253378, 0.870967091524127, 0.9659780544688331, 1.0634448764590432, 0.9395324502132378, 0.7184886379530844, 0.6433278256264024, 0.8134459350652568, 0.9173555018207534, 1.3262476844593423, 0.4056192943294587, -0.00537328838148487, 0.9241221272021599, 0.6485855324388398, 0.725874833841952, 0.9314651627058338, 0.7774244769139051, 0.8156416558814559, 0.9004584756983417, 0.60561881973276, 0.9502226326424429, 0.8286449771999406, 0.9024827615616174, 0.6623851088375327, 0.8037693535915876, 0.9789751897511955, 0.7289237214018646, -0.12596376724735986, 0.9494091588959739},
    {0.8571289140083234, 0.7253847370106075, 1.0339475482498908, 0.8859704331816787, 0.8161092798906933, 0.7095980182857996, 0.9638803999787046, 0.9572662853258859, 0.7787534215865176, 0.5305560073414463, 0.9345954474593111, 0.5509142149800733, 0.9088696664006757, 0.5509330347202457, -0.18130526711025496, 0.8864515665264312, 0.4946250092987337, 0.8716844835015252, 1.0538975738629601, 0.9972560228559321, 0.7063775977055692, 0.32097061330796456, 0.4259802815461702, 0.7868828810260667, 0.789131353003904, 0.8093727264573642, 0.5753033382160958, 0.7001109134801701, 0.9017155168185341, 1.2180866161266743, 0.010241046424413881, 0.576564722806464},
    {0.9184004912318301, 0.8251827783993442, 1.0268631003958593, 0.936934401443245, 0.9536062639688091, 1.1319454843294294, 0.8056578001972614, 1.1820680031859474, 0.683271358895651, 0.8754148907268339, 1.050414937864807, 0.9683334210503356, 1.058575599267662, 0.4265330670064146, 0.015099331931814192, 0.9749920757625273, 0.2908499002702489, 0.7853956719653634, 1.0210038581727694, 1.1308600132684867, 0.8580382810374616, 0.7317686915887077, 0.6303105258912258, 1.1729573158681033, 1.0065712785595278, 0.5965809615509824, 0.6113777894426087, 0.8007056948888067, 1.0722314743581076, 0.8118347897843926, 0.03344055202014152, 0.9689229879103536},
    {0.8430895391791964, 1.182587029109434, 0.7868048738154868, 0.8563697922254896, 1.0560431849159886, 1.0631120070436526, 0.8507885521774421, 0.9788823439055087, 0.6070002418589117, 0.7888859299435772, 0.690274961808629, 0.7866723966920489, 0.6901213228718611, 0.5889196201117541, -0.1034191695677304, 1.0577104537646016, 0.4307728757496457, 0.8707868185938703, 0.953970583427241, 0.9610215186115245, 0.9843707935432484, 0.39707984387556505, 0.34139690598528205, 0.8397207352948114, 1.017481152030738, 0.7300183043757317, 0.9261346506400947, 1.2019635029376423, 1.232105020817222, 0.7998252011277274, -0.18301427987604071, 1.1546848022035885},
    {0.8462346393632868, 1.057972792198807, 0.7841059817677667, 0.6873338704523604, 1.185375673938662, 0.8406167772316966, 1.052670359452897, 0.9000174231197645, 0.7534156720986394, 0.6987941316896429, 1.0811376428387909, 1.0642624270719307, 0.7989989398995215, 0.6806193238532415, -0.19863846261062745, 0.9153303617955101, 0.15042562965602715, 0.87155186019953, 1.1595904018550751, 0.9846348527638357, 1.043134258298821, 1.1914374212593044, 0.6386157200505489, 0.645060495101662, 1.0984844233956426, 0.9037369750882615, 0.7646260584863003, 0.7729922781226136, 0.9646447415628586, 0.9965996425613711, -0.11074951406092576, 1.2780569994067172},
    {1.0892335325468234, 0.8251862765665314, 0.9247118801602751, 0.7310866621689123, 1.0566309026528327, 0.8524930005861866, 1.170118014789083, 0.9691764472343257, 0.7225158966300577, 0.8719796190654914, 0.8133884454036642, 1.0458800082794182, 1.0602951126660025, 0.10168464200937649, 0.16592758671177366, 0.6422438519233113, 0.5380332956820737, 0.9049414891924278, 0.8991280841320858, 1.1230014751865298, 0.6817362588578691, 0.6805742777671686, 0.8199062792399895, 1.010280984263154, 0.8925524972776455, 1.1471145556575741, 0.8968877085792193, 0.8791302548747768, 0.9687765563491003, 0.9734891150161074, 0.04563893274249614, 1.1673914231572102}
};

static const float b2[32] = {0.9076505505317943, 0.9399693443372142, 0.8352095877251795, 0.8026651804626139, 0.8145900441790813, 0.9405764086365044, 0.9242894707561566, 0.9143235304009472, 0.7420044320360527, 0.8641229533752747, 0.9224881544115336, 0.9301734344330403, 0.8050198500412449, 0.5599267598184936, -0.06723474088171122, 0.8884341485957017, 0.41035818773689847, 0.8332827494857857, 0.8846632989789556, 0.8409277258830895, 0.7996250734857873, 0.6723473102715902, 0.5550941320220609, 0.8718390989423426, 0.8013386328490522, 0.8094337053679824, 0.6215229714041638, 0.8320852251321383, 0.9136117036559978, 0.8143290994869198, -0.027404275664269027, 0.9170273108522993};

static const float w3[32][16] = {
    {-0.05298212053156931, 0.6029627907761008, 0.369501572842843, 1.010754025622365, 1.0156358416615234, -0.16980021199762632, 0.16233433492046606, 0.9537508339553332, -0.5431985065196041, 0.9221027345422962, 1.309902182121788, -0.01944728919496604, -0.13398665047675504, 0.8576341174957084, 0.9533331411798153, 1.1390440225784635},
    {0.26636617093459725, 0.8095306717416234, -0.4245565509569546, 1.1204701022207868, 0.937765563608343, -0.0951798806682429, 0.019685701657107483, 1.2658443596535052, 0.06044576714278854, 0.8707733353450764, 1.3047964000317058, -0.03901473776498277, 0.030224022626193926, 1.14954129687872, 0.9946608883830071, 0.3615824111227541},
    {0.289047507765636, 1.1144229157720542, 0.2842733336607648, 1.151888216958595, 1.0002461340314168, -0.08593843872910593, 0.08164474087025057, 0.8720687152939576, -0.26215423405276744, 1.0198012972747037, 1.0364375452993797, -0.17950548010319067, 0.07039535289594075, 0.9355555694460659, 1.1521993022887078, 0.8617410968412005},
    {0.07830173946247165, 0.3244095447710283, 0.1653877873479031, 0.8864520851626583, 1.1477076199338587, 0.028342202027471435, -0.5571307569113009, 0.8338113218634424, 0.0373060588086099, 1.3073068225005875, 0.8218516240417989, -0.009156470541648688, 0.10479020591731518, 1.10122616156826, 1.041449570901996, 0.6878315786958452},
    {-0.011879769802300967, 0.5669716164972639, -0.12077413667983426, 1.3281459435939822, 0.7151593660570738, -0.1786625564331736, 0.3195564065182886, 1.0359544824007676, -0.14681952165377213, 0.9886022355474156, 1.1594136555556631, 0.389697182470115, -0.010956836765759597, 0.9314190891374884, 0.7993097899956589, 1.113986276964078},
    {-0.28695723290804365, 0.49762692054071433, 0.15356477429739737, 1.2615597343844012, 1.3258661053540621, -0.052078347215806245, 0.31238288900694033, 0.798506422743702, 0.060566738569670764, 0.914273419594359, 0.9684252038619219, 0.26073922703895874, -0.3440495405360738, 1.0270547659219829, 1.1685785543341047, 0.5840603233399586},
    {-0.12795720273494868, 0.5302802178009524, 0.2422976575407207, 1.126606540936863, 1.2186625124752637, -0.17794902761978368, -0.1807057495593712, 1.403714060347105, 0.06090074051276533, 1.0478693850638459, 0.9447438386243378, -0.2562341550264585, -0.3579658187427834, 1.327247602185894, 0.9759464225584426, 0.6310468461463755},
    {0.04382365039226665, 0.42371155598398674, -0.19785830072896188, 0.6972311880062553, 1.4664911348240894, -0.1193460390981633, 0.14151022643222944, 1.0658790162371414, -0.36154337699029154, 0.8853105569278442, 1.4242938901328455, -0.4467951919224693, 0.21100371471584803, 0.847059979799007, 1.4597817328271951, 0.6556988826039447},
    {-0.04724198090426813, 0.5375328849538447, -0.06768232928119255, 1.2929629796440982, 1.0923173454735318, 0.1297399235207668, 0.47480423402035815, 1.1118234091218568, -0.26869451880060097, 0.6842964049224437, 0.6013560616493325, -0.1796721015124544, 0.16045100936015427, 1.015235288069993, 0.5063921386019204, 1.0837183880062042},
    {-0.19974267760243897, 0.6751232620810588, -0.08222153442300406, 0.8208981773149455, 0.8164784565921053, -0.3470511150466946, -0.24687902810290296, 0.7880476891278764, 0.2649289117511013, 0.98529775395213, 1.2074045679484557, -0.22556428285074973, -0.20923841020631329, 0.865703668327987, 0.5295571987262844, 0.5981223958343768},
    {-0.21211846668579298, 0.7840277310133525, 0.11172538068293913, 0.969703859912961, 1.2804545955563922, 0.17381765815778918, -0.35311602836416167, 1.095202299981297, 0.10531745426289674, 1.10816970593503, 0.8996390137653835, -0.09270830201527057, 0.12004590811535895, 0.8982340833387523, 1.1495922884959855, 0.6688266810604905},
    {0.03108336765963492, 0.28306470303877995, -0.3419835830812893, 1.1528611412769563, 1.2854939939936032, 0.014249637861057521, -0.24724020026113208, 1.0634791286167264, -0.13387448230575935, 0.6800591892761708, 1.2117802753667344, -0.177893247377763, 0.016372780011331172, 0.8548017977718985, 1.0715460686818192, 1.0172418449306024},
    {0.3096386597543718, 0.7683362804837566, -0.029173792651268557, 0.9290960542607573, 0.9479765019755036, -0.3885884820900389, 0.34600043852914064, 1.3252397970696161, 0.012293965890527406, 0.6857884521624391, 1.2429278129907824, 0.3836775213577879, 0.294999593062352, 1.4096967904149122, 1.014503933087699, 0.5432623071245681},
    {0.3166018469045931, 0.7627333438870418, 0.07380822332679429, 0.5531517267850469, 1.2647204231023965, -0.16447879466998083, 0.32565997086528886, 0.6178638712940727, -0.2566108374356309, 0.7053609410218223, 0.6671472096432045, 0.6479634527650587, -0.17914629240954935, 0.7645117564060239, 1.029560303502686, 0.3085577009612389},
    {0.01836123730147856, -0.08344137233918415, -0.10322704381937983, -0.31009231600132936, 0.4130343647628319, -0.03528096959527536, 0.428576911814428, 0.05851928660722184, 0.05244612547455989, -0.023011589586149055, -0.32405685163095704, 0.41330928060943434, 0.2602375132249554, -0.03247610737384456, -0.4651973256943993, -0.167525229964041},
    {-0.16068480031004154, 0.4419373095582756, 0.4009942447181488, 1.2861550389610685, 0.9816846699953077, -0.08231331624567044, -0.049852313390120556, 1.3972740638665266, -0.26160341968364165, 1.2715829677788675, 1.057633992797301, 0.49142516516968243, 0.2523080062077801, 0.9131548932968893, 0.599130390483929, 0.6305665064399727},
    {0.3411532965818324, 0.23498062193876748, -0.6682526551873447, 0.3568447390994827, 0.724035644878749, 0.11557242195389418, -0.2657993157867469, 1.1845970126919831, 0.11622234773474233, 0.2956226429225689, 0.4165673987594773, 0.41514570455419697, -0.19748708765978734, 0.6495493032192838, 0.5837971141781734, 0.5037762459700175},
    {0.15880737898617403, 0.3628906873651341, 0.08755938352910407, 1.147241468812929, 0.9961161490051644, -0.20821156505907468, 0.1702040891201466, 1.087093071989169, -0.3583932780996267, 1.106157570863988, 1.1389793439283873, 0.16974676019996277, 0.35125767769621763, 0.7527360620395805, 0.8026991870787281, 1.0246886541852145},
    {-0.719660181461664, 0.22475617057704056, -0.32583556567551425, 1.2370210702648843, 1.3562944157297445, 0.03403406690711341, 0.04302840434695139, 1.1336179086101514, -0.07620601469935723, 1.0120761896259212, 1.2199898058113545, -0.047284937053760225, -0.265322011123909, 0.6999314249263842, 1.0281197576677863, 0.5452932090709484},
    {-0.004037644378323445, 0.541295820268577, 0.0014949375730841116, 1.213594313243243, 1.1930718599878816, 0.13401576926515282, -0.38466878699111007, 0.815105209152245, -0.26915888734798743, 0.7345640941478097, 0.9135576988741662, -0.3668946148856742, -0.21506002010489672, 1.1978668182980077, 0.886581046412034, 0.39959047310595575},
    {0.0008748348029590316, 0.7109849351879799, 0.13900896997395146, 0.8529122786188144, 1.0163832529627932, 0.19805067392898942, -0.018147781346663044, 1.0303822460933083, -0.08876294268378411, 0.9963953399748057, 1.0941663773804118, 0.58697793243485, -0.02367054688879069, 1.0331965230662001, 1.0029211908426068, 0.8396729081600499},
    {-0.08806750746697799, 0.23651127844833852, -0.4078352849082125, 0.952427606118665, 0.6660891577179935, 0.3404132381607396, 0.2089602967641008, 0.5803077235558046, -0.0032976038097682334, 0.62540666284602, 1.1899999171351539, 0.18617847711448846, 0.2155364916077131, 0.7872295249016971, 0.8081803978879987, 0.6552198454920245},
    {-0.4898252139762649, 0.7063782982148219, 0.0061983787740252805, 0.49120855081108356, 0.3943802572179543, 0.04999923416410489, 0.16447144737113914, 0.7402440447958745, -0.1707796243230549, 0.9727278607220371, 0.6752573696764481, -0.13120515162675636, -0.20570920070588813, 0.9051729360072746, 0.28416058247188297, 1.004250633456205},
    {0.048144049355081694, 0.5352237804640247, -0.14166045872035815, 1.2151148306422779, 1.0080558770291268, -0.09406006408915352, -0.13115817382973805, 0.8019519416039812, 0.43921305440614455, 1.029249940040591, 0.9090612861930533, -0.19634554863801587, -0.23025666758373034, 1.0053482444211208, 0.8249736550282478, 0.6809235634862445},
    {-0.2638188793055831, -0.05344653541964554, -0.5150523811406306, 1.252154035808872, 0.9170084115383791, -0.30492233013536274, -0.1554458701835461, 1.043782725011386, 0.1144373313964208, 1.4584706655428197, 1.296415260722144, 0.5614398595663812, 0.06126948189262568, 0.9107003716366366, 0.9535243513903617, 1.0902982481918382},
    {-0.38844036326351894, 0.8764965148214385, -0.051958911430414846, 1.1058749819351947, 0.7803593672025774, -0.06341567595748254, -0.16834873518480548, 1.1725247794378006, -0.2184349422082328, 1.165913568274634, 0.8183579317207432, 0.3991703749602805, 0.30089040260978495, 1.1531134586308638, 1.2469262611466934, 1.0365802155987092},
    {0.05506623678254884, 0.40739221403112186, 0.11384296527181721, 0.9297043100423887, 0.5515321909070677, 0.300557281623624, 0.09008785237139984, 1.2751423844857208, -0.14858769077702708, 0.6502333160324443, 0.39047084127684306, -0.0979889172501219, 0.1569551679418763, 1.2315441400902298, 1.1272644020952314, 0.5487206445040982},
    {0.1466507636257155, 0.3257329055434993, -0.04757251771413523, 1.319294179457079, 0.8204620573253734, 0.03869966726309387, -0.5303014877588803, 1.156473134819633, -0.06629774479342186, 1.3737427373652618, 1.3225482276435503, 0.1860172220913095, -0.45422337378915434, 1.1014302400363711, 0.47958189752714137, 0.7978624854555645},
    {-0.010711161918223362, 0.7814110618911647, 0.03271064701213246, 0.8898602252535459, 1.0140377532733555, 0.04206903604170219, -0.0732971859547181, 1.021994446513834, -0.03541737519330353, 0.8421061620564391, 1.3914142257947202, 0.1556530882546871, -0.06940247414771308, 0.7620055399755347, 1.0013365140506816, 0.4464462932106267},
    {-0.14897360022680284, 0.3940630312742319, -0.46083139339310464, 0.7901740781247005, 1.4237887105606482, 0.3031699223259722, -0.006304835552640649, 0.8133297867388781, -0.5698344046797825, 0.9068617093651706, 0.9915029596747728, -0.0026396397109308004, -0.1701132960396725, 1.2482000187503766, 1.5557698615199966, 0.8303572509030929},
    {0.2751081610925257, 0.16165495020486348, -0.13118574262481816, 0.4522154663225332, 0.2679662634317054, -0.3369039593111631, -0.2984465725404541, 0.09108657099280847, 0.37477584865915553, -0.1549058213165852, 0.2027929651106378, 0.007731885991735499, 0.2852519965721899, 0.21012865837615394, -0.13079967057042405, 0.284271552944942},
    {0.033944708473223215, 0.40143531314837755, -0.0019370263492983603, 1.2559534958660705, 0.9835636436710115, -0.5162638299822203, 0.20165988131986567, 1.0750769191241232, 0.13679096422909057, 0.8976862681336897, 1.2468855986437963, -0.3003675165586311, -0.28823578888035684, 1.267729154598467, 0.9504218679948019, 0.44121548163520247}
};

static const float b3[16] = {-0.04180655717947009, 0.44667601865525547, -0.029403005979399228, 0.7210326712098721, 0.742492492088899, -0.03089567360384956, -0.04412371896643265, 0.7584956188960579, -0.01610259322512464, 0.5463209392668203, 0.6355963250037953, 0.030282785379499723, -0.029749103288078574, 0.5562052870643552, 0.609434244056461, 0.41129953604409725};

static const float w4[16][12] = {
    {0.6625473159677573, 0.45590121077108353, -0.15997476202928168, -0.43668529761578634, 0.551452483750318, 0.12179914980899459, -0.1851062007186561, -0.1893633716777309, -0.28691498784016883, 0.5293842024031997, -0.29000240441063146, -0.24437237225615527},
    {-0.8865330080443752, -0.4729559647573678, -0.5070665266846607, -0.6060851700881628, -0.4164693045648895, -0.5714397444070826, -0.6367243380381182, 0.037849421473907144, -1.1855665216839746, -0.21829481615471763, 0.04927877422152435, -0.023340684409324037},
    {0.5068481843255167, -0.3943262845250657, -0.06328467572776725, -0.10482716843209512, 0.07816156994737013, 0.1091321857151381, 0.258380182771353, -0.06856506540642518, -0.10687235324901549, -0.022160738886898058, 0.01520066076240746, -0.33695724697593793},
    {-0.9074751222103689, -0.7919201099642074, -0.793042168768897, -0.9225117257883538, -0.8418661916527482, -1.0530936606113024, -0.18172075023277118, -0.5288536038060544, -0.3055329679910098, -1.3285321938097732, -1.0475506871926619, -0.9224055661757725},
    {-0.9925513834048337, -0.5941795681208253, -0.5807921606936702, -1.0117965590702584, -0.8814273490221931, -0.6089134006705161, -1.170316485905825, -0.9958258017841335, -0.9539693153106957, -0.8873851721306403, -0.8009911783049722, -1.1140039071520513},
    {0.024513114156877333, 0.16057794503815354, 0.3387705140824446, 0.6780849211010691, -0.13160645334540724, 0.7724627293154998, -0.42351758234919945, -0.01989121961859352, -0.26910393875450894, 0.2865962345877671, -0.3520843190434583, 0.20064734466315856},
    {0.005504592049130807, -0.01983697203933309, 0.1694246123612766, 0.15665220613350697, 0.024769091897253487, 0.5926945596865066, 0.3188348660295176, 0.3252187683884304, -0.3195944505009505, 0.05624249980076935, -0.3980162970233215, -0.4163480633979107},
    {-0.8434272233761144, -0.7837171411370841, -0.6075120345836366, -0.872448734042338, -0.8846945212795543, -1.290514422595856, -0.8272970387304732, -0.9935342932218924, -0.37114088554287017, -1.013726200836079, -0.6429380257632727, -1.675427879905781},
    {0.46621646207123557, -0.13174788704013995, 0.3123500767433463, -0.16070627263662637, -0.16042575853496627, -0.29479436701077155, 0.13562177040897183, -0.504325717917775, -0.08501476344105179, 0.5274196744917321, -0.4225915308107164, -0.6790871086221837},
    {-0.9995122186012998, -1.0787577906436603, -1.0562392469977757, -0.7247150430932113, -0.6593367790167949, -0.2602643540548959, -0.640935506250386, -0.7209348319550695, -0.9371361246134313, -0.5968600593368308, -0.9924849810644109, -0.2809025662635923},
    {-1.0425098283892953, -0.7925130307664945, -0.6534214599699625, -0.7492547778221657, -0.7048806124168208, -1.3682075677587098, -1.446210554350986, -0.6176162485991423, -1.2509927217120898, -0.9295093372175255, -1.1870552817612499, -0.7395665671235249},
    {0.09756632203207521, -0.4187722167246946, -0.5510313199718089, -0.5309170378099605, -0.06580552967266955, 0.22761120102755023, -0.4722421888536747, 0.47655465557594967, -0.0022488321794258688, 0.22769274717143514, -0.6569260818692328, -0.6833796988983435},
    {-0.07275125682993945, 0.22004456713494108, -0.013225304355876507, 0.02373578933675509, 0.10141254472752709, 0.16479494221497815, 0.014856238304531071, 0.2535664818347778, 0.5923775408805964, -0.21742382835899238, 0.2758060268032535, 0.49559907914572676},
    {-0.9991073930596759, -0.6202140230589006, -0.8974585490773993, -0.32382263888410806, -1.0393338484994892, -0.07376014575663112, -0.6943615139130027, -1.002392944677622, -0.9732593943790652, -0.4592652783918804, -0.7969404796348074, -0.782347098762721},
    {-0.2735496446042809, -0.6617281777567231, -1.2451971226480785, -1.0230581301106336, -0.875954642520366, -0.990476654576377, -0.3039453642258137, -1.453087997443742, -0.6861184784619054, -0.7336519740340524, -0.9115437865999232, -0.5805880435743201},
    {-0.16170462244678455, -1.5230090961820086, -0.6610696426814322, -0.6812945688994579, -0.6287742994855863, -0.7533998150932104, -1.207276595110232, -0.43788368781800835, -0.8779786351968135, -0.6062406517915078, -0.42135379261318856, -0.6707885862067091}
};

static const float b4[12] = {-0.3534105153617077, -0.29993084726936525, -0.27588554157874373, -0.29083898897621335, -0.28528780744110266, -0.3159560034969477, -0.2626849598968468, -0.22350657841913707, -0.332450869363813, -0.273299051025816, -0.3399739952555602, -0.2840551863385505};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
