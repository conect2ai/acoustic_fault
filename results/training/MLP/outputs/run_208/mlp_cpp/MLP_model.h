#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {0.29004894898650446, 2.1000031240281936, 3.149740845375279, 2.0210689897025897, -0.905147573515078, 1.892529083076328, 1.967004782477135, 4.307894397728566, 2.260655801733668, 0.45039432402338847, 1.5760789164519147, 3.4023157146491485, 4.4940991682008855, 2.031858438972285, -1.848460928479948, 4.0421550820085, 4.228372724497588, 0.4120439064224546, -0.892806125496229, 0.9009827180486074, 4.090197292799382, -1.967896903535283, 2.9476338137423306, -0.2400529665286467, 1.3321415559221017, 1.8567634431420263, 1.2664028311918392, 3.0244019125810224, 4.112212162756727, 0.6107551187843163, 1.0786521124317836, -1.1273219897913762},
    {-1.7128868716132017, 1.9067128592172529, 3.335774073771878, 1.7358030353604308, -3.258898956508978, -1.2185965899830724, -0.7934038499591023, 1.321784641033878, -1.315740854260619, -2.4674655154109137, -1.4294282298696415, 3.538116643533457, 2.345341208405056, -0.6599402394594127, -3.13188417296331, 4.032496597923233, 3.9774903417513627, -0.8524781650839443, -4.578932514339952, -3.045227308750916, 1.790788791533349, -4.435902433309811, 3.050099049468276, -2.2805095046358095, -2.1115445433068825, -1.2781336926637894, -2.184748533147089, 3.222999243272024, 2.326195261256674, -1.9259685793669206, 0.3283694825525198, -4.210131096722184},
    {-1.498010700352151, 1.8981004225756544, 3.9386907761691194, 1.3094363031833651, -2.287256789771705, -1.182484168898433, -0.6871003450175925, 2.9020248996578197, -1.2464716395787376, -2.340008414512363, -0.966968135852634, 4.302051469774874, 3.4835893107792257, -0.8814619373022909, -3.056281272587042, 4.882201060078424, 4.716062174425604, -0.9842226976690387, -3.6582570236139946, -1.7420610305337143, 3.857305434226532, -3.365073008766762, 3.2947629922851576, -2.4021286821211856, -1.6542551378036705, -1.1158700077278287, -2.0285932922777086, 3.410537272563025, 4.071668127088297, -1.3721021715642303, -0.012352363864644325, -3.1199536423864473},
    {-3.0570783323236608, 0.4469912528719808, 2.3853193107243995, -0.25680822619375504, -3.949291115229008, -2.4097777086807843, -2.366707056227426, 2.3125216989993667, -2.271912335313561, -3.992523639274333, -2.5999951758883992, 2.852834237041302, 3.1206531195867986, -2.789551318931621, -4.166211044867276, 4.261417299245429, 3.9018636147503547, -2.9350198978588233, -3.9865209760339906, -3.0207979264745823, 2.474654425759981, -4.829806038765561, 1.876474526485575, -4.160862520145302, -3.109277455009078, -2.5964000689535487, -3.2547787667181303, 2.220784041780893, 3.038995406523353, -2.800558818762773, -1.5878112503695263, -4.324961951358018},
    {-3.748314564910711, -1.6004962924554476, 0.37916374788320617, -2.3287438372513694, -3.558463044576073, -3.5948446287982154, -3.150518331037838, 0.9343729202111324, -3.085877251332971, -4.6402827356060214, -3.273534613766288, 0.49551873853790335, 1.901931513168812, -3.7761551236136968, -4.649365670818983, 1.8796965818842781, 1.6271489385275864, -3.8920161982583354, -2.614216340705115, -3.0146413698770655, 1.1914915368769987, -4.749605353190975, -0.5628799721624433, -4.646542298138213, -3.7364230765741944, -3.128161479260982, -3.6349536563301545, 0.41759940297995635, 1.4852449349098324, -3.54313477168597, -3.292680595777838, -4.32789567617369},
    {-3.829893196336651, -2.1559804824764806, -1.0031843449176026, -2.283349505932697, -3.139121923381822, -3.9067957933524027, -3.6770455748959097, 0.2021408159009591, -3.130543009842826, -4.711047221874709, -3.610038726033272, -0.5909308788575373, 0.7920953371809437, -4.184301856276423, -4.635102388135857, -0.011556066598665446, -0.3536683403945495, -3.6565532698855048, -1.9571174846419443, -2.820979985320155, 0.3347833754190412, -4.472866008229058, -1.380251852642677, -4.792437236344133, -3.7102607572053277, -3.484509928396725, -3.7419977850971105, -0.7390661562774378, 0.332952684040534, -3.5459300824798476, -3.853820391407645, -3.7459778955627554},
    {-3.8911789950424076, -2.6078046705425093, -1.0261238777486374, -2.5860753399430365, -4.0645317667921335, -3.8491944398705686, -3.839038915652057, -0.4403499155781258, -3.7048110334967745, -4.822944532661339, -4.051636521303043, -0.8883249517482759, 0.2835522099938106, -4.159339744231548, -4.236353975948698, -0.585166566887141, -1.059013901127564, -3.6990264831969673, -2.3484825654966195, -3.6858799053689455, -0.13803828932529724, -4.480788477216093, -1.6929395479378164, -4.541731804042187, -4.071641673167143, -3.7835632577675287, -4.21780455169655, -1.1850380404206386, -0.4321650692059314, -3.766948456565746, -3.8493162983731026, -4.186856740238174},
    {-4.1657357673295845, -2.5606720307323245, -0.9810813281244498, -2.923115819112248, -4.3618789391763455, -4.304239594329554, -3.960196744106413, 0.20676289219292626, -3.8555011911160486, -5.082884551688869, -4.146571034064433, -0.32199846087166584, 0.7682421741164634, -4.357542385928201, -4.584736512125261, -0.1564462424050253, 0.10685041441100775, -4.092023124605642, -2.762525372940359, -4.218601120805083, 0.20016244800233554, -4.89277327193663, -1.2579079629328782, -4.96013029457557, -4.408871193304052, -4.41411445420733, -4.283913974147776, -0.5178547435470819, 0.09976762959317927, -4.306730013633024, -3.5901874343911424, -4.55261536808037},
    {-4.032084219821873, -1.5543392174831838, 0.03678966498196438, -2.1697322013594365, -4.50256360597942, -4.095205739050743, -3.548180818628876, 1.3243106875982176, -3.4191989707864767, -4.933351435227523, -3.7589977931712153, 0.585339220022792, 1.6330683748056762, -4.141869391159887, -4.797421882712476, 1.8904537013064777, 1.5253847140581296, -4.0221941208493694, -2.411436147968401, -3.5796899385369065, 0.747829687112612, -4.889436272898477, -0.21244960819403308, -4.915533417955115, -4.16362369649462, -3.873878755633436, -4.3114096073514485, 0.2751194681267161, 1.5062879460012606, -3.7366625315076454, -3.2963227361291936, -5.009206726180704},
    {-3.688563558233317, -0.40130749343054434, 1.1794030901836685, -0.8609820574033286, -4.618326356457694, -3.6037424535633944, -3.408641946185572, 1.2524844523082663, -3.523934946207514, -4.455189210511581, -3.8738798639809944, 1.79243868906529, 1.9524407630798248, -3.5576522431392745, -4.876418975562567, 2.9998845913370737, 2.821829131468917, -3.1648155476294697, -3.135131453509174, -4.094596469881061, 1.2871430936760089, -5.187081772623261, 1.233707480812388, -4.52274496018574, -4.355744445999878, -3.8784302913470072, -4.256298866999359, 1.408665526267217, 1.5553699438727573, -3.906497624050425, -2.540101280453697, -5.4078570857904},
    {-3.7274192546980327, -0.17777193369522318, 1.385447607217576, -0.6728750081324227, -4.537563973758911, -3.512021714722165, -3.324267726564385, 0.4397137613154639, -3.6435867249191767, -4.38119340057242, -3.2827261100096368, 1.8637175153241667, 1.1732461840497959, -3.242457339313668, -4.165836246249966, 2.739379053614745, 2.948137969995188, -3.1317727429129074, -4.128315144217255, -4.223152391833681, 0.4586415370667292, -5.120961846760062, 1.2958336918485367, -4.121093413801259, -3.982019479341552, -3.881622254284629, -4.311861156706389, 1.1578843181548417, 0.9427534477358448, -3.7840321230180995, -2.3431689520208296, -5.215843318922085},
    {-3.255377645767117, -0.3730819484484164, 1.855171138425335, -1.27752296557428, -4.50846836769024, -3.9448240526713723, -3.549543935684018, 0.9843174976774233, -3.925659260081899, -4.590863531681989, -3.7941392311987494, 2.0403143876577285, 1.2359671616737875, -3.708838049323957, -3.900037783969374, 2.595254023758256, 2.6528525042945135, -3.2298153152285463, -3.722546352549086, -4.148899037078246, 1.2861995113103792, -4.849275783159605, 0.9668493167685115, -3.8613354730705756, -4.323790150098079, -4.03239455444763, -4.1296010545193145, 1.4831587611524366, 1.2559822734615582, -3.988146932924939, -2.2003201467208915, -5.019395481860604},
    {-2.6290980050427892, -0.12319270877078645, 2.0622861136685646, -1.4635744036048997, -4.46458073413305, -3.8351390441377826, -3.4617841545753345, 0.8401028831358538, -3.8512047408311756, -4.436868197479794, -3.8312632123968733, 2.3648471943541294, 1.3008484270143865, -3.527759324259217, -3.661167058442377, 2.8428984152683734, 3.060616787675577, -2.2456426333630897, -3.581405146375425, -4.508567410156602, 1.9145324114784268, -4.60605105814804, 1.5679463648628151, -3.923807801797643, -4.450851909326437, -4.076830336471104, -4.290437049237874, 1.8905605547909627, 1.3654238004233685, -3.903243967865135, -1.7631794582423135, -4.891541182675051},
    {-2.8153912693201257, -0.5199864353356949, 2.1976844055213425, -0.9533421522300608, -4.7046659156576665, -3.7505727813382577, -3.431084841950071, 0.6815281625039732, -3.8770212274118907, -4.209217699509585, -3.725176458095514, 2.362063400070702, 1.0789307023148227, -3.7128613318151116, -3.946661968543445, 3.0377191992874026, 2.7991666065401293, -2.3152620001626345, -3.9922203391159163, -4.366743946138519, 2.0012176149256855, -4.7023749332409395, 1.4245533920062199, -4.047766160083736, -4.319778920047579, -4.058713978229965, -4.6995951203840445, 2.1405943059153496, 0.9002352352444261, -4.143273817921736, -1.8977970632609806, -4.973959931197747},
    {-2.8335978664825867, -0.16427709754992728, 2.2702225284871655, -0.867424816677901, -4.501246963868924, -3.5725401012689058, -3.7221109668135663, 1.0955437644941206, -3.6469609586193923, -4.217262418533971, -3.421063192117915, 2.215620850323401, 1.7116183901704496, -3.4504233878013255, -4.1051781527459585, 2.9645558632119613, 2.9227179149958795, -2.2667440298297334, -3.931072494787171, -4.014618888403822, 2.4940969185329487, -4.7446439572130235, 1.469493436368762, -3.867015717568727, -4.122360951434157, -3.7792909419218113, -4.214113753059624, 1.7885007745122323, 1.6995812253562979, -3.969033060974909, -2.1931425562428006, -4.832717069867118},
    {-3.5221141987096902, -0.4881388541043162, 1.5297579023318602, -1.3054602542414473, -4.450593303386457, -3.668621671357017, -3.5509157603027273, 1.2666407868797072, -3.676661188505965, -4.764159687015738, -3.471139529843516, 1.9285988929300977, 2.014990473466262, -3.340546316936401, -5.109374299860819, 2.6980964028910366, 2.6772320497115327, -2.954333161149657, -4.20125109132714, -4.24363163081623, 2.1346160263149323, -5.049761021448506, 1.4400527894320512, -4.610045541644141, -4.038653118386702, -3.8932067184617214, -4.451345329856911, 1.5283597818823331, 1.621880228905612, -3.9768840437184125, -2.536600278445003, -5.103994519735764},
    {-2.988276765559583, 0.1784900502008627, 2.5998467670952685, -0.48803920584590577, -3.8235893513658787, -2.910300057952064, -2.615195690215727, 2.2017846966430623, -2.692257461454377, -4.077524373716302, -2.735198777422068, 3.0295560181681838, 3.0185936945328122, -2.8424244270113443, -4.473168666761498, 4.087117758037298, 3.859261138802688, -2.2838312529374303, -3.7693875025656625, -3.406814693505202, 3.0164087735013076, -4.763595406315285, 2.3961688375722674, -4.207183756277679, -3.3485480686329625, -2.8790470955953458, -3.402570833762607, 2.7344193837962747, 3.3477721652139216, -3.024943656263342, -2.0612692813713718, -4.650796538495867},
    {-1.5241730081886955, 1.6765070540424258, 4.046049779395324, 1.0655598584426347, -2.4990829424028083, -1.4734858468757006, -0.9826216078263078, 3.5866736904894156, -1.1916643598049868, -2.3317940330834888, -1.3673574984173966, 4.1350503392202, 4.2224155429129, -1.1771646954340562, -3.122253175220913, 4.955754617269748, 4.845949156020596, -0.8027420126903844, -3.314748796316919, -2.327563815362958, 4.229803928039617, -3.556446124414073, 3.2639730890233403, -2.9098117019890566, -1.9156489323545969, -1.6295520877850047, -2.1047373085150713, 3.6835630606846412, 4.240245889298589, -2.1376041385271654, 0.07505436873431955, -3.0561647330928183},
    {-1.324917684299745, 1.3298645258429649, 3.3721049361928626, 0.4491014102302426, -2.4711695465678796, -1.8873405365030012, -1.3487671447852372, 3.108621663858025, -1.7494380554589002, -2.925408823309316, -1.642586714178964, 3.9160844481383728, 3.604795924158414, -1.8172597690610182, -3.1702590194469034, 4.2539719495660675, 4.480223162103503, -0.9661625091545539, -2.7465929928814816, -2.004632303304525, 4.144447170944123, -3.0869734236163184, 3.0012696730158948, -2.8160077385945796, -2.2243817306916984, -1.6708376552920035, -2.237766890553339, 3.3980975007165313, 4.0616098393519176, -2.2339880717872465, -0.5381099448876451, -2.9138668240152996},
    {-2.721594772911242, 1.011652632840259, 2.904356339538991, 0.2987594771669145, -3.612190963992551, -2.472231056218848, -2.3092284875742313, 2.8373859816302134, -2.580843515852659, -4.228087318392198, -2.60652355016696, 3.390218504844425, 2.7958727812521853, -2.4895558972971847, -3.8930476608746853, 4.119197280562636, 4.425984077991414, -1.7725225936569977, -3.516426892271957, -3.1465746196818127, 3.3795985219594824, -4.156934917882634, 2.92159587334876, -3.6760432250060315, -3.3169645906327343, -2.5954064047573917, -3.621623247521837, 2.934545093756054, 3.381260038211237, -3.141164748829225, -1.1185548049869394, -4.486498057874067},
    {-2.4883405170163146, 1.2048138954074221, 3.428311788618659, 0.951197620497918, -4.316142542088164, -2.430713871648917, -2.3042812010320044, 2.4850357505747596, -2.9111403921466863, -3.9112261331477955, -2.500068543386978, 3.651682576845566, 2.6262925987322387, -2.078542882004893, -3.9809577034696737, 4.596778675023904, 4.6652799953814865, -1.4641772629743712, -4.2463566478743475, -3.648755899398916, 3.3490884477641654, -4.712884367130203, 3.5616200912330145, -3.653323465918405, -3.0805349818268923, -2.7268201911936263, -3.552264427743688, 3.137533181780722, 3.5934906612689574, -3.036640686997989, -0.5923522727341136, -4.886715660125233},
    {-1.281751188459376, 2.1032917956010406, 4.4139656107342375, 1.8284839659871708, -3.0457732967446782, -1.1792272173053175, -0.6901217892413152, 3.7045928791885494, -1.190426170815149, -2.4777014574605514, -1.0751450059435834, 4.54645549977607, 4.230085170740112, -0.8722168941065166, -3.311391239878312, 5.121272996245352, 5.104551501596173, -1.0356039748032064, -4.090897900123796, -2.3298912220397647, 4.619928719402251, -4.281351549664394, 3.787468384503316, -2.9141169822426, -1.920097425768257, -1.2293639774647616, -2.098849685968793, 4.04376227809468, 4.402748183984292, -2.022906656173273, 0.5016503849112242, -3.7379895834858217},
    {-0.6266094865707273, 2.623978344496892, 4.576115744859413, 2.310385930392001, -2.0323367591195978, 0.2990970623392847, 0.3999832039231469, 4.267374175599336, 0.15561372149379113, -1.212264587320624, 0.11917362463667198, 4.748576699185917, 4.565781752541754, 0.4410399266221367, -2.547976656818559, 5.284851913866638, 5.58647440862246, 0.1893656719972104, -3.7551178080054215, -1.4252165240796655, 4.60120790821169, -3.233019791405414, 3.884361035378248, -1.6978238579899125, -0.7128965707772668, -0.09646648709453776, -0.7164220519656916, 4.082301165410554, 4.577425482314404, -0.9382497226049714, 1.3614174716247662, -2.8075873535467806},
    {-1.6685803473037228, 2.3494267000706177, 4.134408405603634, 1.8563017870596858, -3.0512063030309213, -0.8660899553630299, -0.6946253986333617, 3.3356570663485012, -1.139165524088514, -2.67780777745788, -1.4003375828070255, 4.161572504610244, 3.5857046101026975, -0.7501183075429133, -3.4247646153021876, 4.982049083464973, 5.048031043300706, -0.5870607273140541, -4.235600706048372, -2.37962331740047, 3.9431133770093694, -4.212463868095202, 3.6904782073832427, -2.9003209157916765, -1.6935393924856827, -1.33294588802325, -2.383276014404813, 3.700342292998228, 4.1040503354836835, -2.1092012071535193, 0.5287178778272223, -4.052376582636544},
    {-2.261521048153596, 1.8284532053908782, 3.6570714925550423, 1.619822210968598, -3.4680349547969618, -1.8786439200953275, -1.3631721442409868, 2.4976928958333913, -2.060966137897773, -3.472382693011331, -2.1733558651374585, 3.8910019037880255, 2.8225175196874095, -1.1233906864942749, -3.6132103808881912, 4.8054504115178505, 4.581370701731693, -1.3323026814756438, -4.407215701235468, -3.1644452687946356, 2.8217555943908463, -4.506188034038887, 3.6735868610037055, -3.3239839885732843, -2.5126976193019397, -2.2714664671605567, -3.0900516174040966, 3.7661059024817187, 3.407635461950051, -2.4271836191617644, 0.14963684345536155, -4.721381672178475},
    {-1.7828839495304736, 1.7883210314130054, 3.5133409264937634, 1.1140893466406492, -2.7512054596775655, -1.4593406646876386, -1.5931508780605068, 3.1814519829443597, -1.4919365250433758, -2.91384255840855, -1.9143346671082737, 4.080878491939096, 3.3188523392103293, -1.0598658035071156, -3.0729725439533415, 4.6800165231950155, 4.6926629345297775, -0.8297224110906571, -3.596766656057783, -2.630274879957711, 3.8406486101014927, -3.871464445434084, 3.4295078287709093, -2.6928553491219005, -2.1580810336331315, -1.8112490669933934, -2.3488474848958045, 3.611715833963407, 3.593074569921429, -2.3517545816384753, 0.20903780986855144, -4.02431282817578},
    {-1.7257204217551423, 1.8738344178121424, 4.125460389880812, 1.5474840400199052, -3.0788390407683313, -1.6570039670765304, -1.221861995479263, 3.0379620069240945, -1.910225523096932, -2.9588488918312787, -1.934504736112472, 4.2204163596556725, 3.544573734792583, -1.1371263189938465, -3.217499582655488, 5.257957152393713, 4.8720912347395915, -1.0141280665401928, -4.017406568140337, -2.742191255511606, 3.9826503010618937, -3.978201993764025, 3.593881824905521, -3.2381775369894354, -2.1354650951399146, -1.8815445469755305, -2.4665346802158266, 3.8304038851411697, 3.774804114663961, -2.162362112492564, -0.023733167417464045, -3.9224233643950566},
    {-2.054619852099586, 2.021987814738036, 3.962518211081099, 1.6510464356311594, -3.3734562156263257, -1.7096243696805666, -1.2270675133694582, 2.8559796031362987, -1.8892472739628015, -3.2445971396558657, -1.9697318090620055, 4.233128173763804, 3.6333752629361675, -0.9247260456738792, -3.538661371424592, 4.837035962108304, 5.031134121370398, -0.9885981614708587, -4.468332386746516, -3.0474421953968602, 3.981257792223408, -4.39973708870508, 3.535250824160854, -3.2953262100612513, -2.3095533388218703, -2.1509739043519183, -2.7383680255536773, 3.606639320891452, 4.016943784128602, -2.464519376353965, -0.032535045753801596, -4.079602864985238},
    {-1.845926626666715, 2.258859333600471, 3.6529241463524436, 2.0536021656247656, -3.1299555117056723, -1.6515820583744454, -1.179174816264444, 2.4738984812536238, -1.8870981641061657, -2.8787925393884715, -1.5923269544944425, 4.217596734091881, 2.679961309672896, -1.0758845016729301, -3.054410992950086, 5.1163343018781955, 5.09151471195068, -0.6248934195300963, -4.407759125071879, -2.9559775630431866, 3.5948609104546243, -4.339691772822338, 3.989530344046405, -2.8788465742161455, -1.9642935617256254, -1.8129660112017778, -2.597325113733955, 3.7944638136908955, 3.9849115549191367, -2.2262226641289766, 0.5621891796074305, -4.433765860008441},
    {-1.6772232070279152, 2.3687105835924793, 3.5406952036017403, 1.9895712615096894, -2.9721578657870222, -0.820846720191513, -0.14140378345625898, 2.7583448536469555, -1.3216820375161031, -2.632777826643427, -1.4931094031608674, 4.192711043519292, 3.2628010597866495, -0.36131485363292454, -3.540455567239386, 4.8360803514146085, 4.924926521922094, -0.4615673472456303, -4.7035153271109165, -2.6005248369819913, 3.5170810141671076, -4.633609272860772, 3.9155111186756897, -2.9065977703549915, -1.8867770174710892, -1.1464514113729534, -2.3921275033736378, 3.5561889645025513, 3.7762305445917606, -2.157310228111382, 0.6735107094286312, -4.542673777496602},
    {0.03623901170225155, -0.9654964207934211, 0.29237757297066674, -0.6627102680139643, 0.47395769732685317, -1.4293165011972033, -1.1961002633784779, -0.9834118284108554, -1.538798613043596, -0.7452697717027422, -1.2026512343453208, 0.3589773983675063, -0.5885217703326556, -1.0337409772767183, 0.5071213921483042, -0.7160609576129238, -0.8082825577618429, 0.38269626997971384, 0.7939711093341622, -0.6547267938083884, 0.2960912896461037, 0.563389795573695, -0.631230822294065, 0.1702423600560073, -0.9033904390358422, -0.9719125330860935, -1.0312753516905864, 0.26467522015411016, -0.9172423116998754, -0.9512586103645224, -0.14249267363103196, -0.37338414121528607},
    {-1.7108618948452234, 0.15559553090926265, -0.20216338022339858, 0.19813401825763494, -2.1434594965208267, -0.9229125758335577, -0.5039481391939701, 1.0425997034737498, -0.5220903722835125, -2.1251164897591504, -0.771841518801164, 0.3780183056659731, 1.6872566361267747, -0.6930133763443136, -2.4808844266168313, 0.9021734785944044, 1.7212085319750405, -1.6905422632499314, -2.6459314091378343, -1.4229277057925112, 0.6915738174848882, -3.524009631923744, 0.15144861834634993, -2.0953789656582917, -1.0991217504398818, -0.759675998843554, -1.062804154495766, 0.34455261939945125, 0.04087417586290051, -0.7859027536558872, -0.9832796164561833, -3.0006160067864394},
    {-0.980359266033812, -3.215830068524844, -1.9030446354077062, -2.9366892845006163, -0.3402055326829691, -2.4021091430269443, -2.209323431371482, 0.0008443358369340351, -1.528199582490305, -1.8444623341552087, -1.7986595859232615, -1.9678178075565282, -0.13997875780270175, -2.595448084815679, -0.3276422548473607, -2.056460323766252, -1.9944277089272515, -2.109334206102079, 1.7847184892669399, -0.07613059259110147, 0.6389971132408818, 0.2232441293275254, -2.689880157674168, -1.6319324175306837, -1.6625757742902842, -1.814802776753731, -1.5421669470856423, -1.8048095473689214, -0.845314872193459, -1.4102489798535023, -2.8331375789909377, -0.0924452237891828},
    {-1.7716058953475406, -2.6665862140661183, -1.8489006242664894, -2.055926906090499, -1.911725056581599, -1.5947311839583698, -1.9182928896051874, 0.08968486104105744, -1.5702248087301982, -1.61713551918225, -1.7146767183795284, -1.544999362732662, -0.01601545297866662, -1.4922599145301194, -0.16572528156053998, -0.9257488975921017, -1.1759132026583703, -2.3443308500351394, -0.21978990256442854, -1.7992136239617957, -0.2293944051652887, -0.9413241670663957, -1.924441281890528, -1.8579382337461632, -1.6331958635630253, -1.8239914309931367, -1.478087560206922, -1.2632611771622129, -1.4691676568041434, -1.91757497773101, -1.9550173522073955, -1.5024590653306948},
    {-2.4110208273402893, -2.3155370463355336, -1.5256744170804861, -2.276141152407339, -2.841140683224287, -3.1499135009843897, -3.036003473480413, -0.1500418309965575, -2.6819751759486827, -2.9281077682435925, -2.9328751207583985, -0.9168454308541899, 0.6393529780129833, -2.9034737584428227, -2.352192678693546, 0.05216094807167137, -0.1793907771052437, -2.5514835153926145, -1.5390219360612487, -2.5890100398453155, 0.43862172444524505, -2.7017893599666034, -1.6309033502706605, -2.7472385872502807, -3.0791090363517086, -3.393339973401952, -2.9872596638852302, -0.8842337828039482, -1.7346900210636735, -2.8782597064496924, -2.8945130551320633, -3.2326947071505026},
    {-2.2646518213174964, -2.374551601347639, -2.167611239379538, -2.30035452742212, -2.2016491695460734, -2.813127407931522, -2.46980451922405, 0.2522470422285313, -2.3981428921093264, -3.0677933843274356, -2.690364129814617, -1.6271063346564243, 0.9856559949212388, -2.7512393955317584, -2.4808068088850757, -1.19489364385435, -0.7834175955214321, -3.0547080395586494, 0.23264974975997393, -1.8411281805865993, -0.3210310524149914, -1.6654097879946679, -2.1422271047117376, -2.666668652330095, -2.4402054408029685, -2.456063378004458, -2.482090026539818, -1.760478572732142, -1.4351440548339642, -2.202519432253332, -2.6878598063280355, -2.3969619836062854},
    {-2.315180273411188, -2.956047781814339, -2.1099228610539065, -2.8037304012211735, -2.814021313096888, -3.040671868523821, -2.9141002093692023, -0.4792001744466894, -2.8184880618242674, -2.7934759708810835, -3.06975520390726, -1.7167247615791235, 0.1356960361727944, -3.2586912065074003, -2.1778015788549396, -1.0713430067964445, -1.0908850621057868, -3.3770922553967417, -0.7058711643562983, -2.761010424036642, -0.9745131950534272, -2.4063260914521, -2.5821513993786764, -2.6904504280971935, -2.912917102986634, -2.863240642404475, -3.0018330503421513, -1.8573576913479526, -1.6868323807475945, -2.85313110734805, -3.3388504847807807, -2.9588796530727257},
    {-1.655128405749908, -2.49145916045691, -1.318488617214595, -2.6005991445995256, -2.52938143849629, -2.483709900467193, -2.2980825503964066, -0.7517706681024044, -2.979331098036351, -2.3739964532469005, -2.747623955624511, -1.2294040423300088, 0.0579445681664768, -2.6566203623311786, -1.521406999509723, -0.20768296356253735, -0.3435894160516968, -2.60495550932059, -1.316334814616811, -2.5688713243379597, -0.1309566061063454, -2.1209972761916736, -2.5088947025976474, -2.6442854664964583, -3.041080647384802, -2.5475981540289108, -2.816139279057229, -1.039197819801153, -1.4663415881131208, -2.59086568465774, -2.6410333724008215, -2.7031657660579667},
    {-2.5605194979562116, -2.8518352633758246, -1.6983214072372996, -3.5110163856445364, -2.6656189516648383, -2.639712542416678, -2.7111937384645204, 0.10331759704796999, -2.66669334811782, -2.607026338920114, -2.820281733312874, -1.2457502478741893, 0.32837648730962693, -3.1088100551646507, -1.6685297816709228, -0.7653916972532971, -0.22535355735469598, -2.922493478146302, -0.311412791082837, -2.2130137272765618, 0.08514397633832373, -2.000103940871614, -2.8399967703521884, -2.806110805360122, -2.8844032620287785, -2.733756606003083, -2.6594933454714007, -1.1130482947116824, -1.6963608661522038, -2.572196978375852, -3.304159321379034, -2.4319343446929946},
    {-2.5381266895255163, -3.113807867099676, -1.1364501650499328, -2.7384522473292567, -2.7812631711556173, -3.2710116808429612, -3.0973877415119255, -0.4603776261944265, -3.269557746603519, -3.0767539330428137, -3.1369696099250524, -0.8335586564586444, 0.28319006966045135, -3.1779280516235615, -1.9596316969497627, -0.9846596070152644, -0.7955478789170258, -3.165537618460383, -0.24467981023449473, -2.9766049981645692, 0.7705723962946495, -1.7044453809734963, -2.6468500744302172, -3.3260318274362684, -3.141325995785103, -3.034423888615352, -3.53747537643939, -1.0173424974707603, -1.553288795795576, -3.114420696336465, -3.156299743831086, -2.9019418310321634},
    {-2.189336532220212, -2.8146134850748945, -2.2391092991846775, -2.478161280771287, -2.6545254088954002, -2.8449765737449346, -3.172864568353855, -1.0334487490669206, -3.1495279498095, -2.920952207689233, -2.8965724397676977, -1.9120895962597588, -0.5849470671565004, -3.1782203913594422, -1.6758620208506778, -1.6502292513895787, -1.612983198369887, -2.6215336395732773, -0.2603485327718551, -2.5634245234210726, -0.7206084546797471, -2.186109084796985, -2.6619911510011005, -2.467851917764093, -2.8399767003561767, -2.6931086223782943, -3.2773008412586964, -2.003575210779914, -2.370621452085297, -2.5876298887971103, -2.943602011582593, -2.7757865666266657},
    {-2.735064098602746, -2.9377953242544916, -2.0760421780220457, -3.038607167461097, -2.6613869973187603, -3.292126072234899, -3.25949883629603, 0.06755236199829448, -3.052640802075731, -3.330723064136337, -3.2078627011320267, -1.975821095398392, 0.23519126674598861, -3.3219951710507023, -2.311154264504075, -1.1733229100634985, -1.1901961204415024, -3.0539448561543288, 0.6248407634832884, -2.601454258438167, -0.03953966313979497, -2.4821588750387624, -2.490526853128467, -2.893787061356727, -3.2573989758973756, -3.199264434999314, -3.041135696485119, -2.062863501871925, -1.876810371800521, -3.1200688116695074, -3.185778327219684, -2.5647818791029326},
    {-3.013907280135265, -3.6632372205223187, -2.0719609583560987, -3.373845507736816, -3.1231181797909136, -3.78410067033071, -3.4435106435003213, -0.8592487255881376, -3.5145433006190814, -3.9574797241169013, -3.7414127441937133, -1.8178910779596906, -0.2257149257855769, -3.6879077402964886, -2.8495471022548986, -1.0863537850868925, -1.1978761676066565, -3.9515309909762553, -0.5923254136066567, -3.142787878592225, -0.42520272109019147, -2.751456242680709, -2.795689942007589, -3.2708115798608173, -3.6489417475651007, -3.4199276480022194, -3.5969262949726675, -1.7628213756566555, -2.2244628176712062, -3.426566207058402, -3.6770114074168463, -3.3880776716426366},
    {-3.5330927698924057, -3.5030964512144034, -2.712672559371542, -3.3155402914916343, -3.109834166608323, -3.5856239838431985, -3.5383444661602477, -1.2407659198921555, -3.4449362023328822, -3.9793113152396473, -3.558460042796918, -2.008047241373541, -0.3587311800368928, -3.576905505513374, -3.117901239844179, -1.7179507173530815, -1.5310096681401626, -3.364416533276631, -1.096106205708444, -3.0423442916193384, -0.6914169696722609, -2.7769809090808564, -2.9579443154461793, -3.857008967305021, -3.5193034490337807, -3.497996060488675, -3.3931559455189073, -2.3025313562189464, -2.598877678324578, -3.3031148275857207, -3.5480207890814546, -2.990681641096467},
    {-2.849800501205484, -3.682628695929265, -2.3168143294334724, -3.5296577752392326, -2.3969983925924234, -3.4613656976528664, -3.0852769560313873, -0.16699495973042233, -2.877125309249276, -3.3314034054881803, -3.2173849723176993, -2.0574605886405695, 0.29932033085197135, -3.4987478762344115, -2.529361773622126, -1.6923948687700026, -1.8737332492847416, -3.141723478149138, 0.4321596078406801, -2.2784637280646494, 0.09347554688939451, -2.13331246104963, -3.2608279456068843, -3.24223568554589, -3.4754766759322453, -2.9335435074437695, -3.3784923700098255, -2.1110976357903866, -1.3938319231205019, -3.0166224083042574, -3.620004230137673, -2.2064141032615208},
    {-3.118906881130397, -3.588045872527363, -3.062554078711657, -4.091150042507046, -2.236710735868556, -3.3532736147458486, -3.0118701707980065, -0.014381932950458112, -2.4784701169697994, -3.32684860930364, -3.003796747507819, -2.775969085615438, 0.14304771456950965, -3.375511623269282, -2.9578025631803033, -1.9681125936865234, -2.156384917584674, -3.402698327657263, 0.21581482007717248, -1.8317685311823335, -0.5994848328832975, -2.3808442123046794, -3.648995810317151, -3.2711083542803396, -3.0508195952320976, -2.78912085798822, -2.8588833979702404, -2.6328466215383517, -1.5148541738254582, -2.3329143746329635, -3.7529926988547673, -2.3625424884523776},
    {-2.004430295760329, -3.21673847597254, -1.577180205190665, -3.2512609007780333, -2.053473201128284, -2.646222137224931, -2.19346937432775, 0.6098794824466771, -2.234729017519966, -2.487300340730339, -2.3128632244739062, -1.497443510073693, 0.4912735300167673, -2.7098547874422287, -2.1000180511555593, -0.9715553444370053, -0.9487891358516014, -3.2246604527474343, -0.29726628360119456, -1.720973489660414, 0.663062382622879, -1.908240693269068, -2.5986940484928556, -2.5274839602387287, -2.5693687454267247, -1.97257320527543, -2.192932038619397, -1.5846618725086135, -1.164448604680432, -2.534381957017986, -3.047558156806508, -1.45439516874184},
    {-1.5643050178726514, -2.365321827677556, -0.7430583412329211, -2.334615516245304, -1.4540891931832005, -1.678630078159659, -1.2667414550310994, 1.4483333431821868, -1.2039344763634365, -1.5018286080866878, -1.2889862608145537, -0.4071013969776037, 1.4878401387053188, -1.655212329312298, -1.8162080519803245, 0.26995023832875215, 0.24522068242242984, -2.101583568696452, -0.037128828016151125, -1.132398325756523, 1.3598823643768343, -1.518051594709448, -1.5411421151118143, -2.516323348260307, -1.710752625078751, -1.3383832939936546, -1.6073912306008704, -0.8225429367775804, 0.4178133636875646, -1.4192457353377756, -2.4926789296777976, -1.1342133638576595},
    {-2.154165158934434, -3.6192554936654178, -2.208156479427926, -3.5864507730828774, -1.589186554035778, -3.0887499426665252, -2.7722726727746845, -0.0771993491037959, -2.8771794688806143, -2.395098374100674, -2.420331915887365, -2.1095074399267766, 0.32044794533348314, -3.318682696318141, -1.67793138108012, -1.4862255768010522, -1.4674419814003916, -3.3318827140610914, 0.2252717184039174, -1.4694403345043108, 0.27120735198811785, -0.7893173075585471, -3.098152523657864, -2.644641876489177, -2.5937880393991923, -2.6698492036699073, -2.3903490642507763, -2.4295015720902877, -1.666286802444972, -2.803043548461919, -3.468614788914121, -1.2336722578977528},
    {-2.8219417719781115, -3.7451289981462117, -2.6600942685764943, -3.8134659724109192, -2.7380105779704373, -3.989192642466558, -3.855750832266064, -0.11734281020169211, -3.5597730835637322, -4.039598209645988, -3.5690375410110837, -2.1418611892744144, 0.5877380755633086, -4.073960205821431, -2.1398024291024953, -1.6631349191744484, -2.004922588548198, -3.628666835718699, -0.03370739357218668, -2.5424600587913493, -0.02732499747018602, -1.7351054926321734, -3.695390689269741, -3.3094516294536573, -3.5296569050002353, -3.6049194652498153, -3.5709230324386936, -2.1485404158487698, -2.4334319107064246, -3.4639287797650082, -3.657066082388614, -2.6206691721370627},
    {-3.225979804313053, -3.613794105212896, -2.482119335125851, -3.618102211186326, -3.2340364623432927, -3.9346724768037338, -3.9224060956342672, -0.5900882481128856, -3.915015962872096, -4.1953690838760265, -3.866655019368496, -2.1825180089681386, -0.24509828065764416, -4.174056976016876, -3.0928918816906132, -1.4381171146930707, -1.5887249806484343, -3.8617332355806355, -1.079597065421278, -3.118372152977643, -0.33829484076948113, -2.5034546943017593, -3.3150825560882127, -3.711212173804485, -3.7877215739888963, -3.8711006945766866, -3.919043391000183, -2.009263647948422, -2.288776876911258, -3.730730232617149, -3.7649029368748606, -2.878109587806281},
    {-2.768439797976065, -2.980415819447825, -1.5812880420816737, -2.988697262664142, -1.6153171595902194, -2.8374755092154924, -2.211978346165295, 1.8366212631731755, -1.853397282820808, -3.1136707728192374, -2.456081837092895, -1.2321972124168499, 2.52198710035718, -2.856315644217388, -3.1582134203926455, -0.037882834563286547, -0.13059640254938715, -3.3569720748524254, 0.19973402450357436, -0.8412267072108521, 1.2140819165503, -2.1249640401452097, -2.6776816757160615, -3.1046044266696478, -1.8319590911165948, -2.2219209858343603, -2.188665889979006, -1.0313821165894914, 0.244455949280621, -1.7953647635763494, -3.678614351308278, -1.8421737908252613},
    {-1.9566289396614394, -4.304847426518384, -1.8394100979420411, -3.8461388950045987, 0.10196450990853452, -2.122257122204273, -1.8143933762489104, 2.19132309772027, -1.1367605567884689, -1.648918960272646, -1.766633038679713, -1.372253065896572, 2.877878103973389, -2.95500719803101, -1.207449797751395, -1.7798549677990145, -1.6986059510899818, -3.2358982350058705, 2.81427085481417, 0.4812870721547386, 2.277492354730168, 0.6492423137486726, -4.054616611354501, -1.3807360092997447, -1.2071525212031402, -1.207490801711117, -1.1574855105723176, -1.8353513865622781, 0.002358033985628515, -1.1704452731888448, -3.441802465949427, 1.0267687700009105},
    {-2.634551275031531, -4.590245543210934, -2.685694814291774, -4.353967983735976, -1.239952613230375, -3.6692504253105893, -3.3767142903742644, 0.5028267281724411, -2.7375789093418463, -3.146567983164653, -2.788435220530511, -2.29473043397531, 0.6181991508811829, -3.9818323725504166, -1.7980161342150773, -2.6333613052390166, -2.734097164586061, -3.9715067915534297, 1.9509356216157718, -1.030950147853527, 1.0564301883282858, -0.16538657599315224, -4.220957738298156, -2.9296474780041213, -2.773354530662318, -2.676311713648936, -2.560347229593565, -2.5337036623750153, -1.6583713563653384, -2.3488998160657193, -4.11471935065047, -0.31017692076395015},
    {-3.153844228749582, -4.482001593843129, -2.7064017410826313, -4.145953397215106, -2.4619896223856097, -4.049260759496387, -3.6110447416300064, 0.24956046135897209, -3.696307155005521, -3.8154250915572407, -4.045856869809089, -2.4207833097648455, 0.3592167209084076, -4.093219399367414, -3.142830904380341, -2.065652481477525, -2.229379310011856, -3.9037609928879293, -0.12462478904311967, -2.465152699097834, 0.23617748293591265, -1.822436825282871, -4.119199683591599, -3.4766377674965137, -3.421931356315477, -3.7961124893291176, -3.754254279365193, -2.327001885941951, -2.4830751049205113, -3.4958290840735735, -3.8266880670739662, -2.586913964529781},
    {-1.6733361207603217, -4.550133751532449, -2.593807155224184, -4.229440942181892, 0.2343116302339732, -3.165852798636603, -2.7069752952870214, 1.6292651112444965, -2.112003734227385, -2.1189845173903303, -2.3224723209229405, -2.4015070500892195, 1.886199196168492, -2.97388985303171, -1.0599557388286402, -2.2728140971860338, -2.4138084149324537, -3.3005307145872265, 2.2307608288440495, -0.07242406138848813, 1.5346036250743038, 0.7097086189367495, -3.9132487095820143, -1.4567775158003686, -1.17349417305433, -1.82570391015376, -1.2021560199188888, -2.5596925953668057, -1.0454965516860044, -1.800595081176489, -3.7366335607786008, 0.910797539959612},
    {-2.2691659232012866, -4.154282359656253, -2.184674352009882, -3.7881787027757583, -0.7596250961176764, -3.270813093925926, -3.06307804457636, 0.7004351151316278, -2.638062450013707, -2.9763222404917293, -2.9995911427907225, -1.736536616472967, 1.6916355792817317, -3.2709899511566767, -1.6853445320279339, -1.964070262129126, -1.6666579669692283, -3.0043281424913046, 1.3243635602944237, -1.2319613717362814, 0.7724253190332849, -0.5154460396236284, -3.694896424851587, -2.862524500989189, -2.288771904040322, -2.477819435208398, -2.44462986234738, -1.8828499814147581, -1.1447308803929173, -2.434841697848644, -3.6182816204867425, -0.5696556767547776},
    {-2.2985207220678716, -4.354737268045288, -2.0379356957171897, -3.791590195445577, -0.9736644833716052, -3.338857416818859, -3.130580772913742, 1.0138990577740756, -2.651034770053927, -3.264790686795554, -3.3448860495623527, -1.976437755352375, 1.1066852783534051, -2.873414159676169, -2.0606725988387384, -1.6275438068095633, -1.7548762827776119, -3.3497841099730445, 0.6012897472860678, -1.6519579763184908, 1.1478086262996074, -0.7174085626542817, -3.891352021445475, -2.7436413189414224, -1.809588474673353, -2.8892501836829996, -2.5935891719367983, -1.8826070849592278, -1.2661596314070527, -2.8412343119269994, -3.8139507859508996, -1.2789438757577027},
    {-2.597734877511493, -4.586935986810933, -2.399092377121928, -4.19385927712472, -0.9435683638987197, -3.1197268393674293, -2.969188492129448, 1.3342437595984462, -2.6329274252494663, -2.6437379661205713, -2.8499509823623637, -2.337270871652663, 1.5668458842432251, -3.251852336052931, -1.970283829841354, -1.7512733956967719, -1.9731405365744683, -3.7424742709947525, 1.5169131464567802, -0.7813615036635335, 1.4712336472405734, -0.47835582916639957, -3.9580843217086326, -2.7745367587218395, -2.1168917840237254, -2.6134585987224317, -2.231646685543041, -2.161168156434909, -0.8942871968686669, -2.4163540581265393, -3.94169632067726, -0.3859556598708754},
    {-2.498343091349234, -4.469243245638945, -1.944385696298822, -4.224082314828189, -0.8435723640555522, -2.820073240138273, -2.2829755455830405, 1.7429516819392423, -2.3670798549036673, -2.430160822084279, -2.686368856836239, -1.340289069851814, 2.0599598968802693, -2.802851628264053, -2.0063888053063677, -1.5419878093302144, -1.6639645623802766, -3.6954041254126158, 1.518819531222614, -0.4218244810502143, 1.9490019753424435, -0.6576529176996071, -4.069161933426046, -2.7626124283754403, -1.6490406515390286, -2.3662232244840613, -1.9293875037297439, -1.7471942440246897, -0.17125862254802116, -2.3330680015988206, -3.773622517582756, -0.7577164180691459},
    {-2.1301371784013736, 0.6370357641001256, -1.700101293910817, -0.2707536340080437, 1.5154543265267229, 2.046387715645151, 2.0920144575106874, 2.5340152863441125, 1.7813475203173696, -0.6806894252077734, 1.7562180773916414, -1.5486581370626629, 2.638584115774033, 1.3506955188424814, -2.0019855240944717, -0.37617439724932983, -0.5777761093868836, -2.226852178061205, 0.9750486533682112, 2.026336516063424, -2.4679878019978507, -1.2493489132480902, -0.7103648281626825, -1.5408094259678238, 2.1197975307592527, 2.319447152833886, 1.467347892599302, -2.162601543787698, 2.4012598702109798, 1.775052616308855, -1.3155132271213783, 0.25696883222743716},
    {-2.1642350713648195, 0.5267048570528828, -2.0208115762230623, -0.46907244497902567, 1.3505553652027305, 1.8239582881269691, 2.144893288441079, 3.006993716276884, 1.7191480135904997, -0.6426427343636633, 1.9066701424484869, -1.6201800470854018, 2.563306878933116, 1.0087506415265555, -2.0578696032141983, 0.2688323584338713, 0.12399277877238342, -2.0141504570552082, 0.636020815429464, 2.565041279075715, -2.5370548470793, -1.0466831648328607, -0.340008657215196, -1.4911376680587771, 1.283391627527983, 2.34065283455538, 1.5336387280013315, -2.073671656957972, 2.4165177851143156, 1.6713596683324048, -1.796696163879638, 0.0766304493184859},
    {-3.2379743030669084, -0.1700835088283364, -3.259326015318813, -1.5512720847419437, 1.7880062710783144, 2.1321227651901373, 2.1998540807863103, 3.5527563991242888, 2.535038749638665, -0.9512668102973617, 2.418349830128724, -2.90566763342199, 2.999420276062083, 1.4182936457522408, -2.2511551776800394, -0.9333844514612879, -0.5429970141330673, -2.6928218030424107, 1.159831974569722, 3.2956430344045446, -2.753900226127912, -1.0632222415020052, -1.316149899631331, -1.3941999058163415, 2.4560146266775473, 2.764394199858991, 2.380601683176906, -3.1665199911285318, 2.128406777715494, 2.091752812785668, -2.6176240446213037, 0.4996096273101122},
    {-2.8264302058567687, 0.4696141954894106, -2.759590727920421, -1.038469268744689, 1.893062906985973, 2.1883417425063105, 2.0890688378811713, 3.571795256276262, 2.5679299606346886, -0.7452214872656552, 2.4265071862948147, -2.5090148376723698, 3.0681138556192984, 1.2974908784769945, -2.272386497535515, -0.5337792723176432, -1.0367514777538094, -2.888408165767417, 1.2798437411779342, 2.747973763031538, -2.2324884094472877, -1.3867617664190872, -0.4268752683160707, -2.0087460244523982, 2.2102317597439622, 2.6401522129364943, 2.001294114603574, -2.9261951612826094, 2.099420106702105, 2.2757328043095018, -1.7599832084466827, 0.41046437439230243},
    {-2.8469801247204387, 0.18939186205966538, -2.3483753406365846, -0.9983076816820885, 1.7853408677007065, 2.05730360115131, 2.083605378537581, 2.952574454981841, 2.2185410653221598, -0.906307617557037, 1.8703909083288937, -2.066014161050035, 2.555180107134798, 1.3655370335302355, -2.676317886004304, -0.27481459853712814, -0.8733066418418245, -2.735658460630998, 0.8661861310528706, 2.1071372885503887, -2.762145378519394, -1.7138791244021692, -0.5041313022316043, -1.7877745249192432, 1.6755979202925735, 2.33894940889089, 1.4312887628611581, -2.1726799822740306, 2.0572298334593078, 1.454546654017298, -1.818331457041988, 0.03630878157456682},
    {-2.8071712996248834, -0.11555645190298434, -2.695028977243123, -1.2175735944526462, 2.1997687751324966, 2.151959533541177, 2.275587249909852, 3.1369570181489577, 2.1614991459154735, -0.6710050051405864, 2.3487883966468175, -1.9655803584112044, 2.2740462010545266, 1.2035102342351984, -2.4190079460850926, -0.4475959516239425, -1.0778828865058743, -2.7805716002940692, 1.0006108133695413, 2.5427512439237994, -3.0532008114840785, -1.4861201389323198, -1.0709414930434675, -1.7695267606068208, 2.2045720378209817, 2.23647802465628, 1.9812121360159236, -3.085558149942417, 2.0450182221320614, 1.9367181553824275, -2.026010241471691, 0.9974926812248985},
    {-3.0232931178006095, -0.35681619391280683, -2.8360875784035886, -1.5209866700778436, 2.2792662406409234, 1.754012184519166, 1.8864659477501045, 3.0108905380300635, 2.109220557648622, -1.2806378241211078, 2.1508687518451794, -2.3202388828548135, 2.692737445798343, 1.2440562086499831, -2.474683563631005, -0.9283367217020064, -1.2900092916366275, -2.6991338779181424, 1.3734369514227946, 2.692330846877001, -3.49780799643077, -1.5199538169072448, -1.2431882559459968, -1.9938287636955188, 2.0934777906045596, 2.4561602070779256, 2.2060058170222643, -3.218630221821823, 2.1031386643572687, 2.2525486541140105, -2.234556684941979, 0.7531319688646547},
    {-3.225817497414657, 0.4223382384358357, -2.748570755774232, -0.6133321326924395, 2.755265213349114, 2.1544281310423736, 2.393020253476797, 3.2740387400737525, 3.0676631828813496, -0.8310568892750464, 2.5838277702076202, -2.2475615533518654, 2.8032635871930642, 1.7864944101505862, -2.5130949361687023, -0.5942491411793219, -0.7971280648219397, -2.6111493818335925, 1.3272966097610628, 3.4187303791666492, -3.4623318232952065, -1.5882711506296585, -0.7218803199563966, -1.8362764867923633, 2.3036225277476072, 3.0512763450478078, 2.3797330078113044, -2.5110714229709106, 2.852601904109021, 2.4969577135364234, -1.6357673640956927, 1.186794454135511},
    {-3.531570211191205, 0.21505581693922302, -2.365764990051298, -1.1081305523983966, 2.514674686045419, 2.490543632523084, 2.5376001048155254, 3.8198389544742217, 3.0001015892730853, -1.232704773276775, 2.8600292472747664, -2.571012481318408, 3.0597389120651455, 1.7135047150087899, -2.655066659905564, -0.682403375985706, -0.7002623162544175, -2.6583594412328817, 1.2627377819036512, 3.1652825293802445, -3.4268084094736326, -1.7201469874962367, -0.7470303432688886, -1.907050138322632, 2.4620985990505053, 3.3732819106015843, 2.6771131791302096, -2.6435311923854683, 2.7432027845528273, 2.5911616800227635, -1.6165285236318157, 0.7876588404205065},
    {-3.2878570833254894, 0.018269730018579036, -3.12085769829716, -0.8963208078498356, 2.3960455996944274, 2.4128700644528127, 2.482298263816176, 3.648676566189297, 2.6088302636412535, -0.8460470430435554, 2.6484365188332584, -2.5213288713297066, 3.5753321731783982, 1.809142172646123, -2.9706983454301015, -0.7025628408049309, -1.0879212224631991, -2.720980198718411, 1.6358649638394351, 3.143429709684718, -2.688237689553035, -2.1004939607343416, -1.2578801964437891, -2.3044453003047733, 2.4024852570707353, 2.960472250928949, 2.6674671926195286, -3.0112331927862526, 2.7662775393503574, 2.4967113728741834, -1.8959730992147683, 0.9713688302662257},
    {-2.807520333170542, -0.21139505889944799, -2.733833624601613, -0.9110700288301222, 2.2625776823415857, 2.1188656169103552, 2.3713642267355506, 3.36428632825855, 2.671098338392006, -0.5749899970796816, 2.4999029279678515, -2.0594149281558476, 3.258778133400397, 1.9163249487789642, -2.770291175557136, -0.7892960285396158, -0.6191516687740887, -2.5604710332355487, 1.1663748535239693, 2.9007162677927423, -2.3830241067014275, -1.5895709119419537, -0.7882014758368996, -1.5692734267171087, 2.2171752264079605, 2.9066532589539658, 2.7690466003280036, -2.6327693917451347, 2.3105555677314085, 2.275828635611517, -1.8814967032593264, 0.5521740340954805},
    {-3.377854622014883, 0.46473326463059894, -2.838819212614862, -1.1423712762145677, 2.3404188641615127, 2.4797445781561858, 2.6199466716962765, 3.643105020178264, 2.981469943220852, -1.0860133095986513, 2.639700092869835, -2.4162683271226264, 3.4067926354074594, 1.8084508190709152, -2.991456743284048, -0.7653161665949544, -0.723760513091666, -2.905882494258002, 1.5580149690520568, 3.2149280500332518, -2.53274987296398, -1.3343234711469445, -0.7049200977518776, -1.9170711638156475, 2.7244513838628373, 2.8594295558563427, 2.6840305348842413, -3.206945509128648, 2.337137735464296, 2.6140424749378295, -2.1029656525405143, 1.1010409730082922},
    {-3.3009131447028324, 0.04493083482396022, -2.9699474881316688, -1.2928622453922987, 2.514562762466314, 2.1928123527572265, 2.245701193970514, 3.514091529725957, 2.909834804928325, -1.2607547841698101, 2.5681864451639327, -2.570291451468806, 3.595133910887543, 1.788618644977978, -2.7888566067631757, -0.8588821466177724, -1.1191757979185253, -2.944785963815044, 1.250380777935818, 2.9803142391168143, -3.024421321805511, -1.9716298437467168, -0.8988161585075238, -1.879191968700849, 2.495453710998637, 2.980740218857442, 2.8149865349590724, -2.9759509096320063, 2.7237189409787197, 2.5293221964065897, -2.2291228960677185, 0.6191790037893684},
    {-3.2552879098683474, -0.2614434983111517, -2.7390825823960685, -0.8137265949711668, 2.4704391434894144, 2.179240398710814, 2.2718138602099227, 3.85237139963949, 2.710244457350665, -0.8913644193390196, 2.702320379663496, -2.280136589239859, 3.4852831168436205, 1.5874239007813582, -2.7022282807627906, -1.1025757498711255, -0.985363412664455, -2.5748091636747312, 1.6295429527397816, 3.41216688943378, -2.4722632714902786, -1.4288001208888796, -0.7174049075391512, -1.6205572021103536, 2.449470682587794, 2.7025625511948697, 2.543675932750292, -2.382436436746928, 2.721275722865212, 2.677740750491749, -1.7943023466616783, 0.4953744948661887},
    {-3.609969798571925, -0.25513321754751367, -3.027534610887754, -1.0091551762040476, 2.6129408395916496, 2.2838320823542544, 2.5880220088783368, 3.4900053152309285, 2.8192554502208615, -1.251058242012568, 2.552440678448041, -2.5027182444373497, 2.970270057477623, 1.7073820982474865, -2.8840463423128453, -1.2099081746569522, -1.3651858833925479, -2.8086091502011086, 1.3418033637669395, 3.3749094252240774, -3.1652215381815325, -1.2700272901204541, -1.3755657697052737, -1.9851785279896252, 2.540929480545277, 2.7546552413675722, 2.5014478449030584, -3.162058740640515, 2.4644411221347173, 2.383711718620765, -2.1804195615772652, 0.7542522438256233},
    {-3.6251678081539023, -0.02737943875753247, -3.292234039966147, -1.2281860017900843, 2.4135176106547305, 2.2672853304504734, 2.667186220671679, 3.8009703975436575, 2.4259231490306896, -1.3019703229388944, 2.4422140051126697, -2.7989458985053512, 3.321666895442628, 1.7944628190431218, -3.3643925275400193, -1.1795931949567553, -1.3699706007272503, -2.6049474434285336, 1.0575450544470255, 3.417918661702263, -2.584792488896933, -1.9623655308242143, -1.4853613514419253, -2.393749832378285, 2.1103527766019687, 2.9449303949247647, 2.4552151635862525, -3.4682587954612516, 2.6945667726232982, 2.489311367661485, -2.3114863283167404, 0.45833219168955946},
    {-3.224425702390676, 0.3205797238973614, -2.8760638089497945, -0.9014946650263737, 2.6836507911577936, 2.7109042341480993, 3.0674163241253494, 3.9919650474709916, 2.761403110098771, -0.7847226172909922, 2.995652249525697, -2.0787507662398466, 3.5345651454881946, 2.095071869357946, -2.858925175113112, -0.6281801473719948, -0.43076535072782757, -2.5080154440149607, 0.9840421222835743, 3.6359318904914213, -2.358421779476617, -1.609902529389369, -0.533925474235419, -1.7818977144833257, 2.7733818170965, 3.069060619909712, 2.991373023421051, -2.554820440841037, 3.4293509429980107, 2.935108516807059, -2.1274951381056786, 0.632316756020517},
    {-3.6336249544691186, -0.1175623766268405, -3.0063756741295733, -1.373484586442966, 2.599906001168578, 2.5821404222483535, 2.8484461012581135, 3.778502821722621, 3.017679162280582, -1.0059441716094895, 3.105005923598181, -2.68400190531489, 3.558746123658754, 2.3626128229999632, -2.812708173896684, -1.0649743751044118, -1.0215788549288018, -2.8176705215603617, 1.495093552634363, 3.6412443266141756, -3.0727989147455235, -1.6187076020161915, -0.8352957836399313, -1.6224379996429537, 2.872133041729226, 2.968708340293135, 3.1609889085061913, -3.1656349491266575, 3.0390816976673136, 2.737575968137562, -2.4843125622724163, 0.9871843773604535},
    {-3.3623509474196647, 0.10929315230408425, -3.5032588851937194, -1.2784121474787538, 3.025843475946849, 2.732968802733072, 2.883955228065764, 3.80011110492779, 3.2374889987161968, -0.9141351632921446, 2.940570540776129, -2.8391273277928435, 3.606805000540516, 2.3155176832302047, -2.7513435705688725, -0.7789702699705459, -1.0388643048282356, -2.7978473185528836, 1.1281904048561187, 3.3017008961342094, -3.1555190746403463, -1.1489829968257026, -1.2014810340451203, -1.6163169942532247, 2.959249611399513, 2.9837658159332165, 3.150853470541056, -2.8858302005200467, 3.317528679831051, 3.052120990854189, -2.467293820157774, 0.8108609323282582},
    {-3.114281617801277, 0.7525858410152142, -3.294576905502233, -0.8351467735806457, 2.8734238787719266, 2.8400306742833843, 3.1627155590375917, 3.8425822575721593, 3.6012571935974695, -1.034994238296034, 3.2218407426613997, -2.790669369767546, 3.6708013101731742, 2.303630545267898, -2.555633296795796, -0.7807208003548789, -0.9848232482159736, -2.5479075427101257, 1.9436680760997307, 3.5031314554250104, -2.6330640657499793, -0.8113914548119803, -0.8517746678802941, -1.62090043991049, 3.121959538139027, 3.2572057193204587, 3.5285104719020226, -3.3576681009265994, 3.5008618776209928, 3.144530837289501, -1.9681696746065567, 1.1013511692288265},
    {-3.6533715089392023, 0.4799898999230049, -3.4585685159955015, -0.8671673960563261, 2.7353738287221727, 2.6498934760579123, 3.1168324064232413, 3.7003407743964605, 3.1970408433811244, -1.7176418071959167, 3.135776638298728, -2.994168064221594, 3.32058065284738, 1.9373875474078455, -2.9336062401034337, -0.9099717892901913, -0.734265250040182, -2.7931092751757114, 1.4321071683248432, 3.6984854031780814, -3.217676972595325, -1.5180297401162204, -0.8768375321835304, -1.9973336248965854, 3.015171735055206, 3.397223311109367, 2.8510491313402535, -3.2949350496121568, 3.307669116490683, 3.0077755715008756, -2.2503338398839516, 0.5955009174777575},
    {-3.6506223629804566, 0.28449206246356606, -3.456137282913209, -0.9102847269286579, 2.8935744331684066, 2.962572758584617, 3.332269727324364, 4.021184626702149, 3.727450426660284, -1.74704187735785, 3.091832528971795, -3.169866634952141, 3.610723154164616, 2.56359770441675, -2.9696722391263086, -1.205749457829385, -0.6712719226630816, -3.477521442354732, 1.724061396894315, 3.9344756159905945, -3.3353619290807215, -1.1759565248153747, -0.8157997628418476, -2.135951600904754, 3.1507219826401696, 3.501512368143093, 3.004010848172637, -3.489380872809483, 3.633914703381874, 3.178054384045088, -2.721477896208286, 0.9529671754987281},
    {-3.813497645697432, 0.36224549198259637, -4.132164791638597, -1.5292452257976055, 2.975730855657188, 2.8188862468529234, 3.5880797483995965, 3.9937774947578397, 3.735759755763972, -1.160868432127271, 3.494858095276996, -3.641291545412367, 3.7281090637903573, 2.533102102335552, -2.9252131974769098, -1.889191503849419, -1.5939964215264024, -3.646437155447777, 1.7625884065156627, 3.900491021787458, -3.216410936478447, -0.8459193259263696, -1.4271776460231649, -1.7187299697192913, 3.2994086208344617, 3.753435465202635, 3.0863941882111288, -4.071731308519491, 3.48694143811571, 3.2101037874457083, -3.0636691702716483, 0.8918408762766088},
    {-3.878187542682384, 0.68345465191689, -4.084673595464302, -1.637743309614935, 2.596888707995821, 2.835733065004487, 3.3463486501610387, 3.966919094297462, 3.654912035734955, -1.0876178999538229, 3.2321173563288172, -3.5580107672475423, 3.695986295863711, 2.3026196030615833, -2.940616620889383, -1.885257949164122, -1.6209526359056226, -3.534742745483712, 1.531803449731756, 4.200730339900012, -3.8866672550727643, -1.1117851303968327, -1.4156879561701268, -2.285336446969901, 2.956896908175564, 3.5750180013104575, 3.1569576081475956, -3.640421312541684, 3.247776936428854, 3.33158280979538, -2.971315561898192, 0.8264426584200315},
    {-3.870046984618907, 0.49249722559756126, -3.1183614839738256, -1.3468971058873687, 2.4879372457920628, 3.147686246573095, 3.3104340833088606, 4.060640073124078, 3.3918525267611446, -1.3790629793985978, 3.3990201879881172, -2.818046204968795, 4.075053983791681, 2.0325344022542113, -3.019332229940389, -1.0876635998787565, -0.6650289828862427, -3.187257301403555, 1.3882745221276744, 3.6312334101520225, -3.3600777319951107, -1.4475081614755918, -1.0738960514197162, -1.8453867183404766, 2.969690710794974, 3.7319790846556984, 3.4604900068802817, -3.4421801365083824, 3.8052034118496594, 3.0277590245137778, -2.339613467001371, 0.6051900643562086},
    {-3.823862282623809, -0.09660298183505978, -3.845644416662602, -2.010753888915303, 2.71180237246141, 2.9376232231085107, 3.215473258534834, 4.037991931504218, 3.3490050068969954, -1.624353139035945, 3.378133984101655, -3.577608074929027, 4.303481423463916, 2.208607146627504, -3.32123663451511, -1.7177558987142176, -1.4185188009825742, -3.863801740592646, 1.4003309173769314, 4.013867788675329, -3.6493034833853555, -1.5984414551128887, -1.6243954675710381, -1.7804403150745143, 2.9690405796654535, 3.5291179591619617, 3.1515388861977907, -3.7256892550893195, 3.7462447180595397, 3.4202889170244424, -2.9240959312840658, 0.49951163505040164},
    {-3.726692648500111, 0.27531806041972484, -3.7293293369989606, -1.6686191587220154, 2.783232586465136, 2.9269866056222633, 3.4190450270521136, 4.011286373220739, 3.6718206220690397, -1.8141665316569968, 3.3673810517632616, -3.4739337791651006, 3.5727822338299693, 2.433750091007447, -3.113601360211019, -1.6623522129758044, -1.3508219230030942, -3.4739577039094147, 1.843757824182116, 4.370982086318954, -3.848994402152662, -1.3038333304900023, -1.4872056911507274, -2.2433345243368894, 3.302840365429829, 3.5881667850771635, 2.891742899485101, -3.80591046696941, 3.6598064260004675, 3.3054321626297387, -2.856814003076854, 0.8898566880491816},
    {-3.820146227896927, -0.3317166338126615, -3.6213484652103403, -2.013439893009546, 2.9524865932506916, 2.498608301297054, 2.966936546825923, 3.7993209745463643, 3.3832514246341807, -1.8153338722590884, 3.3979796942898584, -3.2741163946155525, 3.6776810632479786, 2.0169258056436723, -3.2941078033859754, -1.9267742440274014, -1.6546519941037976, -3.324468962449097, 2.316491168412526, 3.845606924477842, -3.264694563911526, -1.600388648321931, -1.5886025113342988, -2.4718211684444307, 2.954959914329613, 3.5623204453308377, 2.9466821804611385, -3.7315851027994946, 3.683985239339637, 2.82444260341594, -3.099489239870415, 0.6598023408535129},
    {-3.9439814628511716, -0.013884798503090283, -3.658531798770229, -1.9297986768353357, 2.5527391074520662, 2.8151121886494277, 3.3491971874435267, 4.075613249476057, 3.473000753874367, -1.5665614128206442, 3.4310166073589654, -3.120771774790215, 3.697215632312411, 2.093607763404391, -2.9127097697714697, -1.991603354412283, -1.7489670925224, -3.609012844839054, 2.374667577306734, 3.9128075215306337, -3.4966901281428395, -1.2400561090886881, -1.5430453500823658, -1.9789930630293258, 3.246945852841575, 3.5962674109781116, 3.3260572555179326, -3.780187584058115, 3.3217298458978117, 3.408881114460991, -3.0556566306010713, 0.624602219853456},
    {-4.035448708995098, 0.2808509663978756, -3.510527356925414, -1.7893237813304084, 2.619257384140492, 2.7461335206331836, 3.239409665622679, 4.063803519492279, 3.7605476691975372, -1.5659647406675592, 3.451393728348213, -3.416072840790867, 3.7273410432881224, 2.3760067454497023, -2.98677633521334, -2.04729593726984, -1.784506841470849, -3.8542756924152317, 2.186631282315576, 3.8241052946718614, -3.391834881766015, -1.581416117238265, -1.947721780239017, -2.4837963132129626, 3.1827390060027207, 3.8515505614323504, 2.9482669341785264, -3.5101681601661445, 3.4842494865194342, 3.316670884409308, -2.913818175710448, 0.519902293931453},
    {0.5746306301950891, -2.8043869243254305, -0.5822499555112447, -2.3139842472587553, 0.8345657450572572, -1.8583091976516635, -1.710231022071151, -0.9213518842967249, -1.9251092343555725, -0.36713656673282774, -1.092921880085607, -1.171248428827144, -1.4781990558493219, -1.4768115946611662, 1.4336976790998508, -2.1124432245257103, -2.7254064390303427, -0.41970043304584603, 2.3596611320232124, -0.1287607743256018, 0.05843537419521563, 1.925918427922195, -2.1465948607001746, 0.7806293221375917, -1.0444961086877802, -1.304616618277783, -0.5063316896618555, -0.8494204762926575, -1.5879796153609373, -0.8410105624483271, -0.8997500362188565, 0.6699330176818071},
    {0.34551098819341997, -1.2584736853769452, -0.7334592048038822, -1.3067942262936523, 1.516293615051992, -0.47098269899999157, -0.4916655483843785, 0.9100571424432883, 0.8479615658416031, 0.34654422886524755, 0.632386348542177, -0.4916571032714709, 0.6460911552428733, -0.5250100204010673, 0.9666810031699382, -0.8537462110234332, -0.5587802619837401, -0.5165675604794959, 1.486825039534971, 1.1627593940289471, 0.794245146087089, 1.4038819878484539, -0.8121012887727233, 0.6620882638543472, 0.45633368831542614, 0.04608621929318973, 1.0588883753712472, -0.40771023236777415, -0.3907465518269129, 0.6343879827308674, -0.9577020125669846, 2.121660622529994},
    {-0.08477856243267556, -3.0374969096416047, -1.7930084028452902, -2.5057565959410395, -0.4230823421808625, -2.3361828610357667, -2.370898477361469, 0.161869622406175, -1.646579864893742, -1.7536868202051856, -1.8933170690411463, -1.6384403585637184, 0.08913934175101289, -2.4994164639035787, -0.0278877457259352, -2.0004284329579183, -2.2194472945838366, -1.7908361288879984, 2.1725325341916664, -0.43710225874922337, 0.9278516861987971, -0.11724275711563492, -2.59083416276655, -1.5539815206754017, -1.9094119049451548, -1.6567459537288147, -1.7371339058661044, -1.1448881819180827, -0.8614111421620424, -1.6693430028078284, -1.7505890819033947, -0.5541156170361051},
    {-0.6130854019881747, -2.598936468032628, -2.248214422321213, -2.018528217859139, -1.0645621768283944, -1.8951495859759437, -2.1019503661762817, -0.15387407747082937, -1.8013106098168656, -1.097823797813091, -1.9000058289700532, -1.9278594140143148, 0.2739312340070629, -1.8184302096379272, -0.1712935088465238, -1.9162480055275273, -2.1784142700049225, -1.555107706435469, 1.2638355300499835, -1.1554240375442792, 0.19794464510177293, -0.2960530713850277, -2.528391663454575, -1.3984638601461938, -1.2956624683014246, -1.827270580061049, -1.5015359755400943, -1.713388942875816, -1.7813642635195983, -1.7611058167867781, -1.9669300583966285, -0.9720599375346216},
    {-1.8634041523518676, -2.6421200785591195, -2.1969739219856117, -2.6562238204241964, -1.4206365921754647, -2.5282695531968518, -2.1125411249361137, 0.7391309405540335, -1.924968130585568, -2.363106724847671, -1.9614155364394648, -1.154209320189493, 0.997868357049134, -2.2621342156885467, -1.7572828799216964, -1.1607283520592333, -1.3227408288589668, -2.8055012490730884, 0.02710623387491225, -1.2971229682671146, 0.08248121546084004, -1.1047281725653584, -2.018116337168316, -2.3068185781327926, -2.42876338270032, -2.345378402817865, -2.0207759146143784, -1.7690863043481364, -1.0530189733280562, -1.9001771798037062, -2.958016114547665, -1.6424589344272396},
    {-1.157732761962118, -1.6120751476055861, -1.0195820587269646, -1.2497496843432474, -1.2318111051529483, -1.9229100137583417, -1.5856831250893417, 0.569742495415748, -1.297176977767161, -2.256827478885038, -2.0686878732595337, -1.1816752167437397, 1.2918197903059352, -1.7630514441619414, -1.440886430918832, -0.6028281493513288, -0.4905960367288999, -2.0889021616290644, -0.2870569124033532, -1.543879623875393, 0.08293746461741425, -0.5066001220413111, -1.1831573785795222, -1.9472708243063008, -1.688773911530491, -1.6971839913828488, -1.6257375401235952, -1.0163178462455025, -1.0979643461280948, -1.4367675343305952, -2.1585261613735707, -1.2536390126683463},
    {-1.8904930662559618, -2.2614116514359432, -1.1185262090068733, -2.3855773638922324, -1.7505241628948198, -2.694147751326396, -2.2201288430588013, -0.2635926904964072, -1.8665638478279996, -2.2414489867081406, -2.4545627683624676, -0.718887781957273, -0.028192808330033483, -2.206762535344515, -1.2096528406001055, -0.7086479394897603, -0.8311284488460915, -2.3368378516165986, 0.05854650589383406, -1.9081864217103197, -0.5545394587403086, -1.3049058665496567, -2.039210694591712, -1.724827256081174, -2.452803522157454, -2.4548496606738874, -2.1581151407033983, -0.9545501225447824, -1.4822151341121645, -1.9056448848061944, -2.2232425519631396, -1.5690525104497135},
    {-1.3144978134558698, -2.0702192600218954, -0.7756800925830066, -1.9965397624419545, -1.3404338077520948, -1.5195226442376824, -1.1332926323213903, -0.27268118919680023, -1.8890094373684578, -1.3951467928205574, -1.8416875742982937, -0.5576595324654564, -0.09646315279356658, -1.775445512281079, -0.6111249866731336, -0.3325295275166831, -0.3809954100913859, -1.9256457420961601, 0.14814209257973748, -1.2786026546266467, 0.20793852092851653, -1.1905887351871944, -1.663767781557612, -1.5283881834636064, -1.6799645979501923, -1.0450153930347674, -1.595126335913157, -0.6243408458993756, -1.0979678084745332, -1.8449867216712468, -2.1502498816239433, -1.2979391410872525},
    {-2.334145523978822, -2.1936579131745586, -1.5921867839431239, -2.550281579476242, -1.5681934191698295, -1.5964259874098279, -1.7242247356496916, 0.4246310891885222, -1.8782838336292578, -1.472749230267609, -1.8978023565028241, -1.4649937710964982, 0.6827143662886196, -2.094118485716431, -1.4772038468120439, -1.3758119937893778, -1.0990407409586325, -2.2765379018200873, 0.5861102371867265, -1.1689598134622983, -0.3824379485213539, -1.3047407656010928, -2.283262710927665, -2.0034733447212685, -1.766570201676937, -1.5372682541180966, -1.514599610087645, -1.3594285548241505, -1.5211454920186642, -1.6067515167919522, -2.920002407960536, -1.3272123911196156},
    {-1.6610182547873182, -2.8929473743177505, -0.9416833959165306, -2.8543193765911146, -1.8188428729731623, -2.363671717464362, -2.1992637390096568, 0.4807240479351011, -2.13731813098962, -2.300000407545085, -2.406097552392447, -1.0069835068390418, 0.6190743428529767, -2.490167411484623, -0.77520191220742, -1.5967978294996266, -1.2541018213162798, -2.215904381846186, 0.9855577488449156, -1.5241781556384701, 1.2052526716873975, -0.4110835959113705, -2.534224567967472, -1.7633765654814908, -1.9648320452136911, -2.3003596623905427, -2.2532278676372455, -1.1508146620278112, -1.2479405664222207, -2.100401457933431, -2.391592517435767, -1.51205995561861},
    {-0.9378016548943485, -2.005562367265808, -1.9605049723105228, -2.2762234538436954, -1.3269714769232233, -2.3469909301294227, -1.8504051184946901, -0.6819121441198946, -2.1664854465615213, -1.9843442635710087, -2.0685325104669774, -2.012149692490175, -0.21385045469680553, -2.515023453397349, -0.2886178632322192, -1.9740986741468636, -2.296490595815775, -1.9378263797284938, 1.3215231596393784, -1.0864167653748455, -0.5981738734254318, -0.33266478003565475, -2.5108588384056425, -1.3116216403930439, -1.3628165292862033, -1.8182077031619892, -2.302004469946767, -1.8996248082691378, -2.307547191069057, -1.5877535825633458, -2.0624822018991282, -0.7825562437945397},
    {-1.6058467616096024, -2.6063278822976237, -1.9054796442096638, -2.822008354652084, -1.4416411448270758, -2.6036046072866132, -2.545458756549375, -0.49971904943958556, -2.3039828765455583, -2.9220475379768414, -2.542213955089506, -1.4418322518680535, 0.4102001108574389, -2.386329753813272, -1.1143988511397747, -1.7564547594512754, -1.7596637754850968, -2.292087821664872, 1.735878952823657, -1.8242466496506404, -0.1497682343532311, -0.8163826420233317, -2.34103605693559, -1.953598196523026, -1.864329065851736, -2.552394437641064, -2.4179523341274693, -2.3498294695582773, -1.7366932543126543, -2.2815075735494097, -2.6931392890279104, -1.5784128238888027},
    {-2.0430962406476376, -2.9103595813212615, -1.647020602575148, -2.9251511327517012, -1.970412004369546, -2.8733541985874704, -2.857190889485948, -1.0046110519851517, -2.505119193462436, -2.7818207796833603, -2.653624997145737, -1.2542221333182526, -0.3262308962012662, -2.7521835432168498, -1.433775172883468, -1.483238863977031, -1.6681676291316785, -2.2472356543147662, 0.8274696533074833, -2.0154210756693076, -0.27564615202388415, -0.8624028019516434, -2.2768502293853583, -1.9053668814818259, -2.282254663925546, -2.5091299714957636, -2.2238520274368527, -1.2743200903418597, -1.9301827322146499, -2.319976513776427, -2.7794483237225953, -1.57145416547369},
    {-2.2078508109818697, -2.5301873483594517, -1.6150353373973443, -2.4459072859325985, -1.2613295565284075, -1.992177590024563, -2.212857415398479, -0.34956013216596293, -2.2616062004372313, -2.560865304179031, -2.228357080689024, -1.2590665420581713, 0.2385097713106113, -2.328855240799231, -1.1466391252339942, -1.851217132125796, -1.5198481954984995, -2.2300908640293757, 0.8978029217127805, -1.1996448631662429, -0.4586801970409437, -0.14835937244869812, -2.5542856477697713, -1.8728266038648662, -1.7243891724079787, -2.1291047642711067, -1.7141374787308759, -1.705238576479292, -1.7679560185903411, -1.916580538799461, -2.8650115309673283, -0.740834516265751},
    {-1.5523831241004655, -3.244593794069367, -1.8635700717428993, -3.0708134809905165, -0.7845049094453173, -2.682102363723499, -2.7533310147594166, 0.08380594073494968, -1.972352216847736, -2.3350025883695054, -2.518452790087032, -1.961285504725643, 0.80976318545153, -2.805558351688347, -1.0056932948493036, -2.2048706130032847, -2.011982465889248, -2.2667668231389886, 2.3335511997746785, -0.5729040280037055, 0.5687331816719544, 0.30480328008541274, -3.2481666098235453, -1.4635526538835082, -1.9559154990415095, -2.2363416427317473, -2.2079579908805873, -1.711757931502867, -0.94123372502584, -1.871409540104264, -2.7733312496836326, -0.16878276105334614},
    {-1.9082326075295395, -3.2520111743988314, -2.434075218293571, -3.315621833212828, -1.0725601460066803, -2.573664850093639, -2.0268958158618458, 0.5203154046751634, -1.2534058815417264, -2.113082952762497, -1.8462642280815271, -2.461298592981195, 0.48353297441768245, -2.442777402154799, -1.5527544796596038, -2.232918868621106, -2.3466088749150957, -2.638240203256178, 1.7119997612381228, -0.9534982900573336, 0.08143901309728889, -0.4387454166819487, -3.323919226400489, -1.9559228153092008, -1.7579876031761492, -1.929527417779813, -1.2627474432167574, -2.4701628647315985, -1.1076422480748533, -1.5406770006346187, -2.898191216505175, -0.7126707374361603},
    {-1.6917523600988913, -3.6237089387018453, -1.9725495890287321, -3.5053730145131086, -1.2195592447223698, -2.502139904546069, -2.150965961879841, 0.11136543147639247, -1.737212718040236, -1.5762921940114158, -2.016310233290117, -2.253732779690224, 0.5192834083817972, -2.6885716305020555, -1.082236720277805, -2.424466205302469, -2.1810033302077203, -2.5966069986743223, 1.6197845277047216, -0.5704457919768643, 0.49390168640834486, -0.4941155071127629, -3.109678385288149, -1.8050524597773123, -1.6782448348133692, -1.3824348224015095, -1.3592452899880691, -2.2515642269116336, -1.1555528315948003, -1.6765198843344438, -2.8592619806891597, 0.2392283565058744},
    {-1.3073251866487805, -4.027197668778243, -2.0190084691329395, -3.662379717310885, -0.3287293329726411, -1.9546063456498566, -1.6172704571633283, 1.2652606759309324, -1.0311854562154268, -1.4157415174978376, -1.3289157663794606, -1.9555938694771968, 1.1139338669545553, -2.272031608202903, -0.6411027745358903, -2.4156178795172583, -1.9977106963101865, -2.848602036892268, 2.0289744343549816, 0.14856931602442275, 1.2810196588659386, 0.11474856400072983, -3.4197199094944577, -1.751041537902351, -1.1160468260904508, -1.401438784165353, -1.168712821430723, -2.0547713922370057, -0.031125055732468872, -1.160391833307136, -3.137839834370322, 0.7872248866307344},
    {-0.8332355188620183, -3.8347718323383075, -2.1642088155661208, -3.2764915092136127, 0.16958219488561674, -2.3287772603857615, -1.9311393200310831, 0.7986614579304382, -1.5465205756843476, -1.4349611458217755, -1.6135729199243833, -2.0330352745302593, 0.9723907588825389, -2.6146304813471053, -0.5121577364762422, -2.6570750047592893, -2.2756147349051683, -2.468129012145451, 2.532099842574261, 0.02488206504347779, 1.009672918166636, 0.644014688664268, -3.5230426373999686, -1.2404861735569688, -1.3564653394206099, -1.532445964605925, -1.2264477323377143, -2.1519399997076443, -1.0912578453604558, -1.4413050685975037, -2.8761606961223856, 1.1358270354924922},
    {-2.05345427522753, -3.908999349137759, -2.7886651645483744, -3.4617174304076936, -0.9973789148931014, -3.141931992724888, -2.8380912473136486, 0.1317068276868672, -2.3967600133659803, -2.9687927638499834, -2.732316505126304, -2.6404795749134475, 0.47024748651748555, -3.4059732230851307, -1.0183549580152333, -2.829647859465037, -2.853693158608732, -3.003531410799283, 1.8393094175651847, -0.9062633637030186, 0.13715575205437439, -0.20864879087265567, -3.6905928279415, -2.461833435739175, -2.655224417589024, -2.5155502113051185, -2.116872822575615, -2.5883055364184337, -1.9964151392257405, -2.260005679574925, -3.427856640306197, -0.874805719988085},
    {-1.923436239805924, -4.147315897149748, -2.75079978620877, -4.164058494646892, -1.6338983347215248, -3.084532618640935, -3.2248642602487165, -0.09444334811169369, -2.6208938629460574, -3.217756926251054, -2.8444729003879186, -2.5528323235522468, 0.24257219125359758, -3.6247145556422833, -1.4171641646083715, -3.0982504506631217, -3.2076010603085967, -3.4208213031313575, 1.8454804600445835, -1.202330453407252, 0.36065658233115244, 0.255009885679583, -3.920426407376445, -2.1920790096652394, -2.4976526447885914, -2.446825950670237, -2.2976264082409994, -2.5206939883991986, -1.7624109462953077, -2.2141298784319576, -3.7911590088953124, -0.5043927657906484},
    {-2.167502298801014, -5.007770001640075, -3.552029616876409, -4.850554201425327, 0.4233850353091895, -2.5088373567758744, -2.2664590752516656, 1.5605587716860885, -1.5020407262505968, -1.806039624210818, -1.851083343483606, -3.1861276781410943, 1.768461031078803, -3.3493884473243294, -1.106434880756988, -4.112493472366666, -3.817524883951033, -3.539308060887024, 3.7496433664240065, 1.0152273738052748, 0.7352256903745705, 1.2746996443505454, -4.8839859164895, -1.9386088468188747, -1.2322295517426418, -1.22837026765897, -1.133379440476768, -2.9636380174441412, -0.7813602126258816, -1.6535035393360327, -4.176670891390691, 0.9182079969417041},
    {-0.5105602045936355, -5.227615752166248, -2.8825754642480135, -4.911484948053314, 1.7731781531900321, -2.0081566540180655, -1.8157672323722693, 2.1305116365255388, -0.6286584243096538, -0.10817966135536243, -1.1481194998907838, -3.030422957799908, 2.239509713343906, -2.772220417418297, 0.7317754517076164, -4.409290958689599, -4.5621117585829065, -2.146793789337471, 4.668558166067187, 1.9021492771379835, 1.7956842802083657, 2.8028712882068483, -5.19398172067395, 0.09440345205742848, -0.2930573514900294, -0.8277002271046764, -0.00022354543066080678, -2.345119146875051, -0.5631686445958147, -0.3989938986015618, -3.5757224982871714, 2.6194926130344505},
    {-1.1511187256373256, -5.048901321511678, -3.259721900832679, -4.687359085170911, 0.9985141247441502, -2.3768748023073547, -2.573634001226376, 0.9496149716868152, -1.6366848593997236, -1.1602921795833772, -1.9358985573623828, -3.081910217201963, 1.1250907287741874, -3.458056326771144, 0.13024232315896614, -4.557080252689786, -4.343522606756047, -2.870893032218467, 3.969958889634295, 0.4191381162954069, 1.1291331724828335, 2.0804310409268054, -4.9415024007233574, -0.8145080716051506, -1.5296321221428852, -1.651455703133821, -0.9019779119226714, -2.9916624918536603, -1.3658810768368654, -1.5075307617321296, -3.9861424342656653, 2.009259303010884},
    {-2.490024767020798, -4.806217897920842, -3.344499937018816, -4.596730277696674, -0.5634748300481484, -3.4850346076872203, -2.9766398664771003, 0.6274174283669898, -2.2719337194033202, -2.737694653272195, -3.119326659455854, -3.2061094936129635, 0.7790576010753787, -3.6298504661284134, -1.5291033601601913, -3.777158386057361, -3.815451203475941, -3.4865216756890947, 2.9001634857716256, -0.9315918475749039, 0.33061610015221604, 0.3137568257520897, -4.7886042078012645, -2.616579094798533, -2.2102718174254945, -2.627746029326264, -2.149141979408033, -3.466209910233974, -2.063021306157034, -2.4563260303924777, -3.9194912547934893, 0.11818719701144788},
    {-0.8641140395422259, -5.141397909961463, -3.3000927130329885, -4.721980191320909, 1.2745015196382614, -2.3705691825172237, -2.185561315332201, 1.8534972206000309, -0.9905276138843367, -1.1157907648087588, -1.4893447557219244, -3.0845845258994835, 1.7890507492340848, -2.723082169578145, 0.2583335230145615, -4.453057430218982, -4.43428168437113, -3.084349801218493, 4.4087924453430345, 1.212396758562385, 1.1748159539940224, 2.2303327641860387, -4.989674832989934, -0.2904454418696842, -0.6214868148628081, -1.1482816899154635, -0.19710663006644522, -3.327165134263781, -0.7523083785846773, -0.8869641521291814, -3.6257994584959254, 2.3847320082451438},
    {-0.6640448821578384, -5.279700585944009, -2.733350066216207, -4.386005783497364, 1.1610892885122355, -2.914947052234408, -2.926181903074914, 0.9724686913210749, -1.754056186584406, -1.30541447460466, -2.35088998146822, -2.657426352197946, 0.9030517911154617, -3.185695774953895, 0.26826602991971277, -4.464244672485395, -4.386415225839694, -2.646034293506124, 4.069952557372383, 0.4004523575274421, 1.459730041628184, 2.3299897742359197, -4.842434316547052, -0.7667440196774477, -1.2851747275911087, -2.032669829656633, -1.041647157624482, -2.7494696764098525, -1.0921927047457782, -1.5248482768278144, -3.525879826309533, 2.02880121030507},
    {-1.1421253983438335, -5.243669739368551, -2.9040956990495155, -4.475846830631285, 1.2100914806692062, -2.938215379995381, -2.7476412578515865, 1.234873395709722, -1.8448244125918234, -1.7602445830362188, -2.376994471427669, -2.9884476465314394, 1.1465909371495828, -3.068315620583863, -0.12094306553976865, -4.454643708092763, -4.448028767772031, -3.0623463967219364, 3.8538982426646036, 0.3318598031185161, 1.5755532148797688, 1.8596691020623453, -5.093185149449339, -1.191635664691117, -1.3432404359070202, -1.9594400632290512, -1.3236229124132746, -2.9339131373089558, -1.3547942372788644, -1.6631883503076184, -3.5762751051237407, 1.7259815042038402},
    {-1.539399193476435, -5.449221213326826, -3.37431186112336, -5.431867218440095, 1.0413547158192102, -3.10997288048524, -2.6952798049756876, 0.956058713111885, -1.7110545690227263, -1.217321140569706, -1.8137760852210167, -3.5783995839919416, 1.1448674881152283, -3.156979027653351, -0.30398437643163384, -4.517625353439642, -4.317163041595374, -3.0383820309554808, 3.989272488823381, 0.7493888572089171, 1.4094546473980922, 1.9658416770253315, -5.0834161678952405, -1.1617651570546201, -1.0920617441594433, -1.7970339301758063, -0.8670495117189614, -3.36489286666259, -1.4929906306355656, -1.580559248593644, -3.9519531987526793, 1.8635852230397962},
    {-1.1681832764029276, -5.449302605114634, -3.198882554940517, -5.390935279862141, 1.0330453437282772, -2.868355654420704, -2.7951197391479177, 1.2361576976991162, -1.5570961046515281, -1.203381455453603, -2.102860438280647, -3.4873261222479837, 1.273639389199518, -3.1130371710711833, -0.014113607537113809, -4.5124953878245355, -4.277346368073798, -3.1427400154207326, 4.437252177769328, 1.0273876826848598, 1.5571174025474213, 2.3438661460308023, -5.47158707363089, -0.9436522939098791, -0.8988263111108755, -1.4007417510031328, -0.6996074232987448, -3.0900897791991486, -1.5824311054560256, -1.5240577207863217, -3.7992267642539757, 1.744125927468373}
};

static const float b1[32] = {6.522703501530527, 6.45782807798102, 6.7146462145075, 6.388534851670737, 6.158527509815145, 6.342529687414139, 6.297306036813315, 6.506588189896977, 6.25265934952576, 6.443943918477186, 6.284234240207502, 6.431498496408843, 6.64462257487372, 6.357992410194054, 6.4879989167466725, 6.513974488427767, 6.35215927421822, 6.472117896849214, 6.6219337258005755, 6.402689535227327, 6.68590561121403, 6.470494071207558, 6.522863398301666, 6.389924148224648, 6.353233684599382, 6.398700420769721, 6.378442516971227, 6.55864542060437, 6.6190937278321735, 5.9584353466298445, 6.492366119000053, 6.431469477876983};

static const float w2[32][16] = {
    {5.762523271773452, 6.114640277702424, 5.866308755329866, 5.205486530318503, 6.542174435583882, 5.61948564293833, 5.599469720381964, 5.896475936457004, 5.877680303031276, 5.878377652234901, 5.563329944978411, -0.008801450840176238, 4.835908826279537, 5.612222049087723, 5.369562207095305, 5.575898484836462},
    {5.833125198119219, 6.000821176164603, 5.773438916271852, 5.756612541760374, 5.91785276740068, 5.881229364550796, 6.0246224280014635, 6.068831564927428, 5.936432239396623, 6.362104511812022, 5.6032262520711456, -0.05810558658982974, 4.994628091739064, 5.696784695412108, 6.626633643849445, 5.690563523634327},
    {5.44778499666881, 5.728132806323529, 5.63681355613953, 5.815445267030298, 5.907919024185134, 6.080016538102062, 5.653144340650941, 5.568951714749006, 5.4140506136410105, 5.659002618433576, 5.495022008439551, -0.3539067562201873, 4.472148868306533, 5.58381642310321, 5.8841627163813195, 5.913811213043923},
    {5.708989321668946, 5.863677293888936, 6.252603017412141, 5.837758622028129, 5.912688962040021, 6.442601095825477, 5.70575889358878, 5.967707830470355, 5.9842955933459665, 5.821151755492651, 5.803647657860228, 0.11054364499952171, 4.8911955028521605, 6.334031772160364, 5.995323719203064, 5.716251608133764},
    {5.322500779084164, 5.323115165402468, 5.234356116562945, 5.010892476837072, 5.1958433545555, 5.366236327366233, 5.467672729200648, 5.046693484092475, 5.379652067673803, 5.298243112025477, 5.541749477619997, -0.26992434751069605, 4.480408544968444, 4.996003497484763, 5.3314236614605175, 5.4725592260227085},
    {5.155809600241589, 5.4631990392227925, 5.778999624929634, 4.729413430738841, 6.005141795682934, 5.566182988028503, 4.4346691158163765, 5.31704058149555, 5.450551429618718, 5.566386308069449, 5.425751363090813, -0.13291812886273652, 4.600930097748105, 5.004742192019277, 5.244896250242705, 5.354443023427229},
    {4.885140956028205, 5.392901395242796, 5.530558149955326, 5.180220273909949, 5.792133122557612, 5.788107150726194, 5.110709849182573, 5.466346067766224, 5.8762205519895625, 5.593728662117686, 5.749218743051373, -0.10196071537406905, 4.227660833584871, 5.298827836732, 5.292142605825385, 4.726996889816233},
    {5.637499760734686, 6.079923629954222, 5.574785465260731, 5.321721791199384, 5.952446778689894, 5.746178626869512, 5.5252885050889535, 5.896207788338204, 5.612325948448985, 5.424284657206748, 5.780296633871993, -0.1689721195448092, 4.919458302464237, 5.548920940209415, 6.0072452141762875, 5.8640981519990065},
    {5.26976982994544, 5.597999861040055, 5.734264916524928, 5.103939497880907, 5.333575071219729, 5.690775161055232, 5.55381169588168, 5.571637930511387, 5.585727912211824, 5.602157140227184, 5.653762394249121, -0.4715587498693307, 4.851829356501786, 5.553858376385298, 5.313194400532566, 5.507573578088512},
    {5.356163893836586, 5.401191630615188, 5.5655155621611385, 5.318977381797766, 5.697536857591553, 5.310801349076743, 5.184672439635701, 5.345902135964199, 5.302770082797109, 5.645881742434341, 4.928802091255685, -0.04064008284810725, 4.625188583370015, 5.293506367797288, 5.20917805421293, 5.588998339123108},
    {4.83029359313143, 5.818345386901974, 5.174042510059404, 4.870872385881848, 5.028077316521804, 5.739343047883492, 4.6652445255280695, 5.625655686676407, 5.748252877488947, 5.559298158857611, 5.692285164514751, -0.061506197184237686, 4.686299250559737, 5.190407893089542, 5.5643752260885275, 5.1872077307689715},
    {5.936758783491513, 5.939258318472508, 6.147091523219756, 5.485135160371387, 6.153341078708288, 6.1013649965241, 6.018883874721498, 5.6988368372795914, 5.752944685956828, 5.885588874216992, 5.246740004857115, 0.16239830192068025, 4.735521198691033, 5.501524730300172, 5.939414004280657, 5.237740663054552},
    {5.263110274358692, 6.288967908628858, 5.5917835406434495, 5.584069315854645, 5.148774531967357, 5.511299645192668, 5.034592538704748, 5.691513633652674, 5.404364257963751, 6.352972646139867, 5.218304511083778, -0.046585971071151894, 4.580772747406957, 5.74864044972592, 6.04872291699348, 5.5180158513566155},
    {5.665451567272469, 5.758031351468379, 5.570268266634817, 5.086755281287845, 5.77746562558581, 5.5050979977301235, 5.261961402019534, 5.529257066650014, 5.245702458782632, 5.817311998100761, 5.542771876176163, 0.1931827271435135, 4.358796888256203, 4.78911042040666, 5.196957833453912, 5.418644807234267},
    {5.141634899606238, 5.538520771574616, 5.689264612786744, 5.229134140263641, 5.313893327795342, 5.692342181125744, 5.501129356914971, 5.233285004333043, 5.714664403341145, 6.034514144728069, 5.709999228981384, -0.3075191849471331, 4.557863967653513, 5.281035328119914, 5.524942151338588, 5.336948305463881},
    {5.299635264603483, 5.840515648990826, 5.513007822418207, 5.2564290268805145, 5.979838527980624, 5.718132076007164, 5.553020735665207, 5.74818104143097, 5.784594903679337, 5.781199619808203, 5.632891129754835, -0.14481574836912245, 4.743610546412058, 5.465501327207338, 5.884778197173416, 5.968109712282049},
    {5.759666376667121, 5.585234996500535, 5.667250312983434, 5.571159174138233, 6.0376304089911, 6.115644698265617, 5.628950057246155, 5.597018572644478, 5.887826617144912, 5.707061891750162, 5.387523677105416, -0.15033440209960566, 4.5127733982431515, 5.777770885789483, 5.475033405244845, 5.410028769064845},
    {5.532537443692314, 5.9779306115124236, 5.65997014494727, 5.127955652688757, 6.304948231096154, 5.71263358459843, 5.344161401833293, 5.4172244801517815, 5.836163367978294, 5.596159226366281, 5.4540595610785125, -0.2809534114450678, 4.945335185252666, 5.750442072577417, 5.967105098888999, 5.9534990960400025},
    {5.413702638074462, 5.960696167457906, 5.301609257320686, 5.799006844971081, 5.949501954826299, 6.154811765970191, 5.319780027481996, 5.914097707302715, 5.6929932848417995, 5.207966447166136, 5.664121989407932, -0.20505530564734975, 4.9551392981023765, 5.195476508479055, 5.670285685998197, 6.290614482107971},
    {5.876351482722947, 5.618395963696241, 5.360352541487095, 5.131094989016414, 5.229294570440949, 5.4324544972302995, 4.836308304310598, 5.343868812524248, 5.2878808669273445, 5.97816531977829, 5.442730781950337, 0.04625472609468967, 4.361698569423915, 5.1574285920379275, 5.186970821410627, 5.715514047090834},
    {5.921614878671644, 5.671068114112469, 5.536242281402005, 5.376870533057893, 5.926609174849035, 5.448708774005171, 5.5383854501995815, 5.1445615969000595, 5.313018884829779, 5.273252245012558, 5.130430023403751, -0.13097884008356142, 4.7964412859936285, 5.78684137164646, 5.427372388472862, 5.543964097905781},
    {5.517183008854968, 5.552501451699016, 5.6119791234279335, 5.483877814143128, 5.814953872254358, 5.355549236878106, 5.1297041259953104, 5.521708110264091, 6.059505890450118, 5.267713063327402, 5.493930668445238, 0.05377711621143896, 4.903527233272475, 5.170012073539828, 5.192306568976876, 5.928617934849726},
    {5.5779391190413845, 5.904522344187615, 5.771537368045008, 5.056800135973873, 6.19963692601674, 5.950323857011161, 5.610317543724897, 6.057957158057063, 5.4495754560828, 5.563620763003685, 6.007491373198727, 0.006901241059130674, 4.993131826900793, 5.5324818034137895, 6.314169982825742, 6.008221419960095},
    {5.265983474670904, 5.534256548906023, 5.950453461778536, 5.068785836413917, 5.854465181626241, 6.260435266441245, 5.0036002124209356, 5.491981247482031, 5.528500346609688, 6.062578585001488, 5.50026332520117, -0.1509380799874817, 5.0065304899136684, 5.04694616498237, 5.4797627044187305, 5.211045540035531},
    {5.441914251021482, 5.537428416929566, 5.14438672364161, 5.3887841445915825, 5.124081030780607, 5.313514696253793, 5.280599879747489, 5.346163784793033, 5.449787664355694, 5.37971296217193, 5.036338198183085, 0.006837780958743256, 4.082678286898284, 5.289074259671569, 5.650561799739049, 5.848158094054878},
    {4.871929310147305, 5.336854038266705, 5.680051693102177, 5.05300814418584, 5.739872108059369, 5.88228204938368, 5.3862491707130316, 4.7445657132580275, 5.788124041495465, 5.389247155338974, 4.888389926280583, -0.08033067173447227, 4.56030860686802, 5.124357229275103, 4.811608631204541, 5.921359062078161},
    {4.847521941929941, 5.421201164509584, 5.32624503088398, 4.51389979890361, 5.104778242130238, 5.110748628780594, 4.835313185077286, 5.063020527942566, 5.552515342436841, 5.148484341191709, 5.475272980460037, -0.13588984872128862, 3.8483010279803196, 5.12490940937392, 5.005130349103023, 5.355703957218696},
    {5.807144912646328, 6.0439337244977915, 5.717272106660042, 5.605726932770209, 5.814496602011501, 6.184764138350767, 5.621477779284214, 5.6440557564526115, 5.916174551578898, 6.192980441570381, 5.6692162582992935, 0.12158231126976896, 4.517232374160686, 5.777086002218772, 6.239932896525858, 6.2554105480997695},
    {5.96212999647334, 6.174151773907475, 5.6807108868429035, 5.306372675917579, 5.573010193393962, 5.7752529887207995, 5.783649133035513, 5.711163818549345, 5.48972503007769, 5.649453825564443, 5.428267078771817, -0.06350073030018547, 4.932255515309803, 5.731167650830904, 5.700056302624872, 6.112063042621385},
    {5.194476637854035, 5.306930707594238, 5.138323879449658, 5.023313107027186, 5.457182987313708, 5.52359059891016, 5.186525688687324, 5.19807863042136, 5.274771226159317, 5.219727839250253, 5.243703021677141, -0.07353334564551736, 4.780506714718551, 4.986798052992411, 5.098858813880644, 5.1006094958250205},
    {5.736372263920881, 6.176057326659676, 5.900437290375114, 5.6291762924474895, 5.93617390540742, 5.421784091549241, 5.026567105956584, 5.844082008878084, 6.208143431421362, 5.873746391240621, 5.402103648743662, 0.14671222872685094, 4.847638022881343, 5.32953057142599, 6.052282146427227, 6.238517286106465},
    {5.45956127701036, 5.316906582142929, 5.659539785218603, 5.249823859620916, 5.624863841450324, 5.28680058969451, 5.135974992021565, 5.345043393301228, 5.479970615113733, 5.376716300956985, 5.23649762182182, 0.3602684670366598, 4.353582916831262, 5.504391224899696, 5.759871352687777, 5.635313174984252}
};

static const float b2[16] = {5.440274385717828, 5.57324854127067, 5.539573335599582, 5.714349556607145, 5.5523191735315764, 5.5823421573877035, 5.630515883099026, 5.471251263475388, 5.410065263483461, 5.334391089338522, 5.587039504302252, -0.050278470778083895, 5.386493507393994, 5.492098620739836, 5.62230897392314, 5.39739361547985};

static const float w3[16][12] = {
    {-3.8957934051499907, -3.6220844109745065, -4.758201912411693, -4.057486041799704, -3.4201262680896605, -4.161875283102591, -3.6217236384779294, -3.8045986888429395, -3.410010757916211, -3.599583917160401, -3.647822264831229, -3.971644818222833},
    {-3.850520849918897, -4.160354947542663, -4.350770429562994, -3.810714120378191, -3.759603872642954, -4.234936115915209, -3.522811173318555, -4.039774665734473, -3.7598285215812033, -3.9178161556222086, -4.041476473623157, -3.868501887909938},
    {-3.670616340445436, -3.4412286796306004, -3.8897090032945556, -3.767230332563536, -3.614201248318602, -3.2888156929594903, -3.9436805242155013, -4.204216668869451, -3.9958502052977227, -4.214472275945883, -4.209122072319172, -4.0596313692871115},
    {-3.7917838052583495, -4.446555061090427, -4.081423570608597, -3.9537255533010045, -4.121815262073011, -3.7103372259706067, -3.4976270150405364, -4.106510629012799, -3.657828671515078, -3.651147515776059, -3.9771077236981176, -3.0692606321371443},
    {-3.651312167269854, -3.727983770328592, -4.188369906163845, -3.574420158314148, -3.687463129134845, -3.8956508473238967, -4.152940386310259, -4.110219113122184, -3.756105663418292, -4.1295451968667, -4.138049641648601, -4.23079527987681},
    {-4.085843019663155, -3.587548387841208, -3.6969416726002318, -3.865844477452034, -3.4175881049591603, -4.320262073562732, -4.202955055066236, -3.9340150678358174, -3.809887127085171, -4.259396699736419, -3.9799056512383695, -3.956204587180618},
    {-3.741618166271476, -3.5459540320186305, -3.736495533651822, -3.846096016986037, -4.369148604669276, -4.527411715894521, -3.913317182395813, -3.2379150621157815, -3.6704824262967746, -3.5548297882788944, -3.6262910005061153, -3.6140601551513494},
    {-3.9989598640051853, -4.048133092395321, -3.52730465203165, -4.022620812774212, -3.9428602395489665, -2.9970597432972417, -3.7374687933629116, -3.6333128403715578, -3.637987912329038, -4.815346294549536, -3.7247787582177048, -3.9470965808979863},
    {-4.1278065724768105, -3.441197416007462, -4.011865247539143, -4.078851853667723, -3.5803027817888418, -3.670272868990184, -3.64339253665846, -3.9756959027806933, -4.247394303676299, -3.228973857744241, -3.4870814862918404, -4.140863522647529},
    {-3.3275459144533026, -4.441762448614156, -3.6530600162149294, -4.411075980303097, -3.3593173084900596, -3.626004852400477, -4.610285494536937, -4.158374094151172, -4.1263918334809375, -3.7095282421606943, -3.5968519419119938, -3.9157245131146388},
    {-4.000822413344697, -3.3689804869086464, -3.191539852260001, -3.525403109730525, -3.8508047251004265, -4.213819697656305, -3.879705965447677, -3.793566915425143, -4.728533580042734, -4.231438550022943, -3.8211270584207555, -4.13178930060242},
    {-0.37612193229203444, -0.17519983109539344, -0.2628409365127128, 0.23277111467987951, -0.19341318797005375, 0.1043484440283801, -0.5293586555414724, 0.4029065860137579, -0.18983854018286164, -0.26385983252426426, 0.5880848185921618, 0.20324795918933347},
    {-3.421919020047142, -3.54555762077617, -2.943700377234023, -3.4170377975173514, -2.91562559877003, -3.0873622343956137, -3.3982880264868154, -3.3330746033290386, -2.689542743118104, -3.323301572934297, -2.757685027020199, -3.444729311900407},
    {-4.083613343756321, -4.1668777490041675, -3.3127722997503075, -3.7128296100018074, -5.067639272540447, -3.948746986393926, -3.189607050967746, -4.220007313719159, -3.8561018303499814, -3.862335239398238, -4.656353831521473, -3.3625638562952376},
    {-4.4550863240610505, -3.8118212116833123, -4.400817905762708, -3.7498745982649693, -4.088323830797928, -4.804073846814513, -3.6806714575337662, -3.396066278213799, -4.282152966169048, -3.4181399911897516, -4.120891463612638, -3.6029584553238374},
    {-3.5591967688768267, -4.319397378918842, -3.7984331990008187, -3.890615996437555, -4.493195027226465, -3.18122629331269, -4.591297406649313, -3.6694463532530013, -3.9050091402890046, -3.679799825522242, -3.7615361273360213, -4.327062775297544}
};

static const float b3[12] = {-2.123072979662918, -2.359686168894657, -2.397875593693727, -1.5826822308683535, -2.01289698528846, -2.131266227314736, -2.9317679886611594, -2.367802593318673, -1.2478755480256576, -2.219563286914031, -1.5156953250243426, -1.7147173255607806};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
