#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.1124836245870833, -4.458726069534391, -0.5547240237228186, -5.109096243414383, -5.705040465071573, -4.958909498717033, -4.939771718249743, -0.5315594216703393, -0.42356962811721816, -2.2386734023236206, -3.1199865496883765, -5.307726263764541, -5.4331441439667385, -0.8058444787402371, 2.2894691685573436, 1.035252695518951, -4.496331585934236, -5.222041213145279, -5.134010029495669, -2.9273210207633267, -5.075547527250726, -5.416625914853715, -4.920883914258101, -2.1688752921844925, -5.937619771225851, -4.954077092939221, -0.7709425105166233, -4.940604807279194, -0.49826563691153125, -5.02558019175356, -5.385562780038037, -0.37886025140486845},
    {2.1373627064057805, 2.2826360979856424, -2.753651777620811, 1.0118269772640565, 2.0055694189249444, 2.5002685040482633, 2.9410468448000624, -0.7071801937119121, -1.9721114118867298, -2.0453586523796115, -0.9670399020438317, 2.848127972239479, 0.9134730522515947, -2.4112752306937724, 1.9110429988803075, -4.231651182528568, 2.9040235786100816, 2.8137900812276224, 5.759822481209726, 2.1303800911354647, 2.291748259440456, 2.260137356905355, 0.030664442393535205, -2.410114273056099, 3.147413006510339, 2.9016373303495886, 1.1290516702049955, 0.07384061947696023, -2.7930221825533383, 2.6126003213459765, 0.8137563682987446, 3.1462118674865036},
    {-2.2146470753860044, 3.850513150634382, -2.2940991760255955, 2.4782763448197564, 1.2651826486204094, 3.2089305883264827, 2.88350419636384, -3.2822546460619426, -2.720104413536616, 1.123199484333359, 0.41020410688968334, -0.24817749483701212, 3.6725949559886213, -1.7757413403227686, 0.7149714346690038, 1.7062534418946451, 3.938531836722305, 3.492675956616856, -2.6601965169672384, 3.056330783568269, 3.0137782887159945, 4.213631224029573, 0.9050988812772325, -1.5469017186327043, 2.25385236085944, 1.699843073139656, -0.5409515267027214, -1.7268738133124015, -0.3480330546121229, 2.6353904495251617, 3.6721336613350326, -2.681937164976368},
    {-0.11122048660673346, -0.026930865278364205, 0.9953945407308781, 3.725848995950286, 3.005599981706157, -0.8315322999701057, -2.333659517865047, 0.8188892732034171, 0.8745188528703401, 3.6627471312768263, 4.0481830522816225, 2.068443619206803, 3.903520832776356, 0.9694450757050215, -0.012742892907901288, 4.38583133918984, -1.6141953403015745, -0.9364232856221734, -5.398328295941067, -2.4741064387056357, -0.8798717544855467, 3.3520991793881123, 3.8287787626861274, 3.107845973526042, 1.3928328921406359, -2.7938949305343166, -1.744971482829065, 2.3777023465559695, 2.3770963623865007, -2.9025857528585597, 4.521010371285356, -1.3950232766426356},
    {-3.1449595351362962, 4.728722966655297, -3.034802938073138, 0.8765880817796302, 1.0074219863805969, 2.598935800551939, 3.4756126023700067, -2.019789861691084, -2.5988617403968486, -0.288310906425272, -1.252734200547087, -0.6727973388393158, 4.062847966982142, -2.376095490738933, -1.9512064678695158, 1.6232351284939002, 3.943455854639324, 3.9258238066756994, -1.3253936797320327, 2.821104735619805, 4.098122366689233, 4.079736324066899, 0.9426048037948174, -0.45704611884582313, 2.4822283090413952, 2.5678504510719415, -3.9312182901508277, -0.9348450254739633, -1.0665758847825266, 3.228526539891016, 2.7861417424429127, -3.1994448935766866},
    {-0.20726046111387272, 5.43473264166209, 1.1510631282199302, 3.9203380955383973, 2.5649098707261992, 5.159587567828869, 5.863313309674035, -0.4709979132978858, 0.6157587398170403, 3.7505554629339573, 3.463747035053799, 2.2093237104020584, 7.072427937324303, 3.3301644646510584, -4.446633318844108, 2.574160709854845, 5.719455828240038, 5.801913230199596, 1.5543847857678006, 5.1794440844101715, 6.274402697880777, 6.075715843874468, 3.3162669038630317, 3.0886965862236853, 4.226509989959338, 5.562542397895486, -1.2597873399387196, 2.910614881768221, 3.123464873526362, 5.689429398295383, 5.182269419398899, -1.9929104172733785},
    {0.26256500729017, 5.338850710768003, 2.552169802445399, 5.699074150239368, 5.039989264997104, 4.908239377762413, 5.394493646592158, 1.0202131513583719, 1.6452158920591795, 5.14987155395137, 5.47011841069741, 4.682937432171, 6.982790934354828, 4.824237290328216, -3.751487167294013, 4.210411932443371, 4.964925469513752, 5.5375970112642845, 0.24126108580762767, 4.177270570239285, 5.818320878253572, 6.792288291993225, 5.1558578390679095, 4.98061862293126, 5.334183723303911, 5.2332682296996, 0.36274837028959833, 4.662165013227585, 4.697934131304752, 5.075049114213876, 6.031070061358697, -1.3844388267472043},
    {-0.247440071386966, 2.937461228280787, -2.5710521680616063, -0.4365182071358233, 1.3252650276197173, 2.1795997663633497, 2.215713491202861, -0.205890153958107, -1.4367602447819137, -0.539275246868916, -0.6930388633277675, 1.655493522662541, 1.4248650896490478, -2.1297556387579335, 1.9135451994896788, 0.6570326817431229, 2.7507166080740912, 2.537409451887397, 2.5747924443256314, 2.1794640543334527, 2.5770064046554517, 2.955225019540068, 0.6164774868928109, -0.42569543858746717, 1.4388220336117286, 1.5053452738183701, -3.1875699657810097, -0.8960920696841598, -2.346616002538729, 2.063903166704477, 0.8764787321554535, -0.4438241678081798},
    {-1.4667107258240712, 1.8431003546225753, -3.1086008955229274, -1.2115235089086274, -0.46677846710102744, 0.9028284612935604, 1.3603986719799184, -1.8942779062285786, -2.700349533746297, -2.448393392480879, -0.9250302780566019, -0.24765165918822657, 1.2967759002374264, -3.036066046207314, -1.548648063638722, -1.4006703646145977, 0.9224166228248992, 2.8088009739842272, -0.3716680240108518, -0.5863168274914716, 2.678301715069187, 2.2358795744734072, -1.21865741765338, -1.776671884559881, -1.0490821504956291, 0.575186285084527, -4.877424737366377, -2.3915674056660063, -2.7446588452358496, 0.8306441284667798, 0.9890481480688867, -2.0215865482232873},
    {4.84629251882484, 0.4109349288140556, 1.2532517061960293, -0.6581166445294239, 2.497276205661623, 0.6151939543995363, 0.8960005381525099, 3.3405580390115506, 2.602122735026096, -0.7118558163985691, 0.16645130299798133, 2.7216464136252116, -1.1263001020185641, 1.0197619137172156, 3.0293753239639627, -2.190012433591641, 0.7022380330616156, 1.6676986834771144, 5.332490160862054, 0.8674352512992308, 0.11815278950681657, -0.43562909006679584, 1.2135022880926232, 0.8793345980766032, 1.9362092061450278, 2.019214579169669, 2.055891855001817, 2.382227263449918, 0.6292592661675712, 0.9126885389317341, -1.6586809525831874, 5.615857858419823},
    {4.071714120745568, 0.6949634791289564, 3.617711080556052, 2.485095357636791, 3.9380056883526575, 1.688020290213129, 2.082151680468054, 3.259927862056241, 4.1259961928002875, 2.5271392836950737, 3.330926947574235, 3.447816241214437, 1.3769199824949592, 3.775010312358684, -0.6258348890872037, 2.1161817365828743, 0.5338707904545452, 1.7983796928802516, 3.10139797606065, -0.043754208378217335, 1.9709974295841137, 1.3895467250930233, 2.822613756493895, 3.647018600785784, 3.1101990688808505, 1.8532776516224323, 2.770303475990185, 4.061223711383935, 4.100986426049404, 2.0203908209053507, 2.434768098650526, 4.603541010038873},
    {0.8682838623421355, -1.6278279988618125, 1.3513753298052338, 1.902047895808867, 2.5412248905777908, -2.729678468722866, -1.885841140556809, -0.0707346808699584, -0.2669618040685661, 0.45260616433450607, 1.5417855240768057, 1.0790781698098724, -0.18807043052670028, -1.266951535700124, 2.195637216555755, 0.364764680124068, -1.8953733022569228, -1.6402731613258061, -2.805895915427698, -3.162383907685477, -1.9783335463756477, 1.0956084228702605, 0.7247523971558472, -0.8150299762188301, 0.5979526672755369, -3.036131467045835, -1.496422277703512, 0.4459031913534493, 0.3979593091132436, -3.1676886712087335, 0.09275476538601482, 1.2071576684552703},
    {0.17384377447125274, 4.2221287950920825, 1.1982825950366784, 2.2907064550802287, 2.044142631109325, 4.838414446630094, 5.303898087733281, -0.9929098788433727, -0.4836497334486189, 1.6221902670884487, 2.006066246427209, 0.7556078989237858, 2.0429153065850634, 2.2701396105756273, -0.2104838336059037, -2.57952135595558, 4.645059960605947, 4.55111571389189, 5.432253347211061, 5.220676282652379, 4.647442555070749, 2.023797467095123, 0.5005867693764132, 0.7493612615019736, 2.8364704003310712, 5.44946656266817, 4.3464829051202525, 1.556224349571028, 0.4933659023338947, 5.342315345614832, 1.7587667631504416, 0.5382690194546715},
    {3.561022692872791, -2.6846763822397732, 4.768696323297632, 4.33331988643493, 3.337068449850308, -1.0927226239015415, -0.7656849644217038, 2.1571708830871246, 3.454296070640631, 3.8777726250880744, 4.932934471216029, 3.6660924672297504, 4.111686844116291, 4.173208771696562, -3.713197975940096, 2.455392506809796, -3.440171448791015, -1.2760533010415933, -2.493030716311647, -4.385463737848383, 0.6410666987120217, 3.3394163593651247, 3.5985387646935187, 4.709233890624624, 2.7367061778812705, -1.108413968579423, -0.1543214189921701, 4.844644849858245, 4.20229830999221, -1.3516620234237333, 5.4814095337173505, 1.9540376558865162},
    {0.328593250869146, -2.2271410843374033, 5.491905114335373, 3.7324087991038155, 0.9669843592207963, 0.28918011150552236, -0.5350641680037693, 1.0317328861935784, 2.718129607258426, 4.112690314544898, 5.29662250777724, 1.8314772758441216, 4.332756032585956, 4.7558489268657205, -4.9084907663359605, 2.7606304720967962, -3.303622458865429, -0.4476277929355205, -3.822958519079487, -3.717996264220881, 2.0461945031903657, 1.890420614795735, 3.090790090158226, 5.275550665096888, -0.11542010840185098, -0.8438881169672396, -0.9220029063773969, 4.799430648503814, 4.173103914983702, -0.9960388681794644, 5.47166306562236, -3.575419124074905},
    {0.03681599697287508, 0.6798890707234355, 3.8073879028826703, 1.5727634272649202, -0.5213176299178996, 3.0228063336090036, 2.9085188127630097, -1.3832760310701304, -0.1561584168459419, 0.6841117126040781, 2.930032408663119, 0.6601905842024391, 3.1219714044503415, 2.925316131527364, -4.215985867379793, -2.010653689092107, 0.25901131735965327, 1.3858104826691717, 1.7912527324390155, -1.180966277368106, 3.759716692063255, 1.3458060699181988, -0.26646979300136625, 2.6283113906897353, -0.01782531961358199, 3.363214514986312, 0.8519365976630203, 3.0322823738750113, 1.2378419796086806, 3.300528471479608, 3.8972405200004836, -3.503140765366759},
    {4.372304478123849, -1.2493985821674278, 5.661465281246336, 5.769354049257594, 4.48092402555514, 0.8232915087444829, -0.7187704177146668, 4.273193388214274, 4.62366702152316, 5.523595503300918, 6.290264864784099, 6.120845137358384, 5.31790359845913, 5.953980151235951, -4.5483640113818495, 3.8758310345286278, -3.1336162908818133, 0.30598164938856104, -1.420069596133009, -4.312297459780038, 1.2706847392505298, 3.9458476549916193, 5.546293954523144, 6.17405418696635, 3.4597300906011914, -0.7312289549058243, 0.3989945255860351, 6.185513661979525, 5.218289557837959, -0.9221057845267554, 5.75591154214156, 1.4764061701081796},
    {2.9538695015121377, 0.1594726600534895, 4.994897077635397, 3.9201826975923946, 3.2089872048343078, 0.7883232105482552, 0.8273575738926309, 1.2478878472061399, 3.049703240085186, 4.126299561132922, 4.9471752678923036, 3.6586797673441653, 4.968417209394212, 4.561792812294324, -4.862135227422992, 1.6846881156096398, -1.5709578756246214, 1.528788754864191, -1.616905451477594, -2.2462104454106187, 2.0536477954343884, 3.0438389814162172, 3.828935299474443, 4.348686923016838, 2.6550406299987523, 1.3069180208550881, 1.0493603072531574, 4.717964442900276, 4.273516825295379, 0.6383225199509879, 4.38008858468109, 0.26503076417032495},
    {-1.230464910522933, -1.4718337051773824, 2.4423653683658553, 3.0302843626521994, 2.4560853137620207, -1.5842180259057093, -1.7639725182074344, 0.17700906599294314, 0.6199778056804656, 3.324662994495859, 3.5338912385525703, 1.7396536568836631, 2.5238104426116172, 1.4677175071435473, -2.0544765115954906, 0.7909461398719436, -2.2456975719034444, -2.101139740718142, -3.2434861552941223, -2.9493818825040763, -1.6203784852873564, 1.9499758007886758, 1.7545690000251422, 2.244783475908033, 0.29798699573848225, -2.186442858248185, -0.5033994629796738, 1.6928793404338307, 0.8268966794122038, -2.2915650691075595, 2.4992549838456783, -2.733962775689682},
    {4.104147966956954, -2.6084361493275, 4.093650507469051, 3.9553982860622914, 3.715438524443968, -0.7237135727837665, -2.124710264267183, 3.9650358040414635, 3.929464813179819, 4.14141665054449, 4.078961255982769, 4.330653962276931, -0.09515058298956007, 4.180644251837266, 2.426603661053608, 3.852204630659803, -2.609740404312459, -2.148249141166957, -0.8790182260069438, -2.9288739635959082, -2.3262606975850817, 0.9789387835900397, 3.6780493950103974, 3.5597877132924545, 2.46992170463512, -2.099491082551259, 3.7504724380620886, 3.7340227319126615, 3.4580374247386674, -2.623649616920242, 2.8626196543946287, 4.233351045074535},
    {1.6157989661635295, -2.909561916238287, 4.361462314496216, 3.259118656354912, 2.998948713727895, -2.3890697949553754, -4.302103978359076, 2.6427888950527016, 3.31008647074248, 4.4890025223849195, 4.451008064352374, 3.407189593322832, 0.44416031031163977, 3.307867793870701, -0.4268731060850765, 3.800719411182942, -4.144126035791276, -3.320708053885866, -3.2940238008648577, -4.1148686762690785, -3.246533014305943, 0.664375296480945, 3.6536193673197404, 4.476528460949122, 0.6318101243351577, -3.5591363689588515, 2.1109907792938616, 4.101331561235995, 4.057505848913688, -3.5953806475252104, 3.060711763914526, 0.15708451127646328},
    {4.145470194157101, -4.376843850102442, 4.705865731032474, 3.615427907747617, 2.815613047695843, -3.251453752336139, -4.0945023935305525, 4.745458155305662, 4.898746932532036, 4.00658645743641, 4.558652995631198, 4.363098854147505, 0.46954269644608904, 4.0606807075854245, -0.799059341856391, 3.509606761301648, -4.868730414889444, -4.004892303890836, -2.8674178910267663, -5.423901378324488, -3.0671085537751526, 0.16680616331019743, 4.175686528654769, 5.004074033059774, 1.4970869790527797, -3.561114660159463, 2.168433318611801, 5.106535450704745, 4.073990344644915, -4.118815417178124, 3.295955212427204, 3.4198112864620525},
    {1.7766606319369516, -3.4100812108939693, 4.132707921772179, 4.224514384057405, 3.5097796594350634, -1.9592271213716876, -3.854877380447002, 3.2338181697468826, 3.528595550780544, 4.561360328754588, 4.009036969460572, 3.572856322753257, 0.6626002586205273, 3.431603549428961, 0.7119662671171658, 2.9862152086367706, -3.8702983120084964, -4.090662481965496, -2.60778738108256, -4.334950674081931, -3.7834352097437742, 0.4175995760174681, 3.848046978210978, 4.04367242027747, 2.3355610894934795, -3.810947099508407, 4.031255260973169, 4.4967550870279265, 3.230698462573063, -3.5906609005506755, 2.906765364268135, 1.1660803000307116},
    {3.217039502495818, -3.5198162167103653, 1.5540285218753676, 1.4149750128573535, 3.198495212290217, -3.252510882772478, -4.8239458347199164, 4.7486846567598375, 3.3771451100726617, 2.4455976342442107, 1.0847608374142261, 3.7298387099814714, -2.7449435603225982, 0.9667507954062035, 4.100116301730949, 2.230401268805488, -3.630111302266708, -5.003146438393473, -0.6290781478293357, -3.9670000432489374, -4.999429718866457, -2.074510079543018, 3.1276233023582267, 2.5952552538856453, 1.6350194963327447, -4.218878064448356, 3.6096815990399245, 3.3085644591650087, 0.9969816766692297, -4.311246855525645, -0.9512980858650828, 4.863168487229474},
    {4.782458250343671, -3.0964474464795537, 4.483419489531592, 3.7534667881555217, 3.755067789679288, -3.6929120132929394, -4.277668382950643, 5.113352432000133, 4.7303320764775085, 4.691166597438161, 3.93669748968087, 4.45125128899552, 0.12169418381589596, 3.8961727925775618, 3.6325885451182436, 5.51751768653157, -3.8535106298421993, -3.4394720098767575, -3.497826577820761, -3.944708630614323, -3.933896013310335, 0.05497703515649516, 5.327418148272835, 5.016009294589454, 2.6591536546703027, -4.476606979605782, 1.8944035428874062, 5.019323477818061, 4.367540359824181, -4.009171987881758, 1.4824173634855515, 4.812557799155439},
    {2.6237505532826866, -4.07825434390656, 1.5124112883405514, -0.2920661711895043, 2.2335163251550507, -4.3687092167013395, -5.691350075638093, 4.703660029657894, 3.242861735439789, 2.1907457624883078, 0.4152002602605693, 2.227798205086583, -3.9081269914399788, 0.8263873633521165, 5.800302946496375, 3.9662654363064713, -4.412456373145581, -5.653222915909287, -2.931465985704634, -3.4092866889136637, -6.278559297178257, -3.517635637080251, 2.7322098399475796, 1.9154475039623808, 0.055470102691347487, -4.9756948396631495, 1.9995699639509534, 1.6430843211112212, 2.0377912231262036, -5.1976200729093485, -2.8293596925847115, 4.532939963472709},
    {4.0869878220346, -5.67155733226333, 4.273783158111203, 1.0911650632851166, 2.5710747915736443, -5.215743654250046, -6.359675366869295, 5.20365056992929, 4.7343294909842415, 3.283147966445886, 2.2914458720501436, 2.938107570023427, -3.9715243342356117, 3.5121283572133497, 3.2275834032306348, 3.586804318981991, -6.268400797679065, -6.36377810586085, -2.13690885007295, -5.839370289838463, -6.2990280654164, -3.7341384759459944, 3.5194921018071335, 4.1467384365267845, 0.07129534881245501, -6.375407069196154, 2.2104291094250805, 4.293115596300889, 3.7658054729365045, -6.3047703643091815, -1.9231709981461473, 3.9418292522703604},
    {0.09601028000923227, -0.9114902420192164, 1.477290316626819, 1.4158642378490485, 2.579267387205117, -1.4087364772881967, -2.76212609913668, 3.462826211383404, 1.676920491612651, 2.4316150721098886, 0.5365392001153817, 0.8453492248074221, -1.7917239751197591, 1.7556716136141104, 4.2120971848675435, 3.7349802979214917, -1.0751156727340512, -2.2566968776604095, -1.6504967748509378, -0.24235121302402948, -3.0687995192489796, -1.3175166909510638, 2.0281682148979923, 2.1871878340351345, 1.9472856450597698, -2.5683867430514162, 2.5103227586940355, 1.9932926884423248, 1.3255224742071403, -2.092008735149482, -1.294060301774144, 2.174003356800914},
    {4.322097723355614, -3.457797606963181, 5.083136820218494, 3.5445015793708285, 4.656043845786298, -4.012333365083936, -5.047601102727979, 5.471091243404661, 4.984782165510414, 5.114377091593772, 4.4939134564795475, 5.044163417810914, 0.2911530915465376, 4.393043117626333, 2.739664799726655, 5.294982382545257, -5.747695164105131, -4.483380990066231, -3.2027175844597022, -5.475219307570941, -4.495504554368361, -0.3671117331686887, 5.547476174011294, 5.403946633104431, 2.1793967672855077, -5.0903073591557675, 0.9763393564831369, 5.969100521809838, 4.809359675194346, -5.28966198047015, 1.1857847100982348, 3.755984486973283},
    {0.4210965380569088, -2.0768522822784012, 3.045912121432795, 2.9753520965834794, 3.5857009879205894, -2.6563382090929926, -2.7816076013918614, 3.5936025615801177, 2.446149464532851, 3.126201061404741, 2.9459620174042405, 2.3230429939280883, 0.9648164447459554, 2.778418412282496, -0.8409323021753481, 2.8123757877660096, -3.517753493914294, -2.3662084923096356, -3.5344356814291307, -4.18665911938298, -2.1061754729410804, 0.3196087815508408, 3.216422623665131, 3.9420707354384166, 1.789135733031644, -3.1458121893895563, -2.2435113252595156, 3.922490790878494, 3.205532580104136, -3.2988808328292776, 1.7738735708296272, 0.5837565859445324},
    {2.0374828465833175, -6.915147885648495, 1.980824428989049, -5.254609674246088, -3.7780558495586454, -6.950203987190274, -7.080596472356002, 2.4055437042681493, 2.3647013561778354, 0.9375985022451543, -0.22160269637167823, -1.9397665067654914, -5.9086076831360606, 1.7715066209447385, 2.0455513355968304, 2.912539303195976, -7.089576688309565, -6.796940841267694, -5.541344683431576, -4.96715211574476, -6.465482348532554, -6.5479182208657045, -0.7487683032996946, 1.375009151786175, -6.199202675657962, -7.085497189138746, 0.3633259688540534, -0.7426200306584558, 1.5904131346559858, -6.949488889597783, -5.483604638357499, 2.211130666811526},
    {3.49733093898085, -6.071050233665741, 3.0317972494769507, -2.019575406603691, -0.22590097484624963, -5.152388939857534, -6.0702782954726136, 3.703327289732586, 3.6092831952897577, 2.133784372701917, 1.7479942223186171, 0.6455333340396364, -4.814806091352045, 2.7694647707261653, 3.928644851202984, 4.185191834239535, -5.736017780199276, -5.847217498833982, -4.456438005554902, -5.738576917594107, -5.7141897924406715, -4.238858846069987, 0.8372859074090557, 1.8502570084389482, -3.932969082471759, -6.110147062352348, 0.17340107633189084, 1.2602086152687553, 2.8860768585841807, -6.201964564293176, -2.2072584319179973, 2.9702086686593527},
    {1.5210265585313005, -3.2549840303618147, 1.300565584834476, -4.044109453230871, -4.156404287147942, -3.334488649226532, -2.4433866435031746, 1.8880226085985496, 1.8448480082451237, -0.07996744206263189, -2.412559635866815, -3.265432130775802, -4.024700136927016, 1.7827348159812002, 3.2015370235901495, 2.427950025596532, -2.86960274465912, -1.9562861122086288, -2.7182804454753553, -0.6031859766950275, -2.9223711157802525, -3.7228327015333758, -2.865242542349955, -0.8394958069966976, -4.647454713032189, -2.4565722619144466, 0.9501783872710002, -2.0460123139765045, 1.413752300917773, -2.68281547187794, -3.8456660579091895, 2.5958575181567425},
    {0.8745111554471351, -3.1914692369160327, 1.3008442656101535, -4.435093824086284, -4.049072226713327, -3.549666229905048, -2.6415832851109995, 0.846842436607726, 1.3578495524747505, -0.595545272232188, -2.8853261000185624, -3.7309226314853206, -3.9419509964454997, 1.0512011045274319, 2.816216563352749, 0.8947195395901244, -2.698037866356621, -2.3482511424306973, -3.389154148674297, -0.43056677717823505, -3.4665298582614943, -4.22373024544956, -2.464309546555384, -1.2059316863905405, -4.76618816039563, -3.055082643121615, -0.010756133362201119, -2.8941122024382513, 1.3154485125415223, -3.476306801887227, -4.38700243794435, 1.0456495377713284},
    {2.37970755640692, -2.735852223227346, 2.3354010908266765, -2.2542735140869867, -1.530022817950857, -1.6395389144469326, -2.4454803954311464, 4.002503996845715, 3.540640070025649, 1.8966887554212515, -0.43802891531422683, -0.3676274679478604, -2.80800530935146, 2.302681786481225, 3.5299361506882048, 3.912368603164505, -1.6730653122439694, -2.1346284205489945, -2.0496390852500594, 0.5247495406407547, -2.2188781201023713, -3.0933493256140667, -0.7195312822452606, 1.320948328961609, -2.4002346245219215, -2.0731893602037466, 2.4738269004378477, 0.13074290503303157, 2.0246864469438814, -2.3016962032682162, -2.6611342809356637, 2.7819080321401657},
    {3.132736205053502, -3.0005662339438928, 0.9889402884222284, -2.754142356831588, -1.3311762374812748, -3.0152341971958174, -2.619365033648038, 2.1827926659268932, 3.1773714888820828, -0.2645520691162239, 0.08034504430018508, -0.028536241254195824, -3.0323759167069424, 1.7925973117870264, 3.160339525903962, 2.4517657323514284, -0.36617091507807975, -2.8455825646277075, -2.3009920826320505, 0.08687150382565456, -2.7252239355832057, -3.7175605835811787, -0.48147248705664475, -0.2581116115339929, -3.50765515787249, -2.4167162670310556, -1.2192364596398273, -0.381663933775793, 2.363440952350291, -2.623727522439941, -3.715899649650336, 3.0793232173832905},
    {2.087278776520443, -2.169077167652289, 1.7608638276134638, -2.6000516647155525, -1.9899554399836519, -0.9282937630735163, -2.1213592034324154, 0.9063406836600895, 1.073342834223212, 0.10593817259735563, -1.7223779139232014, -1.702063816381628, -1.5483863873424488, 2.222877875420752, 2.103906946929245, 0.5603580167916682, -1.51054101613466, -1.4085220732634613, -1.9803102927243383, 0.0492266748951564, -1.6074428818737843, -2.409219958588806, -1.4498430796891042, -0.21235280125950806, -2.8883370199380245, -1.4455721844324119, -0.3445447979906256, -0.45214934179981375, 2.198586741035314, -0.9372664982153892, -2.794609396716532, -0.4133317304340582},
    {-0.9185815230128906, -1.1375825766489869, 1.2608695033073276, -1.4113364232255214, -2.650336049006168, -2.2197842810511355, -2.5225798845759853, 0.45432968643370936, 1.3210390166897348, 1.094316627951267, -1.1925414654914792, -2.6323691692207003, -1.2085587408647351, 0.20302059467230918, -0.417686286219751, -0.1288312824984096, -1.7464837196839187, -0.5356382506541982, -2.9994097196833605, -2.3275260953236687, -1.7774503535124446, -1.3029353491923465, -0.7617151434121138, 0.629351688331357, -1.4819519442028484, -2.46107320739058, -1.57546375832262, -0.42740305331002354, 1.6064678317649306, -2.084989373524078, -1.5441083339462158, -1.6784475074518728},
    {2.9840765335423147, -3.4862061703507896, 2.1030329044291327, 0.1437615166229673, -1.1180420911037967, -2.905332028105104, -3.20154895033278, 3.026991557046754, 2.6059132015064566, 0.01995216408181529, -0.10635459296059892, 0.1596636253479532, -1.5293312612763617, 1.5374261425959583, 1.3645798800903661, 2.9721956067485635, -2.4773971926932403, -2.3368994321953536, -3.2911485725006635, -3.3119907139136324, -1.6292850175309326, -1.968274253628658, 0.6131834749030679, 1.9479865681991817, -3.0860880364881713, -3.764859028246671, -0.7647189272213204, 0.5664499329795207, 2.6764350299406443, -2.242739298869173, -0.006220738721277466, 1.931186475091027},
    {1.796191063000523, -2.094672088417927, 0.06010208460408603, -0.9337897415118402, -0.8921054204967087, -1.545095601022483, -1.788656872269281, 2.3564484940569974, 0.8862686539877149, -2.0107441026143955, -0.20215842226975345, -0.09097530028081101, -1.526669617529288, 0.32769382969196886, 1.1675263126845081, 1.3627192070471381, -0.9076537593784434, -2.1569210305294946, -0.6317050139894015, -0.5316217343684574, -1.2413534475197279, -1.10593170136165, 0.022023883669249237, 1.2952266850719731, -2.115843367081971, -1.9212556120881752, -0.9349881475867112, 0.29558369579699395, 0.20188896157714764, -1.9942678846533721, -0.7764292707016162, 0.5066123451842744},
    {0.7868587334802236, -0.337952808653316, 0.7285939928008675, 0.0760878994612587, -1.2011316856444736, -0.5359275766056906, 0.5301446139522927, -0.5885415659441282, 0.23312347685742493, -0.3034004493550453, -0.4217878073068248, -1.512143663048606, -1.0524040104165038, 0.3539047743940087, 2.142253865816229, 0.47062602497642547, 0.2630587809856451, -0.5979017022496992, -1.3907124363749448, -0.5248391574245205, -1.2841186017682582, 0.002344854535705624, 0.1482404179007416, -0.24528395234005973, -0.5186816616335597, -0.20020793192006603, 0.9721082549638105, 0.7922706540817074, -1.0621381224363875, -1.0183241609438731, -1.534320973196688, 1.0784012742080422},
    {0.5644767551793884, -0.35070471281910465, -0.1406536366487608, 0.7466705607920067, 1.0096441887579817, -1.8295054223334384, -0.4815862219385508, 0.3558430574690292, -0.25198534307910697, 0.9834752636290792, 0.5463655056962607, 0.09347503480183852, -1.396692598564994, 0.0732480342194399, 1.3928449836883532, 0.17162520646184798, -0.7390076759397938, -0.3380381332622603, -0.6300660721972766, -0.9433886230240367, -1.0338956877531753, -0.7530178576773319, 0.8198118140372058, 0.8531787462406546, 0.1709158109150289, -1.0591894435975922, 2.267359280066005, 0.8550879487181705, -0.9415655783603949, -1.0861831483172282, -1.9387642977172486, 1.4913106034155437},
    {0.39793307051012183, -1.8064683434362039, 1.0561228325402063, -1.0740688244247036, -0.29977489719239814, -1.5827193693941952, -1.1614192252931368, 0.910837702759793, 0.9715966975935134, -0.15781609712816994, -1.0707344123373932, -1.5492918441467682, -0.5526568556983396, -0.8705994528121463, 0.755477491071864, 0.8077693540902048, -1.9220577588393166, -1.2723011362538585, -3.031425206248763, -2.569334804797806, -0.9966072559302496, 0.1720853659848622, -0.7907684276567573, 0.5285162482821045, -1.2828786763131244, -1.5414153256197929, -2.6583473889072704, 0.4389590345396052, 0.29458406572612794, -1.8842046628944167, -0.8314573247725329, 0.5624949109257041},
    {-0.35601223368047014, -1.6933482699446214, 0.7313707943209068, -0.444146881532061, -0.7021072614875834, -1.4905525872974867, -2.6208935086763017, -0.6052596132104231, -1.8630051294280385, -0.47205954953970164, -1.970136159202056, -0.06657283994707751, -1.1719189827283136, 0.7626048216312387, -1.2520405710195972, 0.14477189812140895, -1.3705179822102216, -1.6526093537869302, -0.8610025412325706, -1.0253582232133271, -1.2218784415885953, -1.870387153186713, 0.1915362974197089, 0.38113351746954316, -1.1630797196558194, -1.4126525194581312, 0.43650794155967354, -0.342675831815991, -0.6954393202558328, -1.8996331378018654, -0.6713689974741914, -1.2823933055218857},
    {0.8762544157180817, -1.3097011034534187, -1.1000568514690017, -0.018126875781309545, 0.5995987181422191, -1.0896000587152896, -0.8433007512801206, -0.12872934737993155, -0.062287210059775326, -0.24825775127317573, -0.3273667389836866, 1.5129792631506835, -1.6701058405934535, -1.12147266705069, 1.448375550090002, -0.09821740950197481, 0.33940232216429556, 0.16223260346583407, -0.8381996127563136, 0.9668203557537296, -0.20238396176183748, 0.3620779541021977, 0.6885124676092114, 1.0648401905884604, -0.5047812727525188, -0.6142265409777802, 1.2456777868517213, -0.27667529128781954, -1.2850451304328943, -0.6541970637126125, -0.7196815302595029, 1.9138454397495943},
    {1.0413821030737012, -1.5058420379282673, -0.0019423632782189673, 0.30076008342685745, 0.9947676906113259, -2.1786587116433327, -2.6266924137460697, 0.9795663450207934, 0.22597732138475138, 0.02267108033979481, 0.3460605460792298, 2.092161181435071, -1.4387538989957307, -0.05468825107766458, 2.7934477840532876, 0.47662606828922766, -2.0501683513241855, -1.293445579219417, -2.403697724944425, -2.3987580523765075, -1.3530185320191574, -0.6010232799490758, 0.24814271613698066, 0.585656643845429, -0.027706087179621083, -2.4656020509171634, -0.03787854638741289, 1.3134049548215039, -0.3056652916864089, -2.0893990655054426, 0.16944755193877964, 1.562386145577674},
    {0.49923095159937325, -1.3920134855643462, -0.6037343521273424, 0.1868624121734948, 0.00689831815818664, -0.11834118555291459, 0.19005382780306798, -0.20534258926217025, -1.4079624851658723, -1.4092731806865753, 0.16767113231558234, 0.4290157985417252, -0.35401697373819074, -0.4763799192397875, 1.2312870296712024, -0.633877330241084, -0.6584046521777375, -0.44892782961179933, -0.2559055375965572, -0.5077320532725449, -0.39946229426189567, 1.0462103425714007, 0.7374395619897307, -0.6822254797554814, -0.3375435882872506, -0.9028712131346489, 0.17678683878805887, -0.7739998676610322, -0.8183265889678629, -0.43713034620233493, 0.811122860316093, 0.25859279096108},
    {0.3376109859678724, -0.9809669127220118, -1.5089642533962295, -0.413022821087649, -0.9923006466170059, 0.15710619373699106, 0.723542121938802, -1.8248314334578961, -1.3082065075085652, -0.21171448780447266, -1.390028487785452, -0.2183965280598047, 0.4768086636199333, -0.8283497020889568, 0.8866019359894949, -1.6338578176662597, 1.2670336007745946, 0.19831416995875545, -0.23617606463352556, 2.120140228166481, 0.49735422654442774, -0.1888241385144049, -0.7240316318180806, -0.4629146679447842, -1.1586080978390467, -0.2285090163856331, 1.6571057080698341, -1.306225035022362, -1.315269755848835, 0.06954244121229895, 0.6871631674796205, 0.8004834233248527},
    {1.412951966365856, -0.3570512792312294, -0.8472496540441193, -0.8013102730629685, -1.1392133802777438, -0.029841793523962223, 0.5948297350221408, -1.7586789236148783, -1.088079407565141, -1.5657746942952457, -1.4453494957236932, 0.6405270590599088, -0.7952400325939307, -0.4202930196504182, 1.845866307089921, -2.025100599887158, 1.8866768143287587, 1.0838133217306885, 0.8537864866981582, 1.0577378872449936, 0.2229487123814157, -0.13312684843701553, -2.5895155280313755, -1.475872196922122, -0.6579267024360155, 0.6301702312029663, -2.0547139415093256, -0.8603967970535124, 0.30476810923311504, 0.2651276892115201, -0.11354523561142495, 2.1940350665194646},
    {-0.5712578740519099, 0.525767335407055, -2.1482747360704866, -0.021132398810117796, 0.04739666360334737, 0.49836897359763443, -0.09328629125858989, -0.8989096135281518, -1.4845088827712496, -0.8907816729995108, -1.9397521732447973, -0.5971765032577518, -0.7458604594874914, -2.676207967365963, 1.8069118696391016, -0.009449360787661688, 1.3571486198372253, -0.13442349755438465, 0.44908692135057654, 0.2348794329218939, -0.10855029342312292, 0.669570421953904, -1.2469147287229112, -1.6848419392332825, -0.24797562016381872, -0.24575133736697957, -1.3724837605620643, -0.5683340623594513, -1.014356690942826, 0.08430223828421378, -1.1681346503538272, 0.07243048042577561},
    {-0.6187952443005211, 1.470564470547628, -1.133042794568555, 0.5443611120332544, -0.05815374092921054, 1.2137438488406895, -0.03183949979231866, -1.2045835779796792, -1.3582371793483947, 1.31848874219349, -1.1127226667151056, -0.9008730410265638, 1.3525730480638865, -1.3647475736032668, 0.8006006126795631, 1.456038820265642, 1.15058606749633, 1.29062057153038, -2.10281130501638, 1.3855922112692938, 0.6839655188513315, 0.9160758470265388, -0.5179441477906632, -1.7596409313030859, -0.2554598404170363, 1.0994826018953658, 0.3994998153534414, -0.9212542622285808, -1.3231661941255533, 0.6360115543855739, -0.40923042083651107, -1.1912270345244096},
    {1.7491726309232027, -0.012548936036892678, -1.266799024353931, 1.5761268467959992, 0.3094213089520399, -0.43344533502136645, 1.1290941978374993, 0.552549371908172, 0.2344414389486009, 0.6127742979612637, 1.2016171806008198, 1.4733421419631625, 0.19975143444247767, -0.43761968556085423, 1.627180704399392, 0.6657241658328653, 1.3193114766759408, 1.4846919130847693, 1.7891154161854381, 1.443988963475686, 0.4924183780476498, 1.3797426736956229, 1.703040195294259, 0.14859230053415187, 1.2712133917064385, 1.029285704284151, -1.3064590492834716, 0.46218185521028016, 0.4107768052044266, 0.37858957910536317, -0.5073019300053562, 1.8597779585619216},
    {2.301707817118785, -0.8558976201736026, 2.441933141298139, -0.6008062665642115, -0.33270727869155037, 1.7211249486004874, -0.04913120549973897, 1.0882753793982078, 1.3668209922229222, 0.3157407062483129, -0.5824479824569195, -0.17408353573410593, 0.22687828769198254, 1.4979658866809833, 0.6597599585026221, 0.7232555682948866, -0.2921947597125321, 0.2852633603295588, -0.5548514628881542, 0.3219052583742628, -0.24055648871541385, 0.46398417574605444, 0.8674465457053776, 0.6182350975083714, -0.9002352043369176, -0.07498594327758205, 0.08340264545165843, -0.09977102228181427, 1.5412811608006023, 0.5200071589768219, 0.12722835523444187, 1.0580908729754253},
    {3.2151513997290015, -0.7315846314774739, 1.5631518441521808, 1.2557306132999582, 0.7999182806072176, -0.41727704861302006, -0.09656138527201402, 0.9091722143603082, 1.6117795579397274, 0.618574478789774, 0.22757137004182001, 1.7381229992828082, -0.7424984599281252, 1.4406016628149627, 0.21846938366381594, 0.5781109220190853, -1.7227294585720887, -0.6962702684496094, 0.4778127181171912, -1.5653053423000123, -0.8828133733669116, -0.41329396367712984, 0.04525693854146952, 1.0591679561780245, 0.07581150188554352, 0.026319440334008393, 0.4825680923273001, 1.8217026821778814, -0.2185289637594204, 0.033754096807140414, 0.4001396509747639, 0.7324390621494071},
    {0.7499150484294717, -1.0591075680799629, 1.8896613647477092, 0.5844227080141413, -0.1570406192433409, -0.5976050517872019, 0.0775893171026714, 0.7130796603827708, -0.2109697980105303, -0.008691822859803045, 0.8168474531460513, 0.041869301440378835, 0.2121809844933095, 1.0048414266032897, -0.9538180133423181, 0.42291536269773194, -1.7300345170924396, -0.6923148937729847, -0.8003232611668115, -2.6096385859988946, 0.6717911733277239, 0.8014475348232751, 0.29643309104183546, 1.0838122974650337, 0.039554977547209096, 0.4217843706982063, -2.374466294067114, 1.4584780116833655, 1.1504598701645468, 0.34829741394187524, 1.3206804075844056, -1.3799101984321305},
    {0.7628543796033758, 0.16801027176406044, 0.4472124429280225, -0.3704008636313823, -0.7482385347425489, -0.9377252003395664, -0.7057421064519168, 1.4483724562087053, 0.2926705350888809, -0.15924336228362704, -0.9049054214222528, 1.176862499072008, -0.0008128069655524782, 0.11064244051787041, 1.7022373490213611, -0.6196962729968595, 0.3603577934507, 1.2020721565560153, -0.08104343242124255, 0.6550973101899611, -0.5252482786639798, -0.16203948167657586, 0.4114984837014469, 1.0066971694100564, 0.4450547372135267, -1.2994852779789963, -1.4782884671606185, 0.9280456289144968, 1.6354755467392716, -0.2921588373721974, -0.4264366085700779, 2.272390711939974},
    {1.0680466789971994, -2.912055955092774, 1.142346749402516, 0.2396761341607631, 0.35014072985382183, -1.2570642910370662, -1.69536136242871, 1.3975333102429064, 1.5306593394143293, -0.1985115299366371, 1.3542387585042697, 0.7138646432593343, -0.6284961386025227, 0.8177050552785411, 0.6949832295528126, 0.2838785431645211, -2.0053599300548863, -0.9997230083329492, -0.7748324372950695, -2.0143836007411395, -1.782320439881734, -1.7888460912487356, 1.645481794306407, 0.47293625360765335, -1.5596554461219991, -1.9148879530977851, 1.2983819528692666, 1.8147950330543035, -0.15950070055790452, -2.5647076664294968, 0.6044393941956769, 0.7125143773102203},
    {1.1000549402234454, -1.6300844819212714, 2.33949508587913, 2.088531039521851, 1.3934909986051753, -0.19622706283326344, -1.4200432065942241, -0.4404846696450261, 1.8378044701619674, 0.35079316876151306, 1.5953171675666378, 1.498666535428169, 0.15262777378222464, 1.3892076224259309, -0.5575308333230752, 0.7357655432295601, -2.163404892776581, -0.6799436430152372, -0.3762277955316334, -2.335087371841786, -1.6342231010394825, -0.09763309934442217, 2.9110002232584185, 1.6578666184852355, 0.8236904102801782, -1.0143575244750331, 0.45847351605838094, 2.2300236141427976, 0.3885946421984177, -0.6803388723409536, 0.8477997494229973, -0.41027435872792517},
    {2.8949762233581233, -1.4371282497473636, 1.8635347946043495, 1.0407590004819276, 0.9121456472602328, 0.10022451623111538, -2.146399707073264, 1.5327347769887034, 1.6721506608025896, 1.6060398871151405, 1.8456407698743245, 1.6240009079808937, 0.9837645710565088, 0.1199283421488194, 0.8128793596897389, 2.048034016323469, -0.959351197951156, 0.03713006596048039, -2.7117398736464895, -1.8112887330704972, -0.6209199012526686, 0.9153841784895453, 2.744994775495035, 0.1972428656441459, -0.9396234283184705, -2.4665663529823787, -1.1206195936173287, 0.2973296244889048, -0.14330887952585086, -1.4349028881485024, 1.3926174180665678, 0.9819457721667479},
    {0.34553214165498414, -1.6670994005232853, 0.4313201181983253, 1.3420921034168074, 1.6153817258310526, -1.814234436783816, -1.4814181242729978, 0.5810080468589474, 1.5418096711195752, 0.9554166045893254, 0.6096481190236249, 1.6727738724341616, 0.6434460371416085, -0.2620346233172323, -0.5016393172044588, 0.5518970923683337, -1.7842521753354936, -0.020787131324387757, -1.9366748151980493, -1.1045610476009358, -0.11604792174322184, -0.26997886444439917, 1.474463624198898, 0.3689307750912348, 0.6133409894715075, -2.331835314515328, 0.2853185376345926, 0.8569445162289553, 1.061055268000417, -2.56956633958106, 0.8826349394599841, -0.3571590485620818},
    {0.09967161241009335, 0.5852494616892371, -0.626711375686011, 0.05360385911095325, 0.1540157621678036, 0.10389281786843152, 1.4315304578390269, -0.1385655885864729, -0.6744509984837194, -1.1554552052475697, 0.20872301096879953, 0.5034405748902498, 1.4440158407092851, -0.15449439494511893, -0.45518613684694964, -0.3066428660385835, 0.6094822216981752, -0.5670879876882488, 0.41686760794317607, -0.6828809568436307, 0.20428923599416782, 0.7468391257984682, -0.573566263923039, -0.27406492862122434, 0.6261858053479644, -0.12443168669799655, -1.5013411238878305, 0.3931918846193575, -0.8963479394933427, 0.40606599405394245, 0.5571854183238518, -0.13278736767210578},
    {0.7966125255954306, 0.5054072140864018, 0.42360006685938306, -0.0787857447892757, -1.2310460331545607, 0.979805462070377, 0.5603552633259744, -0.5234368856958488, 0.7302506016322204, 0.809371738928916, -0.6148755601457422, 0.6321582693301442, -0.7763473491029376, 0.3456094882605245, 0.7729214457947863, 0.3680626490833179, 0.489976337822583, -0.34653206195875175, -0.07309016190052353, 0.32692056567342015, -0.41195695697664464, 0.3145507734281708, -0.6621810487562165, -0.8862094301805872, -0.5027362882467521, 0.9449219151837591, 0.9233673358295388, -0.5869086321333409, 0.1869992290050928, 0.6819439014940509, 0.002336133492455426, 0.39075736445519926},
    {0.3870348143977923, -1.346701830493772, 0.954284286699718, 0.03978035661711651, 0.7203530500512624, 0.9927976418010637, -0.8037250545321983, -0.18407878972572178, 0.8023010078273516, 0.5799940128015662, 0.40435253794802833, 0.0680634441682958, -0.11911650640234239, 0.34211910252722877, -0.6545216183903929, 0.8116771978262034, -0.7311699513776351, 0.8966561345237632, -0.11233502642368708, -0.10835103055095362, 0.6703007411142943, 0.31464310449594474, 1.374469462506897, -0.481285589704013, 0.3784513857838186, -0.1491414197379938, 0.6523421551810625, 0.5963110931104323, 0.06165326681355479, 0.17602383701702173, 0.038666236295818564, 0.5661521291844847},
    {-0.3327162907801629, -0.09075524811906838, 0.9480953216526766, 0.3474498171582456, 1.0522445949376282, 0.5907060320807366, -0.9015159863714055, 0.3323199118310171, 0.8985193980685626, 0.61183733264415, 0.736951496493513, -1.1991354767058509, 0.3365563752578631, -0.6550219495988071, -0.5174305279600722, 0.9972247711583594, -0.43343459945087054, 0.7430477585888309, -0.8137729056743445, -0.021947613362383746, 0.16481893790947086, 0.15455189300611583, 0.9079093092819045, -0.0041886161905113645, 0.4780784040873119, -0.5620315942182713, 0.7080485798488495, 0.1650593638732495, 0.5040203419207157, 0.14665051236025817, -0.2403366614284933, -0.7984077719564097},
    {-0.9926295572531778, 0.3764760475099247, -0.19330165129454796, 0.5362400904021051, 1.484183327945656, -1.4768318599471024, -0.763362218824565, -0.04026854088276956, 0.8531982767425782, 0.5069025361366193, -0.4880518487911797, -0.04616285687197626, -0.5316269292386103, -0.8241972508206837, -0.45692294710120196, -0.5424314505843785, 0.4588823283050434, 0.23799376272274653, -0.32379600541388576, 0.6871986420494255, 0.764881654295591, -0.3710723298730949, 0.5834294847833749, -0.3131490146939604, -0.293613170783509, 0.21750833836877412, 0.09784031290961515, 0.506870689349845, 0.061671849010816696, -0.2729387950623884, -0.4637103028063364, -0.797394388555114},
    {0.6020273805879569, 0.7967086494778124, -0.4172708686406357, 1.365291161929043, 2.322680290725244, -0.42242130913813825, 0.16458790270184864, -0.05674315742485496, -0.307087507656724, 0.32117111571947204, 0.018788563728473755, 1.8437302408402192, -0.2629569222489429, 1.0865782141280396, -0.3153075059159384, -0.16618320567093392, 0.6866330934527182, 1.1708715689273066, 0.03799296206858376, 0.6985889170632889, 0.2765070225142305, -0.6763168486696526, 0.237130558942785, 0.6852017395260466, 1.4124227945054781, 0.33081988118638095, 0.792108379757169, 0.21411743445834827, 0.2559841098995496, 1.1166738449468128, 0.16561031356815167, 0.38918926476446997},
    {0.9437657237615394, 0.08767192117755551, -0.18945038440111, -0.4239722521172262, -0.6914195812506447, -0.5744622777959304, 0.25869513518345777, 1.3459575443888177, -0.48946536300525284, -0.21017340081508792, -1.008470918471335, 1.3387134894255242, -0.6377741645354732, 1.782261853578808, 0.762136544270622, 0.05684623713014515, 0.10611232682201865, -0.07291027415213885, 0.7902471169138339, -0.32906686022357323, -0.022781522803153546, -1.3579030550650009, -1.1219145415021063, 0.26160950775647196, -0.4183559817262857, 0.20697575629192402, 1.0955585921251787, -0.604566007200833, 1.2096724080733752, 0.6990602512726432, -0.17292032359194032, 0.7044425792805288},
    {-0.473654550194271, -0.7363097602484773, -0.21164237610962247, -1.5845303184029467, -1.4433207972648492, -0.78009176770856, -0.8297494366741348, 0.7879393128541218, -0.851482096829991, -1.3634279146834358, -0.701596959794891, -1.0310145414870482, -0.49688497371319773, -0.4803120677190453, 0.49931075802237207, 0.3551756706222476, -0.04289095549706272, -1.2864084692931184, -0.6196490296413871, -0.5868614111368122, 0.4931892461397463, -0.8283771131935777, -1.7462015905639872, -1.0295232622009887, -1.7064957277177635, -0.4455892505132088, -0.36124152494850853, -0.660381226794073, -0.6610748277664584, -0.3763265552349399, 0.16576508775526705, 0.01850046298801193},
    {-0.3811915627834404, -1.0094221468686506, 0.8574725252145151, -1.3736039442349046, -0.5063748647659865, -0.20961534412652782, -1.77370947112983, -0.0963907091899151, -0.12969836326444117, -0.31205813106811936, -0.34038086372495496, -2.392872911088722, -0.20074034448483713, -0.6106061363421261, -0.7666299895237781, 0.28100670585585696, -0.6946946166194529, 0.014928128010669344, -0.38981715552187274, 0.3713216903453755, 0.023072334043352377, -1.0423027322372327, -0.8069673598731733, 0.5646786482354736, -0.7538402389241612, -0.7240306147244456, 0.5336101935242211, -0.010388384836791373, -0.6642076047283085, -1.141274351094077, 0.025308103718203908, -0.9269167528686407},
    {-0.13758277408185074, -0.47939645691579913, 0.6937872117758843, -1.0262748948536742, -1.179553147000977, 0.5077485990860927, -0.25684760987679317, 0.02976285586590433, -0.5696259090144455, 0.083046261991927, 0.045866981355343395, -1.6228957805897444, -0.2714774031845437, -0.5046060134543471, -0.6511884903605166, 0.0555067116789181, -0.32170385540493457, 0.9196751135608391, 1.010946944502773, 1.0797490450804657, -0.29133450100539793, -0.8287511065051931, 0.8944740126334195, 0.6083036379524077, 0.12394235479509268, 0.3726083694943959, -0.7845886875823959, 0.6445741520505774, 0.354126280341037, 0.6085103013852047, -0.17878858167197334, -0.8775869543049409},
    {-1.4245164999704156, 0.49942074199364794, -0.7337458842415634, -1.3307685543443375, -1.5272557371992024, 1.5097298578730527, 0.8644194605046122, 0.4395195874463737, -1.06443506683561, -1.2340852338615944, -0.12823651456268703, -2.0671058891867484, -0.6916743227557478, -0.9266222369764967, 1.174084275216092, -0.33740127433981304, 0.41224191543795696, -0.08794450074573952, 0.10554787184472647, -0.3482161280844661, -0.6879026945348778, -0.37519855072549024, -0.06423419037595991, -1.1296878582970338, -0.9391842469360474, 0.9781683951425527, -1.4026583320953452, -0.12789933467210296, -0.6425691013491249, 1.0028747081622913, -0.9789163510686061, -0.812665628074598},
    {-1.0996678575125294, 1.1305604013998714, -1.0962550296981537, 1.1874347167853108, 0.8113216987435301, 1.231414063606037, 0.3746864062570611, -0.2599468132417652, -0.9887185482466953, -0.4829633825519772, 0.9205578654415819, 0.33422211071381247, 0.3066769149557479, 0.5724042255716025, 0.8023661894673997, 0.41504661873162807, 1.0053842040773828, 0.33104470102451133, -0.15304573048894005, -0.4152110329496079, -0.13189262754382866, 0.6706605572810452, 0.09373168966184693, -0.5728504786578277, 0.9577748027367827, -0.15313084522380663, 1.1182512010508825, -0.27833369446645195, 0.3889922205168837, 0.09033526268137335, 0.6013835075289653, -0.4804693728277059},
    {0.0966522129269552, 0.34804253818082975, 0.01759636399485682, 1.1983433656008204, 0.8150236886898372, -0.5524846251127354, -0.9249083854533445, -1.7224346243904853, -0.4568076095690916, -0.027904677183462966, -0.36928636498073153, 1.0788509551791954, 0.2154701578898524, 0.35046756461888245, -1.135216382085996, -1.1445062653470268, -0.37410172396264535, -0.03621754617962819, -0.48252960674989553, -0.5114224153659779, -0.8393127563851652, 0.461719096206154, 0.6355894412994033, 0.09938352739435515, 0.2169082080692074, -0.7581133147801417, 0.5701064250429925, -0.6683850922020667, -0.1834643261279982, -0.3259743532828681, -0.2799783860824206, -1.3336551511789725},
    {0.543790362129722, -0.5874100786651897, 1.1623641626044805, 0.336051842942726, -0.14862068184836533, -1.28687771235317, -0.5307424401693843, 1.1298289051207775, 2.1990163833285377, -0.48580476393503497, 0.02624683931209047, 0.9880128010629877, -0.322735965939759, 0.06898698470113088, 0.15835617197124705, 0.0006754558912824781, -0.5682219101388779, -0.01388522950317324, 0.6122517540391815, -0.37190219869685837, -0.18034001260093416, -0.13192741511255346, 0.7977202156786123, 0.5457354342917048, 0.24849273307232686, -0.8505052287522691, 0.7717892567479017, -0.11872737523983609, -0.29389287299871447, -0.11864421221274664, 0.08735201261919498, 0.5554099759398646},
    {-0.4765717198393464, -0.4750631543950467, -0.3098304931394338, 0.12991503512038155, -0.45702173087722975, -0.3586010187747911, 0.8859383502117605, 0.18007212049461885, 0.2636045222092577, -0.18824057342813727, -0.08928256391961209, 0.09614029635555496, 0.9082363215030119, -1.2981045455238651, 0.7233853059395278, -0.36392663127015384, 0.048548357015958894, 0.617030819364607, -0.5649478350722505, -0.11733216049987034, 1.0717080135184267, 1.5900988728380472, -0.23805049642830567, -1.0301714701119067, -0.9280190942875981, 0.7839141257617869, -0.3515661989941066, -0.8456795284960531, -0.6353688328789215, 0.5389560401499267, 0.47944112151761353, 0.024365641268019857},
    {-1.0115660016291435, 0.13673387599009607, -1.3556078303553212, -0.6091511007562983, -0.29502981582446497, 0.4793298051319175, 1.2175292530295503, -1.2559759945101576, 0.4477567274006849, 0.9210022261798525, -0.5499021161559838, -0.6535253429712584, -0.5530487816529904, -0.2418163039509809, 0.30516402916048874, -0.00043564862203118585, 1.1220018912539163, 0.6240580285245954, 0.03410103272225456, 0.9399266075908803, 1.3318345146293777, 0.8109733293685154, -0.2806890233039125, -0.10374713832832885, -1.3522672020544353, 1.1742759620078886, 0.4534986155319681, -0.4541843579942526, -0.7864139507068616, 1.4597143635618093, -0.7158367878891523, 0.40411344389276926},
    {-0.617099511146732, 0.634131278377965, -0.14326265008498965, 1.2482261219889574, 1.5044494218012738, 0.6987665037730404, 0.5837527303209983, -0.19689958322401732, -0.44343767065123174, 0.6361654038192087, 1.0810833952744168, 1.7166097806131442, 0.7393728196843833, 1.1835328303117696, -0.6959844053969998, 0.10511074398887878, 0.7612077502024271, 0.825075355794638, -0.5424381986446222, 0.5094588872773091, 0.25574869768228203, -0.24562861228843064, 1.5120690619636774, 0.8268977703838288, 1.6726123667311514, 0.5768772861452383, 1.5845860005092363, 1.2526621201862596, -1.131451935689838, 0.5368030897056318, 0.14561470045241104, 0.24653125013850957},
    {0.7380266843753627, -0.7148211233595229, -0.10333746010991474, -0.1494830664272777, -0.15864018370450272, -0.4797561322966254, -1.2965328319003457, -0.03995591082514564, -1.1020672396042759, 0.7704371204792206, -0.48207790342519474, 0.7398669504722467, 0.08559523403041899, -0.44125203230946985, 0.08043920913318552, -0.282067140278945, -1.698049505753739, -0.220089726827299, 0.025867756485887333, -0.5671427937975025, -0.6809689107473124, -0.6342048608528644, 0.09033768826382091, 0.9813679703490912, 1.0530050508241144, -0.9686050898681638, -0.8745128833759842, 0.10358624805155228, 0.7382564879703387, -0.8632439455920903, -0.49051343995235697, -0.09847552050059877},
    {0.8021540487984576, 0.10605342618738739, 0.4558960964201175, 0.10827628007740507, 0.23354714546436592, 0.48680684914278266, -0.31651701933030807, -0.9221806439307366, 0.6476673255922104, 0.9729655115752052, 0.33938453865083174, 0.17986129085123193, 0.016001474869880742, 0.9183099716228775, -0.3981657272939017, 1.0370887463436536, -0.37105152830679805, 1.0734805595875534, -0.25399600278753093, 0.49216222735461307, -0.07316277469999825, 0.17246588879332064, -0.39122467328249155, 0.6970913674606235, 0.7845264115818001, -0.2558199758688096, -0.10404510086344053, 0.31939972189006555, 1.4615073045296283, 0.479458954132513, -0.8382617605260736, 0.287567160336054},
    {1.0772481137056702, -0.4133466209196722, 0.9887533393632865, 0.2655627687013127, 1.090317106729398, -0.2939833482153098, -0.7867721623057502, 0.18213931010400622, 1.5248463356110233, 0.007610887099188884, 0.20645097422055428, 0.2567716215103316, 0.10089613152094219, -0.03214235652453217, 0.17795502668586502, 0.6587231691155616, -0.8075132164495509, -0.35097377807652225, 0.19684443309786726, -0.42688899786690354, -0.36145140103669704, 0.06853667927968349, 0.6762671282444955, 0.8905634828784211, 1.014900549180117, -0.8973104913131229, -0.11568015815025863, 0.7447426794260568, 1.200001507301493, -0.768413682327381, 0.5169137952384077, 1.148417105431303},
    {0.546927614381258, -1.1958198866812206, -0.32329225682082746, -0.9316858524883977, -0.5760936471280765, -0.6511648909928678, -0.6801711922294413, 0.5021186997851447, 0.492528831324149, -0.9807776052925564, -1.4726103871360658, -0.839499647694432, -1.1372922277156392, -0.33748299507321966, -0.4740099218016521, -0.09571718885202193, 0.31372742945426185, -0.9502915747783699, -0.019773353847151842, -0.703833918578481, -0.10087378547191105, -0.7152723624995078, 0.45082651531549744, -0.4765366275942164, -0.5430215423887769, -1.14573803539548, 0.38966748752646135, 0.06068643617159783, -1.2787666053322282, -0.37606530466940624, -0.30262700770618767, 0.19925099907161492},
    {0.5984909616653863, -0.0038813616551667506, -0.5476262330948692, -0.3970689322442211, -0.42075327535342655, -0.6509188656251248, 0.97836842100812, 0.9063442198484355, -0.14913243688786343, -0.7990064222047021, 0.43646728673200574, -1.401357803149581, 0.4814807170272227, -0.19509643198554427, -0.12047779855516809, 0.08723846492390157, 1.134030859900972, -0.695657712652193, 0.3596992872579452, 0.359991066190975, 0.7865195597401003, 0.5254867651236145, 0.2181911901425353, -0.4375440235778572, 0.008301459247088616, 0.7709584361621981, -0.4877861092537616, -0.15366400485431028, -0.32100653207675506, 0.405385617409443, -0.20930050559261826, 0.9178869239723394},
    {0.6678874092760202, 0.6365895594906892, -0.7754005386473366, 1.0364177009218416, 1.2853585421023583, 0.24438921527700974, 0.5481614077958062, 0.513755646934855, -0.5209292836037622, 0.8439432731686262, 0.8750205554508043, 0.7821773986119676, 0.7878363680697207, 0.23426250258223175, -0.19467244268003908, -1.1301858352611587, -0.30200311481037356, -0.19391611675356116, 0.839064795028193, 1.2154084932134983, 0.011523827365777756, 0.28436756729667517, 0.32291008283052447, 0.31209532677586643, -0.27887163995728087, -0.6471459141632753, -1.0581166729189584, -0.12020855042855123, 0.8929719680864059, -0.42391641245030165, 0.36606526136560463, -0.11886321072944786},
    {-1.5058041389434338, 0.32814281423063957, -0.8408880507862414, 0.9816722178865569, 0.911542357586544, 0.3274598029727348, 0.2472239674503358, -0.9535309653760883, -0.8812391583524447, -0.6016474207401532, 0.8020285687694807, 0.6958325224462936, 0.34353874249101723, -0.18835487253461838, 0.693262931634523, -1.3889787241784883, 0.2464236830225793, 0.013160439636874462, 0.06700124393711314, -0.07911735289089097, 0.15533898363197265, 0.12462385178934307, -0.07148175853586047, -0.45053412479333826, 0.03797593703761768, -0.4220834838019311, -1.4382974769459531, -0.8340554136440901, -0.14748406711545908, -0.9469181562238023, 0.38700213866539085, -0.16818508145130037},
    {-0.3347510178134405, -0.9102441401139973, 0.03441117981787645, 2.9218503263682996e-05, -0.5595323491697268, -0.1284502487490752, 0.003294037776835773, -0.9831185768934805, -0.42763908791395183, -0.3009994768053496, -0.7334639623063325, 0.1339614756273113, -0.6602913202306668, -0.545802152761259, -0.4136224987425348, -1.019061854513215, -0.5826830261422872, -0.3396295180496191, 0.5280882525226075, -0.7750932529769882, -0.58035786796151, -0.1196847052256829, -0.18598891680782453, -0.3458589222038955, -0.10221855980223767, -0.5527705543265223, -2.4347766766101038, -0.42580240188917845, 0.8881160341057222, -0.6274339447065821, -0.9130914506984956, -1.0390895534247928},
    {0.26563035647440436, -1.5672737164348733, 0.9813388933047527, -0.8816916943689943, -0.018977511287265606, -0.781327192267023, -0.03298212885361978, 0.9006344970925202, 1.5535129557332432, 1.3283855477066597, -1.0077543869061605, 0.03507278016437425, -1.9814876281075806, 0.0027521254358556244, 1.0246165907728706, -0.43085039146882265, -0.0002813687620049119, -0.8202753707544468, 0.07314072133262585, 0.2088706002013556, -0.6577288239644963, -0.4334723304295138, 0.17662789588501396, 0.7480776880365464, -1.0755247656217548, -0.34906211692915107, 0.6872310960021453, 1.0622129859644085, 0.7937642882986137, -0.13095413894820396, -1.3579080047902068, 0.6870218068793599},
    {0.08092131528831127, -0.7876063016708131, 0.1965045434230346, -0.9216722862572475, 0.36396572746076394, -0.33155235866039023, -1.1599703369922376, 0.09677418522961721, 0.5218244996391388, -0.3569129862448825, -0.22559096645057916, -0.135742036824599, -0.4896240256855033, -0.4917846247703731, 0.7311862676318668, 0.17103646339964468, -1.4884924653738605, -0.3929213612636762, -1.1802756852593663, -0.7144304763524492, -1.1553172666329272, -1.8877933220522012, 0.48984529773475827, -0.30761802482458406, -1.8309923527455214, -0.29159273549611525, 0.4221820022175471, -0.8413115350493603, -1.0636722082292658, -1.138397016327993, -0.5966354294741351, 0.41553223250543075},
    {-0.3474881240776901, 0.9120841259558595, 0.17019831994016177, 0.8727390715537898, 0.36080646466077687, 0.5944995479011598, 0.3440559723450887, -0.4729299567966742, -0.5412277138446461, 0.882013482104893, 1.0483264423167893, 0.6720973998227427, 0.7445367256580734, -0.30006129529185943, -0.7925058457346665, 0.8398565802323129, -0.4072161509115516, 0.3283722361097181, -0.2264488012005498, -0.5153096558623667, 0.29113449114960877, -0.00906400056227672, 0.6041161956403407, -0.13644572564439333, 1.6205470278600234, 0.09896865316493159, -0.051128224686251465, 0.3414540539967838, 0.7719054137566053, -0.3343773885223067, 0.9906940732967585, -0.5546503325531628},
    {0.4028276217432258, 0.41645448481620095, -0.911382386922197, -0.1233525835757823, 0.4687940047717919, -0.5419920666410499, -0.8427237899704364, 0.2615726062593392, -0.543020321181697, -1.103246571402374, -0.018671414684185653, -0.5430905492849302, -0.3586010189614949, 0.541983908742835, 0.9686308207397192, -0.7035411244927716, -0.15038814525677044, -0.8526476576385638, -0.14136179739549137, 0.053779318661014305, -0.07667371998820746, 0.4473721542867552, -0.59591288312306, -0.35180979570319526, 0.10498123882383684, -0.6239811989383814, 0.09423412410452155, -0.7587292623810791, -1.1043377230442255, -0.5165788045717051, 0.09087061463391531, 0.5308508105659783},
    {0.7317905325214671, 0.1970984284043191, 0.18663459763839932, 0.032819835700756486, 0.031710679477163134, 0.07048663162697141, -0.8850533565230579, 0.45350124130991437, 0.295521625506427, -0.8538529257655446, -0.09625529202719443, -0.034182279260614665, -0.07761910861770914, 1.5418061132284, -0.6921887537803969, -0.26953089612209374, 0.3284441763174842, 0.391257174835199, -1.1363910353829438, -0.2310450926266229, -0.3952775732337737, 0.30181985430846126, 0.5442061015521764, 0.9249793235459448, 0.05163693667868353, -0.4446573700228726, -0.28966547331320164, 0.15259005745808696, 1.227731184210767, 0.4004118813913407, -0.8258843537844719, -0.276966702677062},
    {3.920662107611945, -6.157105524710207, 2.796970925745076, -2.4901475309139083, -0.16977739500718694, -5.8495528475368355, -6.551493627012809, 4.031282192392629, 3.7880585809549445, 2.114442687264309, 1.3461633390727297, 1.2374416206152976, -4.482335923848334, 2.844217954056238, 2.7349383958883187, 3.4640284140139057, -6.160600047995065, -5.372484228577703, -2.6892991060153, -4.816516749631783, -6.06748851675943, -5.188592316666166, 1.6275729463470057, 2.5223575571529278, -3.875454585169545, -5.962095052555789, 1.2038180109828323, 1.9731662744111027, 3.031408520593422, -6.526964739780952, -3.4376342590525097, 3.681948244246736},
    {4.992915333989655, -6.431881355334519, 4.086832023264279, 0.10426970945122749, 1.6855730062154315, -5.2255354576174, -6.121216669526246, 4.981363570330123, 4.581515406841104, 2.6944563654974676, 2.6286176094801887, 2.94467220222944, -4.386696744155356, 3.5825895531328964, 4.156318971018899, 4.548987714369388, -6.160734635413041, -5.836044966967234, -2.3480980353488086, -5.887457824516326, -5.993958246662917, -3.93302633526142, 2.5615254459556014, 3.2495246590085443, -2.1791661813805643, -6.316530264837897, 1.4580399293504673, 3.075549907560791, 3.511081152066255, -6.512876969541094, -0.5318788800245012, 4.634477068674979},
    {2.2700106546465197, -3.997819996299808, 1.434018138796672, -3.782768299071008, -3.0176597644625183, -3.5179428913054065, -2.8174245706874332, 2.5520096691427296, 1.9592331972814918, -0.2140527212877797, -1.8052519474202242, -2.479316875470127, -3.6205255071559987, 2.076712710640646, 3.1142058650119364, 1.9504421144168862, -3.5829536398838018, -3.0631857679518473, -1.4009140788343535, -1.5253358510939774, -3.4901867717990194, -4.067363809125132, -2.062280953461809, -0.06546353703657051, -3.405320813731451, -2.7358364936029544, 0.6605916484189669, -0.6396734918770512, 1.6316124251297524, -2.9060548555345336, -3.2371039112709004, 2.6723159905605502},
    {1.347985228688948, -2.431904578555419, 0.9368015309415721, -2.8453091664451184, -2.270236605458057, -2.5724753244303313, -2.2374521376791425, 1.2107066479262323, 1.9597924768038, 0.3402602155525869, -1.890564791891143, -2.3844429990232787, -2.557451511014756, 1.354909197645323, 2.975015909929363, 0.8578407981668548, -1.6222701761513043, -1.5650736575871829, -1.895964431517795, 0.13291203461590165, -2.7807936690360515, -3.45965352880458, -1.3242509428884162, -0.45909351253832004, -4.129305424945258, -2.1673362367100077, 0.051339045638845365, -1.2877546885518585, 1.2497078377948474, -2.533653917128886, -3.8252317114497965, 1.238579975009423},
    {1.3851256178322306, -2.7201835402066705, 1.9448716335673673, -2.43664601895743, -2.1705161849566976, -1.9965924806253896, -1.6244075865869776, 2.453112353159406, 2.7507449562002524, 1.4416741459164448, -1.2083549407160072, -0.6049513668114425, -2.959586133767397, 1.2986399749797353, 2.1582147962925693, 2.979560841480456, -1.9257044204948452, -2.0264216353776288, -2.0785679811587014, -0.3821673983693497, -2.2390918002118534, -2.760334230469167, -1.8383930573207476, 0.1153838196442566, -2.5897590599326445, -2.3721536972015014, 1.593695912023364, 0.03421925222662083, 1.097269159427275, -2.159372350646849, -2.183143232594143, 2.211282323336829},
    {2.9188159228220387, -2.8173081468051575, 1.2730061719253187, -2.3861524364586058, -1.201606555712554, -2.739886217114755, -2.052735314794396, 2.3408404108561536, 3.2775772502503084, -0.4722341269357988, 0.297407344752954, 0.26666086695933294, -2.362210982125073, 1.9967851451390928, 2.841398154781037, 1.8757793151230369, -0.5889388833743554, -2.7143731867746785, -1.3950326420594374, -0.8816380699391233, -2.003486815705524, -3.5737300211809324, -0.4050316327061571, 0.17337201234514166, -3.899442091662613, -1.9761681819284274, -2.0217403974639137, -0.21962954552822078, 1.6141428131182884, -2.73051374863875, -3.295712352840997, 3.421469214828749},
    {2.04944440966172, -2.216473983629061, 2.1513210083244503, -2.1407585016168587, -1.1014964623522732, -1.1433341177992176, -2.21182444017115, 1.363644893145625, 1.5367640253904309, 0.3770748077977564, -1.6775334044096366, -1.1562837150975638, -0.6691910730188256, 2.034661852648247, 0.744164606523397, 0.2587212631590705, -2.0512324967292246, -0.9422339346584031, -1.8108082609642215, -1.4025881060175345, -0.896772282989508, -1.6114265413061724, -1.7425574010636975, 0.0017741574810470327, -2.234832235826796, -1.622929455140645, -1.4003277446059454, 0.03841984159485641, 2.110705035820706, -1.0402454096007232, -1.6262564765831982, -0.8734009069006209},
    {1.1014791037134175, -1.5472840138986674, 1.7342306236343465, -0.8828382837895361, -1.9285122005325797, -2.024871506089336, -1.8018943017414257, 1.0332456037529714, 1.6942457640569553, 0.604965620845617, 0.014143058505849663, -1.1594079071473404, -0.9041070089619929, 0.776771700463817, -0.39207775450806726, 0.11948084327807276, -2.0157819784932096, -0.5550706098236389, -2.7123674660808508, -2.4877449664578934, -1.8110842268899843, -1.071085868866912, -0.45464764375540756, 1.2540710518724052, -1.7803259187839953, -2.183757368860321, -1.3374898771985944, 0.19173785399799015, 1.6189182724859252, -1.3638474855801301, -1.090019835583707, -0.8160707454830421},
    {4.035177581379509, -3.5938333492594774, 2.399960333917989, 1.0258017946464424, -0.3619036008828897, -3.508533681938101, -2.932202281151993, 3.3205830753623244, 3.544906606881514, 0.32268793171373666, 1.2747323083545348, 1.2811417367632734, -0.7360449373724777, 1.9207440646460725, 0.7723377496284854, 3.0236233721842205, -3.071039354699518, -2.4754985714326323, -2.8766395523904693, -4.003600113749115, -1.6468380260908693, -1.5014062326697564, 1.2602959000903322, 2.6308341553186083, -2.412074769144773, -4.212658865297468, -0.6830341833699524, 1.6067774548793934, 3.0657620636930587, -2.8991326916288154, 0.9045538290907345, 2.4016270483563646},
    {2.1969031179325147, -1.4175529390411619, 0.215515310443361, -0.355338283379762, -0.34205317384538864, -1.5083661400561135, -0.7328839834047289, 2.0605256256254907, 1.907336324443423, -1.4884129439533014, 0.7540398974772949, 0.29058584864211134, -1.2086687792625077, 1.1634954953951844, 1.0383598319926859, 1.1489826032686774, -0.41215772657764377, -0.8284947047069362, 0.3443357804562922, -0.12585929924456632, -0.16084972564092317, -0.7260087096578265, 0.5576889359989678, 0.9635245531554114, -2.1593371278186018, -1.1713932270707115, -0.4791979388225119, 0.011299976599125544, 0.02891183854406062, -1.8025379126521597, -0.18501681851045337, 1.4271091827910436},
    {2.1817248155611813, -0.5909195018424763, 0.824606605475349, 0.11313051913174067, -0.7411483955372927, -0.36391225245817355, -0.5400600630721505, 0.8888499776904027, 2.1859641868184703, 0.28318530166901673, 0.51188144130088, 0.10173171408370221, -0.967557447797761, 0.7389336019121794, 2.4956958529586926, 0.8865718436210273, -0.024935741634592775, -0.20236146666750507, -1.0406384900879095, -1.2273972796073649, -0.9606471975215862, -0.18203641769624876, 1.5083767056184418, 0.24947374049776336, -0.3862491113564215, 0.2602292844611272, 1.0609665778120443, 1.0324690928528801, -0.16526099111032433, -0.6944351605832483, -0.9145820094108145, 1.749103072479605},
    {1.620416583375938, 0.05820438027506798, 0.5530434809289704, 0.6405895873247737, 1.573014415790728, -2.6553023119560226, -0.08647479537190716, 1.3777982510764726, 0.6232235367475365, 0.9611336640263163, 0.9669123075885976, 0.7788149208432366, -0.483227729152499, 1.0752843739366833, 1.7242350998223441, 1.0229426559365005, -0.6351713192270056, 0.0027105981254717314, -0.13450509131601066, -0.752580010393659, -0.7532846186102324, -0.8869044882612679, 1.4368098016136, 1.5838484294718311, 0.4449418898925472, -1.0774156652320352, 1.6979018409299134, 1.566505901337248, -0.3898563275865296, -0.8781124872835021, -1.2740676811066671, 1.2193040694240436},
    {1.6767316019475857, -1.2159209512341689, 1.8420964522119092, -0.8690424457291523, -0.4741353722588855, -1.3519746668017232, -1.6099052336507846, 2.038449723128886, 2.2107400419663987, -0.0006658305565453851, -0.6420238087288977, -1.1250432262521397, -0.5508248177621723, -0.11028589040767459, 1.7067378053359479, 1.060187227446319, -1.9418808603650963, -0.5752978948879229, -2.5280639486369405, -2.712735498334545, -0.9708261009212583, 0.45313991226208467, -0.5587403490773715, 1.0590578989882027, -0.9029098608800713, -1.631250270036585, -2.4534989672573655, 1.2593728404593143, 1.051211446972756, -1.6790751192455118, -0.19687082643550996, 1.6380128439274058},
    {0.1631423734200022, -1.7082031689644837, 0.10942530248089306, -0.7097034040422354, -0.38304901417084963, -1.7888844593763762, -2.3223683112056634, -0.7141624842897458, -1.5333293817387172, -1.0396414174501092, -1.700721627725405, -0.004119547477779788, -1.7493361417004591, 0.3225741485987168, -0.4030976448354637, 0.3254296068553162, -0.9863146997650489, -1.62333769209488, -1.1498243238171797, -0.578272318331359, -1.0478453872274704, -1.8034934089669528, -0.5314118001236665, -0.431208098666744, -1.3302477071783705, -1.275761010808907, 0.18515976460559544, -0.191636033515078, -0.22083851132515167, -1.7835491469803424, -0.5018446820684276, -0.6044033799508669},
    {1.0988653281123169, -2.0798924599316546, -0.34064194898753614, 0.36482550596468183, 0.17009339495539028, -1.0455354945366642, -1.3874559345062325, -0.3635982671996908, 0.744940614232872, -0.021513854035410503, 0.30568128756455376, 1.823479444764343, -1.8019206356703559, -0.2049673153735053, 0.39124064070293807, -0.4892012440309078, -0.8845082391680674, -0.6001608390515837, -0.6090495863471121, 0.02477453521521343, -0.8982061897988224, 0.22663962148438344, 0.33696634292041494, 1.1514178178103385, -0.5421999397514792, -0.8708717530443919, 1.2759755023859793, 0.5682507066227894, -0.882357620092484, -0.9923159432910822, -0.19492845165833128, 2.066312483623957},
    {2.034829908924869, -1.5502647789666968, 0.9104386424095002, 0.39997189503089625, 0.6641902862047507, -1.7144238105466227, -2.418854277209551, 1.5192409611254785, 1.4247243218343297, 0.7112116557411198, 0.6454758707681684, 2.7225690704459025, -0.3874317492873435, 0.9338755348521284, 1.5739185714694761, 1.4687446866891996, -1.4867111636044286, -1.0935584872702362, -1.7995076024121683, -2.7730273592657833, -0.6717002637790277, -0.37297598067214904, 0.7722770532441358, 1.277258979307722, -0.046082811156863475, -2.2551222721507598, 0.3465696899672722, 1.4031257269728883, 0.8285333308264369, -1.8285157300070596, 0.9873780494985734, 2.349170563654319},
    {1.442748477235202, -2.23126091414609, -0.004774294868846117, 0.05832971670438774, 0.37424829216789884, -1.2560788321879044, -0.6734872739296379, 1.1305599790102672, 0.4704746645856878, -0.750470097311698, -0.2232350216093956, 1.4450700997957298, -1.5980196519371872, 0.6110808074935608, 1.508529336983033, 0.25028066325542575, -1.4735734529113569, -1.3517843269276117, 0.5774935913427339, -1.2115230130903867, -1.7150070407547924, -0.011539134201762512, 0.9113378116302772, -0.20048223275004098, -0.4827471790330084, -1.7099440841842473, 0.859085479124785, 0.04745036178620225, -0.5350064487257749, -1.2200321765614361, 0.27845554170984804, 1.7753671903713586},
    {1.116023246906216, -2.495486341571507, -0.9074318509813142, -0.6252922546945681, -0.4725085603284235, -0.3713131756311439, -0.8215334381380355, -0.602921988520334, 0.2278865516692756, 0.26453506346218875, -1.5017467882774975, 0.06990132493103027, -1.0225287315261689, 0.1318186876438929, 0.5814670187029994, -1.9734189729313918, -0.07929164007208352, -0.3853245497958165, 0.8316135651390957, 1.323866213282997, -0.8452369427077562, -1.0136036287004726, -0.6383773662836658, 0.16904535954654515, -2.476477609627213, -1.1908845003550288, 2.130797693757678, -0.25492415248910383, -0.8359710954888341, -0.975309298677942, -0.08787820467045199, 1.7974718829823624},
    {2.268110945792688, -1.348290527942542, -0.07009916566228318, -1.382889736386806, -1.2798300817043522, -1.1486247537490186, -0.29998632822586474, 0.18365383652471826, -0.034476856390782774, -1.3024658965812246, -1.108605963230408, 0.7449675916603814, -1.659350643768668, 0.77639723842269, 1.5898443512434688, -1.0158920551596387, 0.6470281340088625, -3.885159427491629e-05, 1.1090094840257125, -0.2892270634994465, -1.135199361398487, -1.0208427629490426, -1.3790387204486396, -0.6782065739393806, -1.2287609567583149, -0.9682989988659824, -2.228361059098659, -0.7106680624758089, 0.8641135305597768, -0.6903880188028757, -0.7929984210198824, 2.7585653696233527},
    {0.8888656376314348, -0.3378968658491116, -1.4464497446504754, -0.7087055409025916, 0.17176872377153313, -0.9756561851714896, -1.1031845755608072, 1.403064749773026, 0.4125676004119219, -1.4226087650984913, -2.0065289373532824, -0.5538174099042891, -2.093393408036798, -1.3090921282697316, 2.568045121126019, 0.27027755971681966, 0.6198517088826543, -1.6087136058025577, 1.2478099036655004, -0.5654467844204853, -1.805378836029495, -0.11725586494228021, -0.8362425773812432, -0.435164161700549, -0.567251843316096, -0.9431750351941973, -0.879466833004747, -0.10523608557202621, -0.024288284166648896, -1.2351447591614793, -2.0915275340178896, 2.2869955954141274},
    {0.7093377318687996, -0.022887707658731674, -0.7649961562860639, -0.3980740494092237, -0.462803676876348, 0.13454825562314904, -0.5789150171415424, -0.3859133468760485, -0.016258243532163406, 0.37630179053253626, -1.6456176427890314, -0.8359546342220823, -0.11711070129686249, -0.5605843438135764, 1.4743277615048958, 0.7653158094647831, 0.11111414003515853, 0.36223945322520595, -1.9613871741435729, 1.1515003112107214, -0.5251200495862995, -0.5955738883649867, -1.0235010134671598, -1.2705352646036712, -0.725931783274048, -0.20285200597330383, 0.8249771956729864, -0.4821117306717889, -1.4743079623953035, -0.42123308826379263, -1.699660971377185, 0.3667465394617664},
    {2.6959172551460435, -1.3341164704492325, -0.08744096254970318, 0.892406026662547, 0.18334430035359328, -1.138220661670266, 0.18719090630895016, 1.894483947624167, 0.46292187007333646, 0.29289015787813605, 1.3609088193019754, 1.8075553153411077, -0.6917031061391837, 0.6134675728670406, 2.3306745793393286, 1.3279044051162856, 0.7270740093701302, 0.25149023927974895, 2.2126510457767967, 1.5005940461861806, -0.968661547834435, -0.37456439653325335, 1.5885593103561342, 0.4456052222365351, 0.4568756455402875, -0.20087312842794694, -1.3572013305908195, 1.0463211824601477, 0.017673735757952128, -1.0849778872239415, -0.393288209114149, 3.1204906453155052},
    {1.9285193477050466, -0.9553310085556757, 1.8467517324741434, -1.0592034093306577, -0.6596065363754425, 0.7957061324286521, -1.1673077758289407, 1.274642996159737, 1.3938412185829152, -0.6217137975325119, -1.2178182445012753, -0.03384994985760338, -0.8335565905226977, 1.2150933530372183, 0.5570023819846541, -0.40574945199084594, -0.18613013645433174, -0.06920752921452292, -0.18644600573172573, -0.5861887756684908, -1.3570806548506456, -0.11291818228735398, 0.16689832587492756, -0.4086700401542585, -0.6065991462440332, -0.3321129731701371, -0.23562858287854854, -1.004167517781422, 0.574315721050362, -0.16104966417961905, -0.3946279479255632, 1.2309196478162936},
    {2.8464939910388423, -0.5914965703402459, 0.439495362321252, 0.9118945677190265, 0.15315789564442786, -0.9980811536595374, -0.7096488845169013, 0.5002098213483986, 1.3086352162743689, 0.08358048178483815, -0.45153334218154006, 1.1964321900892685, -1.4978060718685424, 1.1578842755104484, 0.2997138978105215, 0.4932248445780245, -0.8821410808410295, -0.18289917718303644, -0.2198097696107583, -1.0265704426650262, -1.0221065812318337, -0.7223641014048107, -0.3450305071410583, 1.0414485728832534, -0.2383502589534329, -0.33032642784285127, 0.8264409954581351, 0.8207509857405182, -0.9654681487951552, 0.07236448224411923, -0.06958599880907824, 0.810002558441826},
    {0.6694562759749629, -1.2711678074432546, 0.5502539712518077, -0.5506466148618133, -0.08170249198264352, -1.8844437370088718, -1.4154041288750416, 0.7584524490610375, -0.5832540877070291, -0.7888056902739541, 0.353909336065066, -0.8553831697221213, -0.9558985498868842, 0.5543199841688415, -0.32940618920521897, 0.15554524057503907, -2.2103217403176774, -1.3332625555673854, -0.6846196955760999, -2.327040526026989, -0.9247011874857034, -1.024328208714397, 0.23638247282299238, 0.2974538913324222, -0.6661862841871773, -0.5290412146283691, -2.635410649225474, 0.6063956887851953, 0.31769080973934005, -0.8821571185103708, -0.3846969938327241, -0.9740087139311474},
    {0.9312464988839981, -0.712664558929256, 0.3235391107233335, -1.3358176122882255, -1.469157375420366, -1.5160802195660095, -1.6918586728061011, 1.2542076177399393, 0.859322765458905, -0.46832594492171103, -1.326299655537634, -0.33325587715387456, -0.9165522401887742, -0.1443504235232325, 2.1672481796290812, -0.0102979524484087, -0.22593610125620947, 0.6594364063094381, 0.41137366195489, 0.2823779765104265, -1.1951804422922383, -1.7056547212229605, -0.20547513821080263, 0.6831046933411155, -0.62005813280076, -1.5353625683263294, -1.4651282745627245, 0.2065662054965907, 1.4624937072783377, -1.2187782091453991, -1.3387322650144675, 2.1284374643621873},
    {1.287587660846759, -3.1998822798817743, 1.2117231359387548, -0.19297343880114987, -0.24946366606831993, -0.7573727536676123, -1.602452413999956, 1.8380086821282855, 1.733215208168973, -0.054198866630329016, 1.1819025167812192, -0.148717904813577, -1.5655928442905984, -0.3133476317229733, 1.1067348462889512, 0.2893491222473218, -1.641576966599142, -1.3531591862361603, -0.3733200271439245, -1.9745536416738436, -1.6920540681849567, -2.3015702209619717, 1.125859374479777, 0.26423005535203836, -1.883219310043985, -1.7685725929923373, 1.4097063061249318, 1.0452184086349616, 0.0807231832124029, -2.3997428163312393, -0.08935154500017206, 1.1044691828614919},
    {1.5327803719949875, -2.0439900868551795, 1.2293010391155972, 0.9904207150664601, 0.8854661637121732, -1.0363641267804014, -2.220934191581583, -0.37118173375586927, 1.4834931303163843, -0.6441692669228946, 0.08898612970886045, 0.7160316212112546, -1.1148247180604816, 0.2579093064974585, 0.8938435485848806, 0.2878133457977271, -1.9476499802429148, -1.0252519161049847, -0.49480301309803126, -1.475740161568289, -2.770541632942505, -1.2972058514469251, 1.7175697331295563, 0.884093387889647, -0.04313261856798051, -2.262481024322595, -0.26727475349982965, 0.7707652505370359, -0.5400143636654429, -1.8982237385348344, -0.8798159609495638, 0.291763497080243},
    {2.410601806342076, -0.782692271228721, 1.7884618961702876, 0.7607333100028498, 0.28845859366729326, 0.12296676489049287, -1.3863299940221312, 1.061303887033908, 1.9549888496375765, 1.547242337332739, 1.432615065203504, 0.16876686109299424, 0.5775469353083057, 0.09567316306212358, -0.10135226975419799, 0.6573097654564048, -0.18469206989537923, -0.15481472021345158, -2.26708370377215, -0.287721036476853, -0.41742639061503445, 0.8098353655091767, 1.788153853084827, 0.30831442776112267, -1.8147039754768124, -1.730584054317387, -0.10196886755800116, 0.02420664554288147, -0.7242357444828706, -0.9449292508773098, 1.0449815711965071, 1.408841820804612},
    {0.46551314117244585, -1.63853640861377, 0.03277940028413744, 0.36563993181217264, 1.1188005398890244, -1.912814061846675, -1.0674542555181905, 0.46803219900772797, 0.7783327776811199, 0.629434997978741, -0.09960766907540736, 1.6337726747886452, -0.48654175653142584, -0.41971871010864253, -0.8321867025170501, -0.1672759988563092, -1.0394701014004422, 0.39603806966546373, -1.5417378854735093, -0.7530591952274673, -0.7312488129473851, -1.0968635300062823, 0.9666291122455539, 0.11310374197292992, 0.29126016838338104, -2.24774843003467, 0.9518536262265251, 0.47253820943855995, 0.262369370732421, -2.481273074510248, -0.4971787924846834, 0.06508633445542467}
};

static const float b1[32] = {8.397014267718482, 8.566080006630019, 8.395352531192461, 8.451920486903903, 8.53574480440548, 8.479570238223868, 8.522273469512058, 8.335356201362144, 8.315300227999666, 8.476572819448553, 8.249174129623322, 8.45771799257734, 8.456920871299925, 8.35119585049091, 8.490557177052839, 8.488553975876217, 8.619467255194012, 8.577594071407868, 8.32514752162105, 8.690065621424187, 8.452763870583865, 8.485471711490723, 8.48054369389294, 8.372727923129492, 8.621013045040238, 8.510428007147464, 8.470218216170647, 8.229482911127304, 8.384219172910964, 8.451619666609803, 8.45107996126732, 8.48733945597662};

static const float w2[32][16] = {
    {7.30029716990497, 7.070507029853114, 6.360210129706647, 7.3986704281882805, -0.2570630448809271, 7.0644874449355735, 7.285373700052841, 7.3531200675132435, 6.78346211764472, 7.3227262781956455, 7.2433413179045365, 7.639920850499867, 7.743958909567009, 7.223811087168257, 5.176342236512324, 7.198310414736957},
    {7.463381575843136, 7.925171471848596, 6.767630938728693, 7.495087243747382, -0.48595124300363984, 7.0706297316552895, 7.969339772561348, 8.009066287397355, 7.605142291906269, 7.830294830148129, 7.604297144943137, 7.457713421098081, 7.5751952995166265, 8.014591816048933, 4.98872012646813, 7.4372733056947595},
    {7.173272481243373, 7.761107311403652, 6.1564029594810785, 7.3298418103528356, -0.5432383442422875, 7.025782837592478, 7.067754605618462, 7.363571652180059, 6.791621124437675, 7.6244071974559455, 7.444834688661856, 7.41707316393187, 7.158805887808548, 7.021304386640342, 4.8126680207441055, 7.129830426129401},
    {7.774313575253962, 7.800176815167595, 6.369317662902492, 7.32106794694882, -0.13786634320482727, 7.395388941231315, 7.39855562078772, 7.684477386397061, 7.539727739197095, 7.754781817981271, 7.5872106190822635, 7.663242036952433, 7.237202182202923, 7.403694929875621, 5.061415426742475, 7.76164287196333},
    {7.919607870193311, 7.28934573864986, 6.56448139131111, 7.5967935166566365, -0.083690385435694, 6.6636934466783915, 7.699825401169624, 7.71950906229741, 7.310879683708472, 7.175647506946482, 7.593947586950487, 7.642763933206941, 7.805280063943175, 7.601975031192885, 4.699152474534067, 7.741623417314431},
    {7.371343928145963, 7.67664189926652, 6.185118346588989, 8.064753816708004, 0.12653398543135141, 7.183310213030562, 7.829585998194639, 8.276194156853698, 8.128641698730839, 8.062583174251913, 7.931389761665637, 7.624135632612605, 7.532795502163542, 8.032696626065015, 5.782647005293802, 7.821911397073789},
    {7.761637141687737, 7.5719970466218784, 6.752489396889375, 7.548191137114747, -0.046183121057167965, 6.999853434634695, 7.647639863496896, 7.653860908119914, 7.2782739266995575, 7.556761770021891, 7.751604946398946, 6.997283641683643, 7.597142858023889, 7.511968750273662, 4.622828866177033, 7.797629192249474},
    {7.320186854761352, 7.40582312670216, 6.474459444987704, 7.635159485157525, -0.45798271382539707, 7.178528935361211, 7.5371464271164035, 7.496795616604664, 7.352815935688462, 7.077609092143447, 7.34550481209946, 7.0070032266060025, 7.108428010310736, 7.158204616131932, 4.702435239813431, 7.219416809750866},
    {7.500565452238247, 7.292494809284355, 6.502639064112194, 7.652708529907159, 0.006616276661453309, 7.205941389882384, 7.610101482289193, 7.432738781247434, 7.117732574311502, 7.459668799836778, 6.929128029722915, 7.2297712889870915, 7.508039529645274, 7.166134640015721, 4.956195976222534, 6.9144760964297625},
    {7.468323120463851, 7.475153109682454, 6.758574959871815, 7.160603906769076, -0.2434309153062387, 7.199155952526293, 7.906751829616155, 7.564972616579424, 7.375380260471017, 7.166176976570049, 7.645714039949664, 7.776050810521767, 7.5139433633643575, 7.3317093760833005, 5.123819879967843, 7.699267344900637},
    {7.242422089106787, 7.5365108890313115, 6.908818311335803, 7.75485491750404, 0.08134223988668818, 7.001050144537502, 7.677970051698237, 7.616927890073615, 7.5251749596622055, 7.828193280817365, 7.649038866087828, 7.489132995739656, 7.119525623009503, 7.316357589460637, 5.217235405035102, 7.546995865395906},
    {7.607035731023078, 7.175474462940263, 6.657480859790833, 7.643924049171515, -0.23451359370337335, 6.842951169260757, 7.257398581398717, 6.933258184507024, 7.274228042800998, 7.149336487062446, 7.935162403871859, 7.26136095148499, 7.4812950395519815, 7.5136482517497, 4.929530992244825, 7.635889802135562},
    {8.0734496396896, 7.744574455151939, 6.462008017455865, 7.411304708784412, -0.20946432019297867, 7.247696007976876, 7.942761089747486, 8.082498659653028, 7.366930987081136, 7.380604493069211, 7.5662880148803175, 7.761604671511242, 7.640794278068283, 7.46996027627436, 5.032827411643313, 7.798744481490527},
    {7.291978169631619, 7.419849503314521, 6.859707978663756, 7.892972923118813, -0.32084837874462363, 7.156930526848723, 7.509870174205862, 7.006756589841297, 7.169110486988597, 7.010667668937627, 7.642136798083201, 7.96588263100742, 7.753677855943733, 7.428719756238827, 5.272717590532557, 7.624164177288886},
    {7.058491546746822, 7.285284634508617, 5.984680569517824, 8.002437888649498, -0.14209438805848384, 6.498487218189476, 7.800055680722615, 7.6160543246677666, 7.12737915300596, 7.779870348775389, 7.5084999219914295, 7.685779705713155, 7.5499138073271554, 7.690812388933609, 5.392458773319381, 7.0197921974833735},
    {7.204163988853377, 7.336752499376847, 6.3481318999134375, 7.179772647185131, -0.38162290439895485, 7.276248413293043, 7.67214907772941, 7.205044693565782, 6.733101883051677, 7.209960316849233, 7.9925756496848495, 7.3305408525415645, 7.301206799218728, 7.636711883723217, 4.65858332541872, 6.951169288869742},
    {7.385766499680064, 7.469574377376617, 6.540679760649428, 7.960545156280501, 0.23239630734846364, 7.465741632469535, 7.623642989763052, 7.962500389740246, 7.750388854194763, 7.5887652909647985, 7.329252720698422, 7.321607285437798, 8.141858438911942, 7.226971391971935, 5.029090854535569, 7.520087860537873},
    {7.854338087732827, 7.961939071197406, 6.428627842178221, 8.188437389277349, -0.17606413629138173, 7.425754114822749, 7.9913124756771765, 7.703213814002084, 7.428817281065341, 7.527622225359146, 8.058549271791557, 7.690317187450569, 8.173262956736426, 7.0602486719441675, 5.118030936155647, 7.721378831913267},
    {7.742273865170563, 7.314231781952108, 7.108352085668616, 7.678216674843749, 0.0027883943278476492, 7.140686769979248, 7.564537464209845, 7.608386566795159, 7.490525140293636, 7.8846705313591094, 7.514997456529963, 8.057440656251373, 7.4735718230585, 7.8239365452765295, 4.877021644597216, 7.58726508765353},
    {7.250600030644787, 7.574958360394628, 6.70717679818957, 7.55032282754824, -0.6455665168098654, 7.3927465761734155, 7.680715576057467, 7.778035312626547, 7.267946752658413, 7.75961435862967, 7.304764485998189, 7.007376137224631, 7.776991444651412, 7.412455582245434, 4.933260850658066, 7.686381818097421},
    {7.541655969690403, 7.768921722794759, 7.055093150017039, 7.964863094993855, 0.26378328942544693, 7.078356392771606, 7.4410792303955136, 7.980855857432143, 7.484182854256551, 7.9699878472072685, 7.189303796520399, 6.939147952317363, 7.783197574522235, 7.682588442361942, 5.234576509051533, 7.6436202077857285},
    {7.9024792968337785, 7.991942649301975, 7.238967745549605, 7.852583292730567, -0.0798617477217114, 7.509229389801336, 7.7335843421104995, 7.5655021631340675, 7.617324643684325, 7.594541098768089, 8.212325679994152, 8.158853159732583, 8.086679569675827, 7.721882045377998, 5.3757149181674295, 7.559032536200161},
    {7.679804500197019, 7.500128104207017, 6.717224049263744, 6.950328788239148, -0.022222487436083505, 6.608503507890493, 7.670585477544179, 7.530891295955384, 7.20975002612971, 7.218945688077525, 7.564360669603132, 7.681483838105444, 7.410874013958626, 7.579285600440424, 4.674511875708572, 7.520860009963369},
    {7.808604078789455, 7.286048060166079, 6.565546646375536, 7.126361222504556, 0.21273130113672511, 6.982536226112939, 7.101121074199326, 7.46128153441437, 7.372195916468168, 7.397093644039759, 8.100190248187925, 7.406871189978813, 7.32630060406422, 7.47598346722249, 4.543946063618845, 7.305004350640749},
    {7.543592839615211, 7.6433290742982765, 6.637510329505792, 7.4049081555667655, -0.02548182621974174, 7.048153842843386, 7.755482001389276, 7.521791169055964, 7.302582072154614, 7.525610126470817, 7.61342021165434, 7.524310867722174, 7.6826206033820545, 7.568914173010246, 5.262024497600739, 7.911726287328339},
    {7.6771145976728175, 7.682145693250673, 5.883948900207441, 7.798072167627146, -0.5912095987079605, 6.86636403193892, 7.564223111061924, 7.5077817608065285, 7.625644306559119, 7.489650404494437, 7.805234746451701, 7.294348966067769, 7.873534805512404, 7.574172709084586, 5.195982101276922, 7.307833369880746},
    {7.648524748920966, 7.8572475882567625, 7.203427752240914, 7.454506356149461, -0.029399999535062445, 6.554088619124113, 7.369765492279107, 7.374779548062346, 7.4742316354103275, 7.546883816884001, 7.522089680134103, 7.916612319786912, 7.131294363513954, 7.5546498206312105, 4.856404020322753, 7.138664684451365},
    {7.528744452435321, 7.498437238075341, 6.8262312526642495, 7.524030792612097, 0.06673804729686987, 7.108274324167769, 7.849787889834614, 7.258144102057169, 6.980543979690855, 7.628546612778117, 7.68056740847186, 7.0036385592360375, 6.803146869638489, 7.419588581288602, 5.225793940086637, 7.143612686020474},
    {7.850361696047914, 7.654468597006038, 6.863455206268959, 7.725091250730517, -0.32326093102794684, 7.075592342110035, 7.567682364854334, 8.1107923475935, 7.302658739065753, 7.556496048309435, 7.793211809275397, 7.868996364787446, 7.355643260942243, 7.595382435167806, 4.933285171025106, 7.02682537822369},
    {7.580579902539704, 7.3252815330786705, 6.545878158462177, 7.712109642652919, -0.2543149007032465, 6.699888180631358, 7.253434287475668, 7.506057312587818, 7.796070111079889, 7.624531648395271, 7.273165993832279, 7.474172239843221, 7.600606490300169, 8.05640572474783, 4.623543632670185, 7.447531974353206},
    {7.674488683539635, 7.455981772159043, 6.854793764365972, 7.526714704944279, -0.3201762522476975, 7.096530050843084, 7.424302619458115, 7.565107411325949, 7.082764602213563, 7.442539777718562, 7.857641181832595, 7.7401541721259175, 8.196265803653905, 7.6195168795838155, 5.430155101723926, 7.670091516896971},
    {7.530753636028395, 7.280136148862401, 6.185104598866411, 7.409711614409562, -0.0693811962387747, 7.20684106555236, 7.559092323081357, 7.760425443856216, 7.473013892372921, 7.442534730895881, 6.963818744342765, 7.336106723546216, 7.527700489014906, 7.709826218140009, 5.22040600169565, 7.11662540999334}
};

static const float b2[16] = {7.225497177949609, 6.99250291391423, 6.98893038448857, 7.273403557904452, -0.11785826928535047, 7.30125619847439, 7.1564498015468425, 7.294202942574281, 7.369169245241317, 7.039441674401691, 7.16858211351363, 7.264505889777065, 7.068591054792829, 7.052332723462679, 5.754425622644722, 7.0881939352584};

static const float w3[16][12] = {
    {-4.91443809186358, -5.065203653608144, -4.947115383385816, -5.522048312271851, -5.504647631674817, -5.198218780211363, -5.786070720823175, -5.842627325893787, -5.613933848839667, -5.511060520396937, -5.918559894272624, -5.866126798203452},
    {-5.393916436664171, -5.519675530339942, -5.272210661764894, -5.826452097394134, -5.518266041623174, -5.7507048886981, -5.554966066024677, -5.368488954462789, -5.428157859858842, -5.447242965566596, -5.794624200497567, -5.440644143953537},
    {-5.666506670673655, -4.254144604877893, -4.550852811990471, -4.29691566968856, -4.511785405468853, -4.502572649580194, -4.528122337926625, -3.9416662841538197, -4.90916693242993, -4.746579243403987, -4.748680045943642, -4.982944462493291},
    {-5.678496608904976, -5.613984360432534, -5.5991689207639785, -5.886243446964609, -5.437757398571339, -5.157882761508536, -5.87625171633656, -5.273276086957647, -6.298102025803226, -5.435005299349458, -5.314093775674732, -5.71433787223322},
    {-0.06368557839017096, 0.3717724479865208, 0.07259430500838061, 0.1896290476866793, -0.07968230069068691, 0.24435459303197465, 0.2678818207213122, -0.18091186264271927, -0.09349830960749317, -0.02278715161296733, 0.19807769564902883, -0.3658217039799435},
    {-4.639581120622206, -5.471292931950735, -5.231790357903903, -5.124797887055308, -4.829701660510886, -5.600658528757204, -4.573977645491505, -5.33046150137638, -4.894359014060826, -4.581643790720633, -4.3903752418129045, -5.324272574904669},
    {-5.925341082917866, -5.758528504612854, -5.234070109761947, -5.0686618761226825, -5.6606133817491395, -5.364726994154694, -5.501299218996735, -5.89409043273408, -5.15112827376203, -6.5085380553510515, -5.683886693919397, -4.72925826750496},
    {-5.115705708383, -5.1210881430815185, -5.4318512944072355, -5.777402537553855, -5.797724686899245, -5.28634907144842, -5.547956998904295, -5.649418051488456, -6.184288155243427, -5.221131434725999, -5.424501867633285, -5.800001572222316},
    {-5.7349486192813055, -5.5347981449576755, -5.53240149740718, -4.838444032931333, -5.719595386422322, -5.305585504908928, -5.455694051769588, -5.476865478574207, -5.413717293833044, -5.317960809917595, -5.881720437850409, -5.281546875090574},
    {-5.144905528032374, -5.029459624229784, -5.812116794447675, -5.275255424132119, -5.302743294240565, -6.025852505320192, -5.585868790931393, -4.591284258448825, -4.890345441081679, -5.620964421528352, -4.655061746555113, -5.847780140674501},
    {-5.663777202259705, -6.132938115476181, -5.09170966959594, -6.1068273429400035, -5.805439777728248, -5.102868025121007, -4.967790411565744, -6.131239247837924, -5.287816714572782, -5.468761417825777, -5.520385376143973, -5.5567901084934315},
    {-5.308766979758167, -5.4359644133126235, -5.343333858685014, -5.4710497684737875, -5.526159421496574, -5.505712687484913, -5.856816172817067, -5.04774882215518, -5.642664368871724, -5.013633589004187, -5.375806131051329, -4.896731468752808},
    {-5.898388705204162, -5.232883149162004, -5.5933344344247615, -5.442458998573226, -5.581215731287352, -5.242131185348736, -5.251274960769729, -6.2494297761640345, -5.423788067844561, -5.5593736473026745, -5.907386120608935, -5.331911089132479},
    {-4.572180326855058, -5.895169749996005, -5.658280868505016, -5.733443935846899, -5.485902513763653, -5.951476570087701, -5.34005596325438, -5.41248973085435, -5.5245285023052455, -5.175771502482275, -5.520461560744243, -5.182500475934593},
    {-3.7388003861551, -3.2801076986418085, -3.980034669063784, -3.3038497231267536, -3.177340417198702, -2.9733186089840773, -3.413986820438955, -3.392256416908174, -3.1346604760545866, -3.607936242273192, -3.783435118739893, -3.2577270891477847},
    {-5.760229133650599, -5.5702203693483305, -5.8863630861119125, -5.142294138760246, -4.98201998667323, -5.850745886733296, -5.6839447763924635, -5.261725276708938, -5.0621040179280365, -5.790554564503306, -5.135034360772288, -5.769653936298973}
};

static const float b3[12] = {-3.5018574158608264, -3.382082230595066, -2.7650472633458034, -2.9768998301385294, -3.6196119691248136, -2.669820866820515, -2.46407852290503, -1.8601222313971904, -3.4942677447167774, -3.5247968464142785, -3.4058879035220677, -3.2761543584592148};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
