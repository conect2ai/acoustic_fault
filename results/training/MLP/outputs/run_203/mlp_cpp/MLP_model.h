#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {2.7844030077262416, 2.315695157147966, 1.1439688686715899, 4.525664876831375, -2.0507684695287267, -0.900873901942061, 3.929871272969909, 3.6195811689890753, 0.5685856323253603, -0.010061764632357625, 1.0647806376018283, -1.4589455914598042, -0.8384008280134627, 3.921692012530366, 5.126386805383531, 2.1668671873435654, 1.9260834245974912, 4.296970964795114, 2.887696091371655, 0.7742978924437105, 5.5555585353467976, 3.647712457806341, 4.803061788029661, -0.024131090233165623, 0.8493371083374023, 0.1792583563154954, 3.926610786204367, 1.2703824911707347, 2.7525692470406797, 0.6313394501930351, 0.6643359000385141, 4.9505460758231665},
    {3.7406441932807195, 0.8277774623660487, 0.18389761102028201, 2.971520035924868, -1.2021798323145396, -1.1049884864324395, 2.6892638871577987, 1.9380364284999914, 0.027505719850988188, 1.8132187452247626, 1.1995375409478208, -2.19865820754694, 0.034159929373923294, 3.772325981667007, 2.83422735224755, 1.4180201120100686, -0.8511448764604981, 3.65329832257632, 1.9480121397468766, -0.3810788833845606, 3.5240274303675037, 4.011364987797549, 3.938882039344357, 0.4675788103729116, 0.6423218894890658, 0.0010529354335152565, 3.2668267994534452, 0.877772332725164, 3.0755723526564545, -1.6915244070052704, -1.2440830831582677, 4.400702145932424},
    {4.048640348198101, -0.7190814794294024, -0.1464079327873722, 4.6326082732116625, -3.4919199943423256, -1.4819246228067517, 0.24472633136732255, 1.0415978937418737, -2.8009621362608206, 1.5273841242634816, -1.0426455792177693, -2.7039836393508216, -2.786128277917606, 3.389193633087005, 3.966234893948639, 2.0854997911847053, -0.13061151943109886, 3.9475946538959183, 0.4148866829088544, -1.0234850012086638, 4.653619414489842, 5.214113865672677, 5.566918535523622, 1.1118261287130902, -0.3148256187576305, -1.5106481207542513, 4.260389788781394, 0.17393993978914027, 3.1553703554027877, -1.7342860762886974, -2.990408869476696, 5.162846158384166},
    {3.2167117867489248, -2.3034117173679385, -2.5129957098292395, 4.155860277915235, -4.349179818019053, -4.696988150915643, -0.5019517008398884, -0.41374219036621235, -4.736925075896371, -1.9050895163089043, -2.6367592400702704, -3.8498424881582, -3.2897894978608684, 2.6705605345042036, 4.3294815808202465, -0.9205110792345855, -1.4516547542101261, 1.5832746393846484, -2.277609950614799, -4.288643828752982, 4.699566155560569, 3.303822614276904, 4.398896777923218, -1.530941993747863, -2.7316549744121708, -3.126690775031391, 4.768873198227381, -3.7303993431184894, 2.262072603077295, -4.253847387013529, -4.228975181687591, 4.226491972775045},
    {2.071311127799403, -1.8975872559380957, -4.116617700501312, 2.631378105158943, -3.7350201530967597, -4.375059740151085, -2.090202394598342, -2.4925410220361464, -5.058156003212346, -2.5438633948185307, -4.1314933370210465, -5.848028667158918, -4.544405199871445, 1.2102372110381014, 2.2094887016309572, -0.14101655773761396, -2.06737956189888, 0.8384638088250445, -1.589416772462956, -5.235216363734341, 3.473754190040098, 2.475903605323505, 2.649126199412411, -2.517166787379538, -2.1785697357690244, -3.6761656313160995, 2.864221938143314, -4.844488451821021, 0.7045175460297421, -4.867412438512545, -4.575580494652148, 2.9404582508477346},
    {0.028292777042743484, -3.306543335719492, -3.646501463137618, 0.14239181801989623, -4.274265781395638, -3.6812986797452356, -2.7174731272845865, -2.9869698254541457, -5.388488180322861, -2.2928001583819406, -3.3745144390626955, -4.00414858771105, -3.463299193930777, 0.7274893126908567, 2.419892584316106, -1.4541301265886524, -2.4739270561911764, 0.11382615854369547, -1.0675786959620326, -5.312564926934342, 0.7040451932523305, 1.0410829986590904, 0.3240438239853506, -2.659682651640934, -3.3505067442407954, -5.503049020345909, 1.2550380129998102, -3.511058301318459, 1.193352899022259, -3.5645969643090956, -3.902346704994165, 1.4196407056397762},
    {0.26305971435590225, -1.6552510008978016, -3.483281575528374, -0.05530188831871053, -4.33346542139695, -3.8765000792857207, -1.2939703267285638, -1.906847726526785, -4.089707813782704, -2.7364298431454857, -3.423004691005606, -3.4142916967106296, -4.548194117920709, -0.3955337977578136, 1.6165394157232371, -0.7340062879256367, -1.7648887618903808, 1.5014071229045076, -1.4843818503057111, -4.327417056877399, 0.3187895740057296, 0.2198814729407878, 0.7859202963630566, -1.7826691898949305, -3.0887676705527687, -5.019646744763342, 0.888947682797653, -4.3507159188115985, 0.07240354910169909, -3.951811200929337, -4.005237897210454, -0.25067989848852257},
    {0.2216097627124455, -3.716883482099578, -3.3039960815544434, 1.002013681494201, -4.741257590858007, -4.548378747475677, -1.6158989835214277, -3.160560756664021, -4.179285946011679, -3.4150496566590096, -3.5682773121776323, -5.134462016464239, -5.330233104012223, 0.6862211432938173, 1.907745529489832, -1.1028371441226805, -2.2773981648664536, 0.9995977272577301, -2.076615668351531, -4.163568124500334, 0.9935108783261674, 0.5662349237124812, 0.013406423958959643, -4.019290173538628, -2.417804491452761, -5.239211619572399, 1.6274558171238607, -4.5400920106854, -0.49954097621854543, -3.3234524030296186, -4.138014764624661, 0.36988244333181874},
    {0.6351670559037224, -1.885835493170054, -3.9834409396359525, 0.5107933834937908, -5.0507713451475125, -5.518822718764069, 0.12146972701623542, -1.971628196510021, -4.093392306667843, -4.805139693325381, -4.152601196543113, -5.869122325876457, -4.426888914370989, 1.1382066008279286, 0.8151843324936444, -1.2918966102749376, -0.8513774293584918, 1.228976283213237, -0.7960616147760096, -4.568075317311147, 0.6198498565609802, 2.421045394917418, 0.6051637339694627, -2.424090286165777, -2.524872825937845, -4.043662492377402, 2.0231631880838936, -4.1870916283750415, 0.7912933584872018, -3.5679797065129297, -3.121817494208438, 1.5157406968572507},
    {2.419671779788841, -0.28463330780004825, -1.490270819562726, 1.689164112145827, -4.739587270344552, -4.306258603796966, 1.2088433925348787, -0.7346421783317414, -3.853185143018938, -3.3387357617304585, -1.8059663676949222, -5.288867260273583, -3.487669558617465, 1.3260667264584505, 2.539688301586577, 0.06061983090410195, -0.31208968147451777, 1.8465109691297497, -1.0307881760831517, -3.9474745754237084, 2.3710612492894554, 3.1889483120172635, 3.2898288967037583, -1.4726920606371232, -1.3057273580822457, -2.966995355303552, 3.516913455349159, -3.082064984531222, 0.7237292357144632, -3.518071560088259, -2.8194251072588767, 2.5485998126388543},
    {1.465930170745874, -0.25261312435070965, -2.0578990142696445, 1.7216326503646988, -4.37530370193883, -4.143032030039272, 1.237209874886678, -1.1339387733299433, -2.796998439702892, -2.7696704466050157, -2.8707553005616875, -2.8068891970705168, -3.9757765939830323, 1.8953648716170386, 0.8387978731199376, -0.6650455885699547, -1.1356445775941193, 0.4206973166259137, -1.0437306010582632, -2.9420289832493873, 2.2147926950015036, 2.5614833930197585, 1.8744914853197496, -0.34873341500950894, -1.408274340918615, -2.4041327893120967, 3.2518495679050425, -2.0610637399891645, -0.19189347432804774, -3.871935587619066, -2.4734807909984062, 3.147800732197504},
    {1.8124924597261616, -1.5293263955253127, -3.918205534960712, 1.068866967206529, -4.293726897769637, -2.815629217626134, 0.05674155688556187, -1.5894442785315623, -2.8531687022506165, -3.947413754514814, -2.8711625653937283, -4.606134790412893, -4.631160251999599, 1.4802247485965545, 1.3063664316933616, -0.3632486315425265, -1.1440531810579968, 0.40815824413208984, -2.107428774404821, -4.323309984011286, 1.3037112431229874, 2.7977271706451816, 0.7766639973008241, -2.2488083416252493, -1.965275013012837, -2.4450121608606086, 1.8858226803931728, -2.2581216223939076, -0.760560206094099, -3.057112734966968, -2.9996413137352005, 1.0994435580947035},
    {0.16557199927487776, -1.2950597393610024, -3.7328633681261882, 0.6610336110851134, -3.3136105953423733, -3.926897824301369, -0.9839548287367704, -0.41695215273128533, -4.192410839889629, -3.6031369389975807, -3.2006261591782796, -4.017357304909647, -4.935623015195316, 0.40139491183707615, 1.9052667723664172, -1.7286842415125319, -1.3114883651679754, 0.4700310239478814, -0.6167802486495763, -3.9067008146850064, 1.0394050822484016, 2.7725309164651275, 1.374061522162196, -2.8707467808895464, -2.9508382856745516, -3.654440997682285, 2.586814144998641, -2.758572870942683, -1.3072247367532512, -3.3108462806693586, -4.459130280763336, 1.9712108593468183},
    {0.9276896943631738, -2.307252995645312, -2.9089153483385144, 2.50748719386393, -4.590567613758343, -3.2763097105530616, -0.9178132124923014, -2.212398416828684, -3.683742792663256, -3.31390368791327, -3.195012297176572, -5.505282851295441, -3.219709323499692, 0.9501150094848453, 0.16602295092077418, -0.4671846506839909, -2.909509878466166, -0.3988346467316276, -1.6394538990079448, -3.1554655743847597, 1.5511297966606004, 1.4203697901429364, 2.062480405292032, -1.2620830499022797, -3.1873616557279134, -2.6680421350868038, 0.7372779641142894, -3.101522713151731, -0.7680047687690086, -3.9141083370721415, -4.496803452088384, 2.334217490055544},
    {0.5793023905946905, -2.7526094023550343, -2.452401315950401, 2.6964744641394294, -4.317111138938669, -4.1536460876082515, 0.7565310978147501, -1.5502184989050152, -3.0685677768993522, -3.3482589203244806, -3.9565461352864677, -5.3463575912223025, -4.780562037004756, 1.533970027157369, 1.262549788169078, -0.3808118397406416, -1.3478517790705566, 0.49712261460273416, -1.656470354977026, -4.279656075126238, 0.7621547917887442, 1.935664781333051, 2.3382850417315386, -2.245454836563043, -1.5099126258917013, -3.9147754704423483, 1.4445493160921556, -2.048793949719491, -1.1485964882375834, -4.072202045453393, -3.402810757567442, 1.3532053709279552},
    {2.3821371628857206, -2.427519919363624, -2.247629013355369, 1.2934924916854922, -4.315787950441522, -3.584824623890365, -0.9221561512657171, -0.728860692320747, -4.836460154707058, -2.84110107628589, -4.448810040520085, -5.063431169143931, -5.349952216844804, 1.252015924264872, 2.3368945279321545, -0.7492983956668493, -2.5665258614832895, 0.9562132541524387, -0.7286199403035352, -3.059946612317015, 2.3367920596869016, 2.6999950331870948, 2.8723421035475383, -1.9862111910685831, -2.2387642628835764, -3.5414583607932912, 2.57384762968465, -2.3720498543591875, -0.24200997192878698, -4.701944454918133, -3.3382848364966504, 2.4506029167448187},
    {2.7838373344836613, -1.7240256916128402, -3.0799736655910928, 2.697872939736805, -3.8411833714310846, -3.9775273076364677, -0.8150541845444805, -1.94685041636607, -4.933164015452015, -3.6598642939656214, -2.9524243704448994, -4.392553723202704, -4.572182301070539, 1.6328203050606733, 2.8543793300341664, 0.48051913872147073, -1.083435835220593, 2.6465959633918255, -1.8894147284813054, -4.060923483327745, 3.2083007733701634, 4.127060996068312, 3.5799367118912526, -1.4771606733130636, -1.5068652266109135, -2.5398617132876513, 4.024811212236868, -3.4685464254229648, 0.585229418531845, -3.5547543179893286, -4.455035991417024, 2.2941351145543627},
    {3.043135715484199, -1.939476838841805, -2.0172385668163555, 4.902970524969709, -4.738759587031488, -3.514695621809211, -0.30123872925850603, 1.2519362052866612, -2.218736120692555, -2.666853773366756, -2.923143457994894, -3.508207060555809, -3.3945055473537606, 2.7749033394728717, 3.7744510553351045, -0.40776050717324724, -0.15710934824451786, 2.911102580847652, 0.5408548571059254, -1.8338572639437916, 3.4932052488332177, 4.044471492193307, 4.14122253820983, -0.05640153256936045, -2.055132023161504, -2.8298268267730537, 4.975801231839624, -2.373477086798217, 1.4833512310647046, -2.052217420411596, -3.634083090823298, 5.151497907745249},
    {1.9171412552225573, -2.3811938863289237, -2.38524137281568, 4.327568444645621, -3.040128305036259, -2.867152857253623, -0.4847319085056454, 0.43941001982070427, -2.619111992366117, -1.833127832585988, -3.6208522726050605, -4.275609346175176, -4.449547241836593, 1.1067369330967778, 4.477008284214121, -0.5274595723461837, -1.6029428535599484, 2.2385581474569514, -0.8515819307999296, -3.611839952143358, 4.01931804683943, 3.181616819388809, 2.432089483668958, -1.766545033155917, -2.8305844136486495, -1.6229106457059235, 4.870102113812434, -1.9204725984528364, 1.4541417091349729, -3.1853570190547646, -3.630867804200455, 3.968815054650749},
    {2.4446186353305963, -0.9331284678539192, -2.8773435850973033, 3.5233206924011284, -4.784722741874767, -4.8993449621311775, 0.33214967726175637, -1.327277956218182, -4.1955271179816584, -2.1549161462251387, -2.8251927832433776, -3.656805954187719, -4.892533303089501, 1.74462398869426, 3.9231861710907285, 0.47299737669234143, -2.144833890955511, 2.206738803280573, -1.0602388465568053, -3.605859577185034, 4.191966985530432, 3.2682229277597994, 2.876759176300003, -1.3883238024541888, -2.6508742544946986, -2.192850406033263, 4.10376851089765, -2.717313651051635, 0.619344550083061, -3.328753422376669, -3.9282996781869612, 2.6697494808557676},
    {3.49769287691974, -0.9409885225955428, -0.9276938400943913, 3.798999721131216, -4.604187825349889, -4.794993843454149, 0.5538246049239002, 0.399323131383051, -3.912512936908685, -2.446557646648399, -1.6651645520840646, -4.558512707425166, -4.401856336450574, 2.652000495244943, 4.5227750969210545, -0.2835669073927127, -1.1634674645638867, 2.5573496139648224, -0.8883361605959179, -3.675557416420384, 3.416559032559485, 5.015262091006677, 3.6546331669921766, -0.17834709097147833, -1.0057383754368532, -2.174537785799745, 3.566062505349362, -3.3516704570983378, 1.098565180372312, -4.3789319663354425, -3.9264917336501277, 4.40993508918105},
    {4.7041427269342755, 0.44559680191671874, -0.25595700644411634, 4.779974028056359, -4.451844940184939, -3.8844923809899936, 1.9605698522324424, 1.2611062287594894, -3.249465576656587, -0.290224408277058, -1.0564008890223464, -4.3536668044089675, -2.3235060015025186, 3.4364301236344694, 4.872044178277053, 0.1304411628380702, -0.5783709745444072, 4.3608541784174335, 0.9315237433946998, -2.5367012797728155, 4.785113705055231, 6.137870360717636, 5.226364188522749, -0.9654303638346945, -1.5017313627113213, -0.9541448628981172, 5.461883608087739, -1.7715585247988683, 2.6796175581178976, -2.7043600223323097, -2.87349126293812, 5.6778041757843},
    {5.083829244254033, -0.278695952927268, -0.7897616384676692, 5.677537332150804, -3.6208900026162447, -2.5609631762998486, 2.6057753651171054, 1.559853068538396, -1.256735970355332, -1.0089570917018071, -0.3871506187398483, -3.6549829673269985, -1.269816974025656, 4.481202043150429, 4.068837203074845, 0.849557369907377, 0.3873476357360655, 4.433963983835882, 1.1509647167805197, -1.5418485911683577, 6.219266484915643, 5.227522501116432, 5.789407729653534, -0.37199626198492597, -1.1259624705496332, 0.14632965302484072, 6.191830925428834, -1.4603969000245511, 1.6384462658580095, -2.979686055719894, -1.5543929055567423, 4.840760166090577},
    {4.15768053815939, -0.8070450225511401, -0.10393884243920012, 4.719584831570153, -3.4422978095748724, -2.195917045629298, 0.5488501689923784, 1.8476902855730333, -1.8003919925221572, -0.8823616050150808, -1.919310092960759, -2.8639958168799335, -3.078979492500692, 3.2501130682861827, 3.9759497963443073, -0.36411496526068576, -0.6828273835316641, 2.9559329772580805, -0.2738222398964489, -1.8099495466498927, 4.422357839530123, 4.399874040058592, 4.402454358643273, -1.3392441765018164, -1.4276870847556093, -1.6117088814718663, 4.663591939868512, -1.3981162856129028, 2.5700630423272615, -2.5178231040055907, -1.9063314575930437, 4.912583537877227},
    {2.8928106728003313, -0.9966186739005514, 0.02083563796042838, 4.30637458389408, -3.6911163094627866, -2.044643449749121, 0.3504505360565423, -0.34923296154533995, -3.3480494202262046, -1.7053044608576942, -1.9152483546986556, -4.684317215151505, -1.8962285340429001, 2.0728437431255364, 4.177227525886551, 1.543386648585586, -2.0071287544882046, 2.677712317935732, -0.27096953905235904, -1.009486126541281, 4.780303609861018, 4.569578659295866, 4.329448049426661, 0.7113113107084126, -1.3039919897025865, -2.24622800366991, 4.855398638155563, -1.4023427062303928, 2.038216577426973, -3.19661957232207, -2.4122061615927914, 3.8298580595930725},
    {3.0561461477301273, 0.158832942932228, -1.5292546210105917, 3.9469441384015895, -2.796646668057955, -2.729045321890629, -0.21726470800936076, 0.9809149663839272, -2.739625654592004, -0.7063464500282096, -1.029438565308334, -3.902483129799365, -2.7199182973279785, 2.6210421255148293, 3.4494911355461446, 0.744865543729382, -1.1060768660398506, 2.044417845858477, -1.521432429094558, -1.012337963778398, 4.963884738907073, 5.0298212566319105, 4.3756424500391295, -0.7957329859813296, -1.7365449627426444, -0.5580564802747023, 3.806718745053094, -2.700747584689574, 1.7244868046918458, -3.1035972206784805, -3.444117441930603, 4.375880222651061},
    {4.203421504236489, 0.34243027758493777, -1.8950023306049069, 4.964311197173834, -4.235599791135993, -2.2539945206004717, 1.304036813841017, 1.2056607238157626, -2.928520891321641, -1.469829740074657, -2.494573428206897, -3.4339348598357344, -3.4793479274350636, 3.7109995539658827, 4.524369546548264, 0.4352305062966785, -1.0773735850267254, 2.899461722717466, 0.21647118862096723, -1.6010263374844365, 4.2093426092641115, 5.140788193333115, 4.757300756299873, -0.07124119540149725, -1.5446686095846338, -2.107925268146139, 5.479707808379542, -2.322948595603429, 1.434612888990458, -1.9033602764166093, -1.9571890060612114, 4.911811168419027},
    {3.414573508707822, 0.3263710158147693, -1.1633443516131325, 5.130697244078266, -4.642322572294873, -4.085366345250536, 1.2864201763314653, 0.3504183150455399, -2.6734785638526906, -1.9128068762206418, -2.1717649688687137, -4.220528866904189, -2.3104025751466026, 3.1830883366814393, 4.874703127613325, -0.2759874025066194, 0.07736900739519384, 2.536718629516097, -0.950869704605765, -1.5341785595958, 4.913224432587476, 4.339599924635134, 5.387074536529259, -0.5431155208832101, -0.9689997444511242, -2.511185129616158, 5.130327078870175, -1.7058811548130135, 2.8127829648360163, -2.762899233101989, -2.397025442424809, 5.158449312647422},
    {3.734240525798745, -0.2174222520359218, -1.0998481731430165, 5.299068503479478, -3.5748730178958046, -1.7279361646741622, 1.1993304539925218, 0.19959978633939304, -2.8103715742808983, -1.435838405573322, -0.9205122300741356, -4.60136143103646, -2.1294210751382194, 2.450097943009099, 3.6516094692384797, 1.6838929740775292, -0.11604252325833259, 2.856921595204959, -0.09634134168041562, -1.2734511719215673, 4.532693511759802, 4.9942782433316575, 3.6841261694869485, 0.11951747990135732, -1.114947064958054, -2.191953258915775, 3.855173186219943, -1.4584623849713472, 1.862315010298852, -2.4150764508777223, -3.5690882572163676, 5.130023263377769},
    {4.349589794776878, -0.29899351709671396, -0.7425146389771033, 3.9154686795563363, -2.5262727396275952, -2.412854936203804, 1.8358740207146764, 0.12710155952377936, -2.6175300590605413, -0.1961757101422669, -0.8433991367095252, -3.512523740736088, -2.106165532354556, 2.0338680699578666, 4.394146754201687, 1.7593797378651974, -1.082021212457086, 3.301374839825215, -0.8552714412455967, -1.9468897549678545, 5.398260994694418, 4.016031043432141, 4.317766688256851, -0.5334375074333247, -1.321018532754329, -0.22697399931203982, 4.382783318272015, -0.8715195748746402, 3.0531292717823106, -2.9688836802535175, -2.2476978353193258, 5.261697366954879},
    {1.0596867417475353, 1.223696266329663, -0.14299502704021858, 0.08121458144432614, 2.4487548365631584, 2.4209052287392026, -0.26932038093106964, 0.7630532670659852, 2.4550297975209787, 1.9358852953820957, 2.0458739965190333, 0.49225464544317865, 1.159962851282846, 1.53098671012269, 0.5227530077195978, 0.900676740671186, -0.48837511749602414, -0.16115472107868942, 1.4337830438214867, 0.436172419923942, -2.0971786022472396, -0.48478333519094713, 0.505054390479486, 1.6785459793685686, 1.559949556864849, 1.395898369813428, -1.7692715838155346, 0.4277959293795439, -0.20801458620701718, 1.871325954469688, 0.19424166491161707, 0.4409632951468472},
    {0.48129320322554053, 0.7867055043600052, -2.165411289430307, 2.652036538824211, -1.6639791130176467, -1.6242661080577105, 1.680749961371772, 0.4582448163570727, 0.35857232717985793, -0.4569431639919261, 0.2822918938328539, -1.0249299883219356, -1.9447490106829992, 2.5389843961984297, 0.6509231754072319, 0.8311946511173246, -0.45474203465752366, 2.180995948953848, 1.0224174236639727, -2.1040492560682034, 0.7075664947863006, 1.3087024201483475, 2.063487872842874, -1.7233270583462588, -0.3470769225407111, -0.34567585054068184, 2.6046842116954143, -2.0151450529121866, 1.6099479147091247, -0.10460327642022414, -2.211758812953166, 2.6517563372846396},
    {-1.798421566778885, -1.2206095226650797, -2.190702269689592, -2.1384804283567513, -0.20395152004681075, -2.3276454009117487, -0.30370054754523534, -2.858491768800151, -2.8134146636499233, -2.2066349080534398, -1.960692575397817, -0.19286075629180785, -2.5840205698782017, -1.9994224134241156, -0.4878668137922889, -2.059542136269822, 0.34607412141565325, -0.9784372582806661, -1.8905473236319825, -3.023346762755785, -2.975036748465465, -2.1604933078951167, -3.0330222791514756, -2.5811139481398513, -1.2076190984221555, -2.641104849337425, -2.7262268895138813, -3.8766204142559486, -2.2686691965726644, 0.13465829864773146, -1.8278244790248526, -2.224429107376226},
    {-0.15799397489494588, -1.3788164627206991, -2.0438889472964807, -0.27929683035729025, -3.02023606902816, -2.6647229049475536, 0.8435981126655606, -1.119529862251917, -1.644004749389415, -2.6168618365866996, -2.4403377300942757, -1.4424857872284906, -2.5787338901549646, -1.0096702008282952, -0.34612826014003406, -2.833346871047265, -0.8499868335320908, 0.22686071244831385, -1.0055419089299842, -3.072946192058479, -2.2343788846910164, -0.9098566502359864, -1.5821348186856286, -2.9239713574146973, -1.879138096758317, -1.051285014592211, -1.6403285466897732, -3.3195972661688407, -1.2378150743643643, 0.24070777482012512, -1.752754274335967, -0.904368642995783},
    {-0.5461181189715832, -1.6809191073855752, -2.4534541401347276, 1.116895810793275, -2.422525409977558, -2.8946134201980436, -1.0111345008520198, -2.0707774106753103, -1.1617720266983804, -3.016239007684306, -2.077374848792252, -2.428577779061536, -2.5615369420448437, -0.8815538616454386, 0.49313090312951574, -2.5239380591678384, -1.5263684284099603, 0.5775357706838943, -1.7759363736572638, -3.137730538946193, -0.9954029944738202, -0.8631503209569159, -0.16796855089330504, -2.6726648804241337, -3.472502991226169, -1.7533488465030738, -0.018062817839999527, -3.5670042283262258, -1.4213023680192791, -1.1509310922408083, -1.6891528309883093, 0.964965661457563},
    {-1.7184384587500354, -2.046279363345359, -2.438548953479739, -0.5138313873433262, -2.507307622344443, -3.3340000631398485, 1.0423841971872287, -0.2835990259264652, -2.258267256623202, -1.5877290480400468, -2.6338407201425915, -0.7589866293552733, -2.47713921878099, -0.4493872169182268, -1.2571104488199636, -2.0944584659115897, 0.6344088391427862, 0.10761031510008262, -0.500071723454149, -3.128461435377516, -1.6387830709110147, -0.6051022536285791, -1.1992275116419924, -2.070840334210815, -2.880388679207582, -2.8192272384707096, -0.4207315848981513, -2.104791905463624, 0.09579299721064244, -0.7806197972682475, -2.176267953926171, -0.581651259719806},
    {-1.0572196657007575, -1.034970906726546, -2.2148685131763988, 0.4584618077711267, -0.91717896380193, -0.5081087685508486, 0.9899298131278085, -0.12261404469822657, -1.878678879668565, -0.43508774444483606, -1.6631329208274437, -1.9038736088307355, -2.148396254629084, -1.1432377538164649, -0.08181869087367694, -0.8671863541582979, 0.024930606311754686, 0.6288935469464515, -0.6847635924345832, -2.3692800678497568, -0.11208464936272436, -0.9846241055728293, 0.4475149587476251, -1.8054903276203924, -2.5856614188518265, -1.939494864242775, -1.170190963640169, -1.6006453314113942, 0.11443027248957209, -1.520434241201431, -2.030574984098773, 0.3770839078958131},
    {-0.5446758336579446, -1.1771026150758166, -1.421175531133532, -0.9488410502396749, -1.8439027838877324, -1.4672325702552897, 0.8187387365142639, -1.7809377382584095, -0.9989915526690019, -3.089924889984344, -3.652045388655267, -3.042205211616618, -2.0931149105379148, -0.3029790524355523, -1.25940829737988, -3.1318364547097266, 0.4945268804024602, 0.32992775571892946, -2.381308568047397, -2.6343119969683872, -0.5211053715317846, -1.0563843914652578, -0.41696031595997757, -2.961212717976948, -2.7436107580512408, -3.0970115733117463, -0.01080027211910667, -1.4022953354036363, -1.843540128905261, -1.4984494377748407, -2.830991541715464, -0.4766402187199695},
    {-1.1831446289431897, -1.263830843418089, -2.9690767401038802, 0.35358617166698625, -2.8078991225870404, -1.9041005098787105, -0.009894457954725582, -2.901037590036738, -1.2261623291751125, -3.869028898585841, -4.050362494180073, -2.746351554936734, -3.654813226076616, 0.68068731322683, 0.5433856356825938, -1.4890652663414934, 0.746843106861369, 0.9232611575069781, -1.279213260762473, -2.9056796820785893, -1.0125913615953914, -0.5667701391466677, -2.0814107565606053, -3.890255588783356, -2.5896663088378924, -2.6539965653301265, 0.632941683722303, -1.8692821645274154, -0.7975085594419278, -0.8520409571342844, -1.02135492884604, -0.3166240782652506},
    {-0.91682579646932, -2.7472487414279443, -2.0662987050423496, 0.27131591883801676, -1.4984530279460275, -2.092273679358308, -0.806156214541113, -0.778159082554429, -2.9824234588073564, -2.758988533947495, -1.8084930173095064, -3.5903379934500816, -3.8203538247171274, -0.2217100897166272, -0.21671321645127867, -3.272759583708555, -0.17264574199419377, 0.4652829507352956, -1.4995115611923449, -2.3197929465302582, -1.3838973452679109, -1.0130220885726224, 0.04964834440589824, -1.6255511119007713, -2.133242712807278, -3.003881237930176, 0.6774302527040912, -1.8572583724084817, -1.764185871314142, -1.5619781864501354, -2.1725030169050266, -0.6795917112443265},
    {-1.6853693104119198, -0.5970531843753946, -2.73155549857403, -0.1755100001389229, -1.1831604150936532, -1.2626727110135634, -1.162481438342051, -1.7105699632090323, -2.5392903767863366, -2.4322579603999213, -1.7379925860967775, -0.6168620880269721, -1.5354771248898111, 0.4586320238651296, -1.8762113256688797, -2.8840640172637206, -1.9345297996217616, -1.0715773100549497, -1.4376869004087711, -2.1501956154749764, -1.5702574214987548, -0.45617424526123174, -0.32287435896848504, -2.611480619235257, -2.3020841148805524, -0.998445343628695, -1.804172585838589, -2.410706468639431, -1.919714918521824, -1.5766942980327683, -2.093016964468797, -1.00435498965674},
    {0.2907378807273529, -2.1149109690412087, -1.877884661466688, -1.2302796577149913, -2.286860352386054, -1.645065691302036, -0.3993376487403726, -1.1334462002953067, -2.2329313811889926, -1.38987409298772, -3.540988648781219, -1.9588259662221061, -2.00622402265392, 0.44912612512945604, -1.3399675359740133, -2.3068183748344904, -0.2645602864739372, -0.1701511457030503, -0.9978881646800897, -1.9224383914881895, -0.559271694112399, -0.7834694586211114, -0.9431772375627144, -1.9905991108218541, -3.347430385009786, -2.5956756462210775, -0.3817072877236168, -1.4847101365640005, -0.5914655920661126, -2.338759467447505, -2.1093554912262467, -1.611722765672532},
    {0.10501859890395003, -3.1289738353252075, -2.911834799298486, 0.3013223942455741, -2.9932112942900466, -1.7029037482183778, 1.0716029487690024, -0.7826149525503491, -3.012710491507439, -3.155355602021337, -3.265901427773307, -2.97108672482381, -1.937543435564265, -1.3989097755593578, -0.9412469251276011, -2.5875715271396302, 0.8784569274451229, 0.003622966598774082, -1.2666719525863892, -2.886162818188912, -1.3252691485793553, -0.7878483170585154, 0.008889150292342328, -2.1540186739022396, -2.18722855956644, -2.540806610608156, -1.5476563236921848, -2.850475781470789, -1.74848954547878, -2.1284246277945176, -2.6062303964142046, -0.2941855448628248},
    {-0.4983367757283915, -2.3380800272564803, -3.6201109829286127, -1.111701944837564, -2.6764078580985102, -2.7072978645334027, 0.3621641579266615, -2.0080206462338603, -1.826074939955314, -2.2668211039428257, -4.150817458482782, -1.9487257098057145, -3.2471143005731573, -0.46932693357750094, -0.7307097376348994, -2.994684576611077, 0.25099247369165223, 0.05683475051227501, -1.1653640946858972, -2.150947111240389, -0.2435943477877664, -1.7531192695642674, -1.2876621615361572, -3.4613753431161283, -2.655164063778653, -3.3317339625649054, -0.060250875830112675, -3.7890937250003516, -2.211396358674994, -0.9168212948500333, -2.945369370135654, -1.8320631203419337},
    {-0.6562714037478112, -1.8852025862593371, -2.650243806341551, -0.7918706107854185, -2.912817453113975, -2.6389242964848227, -0.2003932631199429, -1.3140969427075992, -1.2340405997447843, -3.6282023221927395, -4.05394773915908, -2.9815960592330772, -3.9341919280223014, -1.6875554536987771, 0.07521281594865128, -2.977141586253455, -1.020426232095235, 1.2343260562421206, -1.6468577451903306, -3.934933668934457, -0.8177116347535246, -1.5663115021857783, -0.13600450887970253, -2.8539489023919873, -3.4252163428224396, -2.8554329461167733, -0.16229281828468795, -2.2829218242967984, -0.5862111327880886, -0.4180548378562209, -2.84851837151636, -1.446864117277951},
    {-0.9422677950020547, -2.945471647043354, -2.016872268097289, -1.3204520708779337, -3.080820924715848, -3.0646900003183397, -0.008793865112260678, -0.9510404728688269, -0.7939267010142891, -3.083149305217083, -3.506177330189521, -1.3413016735196936, -3.660105598042517, -1.3873859502895216, 0.40697533059871616, -2.9797108722966885, -0.12200863686099969, -0.008370837244301413, -0.9192192791049668, -2.244680780347094, -0.4839090511202422, -1.0644781480843315, -1.0547796216343337, -2.586692691135038, -3.7192630378552307, -2.6910793719495785, -2.0295332762134715, -2.5691692437863165, -2.283791251466373, -0.07579771907032773, -2.062316567830914, -1.9616509325135103},
    {-0.8311735692432041, -3.4895844734315684, -3.9300893354733897, -0.29067220275794486, -2.128962541674954, -3.287963410143063, -0.30671857117007245, -0.7838413351598714, -2.4943705873463613, -3.717951324255897, -4.232430205937577, -2.3103727964539815, -4.107761967797581, -0.48211271784214904, 0.42821982970606937, -2.9587841928887517, -0.6112119107933897, 0.4412756877724035, -1.1716974440122874, -3.6771713101758343, -0.9616946644787827, -1.1680577501828469, -2.3494536233587113, -2.3941378296709686, -3.9649057281415385, -2.7937158890185128, -1.547186273578522, -3.221541492409434, -1.3830857246825252, -2.0800320892940536, -1.7381867254256607, -1.0687019977872452},
    {-0.7921219830654231, -2.4167359684724223, -2.6270310240320294, 0.15021834051875432, -3.2372155373605485, -3.4233020288572154, 1.6173104055353598, 0.25237526525706805, -2.0127447149876567, -2.358367886770846, -2.550179696947701, -2.1842836216977766, -2.490578129949095, -0.7410423070166572, 0.6433387739901446, -1.1395574265378792, -1.1429668046455632, 1.8169289298116373, -1.7710721116500234, -1.8074777077290662, -1.0758626423338362, 0.5419119476113693, 0.22862007657336803, -2.5798937385810055, -1.6864852154038477, -3.017231773609489, -0.6028668179741088, -2.091851166144142, -1.8625231733334275, -0.9428162091256052, -1.7709649304116124, 0.12166874606555084},
    {-1.8376579091808838, -2.1122178379047862, -3.208883886453349, -1.5027277261870386, -2.7536537435531354, -1.7674689212082422, -0.2803824625721458, -0.8853792464236914, -2.1039400379005255, -2.9641149048204896, -3.2037209527050567, -1.399203429512972, -1.621638191367699, -1.1436747662085485, -0.45354309813916904, -2.552376587246358, -1.5399090919986909, 0.045589543760660975, -2.1030880832967545, -2.5814330511095243, -1.9165097945643208, -2.1541243447070375, -0.9449642430039646, -3.245903280957818, -3.8058487236423444, -2.5855154147909607, -1.4736473831541586, -3.211498093801533, -2.823425907324479, -0.365059004140661, -2.632221797697006, -1.7590999229084252},
    {-0.20089008117291013, -3.3751288720688137, -2.4754304543649406, -1.5219525589119602, -1.8703585526367428, -3.2659419125987177, -0.43868083625177273, -1.8852297853531472, -1.2913453120899734, -2.291838961749598, -2.110689286847281, -2.8361872142048172, -2.9810873072994233, -0.17634578645281862, -1.012883270996943, -1.9170855855372493, -0.029615947543127068, -0.0009768039775810635, -2.127417501510757, -2.5363817088958527, -2.7611264731774523, -2.3904494223436163, -2.145409049196025, -3.302716412399522, -2.850351895094457, -2.866015339678555, -1.1546570065704638, -3.497769974962312, -1.382417483295328, -0.5832240235743003, -2.612874997892834, -0.7130407875018884},
    {-1.5339542138356579, -3.563592195741354, -2.25406338789521, -0.0965756135790243, -3.717352621949434, -2.495448658236713, -0.3503993639545611, -2.54215986872705, -2.1620138558776447, -3.0351875699277566, -4.22083880683369, -3.286665291334207, -3.8166408005865926, -2.100544393380692, -1.5117780441836826, -2.8117464343423433, -1.0375977964788556, -0.38320343520031314, -2.5948899170105975, -4.6044535998560745, -1.9196446203449462, -0.3014199673927457, -0.48376598958725014, -2.9273052752108106, -3.455150413924142, -2.864718237556628, -1.8229867146922374, -4.0360261805710875, -3.2606514729718716, -1.3260371837048552, -2.363383458350473, -0.2706215184365426},
    {1.070097491750943, -0.7293270358479232, -2.3411183060822696, 1.9716178941439415, -3.096409338865254, -2.995645248558243, 0.17928595264832095, 1.0528750432788088, -0.7470525712868394, -2.179182740688979, -1.371809242876329, -2.65038350838044, -1.2420871580433526, 1.0528797766891858, 2.360742574122965, -2.6149206182368, 0.038261317145136316, 2.85249130941715, -0.0760739357165096, -2.146032495877777, 1.1303927801625115, 0.9067820548591314, 1.9245097303567293, -1.1320756959496647, -2.313568020373596, -1.5616002296661475, 0.016153399933881003, -2.8929593712337076, -1.4707850399345148, -1.8867083297521614, -0.8317587766108611, 1.5545997984329087},
    {0.45766588427809335, -0.5674750759780467, -3.726230601975626, -0.5880379675560947, -1.2174601635773903, -0.04959719796223128, 1.0866076793515125, 0.1185129109761904, -1.2454066432401825, -0.7324541868481547, -1.1441717852793416, -1.1466665533654667, -1.354606458510714, 1.207225034767633, 0.9861645267048065, -2.299577238462315, -0.1236948924400377, 1.5992350574841643, 0.3446593832923555, -2.8170515220852557, 0.25607330586275145, -0.6712961225894983, -0.6213102139733558, -1.8500355084123, -2.471130641999685, -2.3394854415711346, -0.1332158946114301, -0.9858090130894566, -2.252999513422715, 0.6225959464406439, -0.17250125480696152, 1.0338791481055045},
    {-0.3423732031113826, -3.271344939812705, -3.3017307031075624, -0.7575077865747216, -2.2039960100231446, -2.4742197401582375, -0.017879756608269383, -1.5773452578012308, -2.494456347897011, -2.648923571849545, -3.720545532134099, -1.6124632489223072, -3.168394818793181, -0.6733680631118847, -0.11639007072147069, -4.305037315509873, -1.8759526369693642, 1.3558386769182196, -1.0806836775194038, -2.767177780369466, -2.0108937647511986, -1.2769300251449773, -1.7316408357565247, -3.465149389618205, -3.452755521584548, -3.4085209999428194, -3.1605215596840854, -4.410389669433056, -2.338931174394621, -1.8991571377423195, -2.1104199691786265, -2.364311107083779},
    {-1.5623909171599628, -2.3217256465439644, -3.119974450661121, -0.5671682862646205, -2.678246540315539, -3.0098991635061423, -0.7677721482235227, -2.882798500486765, -3.3953984603759197, -2.9451940487746815, -2.8602245127948547, -2.5264468291704465, -4.153169134384583, -0.7070292495632711, 0.15516425802310002, -4.065163225064274, -0.35554037921820253, -0.5674585006519924, -1.1705927646469296, -4.019771319401327, -1.1045896387057337, -0.8294358178109397, -1.5680184005107136, -2.033740527423485, -2.666032065060415, -2.2610706265163443, -1.5908882110195892, -4.693191852332857, -1.6923979319065208, -0.46760216705573193, -2.2270201177678572, -0.012462455474735458},
    {-1.4737864943270345, -1.7621944155202152, -3.5102394836350244, -1.1130882003523, -2.460356009188036, -1.5605309219190588, 0.044966137931653063, -1.1755922922344824, -0.9432975103572443, -2.115466125967029, -2.3249143922081434, -0.10253899612212067, -1.7465563801410429, -1.235147809147999, -1.2855233553173087, -2.948915863386435, 0.5063253311527954, 0.6819478347940952, -1.6304594765376361, -3.0352253519705217, -1.6087025373739752, -1.74150023522475, -1.184306393999558, -3.32725836220617, -2.678027537426837, -1.5588798908912822, -1.4015784803451683, -3.894221378047273, -2.018179741559624, 0.2959469999925302, 0.2913643046372876, -0.3060941003934556},
    {-0.41841881697600924, -0.9511041101082549, -2.597850907883041, -0.7230920295949275, -2.736158244669711, -2.6788422909009566, 1.0790754328581635, 0.31219591654177703, -1.296700159957652, -3.061000633234008, -2.4254974545220023, -0.8611306234477237, -2.69364222351401, 0.14041438995619093, -1.0055920685485569, -2.9925346130506645, -0.6764506969701063, 1.8011000490486362, -0.6324425342799649, -2.4862846257006326, -0.5432837007043709, -2.025474712339772, -0.021695579641515438, -2.469700263589239, -3.4534664049060697, -2.8594137547543435, -1.0010980300347883, -2.825221571031664, -1.1896179075175142, -0.9116430396036902, -1.4974854778221116, 0.3562815753818088},
    {0.30423835336654653, -1.7076690031430202, -2.520082048436611, -0.21556245520101044, -1.5444746787969499, -2.827025494041833, 1.0884636846110962, -1.531090645163595, -1.8736471104940897, -1.3468871854695628, -1.6904433578212337, -2.2447038674619644, -1.8105575357524055, -1.6013976813004775, 0.38847659792848865, -2.547641363443747, -0.010517649933700995, 1.1504726603814774, -2.0575939312256333, -2.370230950109844, -0.30131089221178203, -1.5511287011021544, -1.3489914704844355, -2.5599505204636577, -2.130290429927863, -2.7682860757129277, -1.2024659641748037, -3.592049177265283, -1.5349198348223758, -1.2772580557755973, -1.0707260726120131, 0.5358360017208867},
    {0.3360742672151037, -1.367190284735937, -2.140224921284692, -0.7362858382522539, -0.9335768095878733, -2.3353799169275686, 0.1902250852763306, -2.108012285084878, -1.325479999150127, -3.5495871930002467, -1.91316613660582, -2.5834236366461303, -2.0062686209573033, 0.3076230495934022, 1.0444168367965312, -3.8250675397817417, -1.0910509597090783, 0.8600672967665165, -1.5121974227573869, -3.3698760952130264, -0.3834929415113421, -0.7173878015282529, -0.5463994841587546, -3.7177215229789202, -3.0956231800271405, -2.5517298472976044, -1.4098009614154565, -2.199295782124911, -1.889486671245174, -0.5257358658929757, -0.3790423422216629, -0.04279633768129993},
    {1.4621412583454694, -1.65235659970704, -2.1590048449298185, -1.3329585396563244, -2.248651711908813, -1.5263076494452783, 0.8458051603911074, -0.6359571746046934, -0.5549151087118295, -2.5262414311963233, -1.1248000352309826, -1.1066442698267778, -2.5450105515255643, 0.23606281665010234, 0.4903492177105714, -3.066057254128121, 0.4169887467730755, 1.6939929967743277, 0.49906080402775344, -0.9395419862796239, -1.1568299026056152, -2.0170998411810883, -0.6287865153880149, -2.078346102079402, -1.8118387668878504, -2.7759473648559236, -0.45720086063058224, -2.501016502284619, -1.3936160626275278, 0.7922606772889174, 0.28586065341643485, 0.020640594186791532},
    {1.922165587586509, 0.3912277710732756, -1.7152310913880202, -0.3410201367008238, -0.525875991363574, 2.047291494423654, 0.7769396969185951, 2.5488714360487794, 1.229971093620622, 0.8489688345689801, 1.6118483652253452, 2.155062815787636, 0.7500993389084917, 0.49980547134536507, -0.10517797086270698, -1.2325595511198428, -3.3191785222968324, 0.8856713564827968, 2.215651843286586, -1.3308343627866135, 0.1360769258084824, -0.18748454263440356, -1.7935434901797473, 0.8438936394534142, -2.6485460464447974, 1.566819797668176, -0.9952089001995466, 1.675397589757637, -2.0063765476793964, 1.0133419771531686, 0.32984762621471186, -1.288864353897189},
    {0.9341896463056726, 2.085587349146836, -1.517235651369528, 1.7406898971080391, -1.1050051707278368, 0.8600267527292618, 3.770516608972917, 1.6116824865402106, 2.472577647352901, -0.6386557859934964, 1.0576202501478664, 1.4118312885811284, -0.18168534087209082, 3.0406206902146242, 0.6561449104382158, 0.2383238447619293, -1.666758886190046, 2.5692739174429224, 2.7805013902834257, 0.023459051240720716, -0.24056848476836934, 1.0891597988451456, 1.3656240634612207, 1.0796515049566417, -1.2503292023269352, 1.0330434639394563, 1.494606856566996, 1.9448520821120217, -2.371462405947716, 2.867291928716354, 1.4503928855323232, 1.01125990797376},
    {1.1757533891714698, 1.4996126342367913, -2.1999265399078136, 0.9602411769204593, -0.7484757680069721, 2.2612768598874844, 3.483385995836435, 2.8074222120502257, 2.23757524636097, 0.47665467193409544, 0.950012201827368, 2.927394923242412, -0.7985781227179402, 1.479556311353168, -1.3990549667204069, -1.2841930678717788, -3.428967654258803, 3.1743631753565698, 2.45648475084706, -1.1387858691239594, -0.3213170521176682, -0.7467349658094592, 0.5977672774879541, 0.44325421117713976, -2.0312844544832416, 1.773209987071745, -0.46558247531460456, 1.4106965199621606, -3.104300806280208, 2.4582778270992316, 2.703042782796912, 1.4672970540604204},
    {1.9977825074590632, 1.4702828643074775, -1.7556340349851498, 1.6433264679025406, -0.7056004316641821, 0.26215427252219003, 3.9703600993655104, 3.200729371142434, 2.664737659306838, 0.15375993100912105, 1.5568959436472187, 1.960491623813249, -0.28626919819618585, 2.0368384201672467, -0.7133904157490321, -1.0761141628651347, -2.2874797615710047, 2.6733122421066833, 2.3055181217480274, 0.5889386039729815, 1.2246927431583854, 0.9233330877815468, 1.6122136113112295, -0.24471244018625504, -0.6816917814458243, 1.6897099050596749, 0.33260721271263066, 2.545604890779611, -2.7337539509150828, 2.695384672383722, 0.7492135266698523, 1.3635906891821896},
    {1.0251811037585938, 2.2422314222223654, -2.2434256807784947, 1.8926368526505593, -2.1397253497305244, 0.9377864880464349, 3.183995326061235, 1.4484278304607727, 1.7828615628940567, 0.07356053225791122, 0.5573403784349641, 1.515588913018271, 0.018510467856903003, 1.4707694668377742, 0.5753917989505578, 0.5546486286787216, -1.7545577476786267, 2.4025644632388126, 3.717227631235412, -0.9853781674609194, 0.578348313443267, 0.4720434786544438, -0.15577483899854647, -0.1838790647787513, -1.239237438221769, 1.923782848751415, -0.792578558677441, 2.1290220074589263, -2.5550101106687797, 1.2302385137271767, 0.5974204783554957, -0.1014481096441227},
    {2.2442496590483225, 3.178319664447906, -0.7331680059243274, 1.6136911920150931, -0.9216865847382568, 1.3398047170068683, 1.6976367609460659, 3.31173089149734, 2.8839042285452234, 1.1009832409448492, 1.1612269747549528, 2.2893574079399026, -0.9653979160932732, 3.1448281593068113, -0.30360872527882, -1.2708921550753558, -3.5615334410273505, 1.911456375413569, 2.799557922130796, 0.4075731939406448, -0.6970711945986874, 0.9892173001517841, -0.5285479643175686, 0.6516882319954481, -2.3509130708952064, 1.4181784776412545, -0.7982632673682329, 0.37419996353316876, -2.3822339343513956, 2.8804600773770392, 2.6726390766423322, 0.3154991442970436},
    {2.5015806356600527, 1.62465121462874, -2.425339011672171, 0.6807356502455064, -2.7642355606744213, 0.8342125148720655, 1.8803856369358691, 1.4266197254144772, 2.315131939512608, -1.2693068144383715, 1.5215763557141833, 0.7030035025521911, -1.4595377631005313, 2.376748995221156, -0.20414441748167536, -1.9785786241903578, -3.7898145474569707, 2.3376694892065113, 2.4658055325561374, -1.572361326745916, -0.24002507141537816, 0.33661243350282244, 0.02264451521630473, 0.09893362460620239, -1.9191322355428593, 1.0940320573728317, -0.2522924612343135, -0.4242960424657797, -2.38708615961428, 3.5474942831896104, 1.325105996562719, -0.7230924170105388},
    {3.147126170314011, 2.80944892841259, -0.18769943408409306, 1.0856234946783834, -1.9076605736363823, 0.4117642069216713, 2.2436148379370953, 3.028130961421038, 2.7356985070628124, -0.7207465678601075, 1.4466632243615631, 2.426408914341894, -0.7378927347650012, 2.9832433733014527, -1.8643445279164044, 0.5744440863083778, -3.0598594418022933, 2.7893561764797017, 1.4833100866708977, 0.26868987063553246, -0.09988348365406374, 0.9210289568174058, -1.2182754098638724, -0.31710260409880464, -1.850860106387967, 1.6724904714024644, 0.711286427541815, 0.5597417163230229, -2.671696516919785, 3.31586961883747, 1.1671570734476469, 0.8390488913636291},
    {2.92057952336529, 1.5848644786067458, 0.16862110708348135, 0.6249452342444864, -1.182849875231922, 1.6746349685476172, 3.452751255074767, 3.9677385955711024, 2.945035571974743, 0.5015866849348356, 1.634328154223489, 0.6312186078578027, 0.16125349635633393, 2.5195726678615107, -2.0634571669441, -0.5534198801483511, -4.309356670081232, 2.681457217030036, 3.6205079189639404, -0.011255013056797675, 1.0252432855664904, 1.0518564325536575, -0.11525701694932769, 0.7254018648913293, -1.0556703794116122, 0.16251796415247116, 0.1034236982548931, 2.290742779205651, -1.75814412183254, 1.4891437997019175, 1.4542287457645768, 0.5883374129665071},
    {2.5616645935986044, 1.3042796981915319, -0.4266853169662568, 1.030292195875107, -2.5367397140627532, 2.0739900213917557, 3.2648371033925017, 3.561501594578381, 3.218737989266618, -0.700941713892664, 2.4997923615595656, 1.6691989720109883, -1.3193245062158168, 1.7727603855190965, -2.2792603374421883, -1.424887699524335, -3.8493243083180646, 1.1854168519030086, 3.362530038162117, -1.4848970563339012, 1.3511214870744275, -0.7196024286432147, 0.7574417187678796, -0.10494909943125069, -2.0138682867144286, 1.074628971955004, -0.5392881009331244, 1.2246817720238945, -1.670585507312357, 1.2973529302566118, 0.7686869861652196, -0.18307682250831744},
    {2.056136704455649, 1.521589456551176, -1.0496430028729837, 0.4711830666659349, -1.8035741342310097, 2.4695008586658114, 1.8171922364095616, 2.7991124156024627, 2.1594458026508034, 1.501676909632992, 0.7860238705594089, 1.1679855406724715, -1.036897208718701, 3.1444488715223557, -1.908575255590003, -1.607481344526048, -3.0820661601986474, 0.9857697535108305, 3.2178897119155296, -1.4585199993537545, 0.5102242666933706, 0.7304666119736042, 0.07013056271906218, -0.4602393992789495, -0.4552844100738586, 1.1698181622622028, 0.7676444129519866, 0.6046165152181612, -2.0525204136628794, 1.6093626136308927, 0.4527456181129927, 1.481262169579057},
    {1.7887707887498105, 2.632822591317504, -1.652914128037864, 0.9054902442256327, -1.6713484121213593, 0.8410719681509005, 1.9223048055479313, 2.218625726498012, 1.8852372945470597, 1.783405054850115, 1.1824296464450077, 2.3162966765703996, 0.04376455163818956, 2.302521883482544, -0.19236450507075104, 0.3756904895518473, -3.9228770352333457, 0.582737311822387, 3.2141788506970834, 0.3826439611601101, -0.2864935890321538, 0.8641061560881506, -0.4416544124103164, 0.44558297380705336, -2.753339445831389, 0.3935471214992409, 1.1997745112279057, 0.4830482908036593, -1.7260364797518015, 2.4265744119504484, 2.1621263896293392, 1.4585353334210376},
    {1.5501986056667687, 3.283237318011981, -1.9985165640480225, 0.5141838500924855, -0.7699971034266204, 1.3336693181223518, 2.2984031292525686, 1.809094835800373, 3.374796610874726, 1.010862458175203, 1.9652603976568548, 3.0810958329190767, 0.5640752725913124, 2.7915713395120743, -0.532916244152683, 0.5718097909934908, -4.0624435933592835, 1.9139856862158882, 2.330007228942757, -0.821032571650327, -0.2780986143669609, 1.101274428759795, -0.2639393746025462, 0.7083397152389551, -2.6504461962001518, 1.9021517637575422, 1.3404947170370693, 1.1700480039290366, -2.77849568172332, 2.788505976040362, 1.9994320408348656, 0.8995946287409322},
    {2.7210144861360623, 2.5887668212065686, -1.5229070433284486, 0.8863727664467581, -0.5992253384355429, 2.5728241585931393, 2.2482095502940775, 2.0878636124331678, 3.0987136088341694, 0.8001055135580414, 1.1587272776303066, 2.4066306153547843, -0.7265424866007636, 1.6624801120136476, -0.7203157005177203, -1.1506703816434878, -1.9796309374103607, 1.9361119013580237, 2.709931718066499, -0.38906563523106047, 0.6640331201010597, 0.7078903649969648, 0.4892205335355937, 1.0788136141825928, -1.6116544262667356, 2.336054075806041, -0.34556576165851594, 0.3142508664996254, -1.0990844280356793, 1.6744672010187867, 1.2062636673523062, -0.012692180637495436},
    {1.3981144274498083, 0.9281526682399946, -1.5237334800303173, 1.243578326321717, -1.8604444393350879, 1.9543526817642292, 1.8657761925175953, 1.097547612631679, 1.5538370261797323, 1.5912112522879838, 1.103356390610289, 2.2256287417679403, -0.554488901795099, 1.0362379200884972, -0.008724708770457466, -1.8365179882826255, -3.759378149900227, 1.0635943427590986, 3.4708974192085664, -1.3883894349521433, -0.7761014937665445, -0.4000258514377695, 0.49213322068580373, -0.40201002584197937, -2.3960929118270524, 1.3172630580936535, -0.1616930368106727, 1.1612201659094932, -1.3190612501869836, 1.8129675238154837, 1.8058450940780124, 0.5956607653229511},
    {1.3941344433425458, 1.2850085668668836, -0.4633533143522375, 0.5999346097021635, -2.5611583498752517, 2.263375079492432, 2.6928198494218023, 1.1411530540173054, 1.4042553144300003, 0.41576914721290403, 1.617645026683368, 1.5406571919229548, 0.3121494187587343, 2.2191234509597946, 0.24677463111445105, -1.6846593887041719, -2.519596112737208, 0.3645459726556392, 3.1753988084116487, -0.37143573373085464, 0.22117806578207108, -1.0509473107663796, -0.7603664549736632, 0.17853922240571257, -2.3620974737734737, 0.14883117466659015, 0.13765022211497385, 1.0694431247594989, -2.9553082469765393, 1.430885660585664, 2.757053553079891, 1.17181139717423},
    {2.8857682324900837, 2.6341777723056765, -1.0506440082756558, 0.36863508984033105, -0.49134451502663845, 2.5909922532381895, 1.6144659746038854, 2.525919267388172, 2.6970272438572613, 1.7239406239167192, 1.4070068928592576, 1.9129926523787923, 0.30361606156208354, 3.391352690735207, -1.6113800217410348, -1.9545357914319617, -2.126569623792307, 0.45634696389948515, 3.7579227168152447, -0.7709517343843325, 0.6935646927467525, 0.6811752091967169, -0.25016026704322597, -0.22132978949085858, -3.0091173602495855, 1.689141900251278, 1.2158174633265348, 1.9806749332928018, -1.6763299798989244, 3.3107805411904034, 2.2614267391865517, -0.1421035430124153},
    {0.9903748359865271, 2.922990587091656, -2.4409561079075925, 1.334182562141298, -1.4096425356928832, 1.1100330311791633, 2.70749239457949, 2.0564106173960135, 1.8926284582586363, 2.108909502983872, 2.861335380130212, 3.1263892220988336, -0.9224962512079841, 3.5454977889807395, -1.9146140248077193, -1.2635128951011172, -2.5093408136682678, 1.8898537496384538, 3.7529962204287184, -0.9626382070124128, -0.9058751723667035, 0.8448592639308204, 0.48038078411753254, 0.9092315188854425, -2.6999775477919856, 0.09636004218219082, 0.5788292892583518, 0.789505294455076, -1.1297581960598309, 2.2323516422939815, 2.28603229932693, 1.4596098600154148},
    {2.0637328271427364, 1.5818426669121357, -2.505162768275613, 1.5323741474240316, -1.6166956476110748, 0.9286840680663104, 3.250559049885033, 3.1367065359015966, 3.761697113771958, 1.9402703537435806, 1.5516063599349101, 1.522761192011325, 0.0630504650511537, 3.3901441682376623, -1.1267050768748796, -2.0903321731077393, -3.646192181511925, 1.7874129308932116, 3.937440489460167, -0.9211963975053694, -0.8446900569880005, 0.4320103893031213, -1.1891013641459174, 0.23259827963614693, -1.8385161427219554, -0.2814527701182313, 0.904315819316772, 1.7162893673601727, -2.9900536409250513, 2.739813198011899, 2.490444597227398, -0.008397886433779566},
    {2.5772963138129343, 2.347499385142287, -2.0918793874412356, -0.05429623651848885, -1.7330911366808086, 1.4016128922169078, 3.097522124943191, 3.9125147631651522, 1.9969918227800896, 0.32219399072893584, 3.0442970993997767, 1.8349869568221417, -0.8679146355952152, 1.403247194265634, -2.4191602866726467, -0.031428699446587514, -3.9805854500053024, 2.214261368117886, 2.844930946306097, -1.0270622287920521, 0.14477887015295549, 1.0863286556099365, -0.3050520924704464, -1.0936485978855692, -2.452187248801237, 0.07160741232305737, 0.5616333638499719, 1.6575435787282107, -2.1722114320371517, 3.308592569401865, 2.771222632525485, 1.5004712010609047},
    {2.3047423878722846, 3.156736023188005, -0.23001842519562138, 1.063950294013397, -0.24715099489296272, 3.171644952954392, 2.6305493354375775, 2.697432951358306, 3.213502083293616, 0.8972741978389815, 2.4872269496922486, 1.268110980050407, -0.8726116627890512, 1.4408788236097045, -1.2633137040972349, -0.6259430608289626, -3.3206715388087, 2.0745203806394796, 4.078685129050618, 0.5215943309473042, -0.09454680406551196, -0.6097416812880962, -0.6949288557514712, 0.6386719230159897, -1.8378308752604673, 1.032540443643022, -0.01768960384912073, 0.9616521226755114, -2.1195064745754113, 3.6306545476974503, 2.748749415120726, -0.336909296101557},
    {2.654595159374577, 3.4946588366070106, -1.2803449248658705, -0.025245117270830456, -1.4903438174116495, 2.9119200442200786, 3.6603792844665737, 4.273723093511287, 4.1330437069254415, 2.434484453303101, 1.979953909102226, 1.6672673132445845, -0.9019230010929186, 2.2278746794464706, -2.396745452091932, -0.1594730599786802, -2.501571415956014, 2.367842252808926, 2.891132050982978, 0.731336240876118, -0.1283490216291782, 1.3914248575506833, -1.5506009959163431, -0.3894996548867252, -1.4642067343770153, 0.8871986426881568, 0.2538179449528031, 3.2467677558903323, -2.2582982432105867, 2.4603147675289256, 2.112464850783035, -0.7621181916538832},
    {2.3547220170142835, 2.3839846241769735, -1.8141397854274073, -0.19491658601762435, -2.137262171761818, 2.686809987597428, 2.9808595984792166, 4.392408810513145, 4.021861377337516, 1.9973153328482258, 2.739600144544873, 1.9377020247433936, -0.6373183424510803, 3.4887221117189275, -2.294857828624911, -0.7404359411977326, -3.7175768166126213, 1.0963448284583857, 2.921996472531788, -0.12197854755948173, -0.6213626004821421, 0.399448532596391, -1.7362958687874355, 0.7885499998890793, -1.1713636794905715, 1.1818551574778826, -0.8089782393998012, 3.3502650495683963, -1.2990030293093968, 2.1327485048099293, 1.3520092781266582, -0.34416118958635594},
    {1.0187094409548945, 3.9042046912479167, -2.7811339297393376, 0.24462537937316883, -2.4844857663106414, 1.2345576801145433, 3.9578815687017213, 3.4140560942276776, 3.9860365179076305, 0.3627091241778751, 2.6587165893027738, 2.0397794119258177, -0.14553001624127343, 2.4778720503112712, -0.6654247404554462, -1.551539006390411, -2.162836641360238, 2.281512587353209, 3.037933795292241, -0.00015510680223820565, -0.5068894982559712, -0.03749806477773777, 0.008624628692192233, 0.9933457833778068, -2.8041917089531223, 1.4924186761745795, 0.6393631645002923, 1.9537055625090058, -1.6647488833850372, 2.292314887708371, 2.8483382835617768, 1.1694498039661871},
    {3.1040538263437654, 2.401932626629001, -2.0066592795382667, 1.3193719008122955, -1.257866328693358, 2.613313067729791, 4.430853061178766, 4.2501322134420425, 2.2095934314513688, -0.09271436793063835, 2.028714904952401, 2.7464011750386526, 0.014579439643057801, 2.534728610124524, -2.5676669410943056, -0.5235174077217779, -3.8828054414754076, 2.7134988068052595, 3.312336934787568, -0.19387691832397944, 1.3827502119357402, 0.65660053170058, -1.241693863165093, -1.2994326581727915, -2.1860817843591156, 1.404275908814667, -0.30139541071953874, 1.0724145214654184, -2.7688403984179253, 3.145773432983081, 2.9284649357884005, 0.9673804229491846},
    {1.382574086540319, 3.3231887465746515, -2.134228707737778, 1.4104354322768502, -2.5277481413285847, 1.536659197922181, 3.0492414777088857, 4.173477908148117, 3.6946181222980363, -0.13209197515272558, 2.4610229831490766, 2.6949740227857037, -0.6471356815163105, 2.447983189015571, -2.0961729391257777, -1.9039505021354988, -2.9858089813806066, 1.6709747648213436, 2.5495022923323365, -0.2003775329021928, -0.9807478450744564, -0.22976833891411041, 0.05250970838490561, -0.95414905948173, -3.5255871192006785, 0.6499763153292606, 0.5277656571312352, 2.191092612377673, -3.2611389470614878, 3.8510674572094428, 1.7610268714762727, -0.20263918425569247},
    {0.9957619818407819, 4.08199019623221, -2.587104244423129, 1.6646019932590816, -1.5015523658662782, 1.4298055292125802, 2.763112225535189, 3.2370070515851026, 3.817695158205943, 0.44040389205860214, 2.9984475463929794, 2.671676294873975, 0.6116528841612177, 3.0843439828691617, -1.003290410139941, -1.2067811424796326, -2.529939538789337, 1.25527245133475, 4.1201786008125865, 0.5496745231329073, -0.8090012849413003, -0.3911091672939289, -0.6385629714458553, -0.7920040435287662, -2.977927555061049, 1.190505317530401, -0.3723731601101225, 2.1653118184854323, -3.06663400689891, 2.6995078629872427, 3.1157599488086727, 0.26944830762902255},
    {0.66898293171496, 3.4295444902209695, -3.428951941821471, 1.1288515961818517, -2.4213196295822588, 1.000160129088466, 3.1708612752957155, 3.5182494338120716, 3.9592235192428715, 0.27499869708966806, 1.357627677386132, 2.097801024603357, 0.20374349188201035, 3.3476073703683706, -2.1935620739980166, -2.47847469160023, -3.605341605636833, 0.5681729819397006, 3.826394262946085, -0.9443063617219122, 0.8409789739148485, -0.044724847083544315, -1.1155597568269646, -0.5292346856071624, -1.8194823488493252, -0.4624867844539578, -0.5647600655830003, 1.616535902777953, -2.1248814401183007, 2.8544706251972727, 2.6636823450970444, 0.3956618886004081},
    {1.0134438747586114, 2.9016370051326645, -3.373198102523882, -0.03261280910352807, -1.6287413037867906, 1.1881326957540779, 3.639006387041165, 4.30228041831493, 3.322468227164685, -0.3871214148746662, 3.069218830150061, 1.5791289496594576, -0.4526403778509662, 2.305949655667506, -0.8681721757203722, -0.7168365979366326, -3.8411708753276077, 1.79181720553441, 3.9265298771930226, 0.3023699060398216, 0.20678751621316363, -0.21371004578824543, 0.19804283003666445, -0.9349385255314719, -1.8352855836468893, 0.24576842342833596, 0.11584997143318045, 1.4873973761691446, -3.86743779996049, 3.567443467849055, 2.4807538547472956, -0.2900602256807674},
    {2.610858897197919, 3.038453596657515, -2.5329346367921963, 0.3778292252504151, -0.6816536013222081, 0.6209301654803335, 3.5383072914465252, 2.666935471394616, 2.278723127869069, 0.9733874432992695, 3.0201975085448245, 0.972355569712681, -0.9681057832224774, 2.483780648264317, -1.5442872905462988, -0.6994541210376254, -2.5322891542094026, 1.2428099535159622, 3.3546929789830826, 0.009175027243520465, 0.3151562003860792, -0.37034412961876323, -1.8766352488676536, 0.3850635300667587, -1.9428468588319312, 0.11928175236744543, -0.8615538749416198, 2.56569862357643, -2.2748963230854864, 2.3382440328963208, 0.8690258279231085, -0.1152271505398134},
    {-1.3286180832579382, 0.32560930784691444, 0.14653443166876712, -2.3432132251269064, 0.8537167417224368, 1.9002639198161506, -1.212295183329042, -1.2237196534910626, 1.4911322415250365, -1.001659790756738, -0.07541095446620143, 1.6813147438245308, 0.6585222204380079, 0.2327401523881694, -0.22924358348649548, -1.6801174725512782, -0.36274057768837303, -1.6759722264327197, 1.0290622245507595, -0.9313036601614855, -3.6285177324598323, -1.7840269684383852, -1.703905077196406, 0.15555534312050617, -0.6557617377147519, 1.1782143103933431, -1.6893622873706067, 0.4167691780798835, -3.0170165630108627, 2.5788795044440738, 2.2464162693209007, -1.2153366782457062},
    {-1.5766218947411452, -0.10476746184917607, -2.7179850585404495, 0.14677798928084082, 0.15779712754145242, -0.18520045418089418, -0.9859556267663255, -1.072379624162162, -0.13080229823493877, -0.7688864307944114, -1.8974598576178694, 0.46269532399064595, 0.33130434882812015, -0.019804459698717095, -0.6283910613982923, -1.0106320430819313, 0.10655394203585644, 0.7792987565153074, -0.10674887326311656, -1.793134743446442, -0.7450927206697923, -1.847827792438399, -1.526088393599311, -0.48441376473970965, -0.24311496521289494, 0.22872163603434364, 0.15185401293056236, -0.9198755227151033, 0.10504334141605512, 1.1034231550060112, -1.6354535198155569, 0.16979845792984477},
    {-1.4363454728147176, -0.6208497631448079, -1.7018750731430508, -2.5057074656142158, 0.7259757577518143, -1.7199966852198219, -0.6477228738849191, -2.198873449315019, -1.0690860070100126, -2.1144126137827213, -2.7288808310715553, 0.018914157673116102, -1.3616063000628966, -0.5788784563257906, -1.607022893818442, -1.417516705853008, 0.8866892973333297, 0.29209877038224613, -2.3060688355730297, -2.2239566010052503, -2.3589322760689977, -1.4549231595129926, -2.699003276688948, -2.457690396958308, -1.3120574045196427, -1.3087849391523751, -1.288418502051989, -2.657836476667699, -0.994237465758031, -0.2168877872910868, -1.8354463230278921, -2.965967841536394},
    {0.002041600825530539, -0.8458844186846851, -1.5916738661473444, -0.7917943817207991, -0.3907017473336624, -2.576010624084649, 1.4364355029774918, -0.9158451295847552, -1.1180207280023433, -1.3324762939592667, -0.6297911008540521, -0.3916979086381054, -2.787285616054492, -0.29727457497069293, -2.096943301162242, -1.918136480953569, 0.335565679200314, 0.12032836857892834, -1.0307953941502204, -1.9232269022635575, -2.518670791278912, -1.4123815304646266, -2.697097259235711, -1.6186017638399377, -2.554651270162521, -0.8647142396103584, -1.0086562499037348, -3.0002754182808222, -1.3164197909049393, 1.278843418094358, -0.5928751642765342, -1.4744642318747416},
    {0.5058881257964006, -0.5659232487209408, -1.3923099016553342, -1.1587535080329805, -2.4760650826256825, -3.2819753358632013, -0.4099979804164782, -0.9052510569444926, -0.5319961699184281, -1.3707385280530275, -2.816716194244935, -1.6696671188022414, -2.6935406708931087, -1.2926781114040302, -0.8776478311802468, -3.085848011136043, 0.27535572602251085, 0.43418866277110374, -0.6814551336769974, -1.7863754919296917, 0.25921081465357126, -0.37342680780684717, -1.402732732323046, -2.8549146467707587, -2.2757303279918144, -3.315632339156209, 0.08543782220170634, -1.911834298807109, 0.2691701856225657, -0.525713135436173, -0.8820761855936035, 0.5279233491776729},
    {-0.6231739307258486, -1.4499941231394873, -0.28438681227199, 0.08947509866416763, -2.5979317307157843, -2.065438189725365, -0.4838301772732722, -0.35216603944808184, -0.9879235520609563, -1.4425115750005622, -1.3535359580057977, -1.9170328752878962, -2.4619925673726066, -0.35911987699090575, 0.4848889091920511, -0.13134593885622384, 0.5210070373330253, 0.6894930934676062, -1.5882318107314064, -2.7556988116176626, -0.6353742707630988, -0.9952218371833396, -0.027485340936752214, -2.4911172905750463, -2.522297701637828, -1.3272565690331297, -1.425613241887912, -1.1360102111417414, 0.22473537347986164, -1.31361078699983, -0.28742178622540254, -0.0954323422250214},
    {-0.16539618537239997, -0.3166369253419372, -1.2911252472771049, -0.4270936120195342, -1.364568745480847, -0.21217535666790946, 1.0195716836326876, 0.2763219193373122, -0.3871314741943839, -0.2693185303127396, -2.61826002722299, 0.27656762761582776, -0.1402653672372914, -0.3208326768536782, -0.8201682092864752, -2.323447315986856, -0.8117717191549744, 0.9132930334575934, -0.6118980071996443, -2.122686364506736, -1.6467605282438382, -0.2323718105640411, -1.3403317000162225, -1.4473607386989442, -1.6718540084782276, -2.400391664661633, -1.5237824794199701, -1.751101816532311, -0.0016926485083476293, -0.05051910727504362, -0.13862824887451528, -1.3890431835106916},
    {-0.15603203890775885, -1.6769478824480355, -0.9740054180910185, -1.2303456499943106, -0.9933831147593057, -2.121839476887226, -0.23976901945604795, -2.3175671835184786, -0.7215692073058829, -1.9185845016256171, -2.8050083736537834, -1.653494688846439, -1.7796171235906177, 0.2195663028733961, -0.17903513860309556, -2.6720382371542413, 0.9305305206473942, 0.49802518006423285, -2.075486835212272, -2.798214358392048, -1.7816254634288082, -1.2914643650806092, -1.360254181933401, -2.941823561138912, -0.6004108624784317, -1.2854477640768658, 0.45469127681225835, -0.47166188555768324, -1.8446276437966351, 0.2017251475222947, -2.2177336642370586, -0.8502846659216263},
    {-1.9286616049782255, -0.7491391628396147, -2.8575413058256016, 0.011032707568970436, -3.126771787680921, -2.177130970400661, -0.9737248576273618, -2.593537733763871, -1.7889609713121037, -2.931983483122267, -3.497672346555157, -1.2596647558960907, -3.056202860196356, -0.39201557849952373, 0.1402120510961998, -1.1702949354655054, -1.3620430190923953, -1.2706371932762517, -0.31293651739395595, -1.6394198538884064, -0.7457913105560441, -1.0030855148086226, -1.2585463463185058, -3.528407979409382, -3.1757664810659847, -1.0627209921468634, 0.33977523567708107, -2.138662025080903, -1.7697461768114986, -1.1082205888004064, -1.64945284767539, 0.10996348209170749},
    {-0.14772851380257881, -1.078858776316178, -2.1288404033515103, -0.7418851680530832, -0.8734997995109589, -2.676949083083799, -0.88520190136803, -2.1563520447091626, -1.0511027473237258, -1.105867920641521, -2.504671561067814, -2.165495819092112, -2.3303318406210796, 1.0139423932723703, 0.7019206699271707, -3.034010394543287, -1.0285531560198546, -0.3992605006138623, -1.7939344666831964, -1.271318481322687, -1.543015775799987, -0.5303098962375153, 0.3844782136124864, -0.9555709742404235, -0.452948480115667, -1.249585831600378, 0.6888291789380376, -2.7628312905301136, -0.5625276067719578, -1.054614439345906, -1.1736813491166214, 0.28454864235600325},
    {0.3846272905379305, -0.7915262860781048, -1.3428028994186947, -0.5916874957777709, -0.6806011764402586, -0.2661254590773983, -0.3038471197762256, -1.6193170417866063, -1.4496443446322762, -0.836224901505489, -1.097177854482095, 1.1716910385077899, -0.7531347699896535, 0.7268054348952664, -0.6873584724003503, -1.7616544444729028, -1.3257322100513795, -0.6347751443587734, -0.1478818076487086, -1.8061039045404321, -0.595810854913212, -2.025978173040395, 0.3870247876835523, -1.9359559715661563, -0.06789590887506824, -1.392309882291558, 0.21182381772875783, 0.024197678539586452, -1.8034208892454515, 0.08536696259241074, -0.8635128204017058, -0.6286297808011263},
    {0.8333073575485622, -1.2731492381108809, -2.187263335594743, -0.6654627685372856, -1.3375520380992965, -1.1565508860049036, 1.8431484676685146, 0.3019371053470705, -1.4836913795453655, -1.303917537578454, -2.857473775691886, -0.22821729035886126, -2.3816917534819058, 0.9401560313842808, -0.9915036924360858, -2.898794399449271, -0.4173111969385319, 0.6248632323568286, -0.5169018618950854, -1.760714564221898, -0.7787772289020181, -1.213591202864239, -0.833730816535209, -1.829709934465975, -1.8830174443875263, -2.597360350628077, -0.47293006734024584, -2.8152816296112713, -0.250562207887174, -0.7893920094044091, -1.0595926629889343, -0.9962310445498689},
    {-0.92990349151413, -2.5612013557805113, -1.2249400873469913, -0.2805704807983175, -1.6389332082035863, -1.1473971362970163, 1.2995507373601969, -1.2838833924680244, -1.4020856490147935, -0.5663033128600814, -1.9413364950220597, -1.0233938122823185, -1.520727564657753, -0.3783639535183907, -1.3256560711431797, -2.6445298148818526, 0.8323792766091456, 0.207044077631489, 0.1476643721338016, -1.7356699620663927, -0.4141374138611342, -0.0936287959717041, -1.7885548349313316, -2.490880419600574, -1.3386823892572652, -2.302802023964457, -1.6246015854847133, -1.0417702516233902, -1.6399946312366733, -0.38428047147011996, -0.23989716924428256, -0.3839649347239707},
    {-0.577455056445148, -2.0135189832608664, -0.9579822913750876, -0.8353228175682638, -2.0147182134085035, -1.21294106518797, 0.9498058224506482, -2.1056022779983325, -1.4634744717242678, -2.1353407747926254, -1.8011368386688182, -0.18633028979600122, -1.0362794269156304, -0.849241355184519, -0.7138948706187277, -1.6457170508566161, 0.029124365491993466, 0.6708823002849813, -1.0455904622178105, -1.8986433646644623, -0.06232798977172161, -1.4746366297406233, -0.6529160665763124, -1.4890624892065893, -2.4727818003665862, -2.6930563529490033, -1.1803962726802966, -1.7876219119413317, -1.165823330481921, -1.5843572875847711, -0.8770473813737684, -1.3156515784109402},
    {-0.8356243946550499, -0.8829532556196333, -1.052154683022737, -1.008596386558671, -1.2351576473699484, -0.9316110209328893, -0.11710039866102945, -0.260655040429094, -0.7587572242160102, -1.8128560127829894, -2.8747169337525977, -0.3033784129752792, -1.7155219199683103, -1.5466010902245693, -0.5595978144719489, -2.7460924374577704, 0.2812372797571989, 1.2187931158665026, -0.1611894705412123, -2.487357684612339, -0.23306399156360844, -1.988105187325167, 0.1624609666418277, -2.6018078857763123, -1.5956486404468704, -1.8877727011478376, -0.8998973231147772, -2.9370689375127257, -0.46501513125880317, -0.31834501447668967, -0.35432625203456347, -1.9040136745814193},
    {-0.5092589025122255, -1.650472764946847, -1.5948537583122533, -1.6354284648625654, -1.2444504506721832, -1.2653014416539963, -0.36912768474773894, -0.045244818771402615, -0.13888314682701894, -1.6943291908590408, -2.1456507899010338, -0.3372899344859892, -2.530121069432933, 0.029478803568470408, -0.482571334198548, -2.969285184631214, -0.11691520348231867, 0.9820356287330819, -0.2198521312916443, -2.514443417117827, -0.8944944421673952, -1.33349600074793, -0.9918005058003935, -3.2008007878514313, -1.6842186149379865, -3.1519042763313707, -0.645806352168046, -2.590405009630005, -1.1296680770988714, -0.2472693037192156, -1.7389109087051393, -1.194700475104788},
    {-1.2313343909775287, -3.1684332598111036, -3.9652649925114525, -1.4727992446915898, -0.7316273994372512, -2.418792321844408, 0.8072634649306402, -0.6937361744351288, -1.2903877170384985, -3.7760153428142242, -2.7225928658629353, -1.9412659510543024, -2.831249512332224, -1.8585075931760509, -0.43094731234306494, -2.67623167806836, -0.37513369715985256, 0.4599629382480673, -1.2813305750568886, -1.4283068796535077, -2.754017092722574, -2.447045971223408, -1.7247244827587696, -3.228058892998512, -3.0964691760995775, -3.546479520390323, -1.641577915740083, -2.291961637227432, -1.4927545868995944, -1.9213425522438479, -1.463920631543599, -0.6655069170401159},
    {0.0956021585716307, -2.7131356211972792, -3.4621758086096937, -1.425131015730489, -0.3842090006968107, -1.9445428670958138, 1.3220752444800596, -0.20541205412741426, -0.3092801600607131, -3.3656924956841388, -1.9155796700469523, -1.1055824602693662, -2.565144358873889, -0.7135768052050406, -0.2924926927299765, -3.5374526904775045, 0.17408975601413212, 1.5203669065607806, -1.248804863833388, -1.3100649419275379, -1.6856147430386708, -1.0664591846099174, -1.4061183219432565, -2.609646484313331, -3.0345889809143314, -2.914672510509703, -0.9242565547872185, -1.9213284898464624, -2.3038816920963368, -0.12106361166982418, -1.0254039969553028, -0.6902971857531643},
    {-2.4750550164783687, -2.6783737694455274, -3.845297508557626, -1.089140027681696, -0.02683026352765271, -1.5148046308440593, 0.6194449755968335, -1.265775182937347, -1.4077913806597384, -2.849183219883568, -1.2467264906268645, 0.3336573121135832, -2.4214570453343884, -1.7331057091951283, -1.7177884668118006, -2.846494967888907, -1.0447127775141412, 1.1777303934517978, -0.029698983051309635, -2.596372016045135, -1.1521000140956008, -2.2714399578093976, -2.2968061887011357, -2.209685524378512, -2.8074105578239665, -1.6235870644686277, -2.441263037712847, -2.887958504438189, -1.327667352625412, -1.0857314409117704, -0.010815952512087034, -1.3682456163030485},
    {-1.244028899702039, -1.7425776763236598, -2.872161431135508, -1.7958752628363317, -1.8649170080976922, -1.3051564306198256, 0.5553785984920112, -1.8445932557850633, -0.944390072313539, -1.668792570298197, -2.075970141192034, -0.1834242665675553, -1.5122191818883828, -0.34545493452556425, -0.7206184654087046, -3.3748727190086956, -0.7068088012914475, 0.5444159943188367, -1.3927686194244786, -2.959822396706146, -2.7070237937199546, -1.1837115203997206, -2.5545999080801947, -3.1251402629440874, -1.904071131022569, -1.046878912719061, -1.688558075531074, -2.8314401650499668, -2.4989300643213475, -0.8312661435566757, 0.23412237625505572, -1.0554371344544844},
    {-1.1717513913696593, -2.4438799868976795, -2.796648216845841, -1.1520972777669323, -2.4971805640616584, -3.211343808788513, 0.8872803058650116, -1.124111744087715, -1.107742299488629, -3.4727639859615995, -3.181021970522375, -0.9467064707606626, -1.9848196370242335, -0.8949375133838995, -1.5803245612031187, -3.997170953992062, -1.838636449950849, 1.3249968958634257, -0.7793692645469792, -3.7946972152208294, -3.1122732824174912, -3.051745059486515, -1.522027808344445, -2.610655523426456, -2.6321787717178946, -3.805090351197013, -2.035455159099484, -2.7577647521758517, -3.1485042031295776, -0.07550954002173926, -0.03589815055281173, -1.8506440210732245},
    {-1.1232697769440712, -3.284690805280165, -2.467585628320133, -3.447575735396777, -0.4319997636998823, -2.2691040671525977, -0.5936488337149971, -0.41665609307082074, -1.8572052992317998, -1.8286149944577528, -1.335609331318706, -1.0757499625130147, -1.2968119459346155, -1.6722171098096863, 0.6025658814450494, -4.912376757082621, 0.33389746177538016, 0.9213658510257008, -1.462404490011277, -2.009864972546595, -2.454118315688527, -2.7770410308335456, -2.6715330895417817, -2.3155929358460132, -2.947716538334413, -1.8879414190704684, -3.241851445658925, -2.222628105757678, -2.9654735403278707, -0.5496008790108724, 0.9811856107603909, -3.0723753760057506},
    {-0.035490134390585966, -2.4054846777122822, -3.422601562975262, -3.4798412787325583, 1.3702442274591748, 0.28504795282430245, 0.5786870561867081, -0.0614250171263621, 0.0614886277525929, -2.6874740491179083, -1.121050811157755, 0.24594572058611822, -0.853891907457021, -0.6515948279634655, 0.16763787347502754, -3.2384472037844834, -0.2754001014303679, 1.0199696632091328, 0.32793812818955687, -1.7149432894006311, -3.790384815536118, -4.805768492192628, -2.519534259100214, -2.2854355667848694, -2.7842544303726955, -2.474202959156696, -4.285190091463179, -2.2219085189183314, -3.0903193106818634, 1.835544957607774, 1.2561918393733666, -3.0060184037702307},
    {-0.5281679845907169, -1.9503087195967121, -3.4656100071328573, -3.9822366642133664, -1.3249316910104385, -1.1198127057719773, -0.19955701099095477, -2.4819147136792106, -0.3749134585563985, -1.756792162719394, -2.4516604548484344, -0.37705480264185537, -2.1464307713423314, -1.5909950595462325, -0.9518479199768424, -4.854434577409944, 0.7366156432289939, 0.30972819018154785, -0.26952998900394104, -2.1992568689961924, -2.8656801273735346, -4.214973148659013, -2.2375648837084388, -2.5808428234543443, -3.4158198334484347, -3.4592019115403643, -3.3903665511398895, -3.1162617387604516, -3.215681204492875, -0.486049126765068, -0.8222561795199627, -2.1238224139115123},
    {-0.3210318500935391, -3.5312311841560864, -3.6441286127470582, -2.5699380523486557, -0.5682331727937765, -2.5413321807043747, -0.220984549266534, -1.6023800994476132, -1.1807558896082015, -3.7237236563992733, -1.6740275424304465, -0.8505942692667715, -3.2224795104618327, -1.7387705110811102, -1.8379876058555056, -4.4740133960011415, -1.1748760331399286, 0.21665025626462342, -0.476341018189128, -4.278524771646177, -3.213740869688908, -3.400272251994846, -2.211746340177996, -3.507937679659261, -3.581435718762595, -3.820577986155973, -2.780329776294115, -3.535257811384695, -3.4145114069777582, -0.2248893417104308, -0.705665725088306, -1.52706271000109},
    {-0.7519277809297846, -0.8351451786362095, -4.212350571639232, -4.043895950642597, 0.13826983338393156, -0.909638399099087, 0.8536849323744953, -0.6840268243803087, -0.6716188317529294, -2.693197303901229, -0.7364008055487958, 0.8827623420093266, -2.309303355348674, -2.191618365209942, -2.500980852350869, -3.3568929055593513, -0.04131822239940769, 1.2620462391499885, -0.42430166779540396, -2.9776418703409084, -2.518136508796069, -4.134249900977523, -1.5796558400378355, -2.7615863734830914, -3.242012579963158, -1.425157493873231, -4.357961546971928, -1.5460780252611928, -2.4207495314330347, 1.172647097981844, 0.3087920485203984, -1.7634479412658188},
    {-0.12020321752153403, -1.6403446067356993, -3.122602428049289, -3.6112969472645307, -0.6530871239706058, -0.31449803433757956, 0.5513489606032759, -1.0973389466806185, -0.40311084993378943, -1.7227446564014222, -1.9408195547693292, -0.3451423156928823, -2.1027588757266638, -0.9517656585553791, -1.4750898472273952, -4.82522712690466, 0.6066463722701309, -0.2580565667051724, -0.7977814769421824, -1.210830163448398, -1.8915766264292244, -4.051421542381903, -1.8375946235876577, -2.860501888690763, -2.5978427581981594, -2.9362379003387784, -3.1863527487273546, -1.7513070706986722, -2.050820384734482, 1.5640692346261114, -0.0032638033540301325, -1.9963738038391796},
    {-2.0032996057398607, -1.4114147815345475, -3.4145319243410777, -3.5293810953127105, -0.11412637586127276, 0.1167332686415095, -0.03013509807113088, -1.9375872479200467, -1.276249935417586, -2.4355206532836937, -0.808326490053988, -0.37384907848534954, -2.012338019918416, -1.8319447461825662, -0.8743979154046819, -4.378391042478739, 0.19697656764659618, 0.46106916873533993, -2.010594024106031, -2.819600229252167, -2.0453791096190197, -2.8636465409293907, -2.4587887215535353, -3.5326224905601165, -2.583509135604239, -1.0312955078511197, -2.2292518068260114, -2.4943148361706267, -2.211559765780107, 0.9399338826293888, 0.6848001689256963, -1.9577331938954605},
    {-0.474667759504698, -0.8288752066742658, -2.338472598981361, -2.8496097672826695, 0.8174137797804911, -0.6115784998934377, 0.9610896080154815, -1.0520464417036217, -0.2847198506097199, -1.8164784105043905, -0.9568871134725845, -0.9032971617151452, -0.9846949931933805, -2.0950163523793566, -1.5322092132362128, -5.151523057017097, 0.2564213840106339, 1.069841634644441, -1.077336711802205, -2.9274441247787233, -2.5673910974540233, -3.3853551432678275, -3.7407459263079024, -3.801159770232046, -1.9769200200322705, -2.4637123681645376, -3.5711898407570355, -3.1675692267847064, -2.5596200453971076, 2.188802038481244, 1.0144229658495423, -1.8510516961494474},
    {-1.0983953394104276, -2.428870756255208, -3.545397060764229, -4.530413554926473, 1.439724605714644, -0.2453068845450031, 1.689442333351745, -0.763062406920187, 0.0647364615826857, -1.6185869950040765, -2.3296198194456164, 1.4430396918054116, -0.2504623725468805, -0.8735184610448208, -0.17024983939335578, -3.029353644716485, 1.0911088624551373, -0.20507738062270542, -0.8873651013671052, -1.101328257986205, -2.1560060606450375, -3.5391627631051783, -2.0615026108293257, -3.4928298061006835, -1.9004390927273342, -1.968497950523415, -3.79739683449573, -2.2008043110645747, -2.702135367913418, 1.6791263716288964, 0.6899939470272537, -3.4326768065686095}
};

static const float b1[32] = {6.328902109656799, 6.342002624707485, 6.986083588888871, 6.182273831340962, 7.002952975982096, 6.809139942955366, 6.409028852943367, 6.4871345401321285, 6.76731074301221, 6.8343971132226775, 7.077410584071651, 6.606074707219734, 6.555845212066539, 6.1006298698060775, 6.383634008078919, 6.852582074786278, 6.661246556474623, 6.3783241323249245, 6.079762951610369, 6.8771384120434735, 6.509816638445414, 6.176672673906145, 6.325225793145941, 6.312635053414905, 6.8547518034232, 6.740602786370946, 6.313290257755554, 6.899123762004668, 6.6166119370034355, 6.393788386524391, 5.800056037807562, 6.2186520117775235};

static const float w2[32][16] = {
    {5.002252895624221, 4.952489808855854, 4.115322613251834, -0.3038536816695007, 0.7958420155459162, 5.031101628657144, 4.07203580428613, 4.4578235126587025, 5.688423090942782, 3.829145829837071, 4.564927512828498, 5.393043790946607, 5.202392764830478, 5.028513480104893, 5.265677428378417, 2.7099921967022866},
    {5.364005481926479, 4.407005408599614, 6.333295765747, -0.8934584333831286, -0.13024697202090413, 4.918863676474573, 5.164509749750717, 4.786927313763745, 6.215809466680233, 4.669651921893876, 5.861253451328228, 5.523275749003065, 5.1049546194895905, 5.928163399646272, 5.066192145346702, 3.5859227001389664},
    {6.187565984419143, 5.482419799065185, 5.387252831127461, -0.21761111179669962, -0.7465568188815493, 5.057239533326328, 4.97751013625198, 5.061112147649458, 5.096055924811844, 4.239930081101812, 5.478975439665701, 5.171830340157883, 4.939946456158708, 6.413251242319396, 5.490557538198577, 3.718768194104492},
    {4.7230415266703965, 4.480324464999417, 4.294658012108287, -0.3473364312450923, 0.091817009806125, 4.536003126707998, 4.135943976586642, 5.173129922573053, 5.047812321450113, 5.272688251223888, 5.8690061933454984, 5.783374208179396, 5.317814309917812, 4.888821391346772, 4.165888119033313, 3.118122119912817},
    {6.367024242969426, 4.063663929854912, 4.079719198016919, -0.48106565823636527, -0.4567880908467888, 4.447489737235549, 4.189292326134413, 5.015648538813319, 5.9077887391103765, 3.891032657617054, 4.831644359907091, 4.964959457117322, 5.9178975880777065, 5.3808585966295, 5.513473443236287, 3.717385653722187},
    {5.930632047805518, 5.508124863329151, 5.35782391630094, 0.49942165301904823, -0.21083379551024412, 4.488449369763842, 4.7665408002744725, 4.980349951704422, 4.566780733254598, 5.032447566268032, 5.679594915615916, 4.87906526847041, 6.1360680618176335, 5.224250239177515, 5.109560942622499, 3.3299586377201775},
    {5.430953649954589, 4.535117439287184, 4.191926129732467, 0.012964488169502424, 0.21685158761692325, 4.20390919693475, 3.548315450699794, 5.644586334477077, 6.135343200236494, 5.011654002776731, 5.224777761084113, 5.4512136229939605, 4.480418225867039, 4.235093583251198, 5.666462642465822, 3.2099286922784365},
    {6.139309037169177, 4.742646837673099, 6.071573472224441, 0.25428013307878305, 0.28441927364987957, 4.7941111970975, 3.8122204883985313, 5.12757415645477, 5.561978836459525, 4.129524725314034, 5.9158932694897945, 4.9575512314118875, 5.0605617131540885, 6.3556745308610525, 5.910848424324665, 4.545213615153179},
    {6.2827621966329446, 4.892041089517689, 4.4724682267167175, -0.19860839340141365, 0.41589148378885893, 4.371423260312141, 4.021776358601955, 4.733326523714386, 6.187576057756765, 4.6783181722197344, 4.743611920595894, 6.035815774899307, 5.634417475422577, 5.2762003323224835, 5.149086102721994, 3.0317904651517797},
    {6.613149043821161, 5.2326540166915825, 6.246405473974041, 0.5528889344274656, 0.7515122200472322, 6.02691401053087, 3.7545843932992913, 6.141203780280819, 6.087781717248602, 5.029691904436252, 5.485765860747162, 6.175206197418646, 5.898214909958481, 5.5808156261794695, 6.273142165630576, 3.9753005206168543},
    {6.036882584497621, 5.942267373262214, 5.297130829984681, -0.8613774628295142, -0.9200309345037816, 5.111903116191796, 3.807747218632623, 4.652030250848066, 5.3947792689820835, 4.541550535838223, 6.102545694366923, 4.950889874588342, 5.549343913925525, 5.717066556473975, 5.36425760785157, 3.338577940724615},
    {6.362651301558182, 5.368794361788644, 5.753647121683532, -0.03239865363505525, 0.07041841045441215, 5.19730313201205, 3.8204188451763788, 4.824504095635264, 5.541367208501955, 4.342781448026662, 4.839914824906865, 5.635561456003035, 5.000663302430472, 4.885897640174771, 4.527799966192766, 2.9266055758726535},
    {5.560510716691867, 5.891591753686734, 5.4465522073422665, -0.3134626517259017, 0.18526183377526878, 5.625371049140422, 3.498037834618482, 4.758711945891823, 5.675546006110997, 5.706085437312348, 4.523704099681945, 5.414371237385451, 6.302378234738498, 5.871586946452444, 5.470549549221987, 2.8293537978110055},
    {4.775036758590202, 4.904413632492266, 5.779573974622629, 0.6211375057957509, -0.5306015380059179, 5.2579895720004854, 3.9854237246352517, 5.271831972253235, 5.921560384473751, 3.745003932630415, 5.032871368928764, 4.801269736990264, 5.738566379284607, 5.881075060000068, 5.435622040622382, 4.024391923263881},
    {5.459712172134989, 5.539350091629901, 4.565104625320202, 0.7607767498644055, 0.8919663769268718, 5.162068373366637, 3.6462403069791645, 6.125162430689977, 5.646293014110192, 4.200468427359522, 5.434301510164737, 5.135211237439841, 4.765517027854154, 5.522070452764749, 5.262127619991832, 3.9875439920662403},
    {6.014481427371505, 4.649530286843813, 4.815613430429508, -0.7920292502441325, 0.5042698880959915, 5.55248061929987, 5.404982076063567, 5.737237409487971, 5.444905097613161, 5.271410171103899, 4.784980483345423, 5.634753509962424, 6.595376235023378, 5.859829657817773, 5.957528820938355, 4.865725294661908},
    {6.463342371705077, 4.082520256967814, 4.80773815781653, -0.732132891197678, 0.4899187596327316, 5.723259171625343, 4.8671316200056625, 5.851143668919144, 5.556162641561673, 4.984720805821706, 5.79013623114827, 4.367851186923062, 4.9759056520730836, 6.328180589228152, 5.513312034787437, 3.1081752964644482},
    {5.297874340664507, 4.741747448704496, 5.374602542003593, -0.5490165638300146, -1.1365810770946898, 3.947730453114137, 4.405369194363848, 5.559977449228779, 4.532243490516971, 4.705130487797224, 3.9752678066429628, 3.8363564933862206, 4.891357794584264, 3.7837373561521006, 3.5609639505450104, 3.474781613442685},
    {5.625743491791539, 4.377657862528511, 5.883890900562471, -0.8778838386593125, -0.6349947936613128, 5.881897749010466, 4.373170998064963, 5.281337144023016, 5.630097918645888, 5.262507502455297, 4.596706351657543, 5.3006417599611115, 4.935278017236227, 6.3306265015154715, 5.9680062915676, 3.3572028063635004},
    {6.722427383549439, 4.623662271836829, 5.788426304607162, 0.37044860044375355, 0.8623786117078597, 5.783760204843082, 4.2237582018777555, 5.2839303927589585, 5.3475710755353925, 4.012517794194859, 4.4768034422305245, 5.076093579066814, 6.3130461876518655, 6.02415950081274, 4.543756144954277, 3.5316112416352285},
    {5.8950396070502125, 5.219901501927966, 6.038028819131593, -0.5061754137149123, 0.15094048925226372, 5.308453990498231, 3.768926054414273, 5.407005686190525, 5.648881231362538, 4.521145854550251, 6.040698994528369, 6.155679953104286, 5.657169150672305, 4.873707035682048, 5.061099383579423, 4.284218871004967},
    {5.644623960778005, 5.7099685566802485, 5.61714305672907, -0.7827171505503303, -0.3014863780569742, 4.346917687168157, 3.3844953834662803, 4.053539909429927, 5.75551666560939, 5.549180855551926, 4.7289161556083865, 6.070967865212128, 5.730536314175942, 4.6798131075484735, 4.617206655840379, 3.241356272756502},
    {5.3728300841561545, 5.826205499638301, 4.5149725248735075, 0.5602806262963033, 0.2671955216878256, 5.357072377717683, 3.5758120307287866, 5.865153429675406, 6.285638774898704, 4.632171030612696, 5.698587985367505, 5.291692864925361, 5.659238880688692, 5.890333118692559, 5.834566715937325, 3.4417450591175105},
    {5.509656918984229, 4.650426307605262, 5.676024173924397, 0.18132498582528278, -0.5168704333949923, 5.342330330518035, 4.339617476192138, 4.877546256953075, 4.812309077480976, 5.8683760734281325, 5.202652804946567, 5.7973471168111566, 5.73025772194992, 5.917377435885029, 4.916052039028914, 3.2517036763119385},
    {6.129666653854737, 5.424724440162248, 5.481484665465466, 0.6103245343142439, 0.11473885077390288, 5.4779986336448045, 4.299358448029246, 4.875563763379531, 5.548514002441259, 5.200497220493453, 5.057131578212877, 5.611939497749664, 4.743888138586739, 5.080089377490827, 5.3586334065205605, 3.790565824449401},
    {6.380027986799969, 5.829007129194336, 6.311022587861087, -0.979771564120231, -0.390716860213117, 6.311229669033642, 5.06690036450417, 5.345210620714884, 4.934429862982003, 4.967079634575681, 6.069340377964493, 6.167854585643187, 5.101178638815856, 6.037908457408505, 5.771399365146127, 4.055401374910068},
    {5.020729798023609, 5.745330454642014, 4.982580406482814, -1.235657853693108, -0.7776249243089874, 5.7084044476280615, 3.3849864359669475, 5.391163336549, 5.136049198794355, 5.218741441860637, 5.520610143547682, 6.04935425689656, 5.302865829188193, 5.386778519314062, 3.9767993562587276, 3.272067941622614},
    {6.8845331240566106, 5.698526719101176, 5.725075274415371, 0.02593833072271976, -0.6838488944191872, 5.716018945593951, 4.728509380453023, 4.607159700142791, 4.73381851085238, 5.346163826635221, 6.065164977814005, 5.989154016093062, 6.457794720970903, 5.426499480884047, 5.78317758485533, 3.706432056592953},
    {5.699321758644317, 5.525815473562498, 5.110458053706076, -0.23660375324343189, -0.017052869669952425, 6.07128501430163, 5.3610191189381515, 5.106810277298713, 5.718866889145057, 5.580729083787695, 5.8194146407629495, 5.3408549187453636, 5.218856497222293, 5.820681099301852, 4.454632102827326, 4.745116907480958},
    {5.040908835285284, 4.469676192852835, 5.758108626406436, -0.39249355020144744, -0.5761809677278762, 4.808494415676087, 3.3628759936021067, 5.981598671807362, 5.008916538822509, 5.144598231723191, 5.968054152223028, 5.026880568394586, 6.055881718757502, 5.437757804052296, 4.350378505638671, 4.1802840091149225},
    {4.9150434514122745, 4.700675124626364, 4.789340478920915, -0.4919229598640951, 0.1738705788258208, 4.576761935435611, 4.538324332321118, 5.414480530343248, 5.5052160911398715, 4.429489326533333, 4.701383746725294, 5.30594326993974, 5.378156533465258, 4.859777699355046, 5.890165622442419, 4.4107743837002005},
    {5.595125645295932, 4.537319871777434, 5.7426266768804926, 0.10427212977712665, 0.6036412380298252, 4.363563741572077, 3.3803823603887158, 4.893981343313453, 5.48316667762048, 4.796605255885726, 4.801485758606133, 5.485531349996546, 4.632320708754075, 6.092894245725969, 5.265716780564682, 3.5759856344371572}
};

static const float b2[16] = {6.060887679351516, 5.458318585750378, 5.533808541112811, 0.043045713731164024, 0.0881333905570362, 6.005706238750208, 5.311369719150955, 5.878007915627215, 5.893039657894764, 5.295932856180966, 5.850200838053504, 5.999024542076767, 5.953455048799915, 6.161917317751875, 5.6674216486272435, 4.62315645473684};

static const float w3[16][12] = {
    {-3.0597406754352963, -4.1949320644668155, -3.7491792641210573, -4.263586940569898, -3.5537824926272856, -3.6344648618361015, -3.857498643331369, -4.1496995356213855, -4.178035774557275, -4.280784229737838, -4.4335436874427625, -3.320124975353089},
    {-3.0794841268597004, -2.952596851876663, -4.630201350078327, -2.574821239637151, -2.6393983915292587, -3.497965244433248, -2.9171823299263577, -2.7874035401077575, -3.093855954925119, -4.004251509664854, -4.778707273261266, -4.202932130302284},
    {-2.5525031252042045, -3.5022583383766017, -3.165986274256198, -3.1167833624437566, -3.277789956858102, -4.041211002473566, -4.27439278136979, -3.854956965825795, -3.009180191636488, -3.617747334764928, -3.9884549250597185, -3.6837518881140365},
    {-0.6843442512767448, 0.689447398427782, -0.09619211549521318, 0.5959838475980977, 0.6198664382267557, -1.078839192725002, 0.07460746687018159, -0.8118915234549815, -1.0904003629097514, -0.17407372004562377, 1.143331258479094, 0.8185186184013443},
    {0.5677289137886848, 0.21322050257994735, -0.07198760367811072, 0.3534455240266706, 0.5152675983232826, -1.0123768376212736, -0.0398003766588007, 0.2861282729722244, 0.5695730721158411, -1.050645723992214, -1.6513851297120339, -1.8202944259954834},
    {-3.282161978056046, -3.696531957643416, -3.0559856745621214, -2.879192505644315, -4.335937913604328, -3.4560981418082197, -2.885449781395648, -3.8975410221595865, -3.471839072624715, -3.717167593784594, -3.347092724475439, -2.85104040200686},
    {-2.432138040105546, -1.86410439735994, -2.8491096302132624, -2.213803539591632, -2.902973323120316, -2.818879176453641, -3.162628130120489, -2.414172131912635, -2.5474593462771544, -2.900780082862826, -3.1143636945931843, -3.4349184621822517},
    {-4.321687459511756, -2.8217731328239575, -3.0593285994550956, -2.6836765225727404, -3.69829107906392, -3.4147857666418826, -4.074551927386444, -4.319381178659504, -2.4615694663741947, -4.343657292442197, -4.031814041038768, -3.3380776835075605},
    {-3.1414890397453057, -3.214465584275793, -4.4348762760171505, -4.039292697459582, -3.3471386049771117, -3.1052591586273564, -3.7527033182943463, -3.3613296523769747, -3.6415535826043364, -2.452556465832529, -3.0644271886631116, -3.4760626495875018},
    {-3.3356450678795686, -2.983805807388125, -2.9959498179408923, -3.0004363500976123, -2.36078593576083, -3.930755075152994, -3.666056122905136, -2.3265752182127715, -4.162726703552398, -3.5990920106283135, -2.8817734653599336, -2.8511769215954454},
    {-4.477323566869281, -4.216974842795527, -3.126853022292617, -4.351313432015418, -4.56999795319653, -4.59397777071454, -2.466095468546019, -4.21494830379625, -4.181648031449752, -3.712890617893844, -2.8758183509753446, -2.9493533144635653},
    {-3.796831598551386, -3.7586491178016113, -3.142633420370534, -3.753166141938318, -4.153848119934152, -2.9911162056468523, -4.165017985719461, -2.9657657532795203, -4.333199937677715, -2.9010558349901934, -4.213296343732712, -3.455733972700837},
    {-3.9894494591183682, -2.987697168839162, -3.892877719999281, -3.513189093450229, -4.397937030810514, -4.248170961866753, -3.3154939379811355, -3.744266063292128, -3.727011660084762, -3.0316730402449705, -2.9617066879405893, -4.09674875081825},
    {-3.480164216289122, -4.099294721223524, -3.654565358251859, -4.353947220726407, -3.1307772284021866, -3.764156662356695, -3.591956019416642, -3.4978203541452864, -4.186733169636225, -3.557521133171203, -3.460539142614137, -4.237623215103001},
    {-4.2612320649522735, -4.287040655462329, -3.618254155982119, -3.9286399604527937, -3.1440946912923597, -2.616682436708275, -4.24188315005385, -4.077683317157586, -3.0853727947796656, -4.106199227241703, -2.9923228663027466, -4.349037074206098},
    {-3.4831971501373533, -3.7611835767824386, -3.167201845526782, -3.8280369411656228, -2.8052099383784515, -2.139080659285692, -1.910422483869233, -2.6089394153764722, -1.9956090272778169, -2.199309210925669, -2.111821257129009, -2.0554841893913744}
};

static const float b3[12] = {-2.1113849554734374, -2.7703451894107762, -1.8161252178794207, -2.609114576715131, -2.146228269878379, -2.14034254237342, -2.7926391388251015, -2.2077889139728386, -1.4434924362147021, -2.5190982797244006, -2.125296961798619, -2.8156422477932628};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
