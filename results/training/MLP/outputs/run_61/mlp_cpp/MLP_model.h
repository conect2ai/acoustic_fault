#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {0.773483479472464, 1.0597374310071939, 0.6066856676228415, 0.3214761058945446, 0.875457098724459, -1.5352383392041122, 1.0142396096108977, 0.7529275273895863, 0.9922909352098803, -1.3332671258488509, -0.24926011338151086, 1.125757804409029, 0.6457598922096035, 0.6958915325608883, -0.7767149893651858, -1.2377692227716293},
    {-0.8462444639287313, -0.6081729689467852, -0.8603860072272321, -0.7388353266945219, -0.10508733740272364, 0.13779169967769067, -0.8518347598765386, -1.390197624604931, 0.5479890233719857, 1.3476001010383207, 0.5553258610113316, -0.14007964201686382, -1.5331707630124165, -0.07496110389207113, 0.10141060209346171, 0.2696075346145947},
    {0.23281826908698616, 1.035106361583204, 0.608849742887003, 0.2441799748463024, -0.632723233306973, 0.92114621265583, -0.6778874776225277, 0.3983494736855407, 0.06741862614383502, 0.6657717217227442, 1.321777422243724, -0.16094634416026554, -1.3769574854724516, 0.21668263391863288, -0.5962695514692493, 1.1294790104333916},
    {0.05780139152558251, -0.23139818341749452, 0.003829624510246525, -1.674935372174162, -1.5905022657015329, -0.7102299070764558, -0.7593927135787063, 0.07696109180670464, -0.7142190519922478, -0.15773658563616585, 0.03640536338370068, -0.6203091441453256, 0.2651147695590502, -0.681500931934473, -1.72091003533878, -0.22851031117291673},
    {-0.5651328336788004, -0.03373030059174391, -0.5632695376168846, -0.4899073237867163, 0.11119360844627933, -0.4247409050358653, -0.5506876185276668, 0.8879609422663709, -1.1099070458128442, 0.5815475798082552, 0.8070988973774806, 0.23236257727383544, 0.7500641039000692, -0.7936574405510126, 0.42708540262500977, 0.6626035734418877},
    {-0.15573097567094052, 0.5460221830980777, 0.9132926521464343, 0.49201657528078707, 1.7463746346248221, 1.0785126406534509, -0.3261563107991123, -0.040621170246796144, 0.2064219228543347, 0.779763063418853, 0.35659694492378885, 0.48034513275486707, 1.0887001866370516, -0.6174600226737662, -0.16684363745992414, 1.2707619164215738},
    {-0.306902875986698, 0.5865977313238571, 1.61476645350624, -0.3402551030954436, 0.8875438441643172, 1.213140426403911, -0.38433992271010264, 0.32488540835047264, 0.14639321681752132, 0.33105749861282674, -0.03241055695638287, -0.05528350320300307, 0.63663797119547, -0.4427950916132092, -0.5188409665983711, 0.575294111644876},
    {0.0829358094022694, -0.2183884271075763, -0.6228681751843392, -0.30414728585808387, 0.3078545615204885, -0.4230725654475266, -0.02781607212762441, 0.15663615901743977, -0.5213724799039904, 0.709869507582882, 0.3814510380275367, -0.07630360405960526, -0.39163774917927857, -0.4947717840214462, 0.2677248768709809, 0.3167713209815087},
    {0.08644858398632163, 0.3958930633632893, 0.31269034373008997, -1.3544540708254713, -0.25763678309610794, -0.6445291176039719, 0.5707472777240244, 0.8036301981301168, 1.0381888727707418, 1.2215086593315514, 0.9627371422238845, -0.7479709822621223, -0.5684103780318588, -0.06763571609810438, -0.22509642799737434, 0.6755756087810121},
    {-0.8538233911470987, -0.3507439196622617, 0.4608786043671712, -0.4133707987727678, 0.41648565467493903, 0.2650862354944107, 0.3743505668214374, -1.2637984662719424, 0.6906725960537032, 0.8742272564097308, -0.3401914385758071, 0.47428574663706696, -0.5254019037833338, -0.44126149169112194, 1.3649534052328127, -0.8465295485121065},
    {-0.39815425314367975, -0.19658507908750827, 0.509436390723843, -0.7426972844258268, 0.4428874339306797, 0.33923539085939847, -0.17033595917231273, -0.17280905504878624, -0.4915191138616411, 0.1308026559789773, -0.48951101966075133, -0.026084118467584065, 0.5311500400270692, -0.19932087339943053, 0.5065023459880158, -0.7980629851345211},
    {-0.7204398221082161, 0.41841849222192407, -0.9543435815426723, -1.4062667156542898, -0.714832524271858, -0.19169652759870529, -0.8083104977969013, -0.5803062564878954, 0.5609815151725804, 0.45055904511330286, 0.5815379786248186, 0.060433355804889524, -0.16351404967886088, 0.2714429204889543, -1.3274621501945327, -0.6459989718732871},
    {-0.5103495779040119, 0.43461368634622816, 0.7982470627035546, 1.1241414254618685, 0.17767750074284588, 1.1352911001065342, 0.5348146592423036, -0.24457845060440236, 0.6936425807293013, 0.23196673045791344, -0.08197394407887675, -0.870983122451179, -0.5856080252816089, 1.0898419233812844, 1.0129434584329724, 0.4602848266547853},
    {1.4088123211111097, 0.580718725496013, 1.093795162694274, -0.7713365484498049, 0.709281037026534, 0.8543404352039599, 0.2879241882548618, -0.3893892084180089, 0.10691799083239001, 0.9909516151002957, -0.2783187285017866, 0.31825435359980175, 1.4480177233595706, -0.12187297644304151, -0.6338316945417877, 0.14547992390454853},
    {1.1419096609726025, 1.0374380042229958, 1.031095766902838, 0.6481987381158087, 1.0857062228494374, 0.9530143978109129, 0.26709722168186256, 1.0050814941927275, 0.5431457345005738, -0.4456377167931952, -0.6569739677778103, -0.5161400966034123, 1.3815240781730005, 1.0033046680136626, -1.5289490572739564, 0.9439094496131631},
    {0.39014003375071615, 0.20077055205033476, 1.00144898996314, 0.5829234554881273, 0.9523776469475004, 1.326104843107812, 0.8803599813055113, -0.08280426906615579, 1.366143960055545, 0.1722614920947598, -0.23419454714321478, -0.9564652715406902, 0.32446807508284375, 1.1302023473966005, -0.311483858925406, 1.0597197030921266},
    {1.5059584573333165, 0.13237373561878263, 1.5350334628889948, -0.34596367103894404, 0.9271715900629119, 0.3686783730162952, -0.35089132057470473, -0.4060737392836325, 0.0029690667016155975, 0.6944132734824779, -0.32596668744366747, 0.29972863369761277, 0.9920436224075224, -0.3766877883844268, -0.8315382420084156, 0.6160067795303686},
    {0.8621490719650661, 0.4013552056980492, 0.9091043282990041, -0.045720294213384985, 0.49643843057500314, 0.36598561474259084, 0.15722320704367893, -0.006486968838938833, 0.596566094973467, 0.7857615412383498, -0.4117877742142812, 0.3481350411160578, 0.8146935601502076, -0.32298111477499747, -0.5027505534278733, -0.01494954589663028},
    {0.4283260306123999, -0.013399662725888533, 0.011725995888667818, -0.4275671873879225, 0.26282121470186487, -0.33529329258251656, 0.24925523227771754, 0.4333504394136971, -0.030381550344749104, 0.2760253797632181, 0.2545399752926254, -0.4854416683469626, -0.519442701563332, -0.19742835542665238, -0.6169257511141294, 0.7006873679514105},
    {1.1860567838207283, 0.5951636865091855, 0.2826608419876083, -0.11827258239354417, 0.8599733583122483, -0.16095786846397342, -0.1657889041539138, -0.044472562743451426, -0.20336862422969776, -0.10096679769020385, -0.21967983044235304, 0.6413436054950222, -0.46784500181273336, 0.11580575164579572, 0.07811997117033924, -0.3472503938312941},
    {1.0810899676717658, 0.0609899071048853, 0.0981858049928615, -0.5987735002905973, -0.004102666930733369, -0.3414597004861975, -0.16929660859372975, 0.3232993896055583, -0.08763557460236178, -0.4859969129063955, -0.43969024977742527, -0.20018304952709298, 0.03294929327459914, -0.21196920630279278, -0.8490459700670592, 0.12343401057633006},
    {1.1933480481567371, -0.6053160821378175, 0.018995076458659752, -1.005312337369092, 0.8588832769307584, -0.24546152540756308, -0.05161278406906164, -0.7299102660097091, -0.9331761515893571, -0.5219339744318557, -0.9097594436970834, -0.1764746899576538, 1.0034771075601425, -0.3709727732998294, -0.16195810118074688, -1.0136089619645943},
    {1.2254500179056311, 0.16252534201873073, 0.20398013023703554, 0.5197888499771303, -0.09429693368640671, 0.862731621666105, 0.09100996267774814, 0.07459855369694551, -0.4869183333881438, -0.7250661359098941, -0.16236335393614937, -0.31783735395216955, -0.5118391013989158, 0.2566514932650124, -0.3027523995766064, -0.086261647151635},
    {0.4167859678348411, -1.3165342902193273, -1.3278711455490162, -0.719848931233145, 0.0621570714356088, -0.5760620869557567, -0.7710170673181418, -1.067916461166414, -1.3880398625744017, -0.46084862379740776, -0.19920496584475195, -0.26852142410693336, -0.28324763374663836, -0.5851384327214464, 0.47446195466003266, -0.7883918309757705},
    {0.501601721844068, 0.3811373726001864, -0.33241281952242907, -0.6272157985224209, 0.05902661241642068, 0.1338141192911072, -0.60272595671848, 0.11064251307228812, -0.5190720466116765, 0.1395947569487053, -0.17650076931130876, 0.6218463616198354, -0.010621167140655027, -0.5318005361365306, -0.37996810660466246, -0.8766578334555869},
    {0.8481413048144815, -0.046343722040053936, -0.9907253411689484, -0.4579911611272583, -0.7338892744303737, -0.6685736625459209, -0.703692159870163, -0.33850009015904836, -0.39129443993445784, -0.7611502143344978, -0.15387046978618102, 0.29833870524697265, -0.5288676871067911, -0.3349424639582571, -0.0011883328771963844, -0.9652356103486306},
    {0.14616851901453604, -0.9314804333084024, -0.7634939154241982, -0.5350345297455916, -0.8111799866005761, -0.3496457743879458, -0.533851703802601, -0.3712476572076017, -0.7771840185311764, -1.0104660510019476, -1.190789332831219, -0.22781169668444826, 0.5072856245782559, 0.23593333623350882, 0.2523058503735578, -1.1276401079510232},
    {0.08750152541014772, 0.17304169553993626, -0.057168520139287096, 0.25165763250882317, -0.09716008556498078, 0.12692275279984835, -0.4125860118027489, -0.28930988588771545, -0.84041679767729, -0.3877998371928561, 0.2003233929009342, -0.34016882162898776, -0.3193823243693107, 0.2838466622447532, 0.7010551929587473, -0.05815024336813111},
    {0.6407854803410323, -0.16133014865314216, -0.474718163686113, -0.7007333747089223, -0.07171719113278345, 0.0803850818418698, -0.7282180313539709, -1.0316043392616754, -0.9654374866983649, -0.3739550095741336, -0.5381506583004058, 0.7222602521343315, 0.8311814164914171, -0.5103826636933273, -0.16889042025791717, -0.685680869414678},
    {0.060246180104901785, -0.286243105560164, -0.02207256133321599, -0.5893317820619266, -0.12327047496659234, 0.19122532880649865, -0.5077385650312873, 0.00014558390630106357, -0.6898739042262605, -0.14353980987723955, -0.2730128924727837, -0.06975246691224264, 0.908305833749171, 0.049676821490268384, -0.2805908632249083, 0.4197927092802523},
    {1.3984281360872763, 1.2119423428169973, 1.102574785218299, 0.9340980358732688, 0.8827681947302506, -1.0619329172004157, 0.9775197799871856, 0.13099166832795844, 0.09971124070505437, -0.5349214559919724, -0.9939006572959763, 0.6692783599329828, 0.4079880430281742, 0.3853965139589164, 0.7430723174724885, -0.58718887714768},
    {1.2003273402404742, 1.508963717459075, 0.9842527222045853, 0.6812284061288194, 0.7530470139654972, -0.4461609962736874, 0.9388179976831456, 0.6629058634740309, 0.32318487871242213, -0.044364644913621375, 0.11893570834014962, 0.3585868230235765, -0.15306475003883677, 0.8920104021512373, 0.8409326716553192, -0.45365287933223175},
    {1.1368647999863213, 1.6108635217153078, 1.0682143821942531, 1.3408161212472705, 0.8235078581534891, 0.29557771144200284, 1.1316604638730083, 0.5620215858924693, 0.25821025440709894, 0.14334425760114244, 0.035665984930327826, 0.8739338363862366, -0.1876399723005425, 0.8018694865397193, 0.9628435290839452, -0.3861673292998486},
    {0.7004393366156273, 1.1833374571444004, 0.6879609735194109, 1.0303370510224823, 0.33496284245774727, 0.06740333365545387, 0.6482881933337753, 0.10857139245975159, 0.5538755890923374, 0.3446541765086183, 0.18156556179253722, 0.3899365167670439, 0.06045630002763146, 0.46759560823571555, 0.5872847980800573, 0.22258115709597878},
    {0.4244374345239768, 0.9573317770858462, 0.559094092662992, 0.8935294905813768, 0.5400900158504134, 0.0642097761714539, 0.4076032397184415, 0.30056451710118665, 0.1668880050738369, -0.25974846349817843, -0.22824793437293378, 0.5418932631537521, -0.4030307040138201, 0.10453560866520514, 0.4607516570682613, -0.0711931529746822},
    {0.37391141575153547, 0.5931306898803016, 0.31444972495579976, 0.6764472607763496, 0.25523672200306086, -0.07287243208940203, 0.3359338403431076, 0.33134466201742047, 0.363973088683008, -0.12029757979326741, -0.17961205887557627, 0.5237160202074236, -0.001172440017834085, -0.14729324164810798, 0.4194561110807165, -0.24368653119913725},
    {0.34314230358425835, 0.9991775919942946, 0.6766415108778424, 0.9097590569305779, 0.010770457961984382, 0.2523030554503358, 0.305914537101853, -0.09199665386177225, 0.6874274643891106, -0.3372237841554125, -0.31579216329855164, 0.218302473538694, -0.15522742477001727, 0.31044108126779, 0.29858743309126673, 0.25160463759949164},
    {-0.006402646073369103, 0.13586314427270002, -0.21109748455595953, 0.3688633469255123, -0.10160121851913631, 0.2932864579097876, 0.5336384285604796, -0.0861744758300736, 0.20218135106215837, -0.8148111442311192, 0.02531376067463031, -0.12178370225718792, 0.527863123086798, 0.2598197355928015, 0.11512314826182206, -0.30448265929043633},
    {0.6133391268977862, 0.43367025093746386, 0.3460245146982949, 0.6585105265597302, 0.19901080762919998, 0.16070643063663304, 0.8258928443378634, 0.33957806559854, 0.08611890895312879, -0.4289004842998623, 0.006536693256076481, 0.3717776521848719, -0.013706053529034562, 0.33569904214600715, 0.37269775198225696, 0.22366736965001732},
    {0.11022233122189794, 0.39842107060269927, -0.3180732729208378, -0.03407466458179063, 0.05788536884614215, -0.12809912494705084, 3.0562629013084555e-05, -0.01664051024706405, 0.35627528985860024, 0.19628732692561607, -0.04841945573683237, -0.012235829540077198, 0.3653942203327065, -0.15614878255462156, -0.07759339870451483, 0.1802972965428081},
    {-0.07658751960955479, 0.6151405011689055, -0.15247836628707884, -0.21785999582288867, -0.04905189405718007, -0.17646254449206544, -0.19580156686799655, -0.2797452489244382, 0.08214972130793875, -0.41408004740622745, -0.23350025944576874, -0.13974502495131047, -0.15836096138893077, 0.0338569417915608, -0.35240885431416624, -0.2822805103778678},
    {0.3562146028534916, 0.511238523932164, -0.1844208038452668, 0.24090496423657154, 0.12914768275237812, 0.00486134910087659, 0.5082201199700145, 0.0662560098128321, 0.18451830414009232, -0.4743179872220269, -0.035983324257881866, 0.2859041849713267, 0.0061600682875092815, 0.5253154578594039, -0.05199320358653963, 0.13117219164272634},
    {0.2844907020927514, -0.07135954205608737, -0.35461391508902573, -0.9836491188816291, 0.08972057784248691, -0.025664276454632956, -0.7158260053421006, -0.2907484354718782, -0.015344939418974572, -0.047098337168447225, 0.07607041767793805, -0.20209769506280273, -0.008627553747523175, -0.23510930247799933, -0.478099185841657, -0.452531638635372},
    {-0.20550131293047505, -0.40232509538439315, 0.010018226688788266, 0.18080003613517623, -0.3728088943241021, -0.34671909977192544, 0.05525363530969325, -0.1605187817063694, 0.15037217823133162, -0.4394538268612485, 0.4115974874227762, -0.23385433393450814, -0.1259485793854518, -0.08144960999557559, -0.00880603147379337, -0.2697883596113531},
    {0.25456042079614366, 0.2554592134189173, 0.26636997781645994, -0.6974980321236454, 0.1628301858170303, -0.1448349023372631, -0.013798210508392578, 0.17107340140692948, 0.015874815563282026, -0.09366212725439935, 0.3652545575536723, 0.17923943733567405, -0.12210385672936747, -0.1649644894402138, 0.22403019514859052, 0.18753673349505623},
    {0.33886541314280205, 0.2646133604370858, 0.003483913492637067, -0.27270298223535855, -0.3255473703575622, -0.11751840346239675, -0.18914326962290368, -0.05346710418524321, 0.058028543640483474, 0.21899965250816109, 0.16899034508814165, -0.1453136741681606, -0.085459061362665, -0.14711283044259907, 0.016968136075576293, -0.10997215755092288},
    {0.05198532461062932, 0.042880200772045865, -0.26814040184332866, -0.2638707992438974, 0.09596026808562041, 0.4615932952815504, -0.30364665313522377, -0.055245657315892926, 0.22965345474396373, -0.25344832023640734, 0.1366060330231579, -0.07270630618198012, -0.0336010546535943, -0.26157951264934554, -0.3583076023973885, -0.38093713130021917},
    {-0.13385401960222168, 0.4002682204032049, -0.004102408272430637, 0.37269521617598017, -0.12229831177492002, 0.25431925984791176, 0.0737464403271243, 0.4289199111570695, -0.4784243088076393, 0.12088983583837258, -0.013210729793005548, 0.24961506838830866, -0.39912690814280877, 0.005834813995368409, 0.19367250136575126, -0.20957137692258515},
    {0.21143724350175888, 0.30546632954455055, 0.025101902378335615, 0.32028245789719667, -0.024940646954496614, 0.02723570833329579, 0.2756621850833223, -0.19013756893544942, 0.4150341689379892, 0.07079102438430392, 0.46832192295297803, 0.13480825075598657, -0.22311752252812092, -0.225216786094082, 0.16320418655999674, -0.1794290082018957},
    {-0.8375090653917132, -0.4344583369994672, -0.3911840308060831, -0.4363917863531116, -0.14181835872231316, 0.22008111340111108, -0.424634478382386, -0.11501061522057651, -0.33953579724613575, -0.11619825398321544, 0.3206442093154435, -0.30496772671107225, -0.13298913031971585, -0.8038708626646913, -0.7430776749087122, -0.026095587969695678},
    {0.011091478408475472, 0.05302581460397764, -0.0004020190681456271, -0.028150054077260973, -0.23146291065390168, 0.034687900928960985, -0.1550765258560345, -0.023736870215164494, 0.03800876235049237, 0.22048342131840754, 0.17341011177557905, 0.011677632190874572, -0.25023793818484097, -0.23844308667621783, -0.07668397654707548, 0.07664222318370446},
    {-0.09325962363464244, 0.12724484666075486, -0.11589494195003844, -0.09441357980043023, -0.19964934721427832, 0.3585191100828991, -0.3551762628858825, 0.16619715232812707, 0.11493223696706056, 0.30147187718507207, 0.20950776383989964, -0.007354513457047461, -0.1426176606588971, -0.06802452448444123, -0.11309743511756397, 0.2820169149215414},
    {0.666874346763632, 0.4586454514872257, 0.1948646415921329, 0.16432704302641316, -0.042112379228344654, 0.2759096376547497, -0.07155919182986917, 0.2872073035213107, 0.07783156284222288, 0.17579411223280555, 0.07555807700816257, 0.3495905542794756, 0.1752863752972267, -0.1429130379483247, 0.19393671080782157, 0.29397352035662816},
    {0.28339484623890726, 0.20449458369803386, -0.09365990977161212, -0.4288078999793683, -0.34636213345841593, 0.6126524422013757, -0.11789409215468735, -0.1994212975823906, 0.8385549378503458, 0.24502376961077285, -0.19165072331595337, -0.12653583047600436, 0.44511155789018453, 0.24010549303154538, -0.20320753391890625, 0.2633570054524872},
    {0.3158845637579064, 0.37505733311138456, -0.3144508751807411, -0.37452589955890386, -0.24878988964698956, 0.5062926103335381, -0.06323381905530438, 0.284078993485627, 0.5981985239275304, -0.04038643247298569, -0.15523158274081372, -0.2325266090996513, 0.28980739538026923, 0.027880700443565314, 0.019088754073176836, 0.5402356855341935},
    {0.1505440294445043, -0.5112845098468282, 0.04420089074133695, 0.2709313200940786, -0.14370282122688235, -0.3149238839592178, -0.4103382685009333, -0.07425449950241052, -0.01213261774329639, 0.12059411870014533, 0.6073177694384247, 0.08327097939167312, 0.045189993948116014, -0.5622745406045263, -0.08786618599917942, -0.22479484588378176},
    {-0.2719495970744971, -0.16908109942481256, 0.044659941516955154, -0.46821404984360726, -0.07276112470142039, 0.25623521151722534, -0.43530293439084544, -0.1550763881732379, 0.18851616891768821, 0.028161388258043422, 0.08072610956032455, 0.1418500317229967, -0.09848892435313458, 0.02582911518427665, -0.1583236776586633, 0.2708538311891544},
    {-0.15355833716505823, -0.004751982805123565, -0.409953755108834, -0.029408981442325195, -0.1706284578918389, 0.23688837545454164, -0.5777588758188595, -0.4011989195201535, 0.1630162760935372, -0.6432949704222292, 0.27235412603270204, -0.012563722145507062, -0.059243385261759436, -0.19490786323914058, -0.03912933962017923, -0.3178669021499826},
    {0.5722301654611747, 0.4601420674576267, 0.07001015480978139, -0.07015724384520669, 0.1889458602296664, 0.23702647764846463, -0.07113963191097049, 0.054173476841105475, 0.44737665596906295, 0.14922052063828953, 0.0778659585667779, 0.23130563931670928, 0.09900811008158134, 0.15351809421202042, 0.08587182942428573, 0.16782618127543053},
    {0.07508065563627685, 0.32230410274372134, -0.20100637868774668, -0.24262817878514653, -0.047253497329966095, 0.011671893498727857, -0.007096448072845964, 0.17276548754123439, 0.17374363768488219, 0.4922666500847942, -0.025500704119478166, 0.2633654358739202, 0.06169416720924607, 0.058743588981342784, -0.0775286242744763, 0.34400999548444333},
    {-0.4960478793750675, -0.6852674146121519, -0.34206310562152237, -0.6190526549985701, -0.15946713064965415, 0.06356389188533226, -0.8003094514958227, -0.34637008459095153, -0.5798552844459747, 0.3918244642838842, 0.28269491311304956, -0.1017528936151831, -0.2318454995901862, -0.31112850914180873, -0.2672871821268053, 0.08426342977584819},
    {-0.0389654738345178, -0.16134924348201066, 0.1648462161344381, 0.2278213230204576, 0.11701345534782145, -0.1675501465055781, 0.1383767057700297, 0.10258051223295896, 0.4363098245891604, -0.4004370392325771, -0.03904967839195431, 0.10807525677969587, -0.1278722278106889, 0.0014872195814219587, 0.16307975759862905, -0.030728745472183704},
    {0.06167187208012162, 0.34888120954364515, 0.17019074778030135, 0.28158633525904603, 0.23433704509930697, 0.17444110178895836, 0.15747969638920348, -0.2046668021088544, 0.23538627449854124, -0.30998637127014966, 0.054701435023245495, -0.06197022846056903, 0.17494817083921055, 0.043898083014513645, 0.08780335176367007, -0.24284956491684043},
    {0.09860340449120832, 0.16815844382371595, -0.07145006144462927, 0.0571072869121112, 0.1765635326016911, 0.09797416168105594, 0.4215863175840641, 0.032406525862531295, 0.2089783004697672, -0.008447396586546833, 0.12299327507971235, 0.12972616744501037, 0.1411744854063761, 0.306684357165341, 0.20567390502716232, -0.0768784797674711},
    {0.004062402532547093, 0.12057414879916548, 0.03387614688466305, 0.29114091081550864, 0.15475061367237314, 0.22091817054956622, -0.07059971152560324, -0.09161385157322142, 0.042204243007284675, 0.017998691326162133, 0.08132088238453339, -0.06338971173879326, 0.17062060414641023, -0.004467587603943661, 0.15795778120685602, 0.11911161896793843},
    {0.048533067246267575, -0.24777603572828802, -0.13703100310419142, -0.13833611835457157, -0.2566519826999273, -0.0874558373011631, 0.21650461281899047, 0.13531283289248505, 0.0802467446012457, -0.4037339475480579, 0.3370718312713533, -0.1159125923033954, 0.15089567982703575, -0.12510536225421612, 0.23313066405042066, 0.127800233020375},
    {0.03809585650857926, 0.13210032512914882, 0.08365239815388643, 0.2867805979514437, 0.24105971225077433, 0.207031678492489, 0.3400015011302914, -0.00844069104600442, 0.39275670036668087, -0.23032432563962907, 0.33609896984849463, -0.009253931256003923, -0.02063824115464235, -0.037722357023503565, 0.1273415462369377, 0.35305739853179385},
    {-0.1628995970657119, 0.03425813807016753, -0.3284925358470566, 0.09247756849303569, -0.1898915173611379, -0.043108848304863924, 0.15411979481057617, -0.30022361093686467, -0.254326633186453, -0.19498208160834135, 0.07373719489619739, -0.2321975110028627, 0.04181529482371901, -0.226455435495758, -0.14508479914592826, -0.30017252472265377},
    {0.11832601065890146, 0.46287381414609485, 0.06212365034172405, -0.0008646120919488904, -0.1739097243127874, -0.15934338135016615, -0.0029761176419774503, -0.17697814099893347, -0.14824874849224068, -0.11526493225447404, -0.09572813595850217, -0.3046856835439142, -0.15773215751631137, -0.18398930128390303, -0.16017835527723026, -0.06519108503889495},
    {0.3545736933610855, 0.29671616276395657, 0.26830984603214275, 0.24115378479456778, 0.23295358456220377, 0.13593306135486163, 0.27615108894198814, 0.24281774180815946, -0.04417199277797639, 0.14035351394798845, -0.22221535737072834, -0.11884940841657367, 0.07370744556790816, -0.17204756741991162, 0.21094009456343943, -0.11462325169121729},
    {0.1589949598824251, 0.4860185790315772, 0.22458634168595049, -0.11504347226940792, 0.07450838368772901, -0.08736649832386287, 0.08435964982504443, 0.16390853798656155, -0.14945159344319336, 0.06496225232549152, 0.06897071212694036, -0.09838403437503929, 0.12955526291040298, 0.17325596633779403, 0.04450640585431496, 0.08029174985806607},
    {0.4415590219213294, 0.5748361672507909, 0.049908441574920775, 0.04171331127838966, -0.0034684850510410133, -0.051283284520294056, 0.09231287873415059, 0.16566558501973908, -0.1125076625176379, 0.30557380354192865, -0.09778331351784228, 0.3467169631030204, -0.03353432016155438, 0.4728527039954667, 0.25489899542316613, -0.028554813811009033},
    {-0.26094336153974185, -0.209322345189141, -0.04829634918549424, 0.22043967826201233, 0.1343969526792777, -0.3189901652735776, 0.30342645321281736, 0.18339535829233902, -0.3766831940719713, 0.22481432060155765, 0.1259066402154992, -0.08294690035505421, 0.1429175129471476, 0.0666103295812952, 0.017240515874751536, 0.05418968004122144},
    {-0.2731256235732397, -0.7957368008977713, 0.028033880806291104, 0.09885696759718447, 0.11115258372287895, -0.1813315199216599, -0.00020646848989867774, 0.031440462146195156, 0.25004307232051187, -0.2645565204555693, -0.15905534279530265, 0.1687921610471718, 0.12680264111163259, -0.18254143059895975, -0.11321633821825783, 0.09599298462593502},
    {0.11574279626475013, 0.07376279828801449, -0.07948273617930482, -0.38543115466434297, -0.14331359735316496, 0.1127633192677989, -0.04522251054439108, 0.07394493373156832, 0.015998423174252208, 0.4277785016072713, -0.5035104163906385, -0.019030844207542235, 0.041040393525608586, -0.12283076682279348, -0.1417345340546266, 0.11335853004397414},
    {0.16408103647637465, 0.4953230043676739, -0.09487535578363859, 0.40182305548184827, 0.08489451707282823, 0.21735162992321727, 0.5773989896704311, 0.16353549221382002, 0.41948129927500755, -0.1566510914676312, 0.08105322335970756, 0.06209262237336332, 0.15656677741568237, 0.20027090416344231, 0.07279729741687412, 0.07162012434015398},
    {-0.025894336578073898, 0.15410296416184185, 0.18762374462776743, 0.007045441923050523, -0.09061461887902574, 0.0837334103960285, -0.1533935543001041, -0.05844414061906, -0.06279063155205375, -0.04624338777630324, -0.13440534967523657, 0.05670721743508962, 0.0156363301284711, -0.05915002424230639, -0.2626678870673173, 0.3037908373728592},
    {-0.18328986166231512, -0.4780552836486773, 0.14394584636974644, -0.18397246280733073, -0.11455921209162277, -0.16514923414859176, -0.13616512628230926, -0.05169323915555673, -0.09384538435143265, 0.13779471253243555, -0.05733753669067062, 0.1472091213414378, 0.1669592571474067, -0.1735279336310692, -0.041593660209346565, 0.19641635654585995},
    {0.3091960645047175, 0.4566646741407723, 0.394130094623032, 0.15173614225498686, 0.030972392619233208, 0.0020402784561720944, 0.07348460495647864, 0.24061206123679713, -0.289727330801143, 0.5232862722376657, -0.33219702260750184, 0.0924387511837377, 0.24289792911186103, 0.0595575789729004, 0.023688256428532284, 0.2675883864478522},
    {0.527433185163882, 0.5977416134062142, 0.208196995167967, 0.5070860505665621, 0.28134038821302343, 0.2299055747245999, 0.470665050677853, 0.36179586689371873, -0.12366725674182055, 0.17647658741727829, -0.07918099259106559, 0.015610971654195768, 0.1358304574887616, 0.01535508191536968, -0.007873771135861974, 0.1658267715216217},
    {-0.32520873648411197, 0.22837725016151753, -0.05972437153535099, -0.004808266649293874, 0.027470787009323646, 0.009126908992184659, 0.35577329172421684, -0.2169506355157716, -0.061790512074983435, -0.3753529333983252, -0.06286067699067842, -0.2719798085143414, -0.05039243978670899, 0.06254007156604714, 0.19914453629523896, -0.04991720194879012},
    {0.15929581595656697, 0.34199014991036114, -0.02141321180830104, 0.06165890772365069, 0.1915711761864017, -0.0007669901481086462, -0.019075296046802165, 0.02822038320433879, 0.7290584390718517, -0.06283634487221743, -0.28042370182719245, 0.14235762068540403, 0.3362369577668793, -0.42290267211196414, 0.15360989672514652, 0.3275975562576986},
    {0.12822150921792644, -0.02671824025400056, 0.23548781440008326, -0.058781852566196224, 0.27558245849806495, 0.10958277620981494, -0.028748122574075892, -0.050667228778969356, 0.6427098491157046, -0.042070241756653796, 0.2619491503351475, 0.07109252532491658, 0.19326471831339714, -0.05694012516411321, 0.402929167940878, 0.06812756953600173},
    {-0.5554985229249174, -1.1599608555780663, 0.2641219364813926, -0.01085724135571147, -0.17995333457344476, 0.11649367275962372, -0.13502148257609026, 0.025398358238987513, -0.1316535040077817, -0.0025507514783155855, 0.19144938456128793, 0.31515212708292256, -0.24490561470131952, -0.15937591891066097, -0.07216420624147706, 0.0024476309343379734},
    {0.5921325518708618, -0.01701042137556069, 0.42028698120830577, 0.6490278910034804, 0.3833631955406651, 0.1377812973617155, 0.34861705099027007, 0.2756942667043237, 0.09476887363366014, -0.06431763340985723, 0.27124609848131276, 0.016634561302865343, 0.026086273346593733, 0.24011905843329287, 0.2704712879631138, 0.4061414191975226},
    {-0.008902073368791579, 0.22850491866714479, -0.0617268094877368, 0.11108569451823516, -0.19262434004910642, 0.0922021208858383, 0.2631215050504523, 0.13201531246670858, -0.12873539303614334, -0.006582877339217334, -0.1074905871055771, 0.05970611011411807, -0.059306704215751446, -0.11426866933061762, -0.0640717291514417, 0.017701545343613272},
    {-0.11461256436588169, -0.09172155429720465, 0.045614286708647714, 0.15409503579745776, -0.26610734474257125, -0.14585991841085563, -0.11869604426260198, -0.1296061579769047, -0.6208042512803141, 0.1330970407694012, -0.2858834673898589, 0.12757058597131615, -0.07424239690984143, -0.23067922450272704, 0.05714890591197739, -0.16535666964128343},
    {0.1702490782614976, 0.004021083354143382, -0.1472883980073263, 0.18680564401762137, 0.020379504638954268, 0.14035049789378715, 0.06678042792651741, 0.07678962785759444, 0.3003807383850659, 0.05207630840135899, 0.01747542430238237, -0.06418334130931759, 0.16750462286920625, -0.31693010351061285, -0.05749646525951709, -0.06508185590424426},
    {0.24053061538173542, 0.28398310872261867, -0.13339539618323706, -0.0056933924860868975, -0.13300347079969993, -0.14150658257024568, -0.18473075030333216, 0.16082897638797392, 0.20701808630228985, 0.08123794635003481, 0.014427105877024289, -0.13543967847956026, 0.03677747130186726, -0.29249655821913817, 0.21431903258871385, -0.17526457786104643},
    {0.0634895413041813, -0.10117414863017603, 0.04498719558482943, -0.059849758707993, -0.09101411775809747, -0.0324065682848062, -0.30326102176286807, -0.12439013838733237, -0.16330380183494014, -0.16384678149423212, -0.3499611203332709, -0.08500652141858275, -0.06802567399118942, -0.12352634073750744, -0.08702565906284006, -0.27046761037272987},
    {1.380076136110074, 1.3677508615090277, 0.8903236736117937, 1.0987388530385447, 1.0091531911370715, -1.0863743912179653, 0.37663897687327147, 0.029081750503931206, 0.4112616850454178, 0.3347301638324808, -1.2419085413103441, 0.49283277685984905, 0.026591473352754958, 0.6179038209192549, 0.7873105627956302, -0.1400058843173741},
    {1.257062791523811, 1.2471956945851692, 0.7344736426485433, 0.45616038212786186, 0.9264923273317556, -0.9330947190087052, -0.03909415743354545, -0.6757923784460137, 0.8338543459177303, -0.020054348745202587, -0.8837354549507864, 0.3125725245880358, -0.6825028971113974, 1.056781795667937, 0.5161668744645566, 0.317588304630477},
    {1.096125399166058, 1.1130968971955717, 0.8320898613392399, 0.9992775304760958, 0.759179876877332, 0.026617152052828223, 1.0312034283566547, 0.208700745919677, -0.00620842027081489, -0.34017604919579586, 0.2281406948543222, 0.35968178658416794, -0.23851132629789645, 0.7529067495977235, 0.823337603027822, -0.3592714539449691},
    {0.6701114097318494, 1.1362234421120265, 0.6457797180807894, 0.8204750472095265, 0.4983354379431663, -0.2208387265699179, 0.705969183577413, 0.2746264028615378, 0.38178844789233357, 0.16130220557089628, 0.006503191084767674, 0.2873652465990505, 0.21279549307427859, 0.25066204670975595, 0.5854695103320052, 0.21004024147158804},
    {0.4044847734716456, 0.4763797352777968, 0.43992766733896543, 0.5075371822083553, 0.5149303970446577, -0.24909601350062616, 0.13041644567253396, -0.041280376142109686, 0.17329970232001343, 0.1241317145241951, 0.17456656545912147, -0.2018138977795984, 0.07591131461050586, -0.12776493338098474, 0.17534398545873772, -0.2385573071198748},
    {0.2651426843434523, 0.38061970458768335, 0.30615934668930367, 0.3589948387645602, 0.5196675353343942, -0.13808361255301976, 0.1829007857920307, -0.4011097608718598, 0.25268015735127897, -0.3307105034279469, -0.153919997870178, 0.15723763952053496, 0.2435918088808006, -0.2036741751484801, 0.13968459373019423, -0.2542901335621475},
    {0.04084355571513578, 0.517344293593257, 0.28827267846370536, -0.008481253380493147, 0.4659670644731131, -0.09667692238777197, 0.2737361084811828, -0.2546457451411873, 0.3684780910709296, -0.3455521965045112, 0.17791764410141295, -0.04123400772555734, 0.0897183511404978, -0.13025856208319603, 0.30326923319254223, 0.11973917188719715},
    {0.5930580086851043, -0.10557974321956222, -0.16829068353253065, 0.19896591181652817, 0.11279507661020265, -0.0884108630784224, 0.49219933181466397, -0.15429647970923988, 0.22315106920750072, -0.035314035673082514, 0.10666202744793606, -0.12117923482009463, 0.039881079544152986, 0.08740286468653842, -0.3563302669605951, -0.2731764042999671},
    {0.6842466502498635, 0.47544891552850305, 0.3315967000177814, 0.4414487568695078, 0.5367039453354924, -0.01754058648330952, 0.5640461823770252, 0.1085738242691393, 0.22320160151191443, -0.08738049677971077, -0.2526893576296852, 0.19936284185861114, -0.48023295316935877, 0.4955419783567415, 0.17974182919243428, 0.29866747990207554},
    {0.3795227276850981, 0.4568235481596381, 0.034290916226983555, -0.2286125135281728, 0.2996621126610243, 0.30068009343566393, 0.44568451630333794, 0.13677102470317698, 0.46862551836305444, 0.21229380636023734, -0.22976412179129774, -0.08356788608041787, 0.23516960938609147, 0.4274572606298832, 0.04846747737235275, 0.40835366357462377},
    {0.31401945207430887, 0.17073303131355624, -0.12862356224425628, 0.15735977833018375, 0.09668376214252625, -0.20844366123421415, -0.19327402964045867, -0.1960539615532422, -0.22208766607128397, -0.11819958796263755, -0.6951563403102305, 0.20906573109721766, -0.1876598586976043, -0.20709111204609706, 0.010653325380907058, -0.43555593413761506},
    {0.1475401932050293, 0.3365531391100122, 0.05523916385106924, 0.40341820146036006, -0.19298544822838845, -0.14759935399842247, 0.37283989861682626, 0.0016542367603904382, -0.15295908769728897, -0.09247810815983568, -0.41690693718667843, 0.17080023300647554, -0.29599371413305703, 0.055719287404589785, 0.1986414535895639, 0.20543939149497456},
    {0.6523969154128352, 0.5745840003860143, 0.034194455902151547, 0.23577072975839744, 0.3241406914718482, 0.09407115943482812, -0.06392466769770219, -0.08129149113980172, 0.3696654569915616, -0.11233410340188896, -0.4414981782509013, 0.0343356795816607, 0.34057381086788874, -0.161920964188434, 0.19225232345612978, -0.2702881410612109},
    {0.2208315751254514, 0.0059989474343364055, -0.1656406523400856, -0.015763561852332013, -0.047395176057659145, -0.20124134113076117, 0.2384697298675613, -0.31851149288928055, -0.18391291943348567, -0.46712146085253536, 0.20156894635172415, -0.03966833724080603, 0.15709358503151644, -0.4043669199641645, 0.0002605437293457759, -0.20643945398495755},
    {0.10401016729518738, 0.0619693012867871, 0.12990848193694834, -0.07802706922708509, -0.27839148453215573, -0.2229281266657549, -0.5714154622579084, -0.16655039386641385, -0.00651134251821216, -0.2464392533989259, -0.2429447536634588, 0.1910328464559876, 0.09798706820633825, 0.0349502884189902, 0.12432289119003978, -0.12864066347664166},
    {0.3508285804002831, 0.13141845011018138, -0.08103101327675312, 0.017988099386845247, 0.6228789698477822, 0.056143172084088214, -0.09837946034044752, 0.04220979717734291, 0.16424839502092667, -0.02196818689798755, -0.2316973108302784, -0.08322936750044084, 0.03769226199020689, -0.13917402879373814, 0.08532118960255547, -0.020314303646417047},
    {-0.19233023125845775, -0.22419002381417186, -0.01608944752626347, -0.5241424767285088, 0.07978101030735328, -0.22743593062728634, -0.4596504601625137, -0.365343810184241, 0.04751320796738153, -0.3022646676821101, -0.5674967178311096, 0.028915984621584276, -0.5623195009959384, 0.15422428349632042, -0.12200945936123199, -0.28134217767933417},
    {0.13279869801536245, 0.42831497929335965, 0.036074365347676246, 0.028898948254407277, -0.028169983757350116, -0.35604772932939954, 0.085467282566253, -0.06022265649888293, -0.1283095713302599, -0.20891526400080385, -0.6318782576745913, 0.0194904780948788, 0.03982096803471736, 0.01089200416333076, -0.07495511193542245, -0.21551136739172932},
    {0.6638074083879801, 0.1754728245777219, 0.7485155584940881, 0.6997320431636861, 0.28901114298715025, -0.1891901156020611, 0.2592354547799987, -0.04155654717296267, 0.2762639224584362, 0.06410484165901488, 0.009562842438222119, -0.053030097525009645, -0.06297639804418773, -0.22501888610073498, 0.21350096668048674, -0.23603284051725743},
    {-0.10145939400323593, 0.22948879003934947, -0.04918159645814417, 0.3073577000448947, -0.33297355282605484, -0.48535242044183874, -0.22909237782349193, -0.34871670811694094, -0.05085153215282627, 0.1729715547110623, -0.1382291348880414, -0.10470043465523517, -0.05752914991079584, -0.1440989912856129, 0.04218719964211098, 0.27953106664907007},
    {-0.024876245844611938, -0.09059273826131095, -0.10605432328365008, 0.005980640655827197, -0.2896420490003739, -0.14186657038809508, -0.0466360621781259, -0.038453797755839986, -0.4561288711636889, 0.3740816274567434, 0.03149370297606806, 0.04727199964907153, -0.3281366793379554, 0.0701337986122337, 0.14360197228032973, -0.2422531327689281},
    {-0.05647312534342966, 0.42760773012831826, -0.0018991369717015851, -0.04441940932914318, 0.272829881538009, -0.24160628523190952, 0.17275043137871438, -0.09860737873354196, 0.5765557232146095, -0.04284216228245184, -0.41119038538095487, 0.15487217259029237, -0.06791625823838997, -0.43824902415913186, 0.17358762890687293, -0.02972315051024383},
    {0.39356476879584623, 0.42142056422416885, -0.03687665576326129, -0.3545261525144135, -0.029036779267719613, 0.11626154532737484, -0.13695407171832621, 0.27250943084687307, 0.3243041122649912, -0.16342008308201111, -0.015087400711094616, 0.08529974578174436, -0.09585129990518096, 0.3116581500813646, 0.1970867896031036, 0.14613436766143947},
    {0.40212906120715214, 0.13956481070164686, -0.14391434063826902, -0.5372093365579185, 0.2232153751471966, -0.07035452900105663, 0.2470365847300543, 0.2554271140609892, 0.5914942758325334, -0.06839756829764672, -0.20899835415515355, 0.04009343705424014, -0.004198238115083007, -0.1621349995143651, 0.35509089409186356, -0.15065318368000521},
    {0.06717507830652655, -0.26969392540733556, 0.07185528586749425, -0.1786023332709862, -0.19734803607194953, -0.12469847725093758, -0.2574896172563482, -0.23519827390102113, 0.3343403307528322, 0.34159231555981434, -0.12104065965474504, -0.10094915874492238, 0.27674306339318355, -0.3402644445111905, 0.04348169339551591, -0.029211583226273926},
    {-0.21342472844092195, -0.30351639844748834, -0.0018850490912015383, 0.253755128645795, -0.1174491417558929, 0.0770859956664857, -0.42220130743764195, 0.010175077935825085, 0.025389903752221877, 0.03660944591160123, -0.016638029919267775, -0.17454174840090556, -0.05936514750129689, 0.030942974708110464, -0.11707004528055118, -0.3918603000281451},
    {-0.11686259472947386, -0.47095642806540217, -0.2694601858296401, -0.3479669746757929, 0.09880636642934368, -0.17324912620873656, -0.5730811299436793, 0.15620080748076776, -0.07394002709877995, -0.09660275705759098, -0.1023397104702172, 0.19523818092622755, 0.094410483137861, 0.24754486651735783, -0.013456177139748159, -0.05587651436734481},
    {-0.08549063880033, -0.02891549885289597, -0.4039727616597176, 0.0400719531849312, -0.18426572707845904, -0.11502630020857849, -0.18448031897069092, -0.19539540820052098, 0.04828451254673681, -0.6794191677262615, 0.16860631434281612, 0.060867025872648535, -0.0700467196577056, 0.026342859375405717, 0.10412078445275642, -0.5574213652811846},
    {0.08721109315790614, 0.2685036627980908, -0.1751768023317845, 0.08551207772201821, -0.43143539564636096, 0.0077931558634925955, -0.2648247898529317, -0.10914314473975101, 0.16308732384056784, 0.004958895189771211, -0.2224918705725083, 0.05622858341287881, 0.2269833695394695, 0.09894549570094263, 0.08135705304692045, 0.06720421311733972},
    {0.08267693716359904, 0.2709556082108466, 0.125111765529188, -0.15517228463585436, -0.13184056710105807, 0.13978047807700794, -0.23230840450485404, 0.060332716111507166, 0.18382620283230547, 0.3287144720757029, -0.09027598855843005, -0.21086166188706473, -0.11517942236629315, 0.05013538792472207, -0.10522418003846258, 0.23238395622936997}
};

static const float b1[16] = {1.821665264766319, 1.9135665360077945, 1.9382926226991948, 1.756458324256474, 1.9015819241084706, 1.4243982559317634, 1.4603105135554577, 1.2362445906036295, 1.70925802719258, 1.381034696365032, 1.469893616673706, 1.6544694163572398, 1.2550458630234331, 1.8907717380713387, 1.7923631011481846, 1.281174154645473};

static const float w2[16][12] = {
    {-1.2852615602295798, -1.1809518916963049, -0.8066059887161254, -1.2286665119960372, -0.7746087430862083, -1.0714744445108637, -0.8650232322716191, -1.1455990386787904, -0.07318535621730791, -2.008567805386121, -1.3787965607958945, -1.4191873549416167},
    {-1.7647114841390155, -1.3307657799789196, -1.1391148733964513, -1.330646561390291, -1.0110380467813898, -0.9569848020637873, -0.833884062503309, -1.4680638575125224, -1.018822452409844, -0.7346306274597768, -1.101489899604551, -0.2810925366756304},
    {-0.08548143504900634, -1.2023105679271981, -1.0123367062141158, -1.3649258937883062, -2.082387243843018, -0.8342988968533666, -1.115913763940591, -1.3849409623703242, -0.8790493604897154, -0.4940683752214345, -1.6300921663687213, -1.811597675678414},
    {-1.2247788638329538, -1.2412777944197342, -1.5502240938571874, -1.29779448669087, -0.23288821457251663, -1.3164246569627858, -1.8205529522336956, -0.7701817320845818, -1.0466291589973642, -0.358669958433357, -0.6290778230559263, -0.9458630663106162},
    {-1.343313920413451, 0.0799098256842486, -1.4765067215901115, -1.1322309980955165, -0.3698036005225624, -0.5050915299820362, -0.9692968469354795, -1.7712382995964355, -1.76544507584624, -1.6006661937245514, -1.0345117100852725, -2.023324649516241},
    {0.32847511824336734, -1.1954540890083505, -1.5541581483678981, -1.2303683849803404, -0.00995226134211977, -1.2116917727227896, -1.1643407358894031, -1.6837093926942743, -1.2037664175712546, -0.09297217248430444, -1.3487364655620278, -1.0754531904466205},
    {-0.33001565793965104, -0.7574122529271083, -0.31734401158508113, -0.6480689379273871, -1.6032721232646228, -1.032127899056193, -0.4123045237675412, -0.7011065059809916, -2.0353685726261053, -1.037905662095127, -1.9476467527944101, -0.9266344540549423},
    {-1.736959560365596, -1.5376257054082627, -1.0331951428283477, -1.3819467969078296, -0.9864529563373182, -1.3692793887780625, 1.030840455810809, -0.04545414409345092, -1.4452276845304957, -0.0012387342769322432, -0.5439163708543047, -1.1227937487438835},
    {-0.7171450248029723, -1.0497593720185152, -1.8602833306398625, -1.0889587900537696, -1.2119893223022824, -0.2200113755611042, -1.0601606666559285, -0.09332355682386652, -0.8873845152333802, -1.0536046004228907, -1.0410170822305165, -0.33076638463181},
    {-0.4431507754032483, -0.3401195269053426, -1.7153947234181683, -0.4457770598088337, -0.8811121575608187, -0.514534979884653, -1.4022927184716076, -1.1545082328042922, -1.3495923918460393, -2.102627978374429, -1.0026511030830583, -0.3564582713088214},
    {-1.5424704934394335, -1.5031396063673412, -0.7904578427131427, -0.19641812947088133, -0.4073570716556334, -0.594467099914728, -0.30352029793250235, -0.6382378120791858, -1.081937533624701, -0.7408266694225399, -1.8947464534626781, 0.03885331247264332},
    {-1.5181192616917867, -0.06696905994504523, 0.18935925635942732, -1.706599371411735, -1.3966575649921484, -1.0635331161579344, -0.997866861249508, -1.7615404681715776, -1.1502421164747394, -1.3837979118519292, 0.19475149738293995, 0.7156887584790735},
    {-1.0620270240406635, -0.27503049198091667, 0.282314358072348, -0.9707025707841956, -1.6209707828670317, -1.4226659513070712, -1.077744445505047, -1.0893096519876961, -1.5355401337006007, -0.46605784141436735, -0.7669935187782444, -1.7063658185765913},
    {-1.7672905447029426, -1.0993340154838218, -1.3815859177647272, -0.5583009610794786, -1.186701262217483, -0.5698565071336787, -1.7561693096940032, 0.07616762030995053, -0.21539522459795363, -0.5859118511953663, -1.7460849328145802, -0.9628285540347253},
    {-0.4017113032890911, -1.705016197676224, -1.4387491731588082, 0.3534654653632806, -0.7673606287110581, -2.049844846192046, -1.1086077689726028, -1.07390379254723, -1.0557752902337556, -2.2046310908039364, 0.43334822111593374, -1.7627556088584098},
    {-1.3576786675365287, -1.328701177310585, -0.7360276442733282, -1.4460422350964097, -0.2613273947495172, -0.389833744325451, -0.9272941713759232, -1.079864200900528, -0.7268126685426691, -0.9928333432638456, -0.777488453440243, -1.635101902032443}
};

static const float b2[12] = {-0.8017818080120068, -0.7568740665589444, -0.717176391755175, -0.5980309939794007, -0.5809729419352953, -0.5450547646586353, -0.6552460822507824, -0.7193494753471223, -0.5582102494935738, -0.6330821156812616, -0.40771133561288153, -0.46928038925853127};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
