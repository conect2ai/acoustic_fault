#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.20514127133192092, 0.08128055435627894, -0.022795305901010553, 0.5305771217045235, -1.5444229839808339, 0.6390883647101399, -1.6927951279440143, -0.5456772594766286, 0.18127199539591715, -1.488853801163006, 0.5768873938017189, -0.8505495946519354, -0.7553945293248105, -0.890059812387249, -0.19516089518159777, 0.7470696719878354, -0.11181945684033949, -0.5297548246338779, -1.849135518103807, -0.003182677207134265, -1.4593714853171, 0.14235285922285926, -0.4883547872822382, -1.5639144159446028, 0.6032001046165228, 0.8153254408822019, 0.2724376792406903, 0.23150104770321722, 1.0792037713490474, -0.4292011323555821, -0.8734386818889707, -0.5673344490043969, -0.44809869453975226, -1.3619806798128165, 0.3130138757533819, -2.091744147434038, 1.0218386873283463, -0.5653688981493413, 0.33915467293259555, -0.7582702825643726, -1.5126594563391713, 1.6065894207678018, -0.20265639952749037, -0.3164489412180391, -0.5302308151362118, -0.9600726996380389, -1.273978776287142, 0.5304503681433355, -0.9789692152994878, 0.38090568014591847, -0.11793251860481906, -0.9194178205290399, -0.3280191339365884, 0.7904901731914773, -0.3973821304028586, -0.7081479288526024, 0.41278865478386567, -1.259314156346471, 0.5895396266882693, 0.07284822510488667, 0.5519884754941431, -1.5649980056711137, 1.0542389784784727, -1.3254857043302442},
    {-0.8572340713413689, 0.5975478362771484, 0.8272929375011824, -0.4194402175631922, 1.5843805988362556, 1.0552844278261277, -1.004622057105823, -0.6357661993711804, -0.7302737564332158, -1.3443385078401329, -1.3240982285487872, 0.6119326441151988, -0.5051403528543751, 0.6405052722432732, -1.1551466427992612, -1.3291135498843019, -0.5427532972177117, -0.4178365414239913, 0.6810941112988665, 0.48282148856236046, -0.8956877170972866, -0.5486273320419301, 1.393967630024381, 0.018215218824463985, 0.8320158051357077, 0.10431343189798363, 0.0545544744679258, 0.8442647880446459, 0.3547247098059393, -0.5292525889661007, 0.8399740303945897, -1.2134816702723838, 1.1540615755751098, 0.5607888644490918, 1.1897112364477278, 1.356477205993104, -1.5097954599406036, -1.6191484046705678, -1.0565758668636842, 1.1582120510298088, 1.2379394202596152, -1.623524652209045, 0.5328061460367266, 0.8558078874558395, 1.1312561474305556, -1.121949732451361, 1.0563477658882117, 0.7982496636029216, 1.4943290950211254, -0.39171727518187216, -1.1481888024709408, -0.42447837448553943, -0.5061722991753331, 0.7460989265518503, 0.5361338235903933, 0.4458972774637821, -0.425092655088027, -0.07916488085736716, 0.5238285759315223, -0.4007519099117208, 0.18473683635883553, -0.04581746151741165, 0.19316717020531526, 0.5675556211146554},
    {0.8448348941225311, 0.30463523061063763, 0.5344200091424385, 0.10531795806176646, -1.1199615694883458, 1.0015837039588131, 0.17063701572385773, 0.880494778170719, -0.9267064147964353, 1.5399962840100563, -0.5081691181310325, -0.6136176308617823, -1.0070226491878995, -0.23990575448892315, 0.6978782010709851, -1.2179838484067378, 0.8055635841762644, 0.6797180167661707, -0.5404983093419202, 0.7283242815540019, -0.6620418768774028, -0.33077094438566285, -0.9208261682717499, -0.2695607537708361, 0.9540134617512228, -0.7886435705719574, -1.5007455306385469, -0.7006967360773871, -0.7893713348232088, -0.7935543723035445, 0.6748637680581134, 0.793408215033294, 1.1010024284681028, -0.503847586336673, 0.166585562020278, 0.7776122620854056, 0.8602086000756535, 0.38173252138519065, -0.7041341833365332, 0.2523075724018332, 0.9919549870852966, -0.5523742556388822, -0.5077265078246105, 0.8329083688785838, -0.34370124809068964, 0.4060373863054333, 0.8996108990722209, 1.0165314096101, -0.750443871722024, 1.4014200131256633, -0.03297835859459386, -0.23679660784471251, 1.1701037986206637, 0.7299800156968433, 0.621558332096956, 0.5453784189884534, -0.29629783360637996, -0.9418661883132139, 0.14138698639524908, 1.115040557514165, 0.05407748416693353, -0.5754776464146693, 0.09342988807149542, 0.010545700834641033},
    {-0.10212083114700543, 0.8304854712584973, -0.13035047153165405, 0.14798807337279762, -0.9259293636433765, 0.6617885786423036, 1.2696855463261223, 1.495056076617628, -0.47015094668946317, 0.7460730284395906, -0.28284819063708605, -0.05053189575399728, -0.5462828008721722, -1.4008760198860504, 0.5936770673218945, 0.558296335333334, 0.5172719450677156, 1.8236553045992705, -0.004144887993545848, 0.6345878079222969, -0.6077197574571094, 0.7568337921293633, -0.9423742945032947, -0.5899963097790102, 0.5492640335600972, 0.1338841999004464, -1.4768587858507938, 0.6899634959143013, -0.9755072192802536, -0.5271832832941522, 0.4389381999220917, -0.6991562041032269, -0.7910756676539163, 0.10478690519407809, -0.8924509297179553, -1.1991303737893864, -0.27077883555403537, 1.1731668137600118, 0.09761102557001122, -1.0916277770397127, 1.1278014406604784, 1.234285313197802, 0.6749306062345597, -0.06739067952501918, 1.2974186451832583, 0.8426427280930076, -0.44921795670998466, 0.8524439142851873, -1.1908957155585667, 1.1577347477022837, 1.7715017905219752, 1.254675463865548, 0.9106769762633807, 0.9557923571926349, -0.442663815634741, -0.024913630452756432, 0.5661018255506602, -0.14472804181901422, 0.1779655166514344, 1.9346795543903912, 0.341491551544123, -1.247207493492554, 0.98287730511169, 1.0871299491454973},
    {-1.0595654578992377, -0.9088542140606416, -0.7490383140076619, 0.4253742603950723, -1.108158731921154, 0.519684791428921, -0.06100453968130427, 1.4666639205092575, 0.1885086418994376, 0.4727113967031666, -0.5192190406347448, -0.3194541419294529, 1.2827487071880581, 0.1234389157833134, 0.3806509428511317, -0.5153140194109826, -0.8407921611849527, 0.38712162570173514, -0.6151436629293463, 0.550805367116177, -0.07149954780329752, -0.4569066377803502, 0.8461207464329571, 1.8385432635376942, -0.08155948646911998, -0.49251569286218827, 0.2640845865332005, -0.3141368690888322, -0.7938914132178139, -0.291378450518021, 0.45003698500479516, -0.8616358123832065, 0.5156897417338764, 0.39780780308053165, 0.4626335085364028, 1.5436226793008634, 0.30974085105642796, 0.7487806835928974, -0.91564903556472, -0.7593984217226186, 0.43366026501895183, 0.4253523519143337, -1.006617649783121, 1.297892594628725, 0.4102106642494229, 1.5177372817580448, -0.22620582416455184, 1.4891200126189361, -0.90486785254936, 1.3717241951521546, 1.037115600381432, 1.4930595347366455, 0.28230881873499825, 0.8875159555642578, 1.1778413011158126, 0.8304056276361477, 1.4999630294399469, 1.2593255848327094, -0.26005646864892096, -0.24244698261186085, 0.14466629134177356, -0.28394419235443913, 0.3053138838405181, 0.605423291692955},
    {0.39956952318922234, 0.32163138802680824, -0.831628214902245, -0.15380957752155203, -0.9704948161711442, 0.06642950208137187, 1.87946314439113, -0.4426103506076931, 1.7028881355938923, 1.5275512992430975, 0.7900146726106574, 1.0607417988550656, 1.027271929502629, -0.4200172653869365, -0.7410267042360642, 1.2452484994190154, 0.251897179887926, 0.7663436106360118, 0.25224909216426833, 0.13811002087227325, 0.9834999712936013, -0.22958576513680795, 0.7868757322302147, 1.86487181678233, -1.1954527584557362, -0.5642422488677283, -0.6022921980511686, 1.5591701698976406, -0.04174565031205949, -0.8293699672642365, 1.1311530109035601, -0.7764074859215807, -0.3719954712010996, 1.1255062984749793, -0.07021337333956325, 2.0378350757995944, -0.36381450004316873, 0.03444950142150984, 0.10979110839255789, 1.5140128952498113, 1.334968989468741, -1.251130642802301, 0.8677121027347325, -0.3290036506853731, -1.4267089505308121, 0.21344969397388106, 0.5018664184174852, 0.3382155228231232, 1.233900909198351, 0.1012468461926779, -0.04669997864264782, 0.7589695920434207, 0.27538043718503374, 0.4073195001352468, -0.47012914499527514, 0.03491725420324514, -0.0916100522807347, -0.2330800419498938, -0.725644569769487, -0.8423475706879104, -0.24020172377016044, 1.311514658007215, -0.9522299277246454, 0.8044736200164894},
    {0.26300654918574906, -1.1259252467695056, 0.059960006279587974, 0.8019406073848825, 0.3221295832999859, -0.5600243706201831, 1.9835044446837466, 0.653086593738373, 1.9612914362085925, 1.723993869194855, 0.08094530986353997, 0.9741441751590382, 0.3533424769688637, 0.4805064723000334, -0.8641864471350492, -0.4926982070621202, -0.9653360057053196, 1.2511340096761887, 1.6833346136775778, -1.0813073921871235, 1.5514538029632303, 1.4932649977762538, -1.136348133779972, 1.857871778383326, -0.5704448304883167, -1.1559381259762687, -0.2853647639571678, 0.49593558354263806, -1.0559413180275605, 0.24186399220632251, 0.8224697963695041, 1.0221139365751077, -0.6563880880978835, 1.0786149054797518, 1.2513365864011772, 1.2934172361394438, -0.6637691174198922, -0.6724728138645282, -0.5877039541255873, 0.06868838851356106, 1.0570497202321543, -0.9817942801640188, -0.09044046086825328, 0.5929232162916819, -0.37618910905704356, -0.5594168209591932, 1.7842039563792207, 1.3681494449497598, -0.21746324778227455, -0.7206721307975893, 0.7789778665484162, 0.5231939385803924, 1.6447100932216976, 0.03923618666437937, 0.2689023109716043, 0.5051351723148578, -0.16482918830113502, 1.0465652388308462, -0.9731984630573844, 0.5166761219834894, 0.9232374980869279, -0.0042707492126554504, -0.504155004864584, 0.7896071017136941},
    {-1.3348627625991856, -1.3884461487823128, 0.0734618071768954, 0.6807539933305701, 1.2640233671817305, 1.1972813049409938, 1.0601858974608749, 0.7646414900233065, -0.35838757676626953, 0.17410656595922955, -0.779698786680629, 0.017130489659514008, 1.2946364501990322, 1.5565840463203044, -0.4116691339834633, -0.9347445868821066, -0.43155149876198334, -0.46028008653712627, 1.3191796877686108, -0.8522226215169137, -0.02573148994955633, 0.34368439487087404, -0.8009536387838805, 0.766861347924907, -0.15261512460408236, -1.2459359303586126, 1.2362297086451348, -0.5753092443943003, -0.9280752367955005, -0.9750147229616846, -0.31885042942543507, -0.7989521764767973, 0.5829932588826516, 0.03931008060342928, -0.8330416525543606, 1.7440546280081093, -0.8801969932490801, -0.10220393427674652, 0.11692758844859887, 0.8185081969631454, 0.4372648342985808, -0.7337554418228401, -0.9935332508382932, 0.32798059810007035, 0.43033053842844615, -0.6898410350311338, 0.011453928431634766, 1.4181680954686369, 0.7828760214839741, -0.2398088113271921, 0.07249923886845426, -0.7269582864885883, 0.23563034986332715, 0.8204724507259941, 0.08694856739638519, 0.16898545858791192, -1.1491743662454055, 0.6319551096269649, -0.9012770225825302, -0.5200289677994058, 1.4922085291634541, -0.15294279002544037, -0.9293330544316626, -0.7783039313902214},
    {-0.12173410256826692, -1.3893559303921468, 0.5724331719105726, 0.8902113453775299, -0.332467022646356, 1.3804148153889417, 0.6204196429397097, -0.2509617688670126, -0.6952740184536116, 0.8790700542750608, -0.20797056330757363, 0.6630852530015087, 1.5457992456867884, 1.0927825886973914, 0.41887144932013715, -1.2879638686430137, 0.3981144798421548, -0.19557303531327824, 0.1892986758671622, 0.8509018596027476, 1.246663782187218, -0.2777615625992471, 0.7457506463364236, -0.22076978338474124, -0.18832835431149503, 0.7463714996817287, 1.1586450954470973, -0.5911319648123093, -0.07553829937197827, 0.2222952916786838, 0.023891641055974654, -1.0920086822449488, 1.1517224787136968, 0.8940917900825066, 0.6196299632769376, 1.623690469250345, -1.1593772543724772, -0.16122204986275032, 0.9766135878288807, 0.24656161715490718, 1.5508571296276543, -0.9217877966457303, -1.225981410058221, -0.4889808834996531, -0.834646343272097, 0.8589687493899048, 1.5614565539622427, -0.6540532567119458, 1.505378409278703, -1.0015312162795138, -0.9354346616980165, 0.6750452759457601, 1.1656087966676347, 0.26796931878802477, 1.0036941784276212, 0.48463957945524166, -1.1466433787202328, -0.5225251375998826, -0.9475246497140685, -0.4723622264450408, 1.4081801222255383, 0.7753091503613239, 0.49833482073544255, 1.0850375373455416},
    {-0.25688962715037655, 0.61253422313727, 1.389684685253793, -0.966920185820245, 0.5025270692293153, -1.2119591522838036, -1.4316386595581916, -0.521365341002705, -0.8148958427437601, 0.057983302880352076, -0.9661003054035632, 0.9130652558901148, 0.8625133339591272, 0.8576662505274024, 0.5602510400286045, -0.6457327874590321, 1.088993009130241, 0.8184664060481622, 0.3701654819172949, -1.0436884897976064, -0.11081236064364468, -0.8597223956858847, 0.9840724506042188, 0.6258195795085238, -0.9974151584452043, 0.3635523786126275, 1.1664330011813338, 0.46307945874904055, -0.6997331368231464, -0.5345466158342324, 0.12235431694179684, 0.053727334635331796, -0.6179708834208667, -0.4294339955453539, 0.5355112846701667, 1.0785619626712886, -0.6670734790392379, -1.1432245276823334, -0.0644672324955019, 0.7304446022397678, -0.49756935478567166, -1.3420437715601037, 0.5965909344219924, -0.18727578457341928, -0.5515432783715187, -0.01804325558858434, 1.5544547110917848, -0.11653402639095665, 0.046537939411321096, 0.08397408754225605, 0.9640067554258199, -0.40759386547531756, -0.4677552802799698, 0.04622048162824055, -0.4623667980581934, 1.4320163308335385, 0.3970155929534209, 0.6261123878471038, 0.23729035646644328, -0.9672707084047594, -0.7102261960713141, -0.5720704225205288, -1.149698136391309, -0.9158914482857958},
    {0.8102218600467019, 0.7229394634549419, 0.24612623078678073, -0.7033215725970239, -0.6535638150752285, -1.2603310045032865, -1.0173102736577024, -1.1643744325357017, 1.2200013696910077, -0.1583887984473027, 1.34087857840813, -0.8468229698639265, -0.8819540221586243, -0.5450291776725514, 1.2959374829574453, 0.4906575784739216, 0.7258294144561898, -0.7734552637055612, 1.6001473569198776, -1.146851951714729, 0.3877675257240002, 0.09292192995299971, 0.6404508260381951, 0.6010113636989854, -0.3712071912944212, 0.3815769754047882, 1.2474039922277647, -0.2963622461487048, -1.300684460095786, 1.3641312458742083, -0.36125507749373975, 1.0595110652403226, 0.24878078003321974, -0.7268115093578792, -0.874398462716543, 1.6101650197264201, 1.0248950867251652, -0.428599274899658, -0.10694574375540146, -0.5809369391905349, 1.1870594223431905, -1.396217661061621, 0.23532240821893866, 0.8812630812767862, -1.5070617269800337, -0.687322229006325, 0.6998085081445977, 1.1617297023537434, 1.1633452371788262, -1.1738404493574435, 1.0834578500699317, -1.0106557274748467, 0.8933587271747354, 1.0688869100425091, -0.6795182474364035, 1.1852055988367858, -0.6888240655518011, -0.6225952470324152, -1.3488234656579627, 0.8510493417792854, 1.1167512370013235, 0.11111839889834718, 0.13867327975328908, -0.6014677339875655},
    {-0.8321530262846947, 1.2549314447358613, -0.2741738836453943, -0.8365662762554691, 0.15700332026267816, 1.1425477483828101, -0.33577140220752, 0.023617704584324464, -0.9191742613719985, -0.13607209601834097, -0.8366937927966619, -0.9159291301228752, 0.8149651256991058, -0.6401420135812886, -0.9285662835245339, -0.03861147476151763, 1.0706067504704433, 1.5209178821290663, 0.07328773917586001, 1.2856608576212156, -0.8736232169848992, 0.19575375391980987, 0.17510238843369832, 0.2369814326100508, -0.34686800755843444, -0.36264995490738217, -0.8157445353307545, -0.8650727852754967, -0.6223463237808979, 0.19170246413336042, -1.0864018604833765, -0.48260917957108596, -0.44466776065623015, 0.9269142281895295, -1.012632554226564, 0.45429156458466674, 0.059439315330713706, -0.3540954024722881, -1.049019636095308, -0.9046580123513054, 0.935270274456506, -0.18335133136605022, 0.19929346299215991, -0.2072773282095983, 1.3357243600002593, 0.11522480070843885, -0.8185566531387607, 0.6342752007488013, -0.055973311720574084, 0.2685663793156655, 0.39335518737759745, 0.12365551537679359, 0.48635317184654814, -0.2889416032308562, 0.6864415202281415, 0.46119212629273293, 1.2394527148967385, -0.17262565396579974, 0.7155938976988585, 1.0198116355669737, -0.2440755203993343, -1.163058564414525, -0.7656318773848011, 1.180220609925402},
    {-1.137274162017785, -0.6612386032357132, 0.24905250559525444, -0.8093969692409219, 1.6491101415100695, 0.21309453166335357, -0.9882415741958969, -1.5828910871262494, -1.0910614845202775, -0.5895747242293752, -0.07090777689473705, -0.3248942955060479, -0.9929496776268527, 0.6170012125271473, -0.10624956713849576, 0.5653000659312729, 0.6551156012865594, -0.8559725318676624, 1.1513176888221017, -0.44252161458923556, -1.1086016508514271, 0.2639118929677283, 0.49880367481861365, -0.3564252885993578, -1.0600642375711031, -0.7143115155446567, 0.1664910540483836, -1.0940231754194334, -0.5053938589242251, -0.46909794090548207, -0.86953791092576, -0.27602922806436314, 0.22840642810223344, 0.7218380097580152, -0.13121227834642846, 1.5615595476072535, -1.4480134096251802, 0.4474370340602981, 0.2110305755834436, 0.22764810492742343, -0.4108239681302117, -1.7828543077551573, 0.7200091319991501, -0.5733109299151739, 0.6027097394359373, -0.9277772364252734, 0.03666140799161581, -0.8479906928163262, 0.5273485625653773, -1.7334116988996946, 0.46786624469124255, 0.10486169888273499, 0.473819016419138, -0.7730923826324144, 0.4962271788302103, -0.6730830899721101, -0.921693331221899, 0.9897163856354861, -0.7274918537912319, -0.5145746857889547, 0.9545133152324169, 0.5851927492398877, -0.9378665806869252, 0.7474953946836946},
    {1.827718780909445, 0.3987237690839347, -0.9834754941314922, -0.002434267926362653, 0.5794023405209959, 0.695072355906205, 0.6528575309267657, 0.36129151506489343, 0.6019974065462357, -0.5800224551583165, 1.6083924731316823, -0.8782236229396108, 1.2175558219434495, 0.2020020085039384, -0.35546022123227355, 0.2142663279061232, 0.37990330542995265, 0.024344579777713142, 0.8785209081535705, 0.17262617255829907, 0.3046393839135347, 2.0115938664401063, -0.656906144682052, -0.7421920249694731, -0.7517543212059772, 1.2084150237918363, -0.5030071107141649, -0.477773117830398, -1.4833356470314998, 1.4899001288755809, -0.43184284192337136, -0.2908016780963848, -0.4943445261421294, 0.8302364797658761, 0.07133564592307044, -0.8043444033261616, -0.24469775851622932, -0.07899479078232835, 1.612968341874219, -0.7041078535480657, 0.08075889482252437, 0.06402249819222, -0.8554602214525757, 0.14969222918884964, -0.3856894419022979, 1.3035172899479153, 0.16271511401247016, 0.41011979038842217, -0.6142107803150048, 0.018594998824529054, 1.6943660351719751, -1.0089500665466853, -0.1220695409195577, 0.763762412800662, 0.5295599425540537, -0.2140682748682505, 0.8300476954699507, -0.3140365285445464, -0.10865965215617476, 0.12189742927004757, 0.10604313072888685, 0.023422618169967387, -0.6838944568512063, 1.1442148043674656},
    {1.6734560555716143, 1.2411991926571737, 0.6074569034412682, 1.8144577914617988, 0.6252621509536554, 0.7217121565933197, 0.8374238011440114, -0.1721748097136411, 1.3821285541304027, -0.505062068099087, 1.2560458832556327, 0.7580835123755637, -0.7080523518069909, -1.9869781503171624, -1.0303433588621609, 0.8204784359775177, 0.3876018302987154, 1.162388346482847, -0.8849684172777239, -1.043841485166187, -0.5698924253334202, 0.5850950782818201, -1.382696117272718, 0.45909825640639673, 0.7128899777085225, -0.21028393205016252, -1.600894957530988, -0.4065255652755226, -1.7797343045420075, -0.04061834299570532, -1.510071676277523, 1.3311571340091, -1.1100680569710557, -0.32743897736803257, -0.19035868174083484, -0.2828422551749058, 1.068250487477131, 1.3727763336062881, 1.4903923722349617, 1.1782496816403805, 0.03316616493986564, 0.4863223484024734, 0.4653854548874234, -1.3920348330837968, 0.6719117415758543, 0.45186453474199745, -0.12565364444134838, -0.2512940785332642, 0.5840970185906178, -0.7384386140158364, -0.2871861851445156, -0.3358622145224508, 1.356189540782748, 0.9024366871104466, 1.3669516562951693, 0.6076549550059247, -1.244119780682391, -0.7540788059417479, 0.40253959351470525, 0.3271896320365578, -0.08984439187241686, 0.05113332846842931, 0.6413832819499319, -0.868334028840596},
    {-0.32942721094712335, 0.31620296076425236, -1.0114944929327463, 0.13100872191127955, 1.4733292954930601, 0.11656450993551372, 0.2012501910839259, -1.0234163100011522, -1.0544822769121407, -1.2036378318986072, -0.697566991492503, 1.33192306425025, 0.6251448488778105, -0.4481426583294769, -0.4886803383305214, 1.3128364265682708, 0.6755439498111774, -0.40608540848815156, 0.9055059014841811, -0.18570671376122186, 0.09429815743579932, -0.05530779555280773, 0.9932252674444055, 0.5835879053208867, -0.8030760665141183, -0.5345422182127533, -0.2343704431041117, 0.30901672181943407, -1.6255111706222658, -0.5006573252317614, -1.1113661749509567, -0.35048324385320345, 0.4093532150001154, -0.3546184950145014, 1.3369817358907008, 0.4387959835141763, 0.3443688421233035, 0.33288459999081155, 0.378591440437285, 1.2140968311876537, 0.5992774601725388, -1.358564913546601, -0.40093538032384257, -0.716288918347777, -1.2149957738307824, -0.4276555115111472, 0.6021013742277643, -1.6367073059232533, 0.8343049990904998, -1.8535737526865228, -0.4589518834092274, 0.9835051865250342, -0.9321422987613326, -0.6693443820083986, -0.2723808287183129, 0.71074461583148, -0.19122171771227137, 0.6694408060874298, -0.9348243877202698, -0.34171005395307863, -1.1129506735316874, 0.6110576734444196, 0.732248011868596, 1.286175619052615},
    {0.869600172051369, 1.5511898528442192, -0.5943656955785965, 1.971791026754699, 0.8196874254452446, 1.3886713525514138, 0.6175677798250061, 0.9002635848017805, 0.4943045936516694, 0.8638635723692856, 1.4973804139378122, 0.16926634289455272, -0.7362653360384649, -1.367816510176012, -1.2875580950948053, -0.08509935981335601, 0.9153823812910261, 1.1875485284425118, 1.7159161446463178, -0.8673400141060477, 1.132520527645119, 0.6665551735339396, -0.8850987457884545, 0.6496552490488489, -0.21511557955737726, -0.5157167573790431, -1.107242310432972, 1.0122480288736049, -1.5246303552336744, 1.4218058711342039, -0.027878605671899714, 0.22713253053572838, -1.4550938805524176, -0.3432324433799065, -0.6125664322359129, 0.2700302335382001, -0.8786999627570026, 0.699064515008487, 0.9383347444368766, 0.6244778291411648, -0.8729492536532235, -0.2290383360741313, 0.23563982083219656, -1.029226489999975, -1.0161743965887122, 0.5309442469661086, 0.763598640612843, 0.23450786748546995, 0.506165214966397, 0.07245533194722575, 1.773371002030986, -0.030342257017386902, 0.6159228805413811, -0.17160929468751313, 1.8165629368195708, -0.3154500726886374, -0.8742024630121279, 0.027080707541768417, 0.158011231298825, 0.5946872513712744, -0.045690129111566356, -0.41189803713607664, 1.0435124354977652, -0.6477624123494419},
    {1.4953076210833602, -0.1837926062841355, -1.0950246754375117, 1.445664342021344, -0.3182022772860916, 0.6876293903341737, 1.5444999626321554, -0.2916114728652001, 1.2227221739933154, 1.214349760588625, -0.21991593849541158, -0.31304117030254863, -0.8329904791363616, -1.6342491513587536, -0.11290645306713204, 1.2295869656084875, 0.6232870404805056, 1.1623698732663448, 0.09823979677421071, 1.1126438220236943, 1.016077296512996, 1.7297726699052272, 1.1076601409402838, 1.320205824675118, -1.5014394406597995, 0.24816257298199296, 0.24716463835853608, 0.3422073081588302, -1.0872631824871142, -0.5150676944125331, 0.2092910435497999, 0.5983252697764248, -0.7964188920599158, 0.012872626206151271, -0.9901292040441989, 0.05326055457480905, 1.1899980001716275, -0.7880278121664552, 1.1824743484232294, 1.3594230351442913, 0.15980912958448934, 0.18497859077610698, 0.9586291833016677, -0.6515757719006637, -1.3657347988687836, 1.4577769330713914, 0.7224350807250853, 0.9413433866540228, 0.011375391824941804, 0.14115124192656395, 1.5290428273780454, 0.4920965404197172, -0.2224039676165818, 0.27800474383362445, 0.5237614802773545, -0.6045445681937709, 0.03592854339657313, 0.2147307321814834, 1.2529734620969861, 0.09287395429232925, 1.0605863137153992, 0.7659609624159327, 0.9295647223147997, 0.4934210070812739},
    {0.2353555181599447, 1.2214347968960784, 0.6311274468615191, 0.989740793037381, 0.8328133087340305, -0.2568135501648, 0.2942020655630608, -0.08137612163577285, 1.0803476151489315, -1.0456759178409774, -0.5051523189046017, 0.18610144756227046, 0.6141074036885129, -1.4302261159521823, -0.45227365307592543, -0.09280819157106994, 0.6188906304677161, 1.2520983644471946, -0.5642722225533929, 0.9346506403257815, -0.2929500064941391, 0.8311614627561154, -0.2387156881215559, 0.26903241298141367, -0.9229505263777342, -0.3872879199230364, -0.6263095733632125, 0.25041785958190727, -1.0511422316789767, -0.9421143510068012, -0.4206851929156419, 0.3002210347221107, -1.0128278690067913, 1.1675017339127973, 0.7746310927823237, -0.781493035828306, 0.6707879977952627, 0.4153877223225837, -1.0859452773059872, 1.1039371703667296, -0.43180019897561756, -0.3213670030333246, 1.190439362819307, 0.3002372243687406, 1.046893174108955, -0.47754961245492367, 0.1762133476468645, -0.8095529309429704, 0.9974047198773495, -0.3618629434416517, -1.1488522362049778, 1.09185913972974, 0.8011737264229054, -0.22667349748015048, 1.0987709522476787, -1.0464085057067418, 0.5214748372023754, 0.841111704770517, -0.09293569573128678, 0.2419981777585173, -1.135357131377965, -0.6670248128124147, 0.5216812786182113, 0.3814159191921103},
    {1.4602587421674078, -0.4935675871192436, 0.8831596418409805, -0.26903540265408193, -0.67037261954259, 0.6743342142738836, -0.07014654684206746, 0.4101352138061426, 0.4913336710544904, -0.2883975394699098, 1.602391258750627, 0.24072898674655555, 0.3814556148798039, -0.5400230661571978, 0.915439342125648, 0.6353449607266901, -0.542679661879865, -0.5645887377196849, 0.5471233129846806, 0.43167387724360956, -0.1439672734364283, 0.9141327607748454, -1.1979712203994703, -1.4412940349812673, 0.935734017573068, -1.2041901710175793, -1.2693502009199062, 0.6776721174417231, 1.0461740045376207, 0.6893180929957258, 0.5173620597689077, 0.38246376386655273, -0.9434085403567373, -0.036449584259788656, -1.0050146775943576, 0.016223315257841934, -1.1885740496758113, 0.22867598525317887, -1.0329783264186017, 0.5342430641589082, -0.21566726252361118, -0.2620203679520584, 1.307670963268003, -1.004717726234131, 0.5268513146305693, -0.11835743007165161, -0.5905188463051589, -0.564879501368344, -1.5357781802136117, -0.07129715847901888, 0.6726569540280228, 0.10408893157049727, 0.15869374306389267, 0.3885670940857241, 1.3532865490545027, -0.781802358842177, -1.103195070789234, -0.6871896878667798, 0.8152808040759978, -0.47117071148975354, -0.2552785136897835, -1.3824426226133806, 0.38445382114186294, -0.6041854965163468},
    {-0.41194951741384683, 0.7906057612453992, 0.21873455011871734, 0.8010024674917445, 0.98329350364491, -0.5877471637394132, 1.1972542882302961, 0.9795744244367826, -1.0598898433261232, 1.2584864166144938, 1.424041292976854, 0.8605284624888794, 0.39756182931632034, -0.9415359428347266, -0.15692785030928877, -1.0829371020032563, -0.10641631278403518, 1.345965767104517, -0.6759853843914425, 0.844019180554996, -0.24095913355136345, -0.5140005588582103, -1.4642283052375427, 0.6426291785044531, -0.5870986372920834, 1.0568568984291993, -1.0198855809205052, -0.41808085769559966, 0.11334551083861111, 1.1885886818586573, -0.9142046572123333, 0.3592555034712979, -1.2158693329009453, 0.8730773799606804, -1.4783773570473964, -1.4482196745045526, -0.8881475556442905, 1.6064593301408125, -0.00731428883303671, -0.6125725462835543, -0.22121668656930984, 0.15740771099576353, -0.3235268996505717, -0.4305109414729865, 0.6258726948356405, -0.09956378908354414, -1.6046450817179578, 1.0576382963829816, 0.007602187915054076, 1.0819734439325597, 1.177153657222741, -0.29380541756855455, -0.580605413942443, -0.7046994835667234, 0.2934324969830203, -0.04354571476439906, 0.2592761853645798, 0.28802574287664334, 0.8862952249800625, 1.3504306764078724, 0.8212070511664317, 0.5215666646472362, 1.2417201166778415, -0.16110909361624423},
    {1.3506615030233953, 0.09435515696639488, 0.6917897979657626, 0.9877710106631354, -0.7267533264778515, -0.8560445572730617, 0.23001891107312877, 1.221716820391402, 1.3800229573541234, 1.5526697583294544, -0.33868933530314826, -0.5032681253021978, 1.4316655229943536, 0.1706431831212375, -1.3185512946251965, -0.7077743647105887, -0.8327063060048429, -0.00440658895353123, 0.8494853056859376, -0.0880200202693678, 0.6810205189489966, 1.5445934141476658, -1.6644625398185544, 0.5646274657769216, 0.7019726212052455, -0.12972735353779427, 1.0035378132801591, 0.7708952511703412, -0.9199977286773116, 1.3667055705939324, 0.11614210158996102, -0.40746057537170755, 0.2684257996164942, 0.33080722546640307, -1.39326532121944, -1.3352122532899888, 0.5179349028540436, 1.1722428966311067, 0.6242198111264322, -0.22978231630024687, -0.5252887978902693, -0.24982348337141208, -0.38213943903131625, 0.7280361416545121, -0.3196927802539377, -0.047072195509423924, -0.36099174637254394, 0.04664638695994188, -1.0261461078243852, 1.1376111451408097, 0.025998636830326168, -0.5350136128180598, 0.6098956317251295, -0.6069525492441151, 1.2303668149293838, 1.0643546702560915, -0.6651234755033889, 0.5364371343904284, -0.09806207916816304, 0.3110337223636528, -0.5446567238035921, 0.4942150559628785, -0.80174497166276, -0.7507703305194153},
    {1.1886542368684176, 0.003069128851443404, 0.32754973079755284, 0.5762177350108679, 1.026719434655713, 1.0754809395057925, 0.499785751080265, -0.470635361397637, -0.20837654076498277, 0.7378780546740005, 1.347344216117403, -0.6337471675182242, 0.4350683883239961, 0.8121115569923228, -0.4017121937766538, -0.5898573758653608, 1.1723773683253793, -0.7823044130101316, -1.004019855524799, 0.868381301959501, 0.5921263266894272, 1.3930728604715592, -0.500395885228619, -0.13456232473718757, 1.2656406529518862, 0.7411525960819879, -1.0838879111956448, -0.26295829931941805, -0.7224814901210325, -0.2929100758628041, -0.47044979837191636, 0.9759659336884294, -0.5266779530979451, 1.0638039675579314, 0.6218090123656137, 0.21653391141615735, 0.5909100438885767, -0.035729033708193074, 0.6491878713234218, -0.9829204041785914, -1.225179288264637, 1.501324460102762, 1.3641356742462858, 0.9050349175978867, 0.303249974654414, 0.04286713462581423, -0.7599806193736114, 0.9397492540598841, 0.22164164417867668, -0.7593599718832771, -0.7005576588934412, 0.7935443926634185, 0.5607956648578143, -0.9562722082208978, -0.001774053123493232, -1.0296480818770142, -1.1690657860585436, 0.32960857478494837, 1.6382318108916833, 1.2535862776847366, 0.0017942715025955557, 0.19997322446025664, 0.6613574725155184, 0.5456730343151616},
    {-0.9704368036931569, 0.004044157407275285, 1.4516703021701043, -0.8273931050919336, -1.4479962072273405, -0.7759527121308863, -0.48492264642112737, -0.9988614587380317, -0.5995206524738382, -0.3051139808275776, 0.02450480553800911, 0.36970333029482155, 0.8790296586432702, 0.6385259294727338, -0.47097073620570823, 0.06433993458705177, -0.4781033137971885, -1.2416967007513586, 0.27581566048833855, -0.7115136570548001, -0.022904988804652856, 0.8638894028592028, 0.45450424468218575, -0.5039580790388671, -0.9988257618875588, -0.7463065594110206, 1.1154048435688597, 0.5927777906181584, 0.8549552162115842, 0.29951305942281536, 0.9018683675361374, 0.4906913193784749, 0.5309110663447941, 0.8347025068490058, 0.5031683827858022, -1.3147648435987533, -0.08187094053727771, 1.065134833122163, 1.0490371151508504, -0.8281688074564361, -1.3720586342884202, 0.9850297538393316, 1.4816025903289554, -0.4498896773023123, 1.1243661031072734, 0.8972226307875498, -0.06561811841026617, -0.8142186357039948, -0.6319962152796633, -0.19392313609623046, 0.04685125263604165, -0.8341455021005579, -1.1036615813913992, -0.7236824629136889, -0.37474515257710705, 0.5862941948742123, -0.39372448766530255, 0.49433452269419925, 1.2934446056945148, 0.6898217135167245, -1.1539679665552915, -0.045996079175876586, -0.9945063658751713, -1.0102654919268956},
    {1.5837381177730632, 0.6145938052676521, 1.2335890470097706, 0.805098684057028, -0.7507963230891473, 0.7084409094159967, 0.9430438004161897, 1.6876521729453995, 0.6454657923372447, 1.9394673679497412, -0.354159862968261, -0.4093336002213626, -0.1758190102569884, -0.47911978904919056, 0.7951599327251061, 0.21440010413106705, 0.5047395720321886, -0.3195791271650962, 0.5641755545533529, 1.2290405586138058, -0.6571679235494017, 1.2724772639303874, -1.587745435382579, 0.43825100573343945, -0.923760809840898, 1.3614167608905732, -0.482720028729002, -1.0173391621212875, 0.669834873054967, -0.3799859953383472, -1.006604600758454, 0.3834736837989358, -0.3351303531725901, -0.39966424398077066, -0.8275864933786403, -0.10129764702356449, 1.5465274770123072, 1.6647425953489006, 0.7528066432532811, -1.5153555029308265, -0.8742740003591937, 1.0598933501971037, -0.09565163424227047, -0.6318000330597302, 1.2077938264842427, 1.3767209924951826, 0.9773814349033139, 1.0157210619094073, 0.12412942948959133, 0.749640525489107, 1.2528181266062048, -0.4912640182639732, -0.7634818890006169, -1.2158126027936567, 0.2299471814385168, 0.8620970907242498, 0.4134929193089762, 1.4447694156722874, 1.278351793482067, 1.651233976712195, 0.13404735201293425, -0.809540578803679, -0.4024102712989374, -1.3384397544864},
    {-0.01178730766170765, 0.9520291185982622, 1.6753973933132869, -0.6298436236329802, -0.8967849155547094, 1.0058103657133544, -0.5236735540850891, 0.1814131352926826, 0.11407051928855934, 1.2395278608274725, 0.10902844546091, -1.4193745818668053, 0.9919890539632823, 0.03468015909493677, 0.152930852845997, -0.7842773177384097, -0.13163787965802676, 1.0978731117408989, 0.6567937783780685, -0.47477237328521754, 0.5431407920990277, 1.0236335018521932, -0.7790604921147412, -1.6820155552970204, 0.1041403800444651, 1.647384682556326, 0.4063679787596787, -0.05529898941215805, 1.2081244616686897, -0.2628249432376583, -0.7438728540308742, 1.52015124987629, 1.177217702420601, -0.22934302388721814, -1.0613646478164351, -1.7666799055778657, 0.44018535728900854, 0.9937556959925014, -0.9076057596206832, -0.010794623646430909, -1.0351495551332797, 1.181536911365166, 0.5242841114357155, 1.213953937472731, 1.5443420861833985, -0.21853930748101666, -0.3499712966104119, 0.6912119096741868, -0.7304743322175264, 1.1896444757807623, 0.29797168979415056, 0.6195503864951535, 0.5621277409894616, -1.0438803451022993, -0.42899734089361446, 0.8404905818860056, -0.8328295536882302, 0.7222375026296276, 1.8640424359004304, 0.19103906837731985, 0.4811048287757155, -0.290339560020735, 0.000251746936554958, -1.7752608585264267},
    {0.7511720280547013, 0.7991912895102509, 1.2940587008055604, -0.1153852163250296, 0.3848797771473488, -0.23170443763836535, -0.844143823978044, -0.38202200189967317, -1.4126893924992954, 1.2089571571792423, 1.452067278451563, 0.36357954872903825, 0.8933466844493831, -1.220011133226224, 0.8375781552139088, -0.564324651551457, 0.9254363253467927, 1.0382193924023708, -0.8516725692723298, -0.7142873076436499, -0.8083702121948189, 1.5189436296823882, -0.6967103598613663, -1.207219785928822, 0.690234182939417, -0.27836675208686673, 0.16702111714435008, -0.07146592720865855, 0.7421902828238292, 1.628173737874315, -0.4182728110373536, 0.3061198081161155, 0.3110225518957506, 0.7872964138740858, -1.2907338099177361, -0.723878638125434, -0.020198006234328963, 1.4125208714727344, 0.7760397729270851, -1.7058190029007214, -0.01200790979515648, 0.4882913799521143, 0.24600835354175754, -0.18681478371888188, -0.43639054664254845, 1.1029326169116886, -0.493791049217966, -0.7067495326086777, -1.337130521325024, -0.11437053056130304, -0.39365334862224716, -1.5646029193090387, -1.3293140230492335, -0.978754532988048, -0.32311482004748787, -0.28205846808198365, 0.6770122394321757, 1.4953425772642017, 1.7847178437556732, 0.2667722863315715, -1.1646882309296784, -0.31455144735773516, 0.19701691898979257, -1.4714126791413566},
    {-0.33378347622385557, 0.13382348298417812, 1.391881830968725, 0.42906834089840484, -1.0521352920695777, 0.1198877317015502, -0.7395081515068221, -0.4343894149979773, -1.3599014513054628, 1.0680578149244395, 0.11285154614954451, -1.6741117920446933, -0.14913024312489973, 0.39305236095143525, -0.009100350974362202, -0.12371677398763477, 0.15292685495667166, -1.2621171151732387, 0.7523004274173138, 0.9818333535861786, -0.16929049931643025, -0.0414650047307514, -0.9558483220937727, -0.05465858184176863, 0.6748652833853298, 0.8045950344601607, -1.3901040345029807, -1.286179719458294, 0.436144820113785, -1.355652446864268, -0.19389751765723529, 0.13756656722556546, 0.9216450840181039, 0.1989578701143681, -0.2924464424129456, -0.36305020852058034, 0.8373687828743314, -0.6287773554099588, 0.05585017218985513, -0.8985730046431956, 0.06642795942277696, 1.1911439119535578, 1.2269596224770407, 1.10904686003622, 1.3078159677049768, 1.2333107737446396, 0.4538230003551412, -0.6866108357822622, -0.9379184955984854, 1.3616558985337839, -0.07881612525562963, -0.6298636412494891, 0.2741046610827105, -0.46981375694471017, -0.7721959730098992, -1.300236888733991, -0.7229932741565118, 1.350635453098542, 0.30117234765055034, 1.2106790919568322, -0.19044487074576566, 0.5746680145728297, -0.6525568628233253, -1.19723734577806},
    {1.2606755637033669, 1.720306239560287, 1.3235096041016716, 0.010502337569154335, -0.5443166158006166, 0.75400337700577, 0.778015652124038, 0.4537806948084132, -0.9010115360742217, 0.8151932371484161, 1.0426346532091093, -1.240321647144316, 0.9591084873475181, -0.6007891190156299, -0.2963306376316844, -1.2160577464179385, 0.3930117912299615, 1.063435673665698, 0.9737225603395047, 0.3759326479630617, 0.34379431434147695, 1.1325886292158762, -1.7280700139308973, -0.15525295291782273, -0.9251938243087646, 0.1419850026519971, 0.6409569460137741, 0.5859938057288379, -1.0053389020625354, -0.3116698411474335, -0.8555593727329934, 0.5014477301291648, 0.7031395144268345, -0.39991457792323276, -1.091330056984373, 0.15032541401313665, 1.2574923162679965, 1.4777759492498808, 0.4046153442144936, -1.2146943586311056, -1.3119973848095106, 1.2011927961342388, 1.419986920633809, -0.3715219096729251, 0.4967119584044718, 0.10594137878380398, -0.32397367204938154, 0.28518765100015336, 0.12733555239198233, 1.4004049253053665, 0.9220192864144754, -1.4301336542536547, 0.6421596800505515, -1.3278366897187521, 1.0434251340060483, -0.14615307724144336, 0.4606326982939726, 0.10029412212873176, 0.6099807299118586, 1.55165022252498, 0.4895875763968855, -0.03688243864694958, -0.24609031155205405, -0.3852921234596389},
    {-0.5858374881756665, 1.1948054501483887, 1.2100313220023582, 1.107605997588003, 0.301239154822403, 0.3370627075591549, 1.168665702120063, 0.7942461091666108, 0.5895929862747863, 0.6090763028899182, 1.356530144348055, -0.4800110738421142, -0.14566869902921845, -0.8652859732007349, -0.6651356016503509, -1.1137891754323879, -0.7249838218016514, 1.1837353862869315, 0.3434633656528131, -1.0098539621233735, -0.314784215360172, 1.479610488155749, -1.400301059398071, 0.012075461061963317, 0.3594902700475709, 1.5632426557752732, -0.410388050183699, -0.7914366675392941, -1.3001363361181995, 0.6083512389125353, -0.6174540722236638, 0.6983137388142894, -0.04019263876271632, 0.6006598722880763, -0.4308716237445441, 0.26767625242093973, 0.8452012224046197, -0.259166385480014, 0.7649624441175205, 0.0922353118707188, 0.5442166185430659, -0.4262784489202678, 0.050920662684124374, 0.18534245967748914, 1.0843212795022028, 1.292118316629128, -0.22116821696374953, 1.1862674374895583, -1.1634169358801514, 1.5531917646868965, 1.4379896222823372, -0.8330723689688359, -0.0348374254758015, 0.7152096221625078, 0.5663774369963491, -0.263499573310215, 1.0796397906765063, 0.3769631854954388, 0.30587980165807394, 1.441368236875754, 1.1333938410154427, 1.0052369499655103, 0.8132924550736044, -1.1805138875604573},
    {-0.5464157316966562, 0.733556911234311, 1.0517032099345784, -1.3506911545603675, -1.125573613786448, -1.0504094662710022, -0.9922842764520952, -0.37729315200499147, -1.0089942143276656, -0.46512783158948806, -0.8552165763434361, -0.7184509199054272, -0.44725054994415336, -1.1423066715558219, 0.2978396563711479, -0.7048863780593719, 0.5423687059151199, -1.5128291745375937, 0.30110588229108753, -1.366892414873734, -0.13813764113370325, -0.16644555920176307, -2.1342196021531037, -1.814100068253154, 0.2635011052305664, -1.0438667836267475, -1.7491410611607747, 0.08054059197118377, 0.7254545906529579, 0.6529817205755772, -1.695019076125151, 0.7871741749286532, 0.18132121494048636, -0.846340678999818, -0.583429119652413, -1.1036204073218663, -0.7358887189729071, 0.6887772802940223, -0.9337781357874061, 0.8148581186896781, -1.229954923841764, 1.0403631822921597, -0.7564592744039196, -0.36995914778442246, -1.51435523483069, -0.04889690277122796, -1.1739601286630583, -0.5415077330937481, -1.7131275652844509, -0.6295849422810861, -1.081175170601737, -1.7356857809774793, 0.09460082376901063, -1.2737877627662402, 0.9368440774230412, 0.4118533444951111, -0.442744871185271, 0.7180329257174604, 1.1213499418419401, -1.3896138796353135, -0.7048694760397096, -0.8809088840453603, -1.029660523982313, -1.4546418997291282},
    {-0.5578484357319181, 1.2769568395331774, -0.5419632342213831, -0.39821853400171897, -0.037722147194766326, -0.4680828743081666, -0.9079998991098565, -0.5256787558697285, -0.4533426619204239, 0.6352629066975489, 0.03812544226037292, 0.3531659945846788, -1.009414650781257, -2.0690809023317134, 0.8656501476397326, -0.012965107216918674, 1.2544399681196525, -0.3220108212781552, -0.34950970319905056, -0.8969750302308716, -1.0052677883222394, 0.1770455732382237, -1.5224216911082442, 0.06302507374442924, 0.15565735508547887, -0.028771711126435992, -0.8209353348420388, -0.12195148725046069, -0.3800001544845236, 0.08350955044731888, -1.7154093728431807, -0.759526011764292, 0.24765906442694235, -0.17262939099113792, 0.047073243524926325, -0.8381534688953236, 0.9450354764092511, 0.6067830105776917, 0.7721630641795604, 0.6181342946267706, -1.4977356951742702, 1.443088075752294, -0.6490632772180022, -0.06427394848443636, -0.25825848687801467, -1.1898958726849411, -1.156445719714512, 0.07149492228065216, -1.085895404816579, 1.029060464747464, -0.5372366131297305, -2.0076738056130146, -0.09923944165435267, -1.3562541806039778, -0.5167004046153194, -1.1209246838461273, -1.4667314765290236, 0.9370125286127023, -0.1944797336851309, 0.40627411386583423, -0.9695644280491827, -1.6029711812303382, -0.4281357755967622, -0.28291901669240643},
    {0.09419539547788176, 1.3595254198809652, 0.7173883345318518, 0.8729063310864185, 0.9545128742183363, -1.097738405044687, -0.530897759442744, -0.11586408571263322, -0.12676365951494484, -0.6603885985121336, 0.8180736090393841, -0.34648004053785225, -1.020965793215152, -0.44704373421468985, 0.5659024419075545, 0.5970381477333591, 0.8502976192668964, 0.3128429014411059, -1.086608710690073, -0.040673573161085955, -1.0251023955420173, -0.9402981288253548, -0.9677772348399392, -0.667587658670209, 0.786520343417239, -0.39482324150694925, -1.0983861748464798, -0.9353515536349009, -0.7467187797395874, 1.0217270647676697, -0.9060444432864192, -1.0327407300568743, 0.2239609072349041, -0.10346883226402345, -1.319323641243119, 0.4707796729248991, 1.213626001944407, 0.8943432402371468, -0.27744252508226686, 0.3556933613661222, 0.5264532828070085, -0.5033617652034665, -0.9403908741850453, -0.7870461377279024, -0.0356705811931696, -0.5154601659286965, -0.6546748808514282, 1.0223437419256283, -0.9330990471302005, 0.7271532085974179, -0.6826802828819485, -1.005273490518098, -0.8974080280038147, 0.7910590784274485, -0.2882669232506525, -1.0978431594093057, 0.9903949233455289, 0.6223536363576662, 1.0920006437253813, 0.5827847480685701, 0.8099872213565922, -0.39670631004138357, -0.8484909084141679, -0.8306298256371797},
    {-0.9659926822341868, 0.7172573406930424, -1.1054419650361877, -0.33232156775667143, -0.8288211425425295, 0.4101497048168395, 0.25330519501998516, 1.081402765134244, 0.6858035894242316, 0.08629685884149026, 1.044792426891653, 0.965004665526798, 0.09371005166178548, 0.2617687028177397, -0.4722086056444721, -0.3380393104327876, -0.3374439790890057, -0.6974028205048586, -1.5743031039281152, -0.743611986567367, 0.17748984982885171, -0.9652812762621237, -1.2946449511506035, -0.4503585821146937, -1.0832390704461052, 0.2459525964987247, -0.7123243764977437, -0.33299797943194764, 1.0219130166610322, -0.7146099091306265, 0.25251515144888975, -0.4909875721137085, -0.7925529894235371, -0.9588233469677124, 0.3868108304974016, -1.2756504441692633, 0.7762607403841694, -0.036881537453836946, 0.518916276308037, -0.2952757957187534, -0.27964399917836874, -0.2278451215106958, -0.2531823177356537, 1.074532817876425, 0.9464167560578349, -0.23330951662835184, -0.7898375712574366, 0.16100844251339186, -0.48501975168330247, -0.49560641819425727, 0.2304900279881996, -0.8715289755089735, -0.5123393697681502, 1.2078144588098927, -0.43001915550810305, 0.7569825137823906, -0.9670995976583564, -1.15074712760734, 1.050927166894106, -0.07526414630122173, -0.502782479423646, 0.8483383001918564, 0.03227352035003597, 0.6134268572913782},
    {0.29842620151476296, 1.208494166538828, 1.1545484930743235, -0.9181974751138444, -0.8664897774183496, -0.3990607404195339, -0.4415668186216492, 0.31479852401886377, 0.6363797718396688, -0.61280561570782, 1.0272444443504392, -1.0516783265513447, -0.8752638390743908, 0.29095480761329584, -1.0763467352919383, -0.0701867125487653, 0.7065964820968966, 0.6564803804468364, -1.5454636285273307, 0.22282819541720175, 0.13514291108400278, -1.3594411060000469, -1.5228120505236828, -0.8689408174617853, 0.554934265819174, 0.8750090348141928, -0.5460141643665506, 0.6780344509605094, 0.4897994691730019, -0.5153523665482429, 0.14710898783248944, 0.6561938181000938, -0.19824400511999107, -0.14336783421412583, -1.2691545298196891, 1.0000542976850748, -0.9130879326973368, -0.6252574663755048, -0.6900661619045789, -0.42714880405505623, -0.9986064939547008, 0.698287467861329, 0.6295489255119583, 1.2322899907384428, 0.32853707519780045, -1.2993311990471252, -0.7159718858637036, 1.02918856200479, -0.6162723307354456, -0.09147074953939689, -0.8020757743373796, 0.8053641840509604, 0.37323171281568046, 0.5208815999448222, 0.5627302287371475, 0.3299396855780015, 0.03607954173676107, -0.47440990696746593, -0.574460495704164, -0.240578701777887, 1.0210114939079187, -0.19387611917038414, 0.034803052447412844, -0.2325032557189211},
    {0.11275511326167495, -0.07162009082196935, -0.13635634107442623, -0.1974736292422241, -1.4962284722273431, -1.4579797229185263, 0.11897366552827379, -0.2332401228634557, 0.3632857646755811, 0.4588210126267667, 0.7120393914397082, 0.5464587027003254, -0.19994978332939586, -0.5679641750715609, 0.7133354098895603, -0.5223497311706835, -0.9619689037252116, -0.45076607779230493, -0.6652269275714288, 0.6790544550107503, 0.6329344552301881, 0.509695744919865, 0.7111392973297481, 0.5145707262438961, -1.064734564839794, 0.7562706012928629, 0.5455170770614229, 0.667757861750857, 1.0806056713725705, -0.3834199508470585, -0.36697285457291623, 1.1344329279324283, 0.48698839836851376, 0.7010148823620199, -0.5476854882869583, -1.1176737405560668, -0.5770003013324376, 0.03136253526068333, 0.011530158715425828, 0.11645960395199785, 0.6766732033255581, 0.19700438243559604, 0.8551807792787384, -1.0214991646933296, 0.4043559606596471, -1.2480774785071025, 0.6311711701513489, 0.17134422415729106, -0.22936867404930442, -0.9862219265562517, 0.3341594817619742, 0.47031987780522777, 1.1125696528459958, 1.0056751638932482, 1.1938366541292273, -0.12847671053714285, 0.2084377233312993, -0.03558947002729388, 0.056142299087377945, 0.09556020531554593, 1.2372462850929526, -0.11707603458484339, -0.4395862017388882, 0.2904053678206519},
    {0.6876165105049881, -0.3187228674788757, -0.11654353816236221, -0.7165241637175529, -0.413472528986285, 1.1616333330196258, -0.9707999262330471, 1.064077622305993, 0.3835253572774908, -1.1908695190775778, -0.008622508561806548, -0.2730072687581947, -1.0629949387409108, -0.26407489889626806, -0.3425399881157173, 1.138135747896249, 0.5302204180227884, -0.7963394042020571, -0.41054280678483945, -0.4923275567440021, 0.7733979521969367, -0.3356637752160062, 0.5803644144548448, 0.8317567352874737, -0.9014854305461953, 0.8435670732404065, -0.20589418522592012, 0.8974448955107616, 0.17504624345816194, 0.4206031892187505, -0.6437540398311888, -0.8175061702057241, 0.32719215784780625, -0.2718665587552175, -0.0972359646799381, -1.2877172813980748, 0.8979662325671458, 0.44547317364742645, -0.2033170146946544, 0.11750089951107202, 0.6834520900651888, -0.43051637161447887, -0.9303150735507367, 0.9642291635057837, -0.45554175907107436, -0.3753627144220119, -0.9958529500880782, 0.3376914714368311, -1.139903420659769, 0.5047377719027698, -0.8145454213409138, -1.2248682102935782, -1.3372412763856605, -0.4167350218614474, -0.6220335082676869, 0.11373104312524135, 0.3352062996919685, 0.7894377595315188, -1.0979348780088, -0.9177109542194603, -1.0470726785185576, 0.3464439763569681, -0.296311216021373, -0.6382678094503484},
    {0.3083821066280778, 0.15655790770765823, 0.13834942351698876, -0.24230101397587298, -1.0835061049248793, 1.0587155780185955, -0.6542116281884263, 0.7034725165734314, 0.5502135297535294, -0.15180160515920937, 0.2406824928064253, -0.679655462314009, 0.4847819623738934, -1.5153599652996792, -1.085738906774454, -0.19918979805240697, -1.2978891559964192, -0.18407959557772402, -1.4380481389994457, -0.6612063796927998, -0.9494729365494478, 0.08925901739801287, 0.5929733241597548, 0.14829066622209472, -1.0819233575238674, -0.2710863231032078, 0.3768704303725932, 0.38677321119076197, 0.11612511808370103, -1.171309523965521, 0.1857139727715015, -0.011454424943084185, -0.00023264026911173742, 0.26599228812934, -1.3051850622972805, 0.8042120334498968, 1.271960483194521, -0.28190205238056126, -0.3159886280961501, -0.37013677908734716, -0.6745370361291889, 1.0256690623196876, 0.7807364629863939, 0.08553966150537468, 0.38535068788796034, 0.7690654594636176, 0.4559865664708188, 1.1846320412745273, 0.03499455608931699, 0.7621587618474283, 0.9974681672780397, -0.5698519284352587, -0.30989545640248867, -0.08174941186811652, -0.9654445414980948, -1.1509110409427012, 0.4157123856418014, 1.026164503877341, -0.5472970445379851, 0.4645312246742941, -0.7293770468456156, 1.1069240799424673, -0.3476848722557612, -0.995961635268055},
    {-0.1659018893223911, -0.4583926869324603, -1.0294440062398942, 0.5250545237235772, -0.8047372754000429, -0.8122768887429492, -1.4253947380714722, -0.6400268778228897, -0.9617586245368227, -0.0840237216264705, 0.09498773273926622, 0.3287200470208322, 0.7274451861037914, -1.1089917976408619, 0.2040723407019125, -0.36880574444246383, -0.7967645836138696, 0.273977880582928, 0.10926857546642521, -0.736856813534994, 0.36619752678521145, 0.49543371426700816, -0.7138393270635558, -0.35844331277617464, -1.41722095024889, 0.01603245830651729, -1.2259223062416382, -0.0570240281936997, -1.0898892348123368, 1.0151008188979522, -1.3250521788753111, 0.008682660423793747, -0.5287992254788573, 1.1673433758750504, 0.06488624193578114, 1.2068082149991881, -0.6241717633140116, 1.285018798027015, -1.0602512155361061, 1.3814322702769686, 0.6040083283606972, 0.5514751927454632, -0.5280598516178228, -0.44706051897147836, -1.2035784881653113, 1.0172843918868344, 0.7573004222620499, 0.1189606163631399, -0.9419518301003099, -1.2402014432162598, 0.6697276277082209, -1.5397252098749752, -0.6690997129816696, -0.08628705665232071, -0.2548291836711872, 0.3207549329109551, -0.9106567519904849, -0.08730168416200554, -0.42973277154025336, 1.3405237262437455, 0.8127532779382741, 0.9344687155356648, 1.0427936240415605, 0.9996940460564578},
    {0.6816741854802816, -0.8082379683742151, -0.35501833077184386, -1.2476217700529233, 0.7570207624136766, -0.639047548208138, -0.8735840170319609, -0.6527626018548335, 0.12713500804206762, -0.07753497385094285, 0.720978256743275, 0.6664131117638511, -0.683441715624175, -0.19272965680861207, 0.43029319652219483, 0.7938932610111046, -0.4332134340255895, -0.9071167612944654, -0.9758317673532816, -0.5123257388191181, -0.36174583788453196, -0.8884970467084893, -1.3457971742770638, 0.2836254422226666, 1.0575489845581998, -0.8031173972159087, 0.20982725341373668, 0.050433144471185604, 0.4447847280798238, 0.29168195864536667, -1.0876346025275279, -0.8912849889873881, -0.8934876294055998, -0.23338464616157045, -0.27256570316978784, -1.2816720104173216, -0.30237854954373805, 1.2937747135494924, 0.2504630302634454, 0.16451291524245293, -0.8412167639596452, -0.7319344612013791, 0.03459889719322393, -0.19960190566686997, -0.015359387505693285, -0.5749639534847861, 0.6428514964544504, 1.5838481827735444, 0.6433766096670186, -0.38989825474197654, -0.11854439818436867, -1.262144413170233, -0.337392133476041, 1.132866755732222, -0.4081010566345838, -1.1250408986019031, 0.5410165826040007, 0.8829356803386211, 0.7501176004976715, -0.7260823293613776, -0.40016251285847276, 0.003937415341016596, 1.0292555596037516, 0.25935361887020497},
    {0.7349756046342407, 0.9992749449037418, 0.615093586134641, -0.18991256276160084, 0.020677423095753315, 0.9655924912842226, -0.9339498586702037, -0.35779482452604183, -0.6173972366612789, -0.3136715634744122, 0.42564604024918584, -0.8373872551515421, -0.5228514078292533, 0.11179452792803982, 0.7591708741102632, 0.004245660531905742, -0.662821906115802, 0.3761963296539235, -1.1393523134321524, 0.7106092442457702, -0.5303187332174694, -0.9869288629711854, 1.040343512980819, -1.0959742705427218, 1.0118843883864086, 1.3010270622421725, 0.018874082886573825, -0.48441149336404077, -0.014054353231885437, -0.7044828138489941, 0.6192611819850673, 0.5792598688716104, 0.20994530533914949, 0.2652092138595045, -0.1321167912748027, -0.8435747201385275, -1.3811664205859997, 0.37538928908338903, 0.5254573448932454, 0.5323901009537783, -0.3540346571108484, -1.114281456518969, -1.1392663638511797, 0.6113473179790035, -1.0299133812779173, 0.004883536680092944, 0.14620801084686721, 1.009436035319085, 1.3087517753990143, 0.02250617544014425, 0.3553282034847561, 0.013809219373021858, 1.381395676365858, -0.13520358311503372, -0.34429863898336655, -1.4144193681577522, -0.45553559202157845, -0.5198822279325856, -0.6278706594961703, 0.5801485381165219, 0.033875583209556304, -0.7859837696698798, 0.618391014231462, 0.12714701000933218},
    {0.7247668820949664, 1.287429882770104, -0.2443317135721282, -0.056494933886389584, 0.2660598826725874, -0.3350356055087329, 0.07335708575649316, 1.20153163282149, -1.122293361991132, 1.1318827199467594, 0.5776853746023427, -0.3356698936686891, -0.47714978910516936, -0.045322094649791936, -0.7973184025027004, -1.156512636824578, -0.829944603882909, 0.725701404773795, -0.5680770958658724, -0.8003526243330876, -1.16093785645891, 1.1352965699485744, -0.6956097122975018, 0.46856055396777524, -0.521299433408667, 1.1836641030183899, 0.21251895016430356, 0.47466031445807283, -0.5975016966780617, -0.022809775915332967, 0.9582838695974597, -0.5179433748562345, 0.3734992546924033, -0.05392327500872722, 0.018017981144266327, -0.19010312897964285, 0.5672275359135599, 1.1045955765413369, -0.1553936146743054, 1.103981791513676, 1.1810653229913257, -0.3277308259275146, -0.4792097898915344, 1.1145851601419716, -0.8565692116818886, -1.1306040647864164, 1.2497118176697348, -0.696707476112947, -0.30513398453015184, 1.1364803991352428, -0.23912258222573887, -0.908036914677536, 1.2506481470120112, -0.31859615294238564, 0.7012128335996136, -0.13705442169571536, 0.09966291754413535, -0.5624892501517621, -1.006076775092411, 0.830382805435765, -0.9720867865727517, 0.6800354933803247, -0.1264125087054893, 1.1071171809587346},
    {-0.7745400762546663, 0.8220702942424624, 0.23875773377164836, -1.3366039941373429, -0.8666761844547893, 0.734906483679883, 0.02676744088429627, -0.057904054200998686, -0.5980475901849431, 0.7872696999015732, -0.03517789995974878, -0.44028102381571943, 0.2753660043166121, -0.42163637824911293, 1.144432262170725, -1.0509798049142163, 0.027719040386842555, 0.4607543194629375, -0.24667755142425918, -0.1592482395004421, -0.4140404535328738, 0.08616036716324556, -0.6493156576597761, -0.9766760633354215, -1.1011910223951866, 0.2905234597852536, -0.18559700735113385, 1.1314234953512354, 1.3073047158943432, -0.45765457866458414, -0.7068676878830977, -0.7022026778744096, 1.3285297771110525, 1.2522604236886359, -0.7567877356069426, -0.2642148632933367, -0.44434093415407777, 1.1172984088746392, -0.17289089352838294, -0.8360667131493326, 0.5723247912507955, 0.5319642959336984, -0.5411700203515766, 0.8760781866286225, 0.0497923891504007, 0.01954242719441621, -0.08188862252716911, -0.2319848298938728, 0.7673694878308502, -0.6503731337765731, -0.48502485140647544, -1.0483181390698626, 0.23054397405419363, -0.25865232640542957, 0.18496478511594472, 1.3930902524919895, -0.22652002804682653, 1.0343800018611755, -0.09264292790521227, 0.9003669229246232, 0.2591168495007204, -1.058294644579448, 0.2056025640700539, 0.7889676574637596},
    {-0.7255885709432068, -0.6435822348235525, -0.05976005371388903, -1.1168478037025857, 0.13269115253498584, -0.1630441187680368, 0.8650316259121744, -0.5134998936460796, -1.4493617252376552, -0.16392619840371422, -1.0255076897344542, 0.9073824948549342, -0.3372215537238497, -1.1851986787432103, 0.4963479999764673, -0.9847176938349913, 0.3860755316190383, 0.7051165830132888, -0.14525294454922155, 0.9279954078537631, -0.0010244722192508133, 0.3516105103007935, 0.08919459157215025, -0.2745991369826229, 0.5320403416025036, 0.6110494081857369, -0.6312733743788642, 0.8967735511909757, 0.02251166959436061, 0.7723674602039804, -0.5111486308767438, -0.7209320652636058, -0.6510868703734356, -0.560961881259629, -0.5254073930366607, -0.6546495731621945, 0.8009507714328409, 0.5476944041997132, -0.7484040196786709, -0.34262491113068166, 0.17512018976963173, 0.852458786957138, -0.779840992350737, 1.074005603659293, -0.3513536385513354, 0.9143062895700249, -0.373846719106056, 0.7539493396062203, 0.7121893786536665, -0.041102816257783795, -0.3836324599868311, 1.1713099582151905, 0.3238394730498267, 0.6659619665339551, -0.011520706802063818, 0.6684131258402154, -1.0085546969560675, -0.15260504696460594, 1.1445619835357543, -0.9303300867950756, -0.5568460053611307, 0.02498875972930004, 0.1736607270464776, 0.22154330095940078},
    {-0.2755382396020629, 0.6943149334571607, 0.16970207289517594, 0.9394700800195172, -1.2596918220795872, -0.1126938312674842, 0.3492775257346822, -0.774580368231126, -0.8842234326970301, -0.483226162770631, 0.9217905056533183, -0.41372073550687166, 0.16998955092751336, -0.8229749141931337, -0.8705206745789655, -0.09079794837200837, 1.2983417387360512, -0.4461724205643038, -0.18606386851152962, 0.029955786083467786, -1.3150866705973416, 0.15918562411296103, 0.1680869718005025, 0.10103279505551888, 1.034507146819287, 0.18233014192676544, -0.21672048293591809, 0.295175592630205, 0.7891789010372331, -0.8120615295413761, 0.22163257161603764, -0.9530155347645541, 1.3172319909959678, 0.9162026748052113, 0.8406269604988439, -0.9041065645699118, 0.5650519668371331, -0.16179671142004337, -0.82785466791373, 0.05596413340027066, 0.257657085512049, -0.9560379024299802, -0.034174179577076955, -0.5026271901396868, 0.8368258424249059, 0.8800700278249635, -0.6194215662376552, 0.8789629586714229, 0.5689468987622459, 0.17107357998400688, 0.5998665718180478, 0.20274302258672014, -0.9161106514792347, -0.6416767387331423, 0.142156991863339, -0.7523377539334051, 0.8525126008263825, -0.3520405332403162, 0.8195957226344186, -0.8572600165943836, -0.6795615098013132, -0.6772600641413925, 0.49317518239700825, -1.0129156219959277},
    {0.8081563796435887, 0.22838717612281792, 1.2004657925745326, 0.4752519142559528, 0.0030234902869563565, 1.274908650369861, -0.951014922640838, -0.29070233273411883, 0.6270624237990011, 0.8076351852959225, 0.3991957251365746, 1.0276870254595318, 1.1435110582079797, 0.8010384774606429, -0.02554582942690083, 0.5394696917460347, -1.0258072103063784, 0.47501745984584925, 0.7501541357303334, -1.3082400235469025, -1.011452631016045, -0.8231813486206968, -0.5834511418089516, -1.1431937138495154, -0.22605188044390043, -0.19616978972543067, -1.2142442525012922, -1.5088981299511994, -0.47418712242992583, -0.9069053792544746, -0.1455719024048109, 0.8918171595844717, -0.9250758320422487, 0.6564920287483317, -0.7353536068700238, 0.38854778353427055, 0.028052956068865646, 0.10581242450892167, 0.1643616718034769, -1.187914370257666, -0.05527333576702521, -0.08922600429821596, -0.2877167418622881, 0.6016560336880518, 0.9667337315170011, -0.5601089488544067, -0.9570881908276049, 1.2979940967764654, -0.6896324041292462, 1.2993651040486678, -1.073730232429709, -1.401832296711061, 1.0007616196247875, 1.0902805842952081, -0.4979074800379545, 0.2695003603624924, -0.009727885778040846, 0.9172647198298769, 0.9990173720582147, 0.7468708498356434, -0.5654607752154653, -0.30011977725019967, -0.3635604448183974, 0.08556169513380907},
    {0.02501683200629238, 0.5316131522418938, 0.44192807400061007, -0.9942233068409557, 0.42624065397961897, -0.021626250266055365, 0.7877093801235484, 0.4742183806106558, 0.7109880541771257, -0.9896482329579923, 0.048705302680397945, 0.00606255236761492, 0.07379560511943514, 0.9813666398139403, -0.05641938169804238, 0.6149866692152601, -0.8304124747228391, -0.8857668797875434, -1.272773875806578, -0.7146374255508818, 0.2614047086943497, -1.3942031945252147, 1.0058180974295714, -1.2935975638107073, 0.17823648680344867, 0.018815796986835186, 0.10050594043459604, 1.0800991018866757, 0.6231633052843273, 0.22348497917586982, 1.0056777525378824, 0.9265524856028633, 0.1999631483321042, 0.22054261629475597, -1.0867997524466282, -1.429456142329651, -1.380626458504058, 0.1613382935202189, 0.4271576936460986, -0.049396520984656626, -1.0442138324494532, 0.9949109072089777, 0.2283131295602602, -0.46804647435236896, -0.48043316285714727, 0.776017197272935, -0.7314735122563807, -0.5085346003017798, 0.5910314726581934, 0.5477588964969001, -0.2946217087595672, 1.453585417710316, 0.11631720586417378, 0.8887222904592562, -0.0384116165119459, 1.2143210228802983, 0.04749806580445364, 0.01060200655066103, -0.7357182462535619, 1.2116465435071315, -1.132643524627795, 1.1725005330403175, -0.29329942885142385, -0.5420130131709292},
    {0.6641166646497658, -0.35392312520522956, -1.3192697590761202, 0.43341880517208137, -0.5264306925358984, -0.3348240158507475, 0.6547291119443052, -0.17526443487214177, -0.8873024856221596, -0.09090828953883438, -0.4893167337670822, -0.39345354143888167, -1.136216100223374, 0.672185774649499, -0.030630793599637687, -0.1584455715312641, -0.5039648926748952, -0.8482719873666845, 0.7528518625664168, 0.43003846997558537, 0.5791363521437787, -0.7366014514239284, -0.10885721490191527, 0.4947303269634747, -0.49671041381799613, 1.083327615183365, 0.6085879502626375, -0.44739331560605905, -0.811754420844548, -0.47034266312235135, 0.307186987188592, -1.321313652980414, 0.6151350334825395, 1.0249661239400065, 0.7921330626474693, -1.248290686328766, 0.36269611002636853, 0.38397627168568876, -0.967296930845931, 0.7520983209057577, -0.6153045859536855, 1.2468443641584261, 0.1190451665902154, -1.0344304514710898, 0.12697651997602405, 0.9278356184613051, 0.049380404165322314, 0.5016184550359604, -0.5758815674743607, -0.7227860340689953, 0.09827161405130047, 1.0048889297769323, 0.14287137150942353, 0.864945706257027, 0.28335657412087956, -1.5139804018745389, -0.7318423230759283, 0.3899657960925705, -0.9752038541577333, -0.04431473150822159, -0.3265752210077985, 0.06323768475890448, 0.28864685020327663, 0.6690919561953216},
    {0.3487621057223537, 0.5385045211632068, -0.38347674851332675, 0.33072880767751645, 0.8882032288552986, -0.4910448249505614, -1.4617810670146028, 0.9091759911274664, 0.23099297608155353, 0.28818502383076705, -0.6168579725990389, 0.5631299663583741, 0.4491671143902148, -0.4092802654656988, 0.9356533221440175, 0.986541694930524, 1.4127658520523454, 1.2469212527366464, 1.0641305798147493, -0.9818014196018704, 0.4786605146993665, 0.759500874676236, -1.147672721908676, 0.19338732630349326, 1.3709016651028638, -0.6044902392041634, -1.5083859541015872, -0.3594160176786535, -0.5641339928000131, -0.6910175441834033, -0.9546737180757754, 0.2533680364920733, -1.2312111678467215, -0.2582247546145129, -0.7393736613770873, 0.5100881001940311, -0.02258433884861956, 0.5867603389487299, -1.5655869474232529, -0.31487805611065733, 0.7060284989508739, -1.1834324706899542, 0.7161246574353807, -0.5867196835896075, 1.0170845646093996, 0.21215190820824315, -1.1487476498254372, -0.03634844805798803, -0.16235973018489158, -1.265319703731295, -0.23719605892253104, 0.9337007976942415, 1.3614701549408923, -0.3070264864608634, 0.23624444510170645, -0.9473204574796023, 1.1715923265553136, 1.0611253172255322, -0.889450544798682, 0.8457819628677391, -0.9352603944154472, 0.9464365282582338, -1.1600438221899678, -0.4646428814579912},
    {-0.9565109612098747, -0.6851856853050191, -0.274194765800697, -0.45901905003152604, -1.2558801577094567, -0.657442777862621, 0.3858240908837484, -0.9412075973939391, -0.8873046844105099, 0.2870815289130468, -1.5053832525805206, 0.4702216212587511, -0.32387882116973477, 0.35630413246412473, -0.025093885670177438, -1.234440642586388, -0.043958876948034194, -0.5549011327514543, 0.9866345806239221, -1.0838187189688242, -1.6356554394699836, -1.1256615763915976, -1.1441306498960881, -0.9912062797073251, -0.5419781172454653, -0.5784573512878602, 0.3234544090497088, 0.2728619720956961, 0.97897148292208, -0.4963230069159106, -0.5750743970857761, -1.5543961159409982, -0.5937890474916605, -0.9153915208837143, 0.5800385865224278, -1.1983776513171007, -1.449132079984543, -0.7152854107461298, -1.5904873522819776, 0.724409657255528, 0.35905730845802264, -0.18084745452443962, 0.6439999976418922, -0.25442615102920635, -1.0463238350262583, -0.8058297385648647, 0.8043323281432574, 0.14136491225444442, 0.13821659544573248, 0.22403403203773373, 0.18607908997516592, 0.043349950057078535, -0.011372427090900115, -0.7624298853356415, 0.12630349168350263, -1.2349235797563507, -0.5279742382533232, -0.7129330148277588, -0.7448698404137591, -0.37362843093113757, 1.004918918397018, -0.8242074819756282, 0.5434133783964897, 1.2939703105483054},
    {-0.63219918268904, -0.4920754285668438, -1.0183523051247925, -0.8632190982429296, 0.6036359876986565, 1.100170600716688, 0.6235275003868622, 1.0277128437975875, -0.5063525996906418, -1.151860532113545, -0.6857973058034712, 0.3388745377525949, 0.16429645145397134, -0.3048219512078148, -0.6168317295814458, 0.930884809185328, 1.267912095187533, 0.09993817404082417, -0.37097385735698146, 1.2804436456375021, -0.6347076456187131, 0.7489574588558817, 1.4529198135439856, -0.8795669776669023, 0.766108546406732, 0.8966814950656117, 1.0579152752868237, -0.9462100238412016, -0.9254274103661607, -1.0520767705004634, -0.3499172005371961, -0.9576356697440697, 0.9052974521179524, 1.3731093150480758, -0.6833188258204613, -0.5042956184686936, 1.2610145774636206, -0.2230730702563439, 0.41135379420736456, -0.47733370622681354, 1.1275577393250824, 0.6817153239896845, 0.2169962902608306, 0.96484281895484, 0.2768392763455305, 1.1816811084960062, -0.46706068638734854, 0.5920051687765227, 1.3794855824877499, 1.0391234681116601, 0.6560142034749356, -0.09076085763290237, -0.40283227081446316, -0.559143413775357, 1.3366628319973433, -0.9567989654919007, 0.5882762308882025, -0.3541655279851584, 1.1404806531995821, -0.17059918947054256, -0.49379953269414145, -1.1381070181010993, -0.6870682597831154, 0.9514134789020545},
    {-0.26220156616017026, -0.9590310301067411, 0.4659079626958492, 1.0454912027737473, -0.38357592960497233, -0.10194814707755255, -0.08287613856942926, 1.1051295387561224, 0.5751994604080347, -0.37827393847561813, -1.093566626889834, 0.5377520796149793, -1.2983438648609602, -0.7418463137785158, -1.0291523502882558, -1.4643447891843255, 0.4167822776864586, -0.06484070631682595, 0.9089685183831017, 0.12057524897828789, -0.34674281980866023, 0.43843229860521526, 0.18641757385017516, 0.6993748348454842, 0.74743989743041, -0.44050170832988833, 0.09996658174477285, -1.2681057057769518, -0.8594367355610265, -0.6632240370154341, -0.7993504960416385, -1.5192959735933331, 0.05259041805882691, -0.5713870879181735, -0.8328042151843922, 0.05883474590606205, -0.36574599123722484, 0.2711939138513151, 0.3647257443573981, 0.6268915691319071, -0.6210484570514716, 0.493587591142361, -0.3320722581236761, -1.0470933363537578, 0.6901316102559556, 0.905826443850597, -0.95006313806787, 0.05481668231660135, 0.5854337825180447, -0.22203291109063236, 0.06275584111249506, -0.29709920294269904, 1.434335239536469, -1.1115812760272277, 0.10247476022395433, -1.1043323968041923, -1.2340895201113924, -0.03618049939875129, -0.47918411724230586, 1.1726237426530375, 0.4451831573865415, 0.7692224512183058, 0.21298298921360084, -0.15481020809809326},
    {0.20043482382605593, -0.4301698388361334, -1.4455303560964172, 1.0002243604138743, 1.3848837856372231, 1.1646793506729793, 1.0872855062781832, 0.5043120681459021, -0.8554730897391543, -0.14730262167776056, 0.7938840259953389, 0.655922638403644, -0.22442937240566146, 0.5775431701179623, 0.3761754845620515, -0.39382476204450856, 0.5420770333551935, 0.9463267944157463, -1.0302959593803447, 0.830844931931153, -0.7868816726866853, -0.38778727601922586, -0.30199105451939817, -0.7850994526635523, 1.4232920696462985, -1.343680386989759, -0.7690305969451755, -0.712704794347031, 1.1635578704678844, -0.017799818270893154, 0.00715253373898639, -0.20738970231367626, 0.37206207461938057, 0.6768541540671463, 0.22189094940751417, -1.108941632601813, -0.2815155612498737, -1.3327469827137, 1.1010625216828764, -1.002480878238056, -0.024742603452805146, 0.5512261096774962, -0.8767288302358077, 0.7577256432378171, -0.9472536885573812, 1.3970594589263816, 0.0754680943667096, 0.6411337615809745, 0.7376658070326231, -1.2010081903937608, 0.19458560221359886, -0.6024137865904227, -0.8866164677706094, 0.6119051764680851, -0.6087144321029119, 0.1227645990502496, 0.6363781432167572, 0.3839522721090946, 0.5260146588149496, -1.239402323752148, -0.6062069460718023, 1.109379563732605, 1.343166248251391, 0.8739911676708275},
    {0.7418916090131145, 0.7927894548450566, -1.0255556133526047, -0.06112573707256066, 1.1210424575651794, 1.1452848066988646, -0.05333176185550155, 0.17358151627233714, 0.7090712169651827, 0.003177311014046071, 0.5471179710313748, -1.374997575781367, -0.9783787616412742, 0.23223595936138838, -0.7085521588031206, 0.41729917044182147, 0.7624080121082675, -0.7805974156706948, -0.8039993599064604, 0.11607127564332986, -0.8152307204104612, -0.5476986152627392, -0.3405157344768132, 0.48909254775630456, -0.8989989611283393, 0.4824916649179717, -0.7265803134066878, 0.49473208037185196, -0.32883343494433187, 0.22266993976141083, -0.700811101666528, 0.9811509717604937, -0.7849947579863856, 0.7491052933930245, 0.2778728611908319, 0.3001903535297637, 0.3430726595095586, 0.5839853818672512, -0.4635959065314318, -0.7895577113784725, -0.9648718651824243, -0.03854399570326699, -0.8016824104078685, 0.8718974799561793, 0.8831770491436689, 0.040175759205906166, 1.4430072069674071, -0.2725573265431459, -0.25833524747196857, 0.01779739392777923, -1.0235151638737325, 0.8173428676177246, 0.7897218360878037, 0.5760105508716491, -0.6403618285369279, -0.09955298802085255, -0.24140623515969226, 0.7666622025593602, 1.1083038890494477, -0.7944373865950759, -0.1911986531703901, -0.347605272246597, 0.8969920446941809, -0.6775028265234138},
    {1.0595822396568442, -0.5884572951635241, -1.068957125251931, -1.0224321360246897, 0.6863004040716865, 0.48311554410779484, 1.0258750749962426, 0.47777984944656615, -0.24771801027525145, -0.7927481345780724, -1.2843986994999632, 1.100877633148212, 1.3562222301648788, -0.5688699579619575, -1.220148879330016, -0.3121893195355749, -0.36403993121849004, 0.889185254913634, 0.13134177934144264, -0.5897328099096835, 1.1052270697176783, 0.2875421943601764, 0.8787700642869555, -0.526351492442714, -0.997413715228957, 1.0862883105665477, -0.20834589695732214, -0.48065056986675087, -1.1887270014040658, 1.1251615099588916, 0.37047340669787626, -0.915358964413123, -1.3424991069068748, -0.6394942235597317, 0.8794596559906369, 1.1350382340657843, -0.37632588791667826, -0.793210335538436, -0.773858161701946, 0.6408414987932566, -1.410736045166896, 0.21345594441129734, -0.6533793190540075, -0.43511066016240285, 0.47646010622813545, 0.10177310042510647, -0.6943180581676441, 0.11540600207982707, -0.2929736414090965, -0.32104358602018157, -0.25486743107379767, -0.6547529515626879, 0.6921680455999287, 0.0010685618261163377, 0.417390618775053, -1.2906298107506826, -0.9968765611651095, 0.43939558056688627, 0.42169545200352593, -1.3081325972430347, -1.213941646579275, 0.5259771689137308, -1.1169233783654615, 0.8912620990683912},
    {-1.3715494023100754, -0.5054354485055965, -1.578361899840988, -0.6214153370318218, 0.9143630017537865, 0.24112680142745915, 1.0882886387342772, -0.18246762380350326, 0.9852062431685572, 0.24792293770380355, -1.0114861051702884, -0.8300313826942127, -0.7450412793970597, 1.4609314798075999, 1.2223908588636456, 0.5994176184518131, -1.3355009580407837, 0.309530755991119, 0.2634880487264081, 1.0383276423436458, -0.4734948712404837, -0.8367181704526037, 0.06137049852239156, 0.7535608035686255, -0.9267149485743442, -1.0242054051286857, -0.4141747615606224, 0.4579593858911625, 0.05735916969760537, 0.03999042498828748, 0.06769370171439543, -0.10669380561815069, 0.9992133253309292, -0.09342380906113323, -0.8579988551140285, -0.07620215808119442, -0.6714080649437166, -0.222667770160942, 1.0104627880036732, -0.4665977896532913, 0.27356900409690227, -0.08652783686004338, 1.0488997702172356, 0.5956074480863782, 0.4300839058012069, -0.6991537005384606, 0.36218008100509647, -1.2669292244853902, -1.0108834458428506, 1.0823355756228088, 1.2850673601930158, -0.598173245665462, 0.8229188593856969, -0.6726098369074657, -1.1448656088664062, -1.0673027791114968, -0.8415929586471995, -0.36341569241615596, 1.230947023289481, -0.5669329412665183, 0.27350261432369577, 0.48823958090236974, -0.18801001990746916, -0.1867665267608625},
    {-0.20172805785859718, 0.8341160325268462, -1.090127179848865, 0.6955769502169757, -1.1034374350778215, 0.1898360781098272, 0.5551220970408898, -0.27832301517185604, 0.001986114246101383, 0.7682051076380123, 0.39624762637529903, 1.0103020856896052, 1.1270469002005536, 0.2175805459664314, -1.3600994644019433, 0.8331840837153397, -0.9471484271344308, -0.5514021492735459, 0.3757117649445797, 0.39751564603188244, -0.8020625620655802, -1.0986423017727565, -1.4055778535421788, 0.9201236489769286, 0.4571717320047304, 0.9278968572692874, 1.3031540218903113, -1.3945228654053492, 0.7484941140286886, -0.059611715520600156, -0.8232390700364417, 0.9531271464914126, -0.8749782767555372, 0.40846487030141154, 0.06291332035341313, 0.16370195289296288, 0.42668168465257295, -0.026892578806203302, 0.8681867868339601, 0.7888547446999095, -0.6090018094431465, 0.9450112894821258, 0.48662006996668655, 0.9792900637942846, -0.19157967861192376, -1.3036123609650687, 1.1619448288243952, 0.8159151028512378, 0.08755952559686328, 0.853115401379312, -0.46592009891486497, 1.0893594366709347, -0.4712513619571798, 0.11914960635863339, -0.5176651744768239, -0.5318585986005061, 1.2246868749883173, -0.8475165064761948, 1.1841597576563923, 1.4403913515592148, -0.888555758544737, -0.38225475359315275, 0.3366793764165406, -1.48951384604766},
    {0.6617939692590535, -0.18494704446968147, -0.6140971071867241, 0.03937792401161471, -0.5685188692347602, 1.3840442046180996, -0.408218144673916, 1.5397376298238776, -0.21164652488292288, 0.6129489489710422, 0.6087717659302961, -0.7806672072998762, -0.7051838730888741, 0.805116349291138, 0.5762114602517595, 0.7338927779811094, 1.2566791845549692, 0.8654448565647168, -0.8994763242844991, 1.063290675888435, 0.031913528822698496, -0.8528362489333206, 0.04532719133921978, 0.6235100752695488, 1.2747584608099645, 1.096956836312352, 0.035349333267054056, -0.822583258247263, 0.3787108200480708, 0.43316443191014464, -0.604713289274426, 1.3718772188577912, 0.7683096418517499, 0.6714040701086741, 0.756595306794554, -1.4012689673478085, -0.7983194731943899, -0.2314890515605841, -0.4002159795101315, -0.1355894268687984, 0.08606618435945843, -0.4780634043729316, 0.0285196015792156, 1.262434654500849, -1.3183612828981526, 0.6256897666729203, -0.04846054457785542, 0.2827017812693582, -0.23764397749121, -0.6651236028063563, -0.36757100129511633, -0.5499746614260483, -1.1773699984786326, -0.4217808139572395, 1.0199578839065129, -0.4310630278574467, -0.518248700887089, -1.164087692011554, -0.4308962801244564, 1.244659783902593, -1.3122278147276167, 0.06745581340530188, 1.2293091493214217, 0.5829071599121293},
    {0.5110346365193894, -0.06328555236020433, -0.48503305871061925, -0.38270926880172956, 0.8033616897208584, -0.1306148126526278, 0.7104488383273858, 0.19755592123028273, 0.9613073820340541, -0.42551149685113415, -0.3771138044587114, -0.6331251398137658, 0.33131390352665774, -0.6828312543972395, -0.5198200674978471, -0.23919558127672694, -0.6096359811767678, 1.4199499293116182, 0.0855160129123513, 1.2838325313340624, 0.47164348481525703, 0.5620164760975297, 0.6622215461209594, 0.5390647099237875, -0.5398912353324286, -0.5897216075413181, 1.2576344712271537, -0.42776099692083863, 0.0005541103388429715, 0.5930982917532172, 0.883560145810969, -0.563438143665508, 0.4390242501534915, 0.9141349044457953, 0.6249076442254662, -0.21569207037719954, -0.20794041780624284, 1.0003429044396923, -1.123558457913513, 0.6997058801015739, 0.4806289766028249, 1.2749995100454479, -1.165419914490811, -0.806618155714958, 0.44755262769780574, 0.671872531321526, 0.9626755610470674, 0.5233448677524889, -1.0897876662427408, -1.0535531177288178, 1.5575729302774566, 0.4250513757910201, -0.021756751469501914, -0.9040411636901852, -0.09680328185117108, -0.5859181015744195, -0.23810244072535633, -0.9901187774535198, 1.276016227864165, 1.7068081070817942, -0.46855012214057035, 0.9385043951272949, 0.1460747084555962, 0.8820145868489169},
    {0.4339107264628489, -0.2349004389576426, 0.47687174851879904, -0.7601519516711222, -0.9004324496773277, 0.6108916753451622, 0.15593767366052438, 0.28581927943148194, 1.2180893706590064, 1.0452990163237434, 0.5393790164349136, 0.41245743892388365, -0.11328486788366605, -1.1456486592290445, -0.6472932228662539, 0.14246179146270146, 0.02010469383910205, -1.0776650167140094, 0.4253456868700493, -0.3864568621413365, 0.8539759154678892, 0.9644900975387595, -0.12459625546096628, -0.7054719698739556, -0.5321696609406696, 1.2923260824041596, -0.29752772538700134, -0.5006692642485475, -0.3616617287528731, 0.832247299395467, 0.8073626379040588, 1.1464437089328559, -0.3945723027318854, -0.04768005832972574, 0.3763757353805679, -0.39846511496536935, 0.10178175269350953, -0.11985446390835124, -1.3834736306092887, -0.37459235148028186, 0.5683947692129576, 0.5196397584410214, 0.3469838105295679, -0.0628824359347644, -0.15920512808116302, -0.7716122305884928, 1.0522579523264268, 0.5153538085357607, 1.2473974577239864, -0.8949975603314496, 0.42140500998516683, -0.8436862553071948, 0.36248761487377346, 0.27172897107500565, 0.3916953091331672, 0.6753133585980289, -1.0930832279316105, -0.32908599165213664, 0.9120816378869973, -0.778612590063572, -1.163807986727155, 0.22110790955987328, 1.1075665871270512, -0.9964099455620173},
    {0.5362206518940714, 0.2779269984550744, 0.8691621747500762, 0.7662129841162709, 0.6966898375324815, 0.18210672065170283, 0.3222945502019378, -0.6639820523956634, -0.5654084288397297, 1.2095407087316705, 0.8131744221064963, 0.3414822972428153, -0.8544232278131798, -0.08369919427671473, 0.677287531543186, -0.6418203723469526, -1.2823480048725981, 1.3040180909089125, 0.38095208604469905, -0.8807424539584708, -0.3190444434420346, -0.4580434523523375, -0.24424627854611514, -0.6400099914619529, -0.04639808062201708, -0.3518990048437662, 1.3259093457224758, 0.9178729565336136, -0.6355977749277956, 0.6376142213746129, 1.2781611551584455, -0.14683298724912958, -0.1956721260144156, -0.16531239616512983, 0.41165286564971615, 0.06575183915897667, 1.008122618998276, -1.091201161344956, 1.391801247261384, -0.531992111773943, -0.25955028841789435, -1.1282345983584232, -0.6435980868989288, 1.0224753990804034, 1.0800046195558732, -0.16937491010106473, 0.15241058525252515, 0.7785083653276536, 0.8594963592528165, -0.30261998428416026, -0.6703311075992938, 0.027822125131522615, -0.45948787040416356, 0.6759564599266062, -0.12383049165397904, -0.18101966946486903, 0.3373908657740048, -0.7222801183968423, -0.06139329600404264, -0.34851338602970594, -0.7656289689829046, -1.0248789382786656, 0.44364204352053344, 1.1411170898168308},
    {-0.9070917231683956, -0.6438591426972242, -0.5013896892227961, -0.2478145523042692, -1.2168559430544206, -0.035371070402040176, -0.5327709136456266, 0.3803972365797912, -1.3406619328347835, -0.7132267502946233, -1.1674874108107907, -0.5900092667308204, -0.9239114774399632, -0.32432005154683646, -0.5842419744150044, -0.8106757057566331, 0.06422710973484556, -0.10350100174555318, 0.14916394432400823, 0.16448012820535812, -0.38819049427202473, -0.33237951207341065, -1.171986114578306, -0.6051714704903819, 0.47404161075927115, -0.9013817254625746, -0.10199023685797463, 0.31571914932395484, 1.035852431850682, 1.4671930147916445, 1.1365742969215595, -1.4417348969093886, -1.0707017501625253, -0.6763534789612022, 1.0755806651072464, -0.09688122079538682, 0.5696196811348813, -0.6361176325120435, -0.9592432939412007, -0.5626584167085368, 1.527190021485376, 0.5086261456555942, 1.0428679885019838, 0.39054697275207967, 0.5776725910428411, -0.9178374440617985, -0.5793921930066415, -1.2953053288005516, 0.8147810506076525, 0.70693142755393, 1.2069492966367181, -0.08480510306819915, -0.43244172813751214, -0.8533390000929783, 0.8533709846421971, -1.086104372794877, -0.9612258727329511, 0.5753857945275147, 1.3954388299654867, 0.7941822130364653, 1.2934149585564099, 1.1071082137304147, -1.1353474927864056, 1.4221310952072759},
    {-0.6280177331140528, 0.41350032795335534, -0.1473739849753613, 0.8568557821915663, -0.6212252048288297, 0.7407195907246282, -0.6371387515826211, 0.5701207656516508, -0.913620004198628, -0.24629549725515815, 0.27701040010688227, 1.02427895790865, 0.7828807771428198, 0.22670919092736508, -1.0007800048385518, 0.005754393547817181, 1.0153753003128927, -1.3783556880766978, 0.821413517904977, -0.4357725236126219, 1.2518943578039132, 1.1572019438882082, 0.32533106095065795, 0.8844254972370054, -0.059251718765309755, 0.08943684087698675, 0.1260203537091154, -0.20780177414845413, 0.45217123345403165, 1.0457212703213372, -0.2877760155596981, 1.0985799870033204, 1.325561395097813, -0.941913608505253, -0.1252849851613204, -0.7854531915202877, -0.44477103648894084, -0.9582197495189466, -0.4099768089612839, 0.7136866357573844, 1.12344697806416, 1.27797400973537, -0.6475103752998119, 0.589510462143668, 0.30507187452625506, -0.16048447196715449, -0.10968084326353775, -1.1605572669081423, -0.8467706963492058, -0.9339776598275668, -0.9587994199221388, -0.45680757565136354, 0.26964585640191696, -0.4717339013982796, 0.7549008302751766, -1.086068021098121, -1.2746844474173171, -0.126099538672844, -0.2881896468245086, -0.39350702118038267, 0.018626468434945222, 0.9840346116624312, -1.0162400384608303, -0.6837649673577482},
    {-0.7048129338094816, 1.2322452839354396, 0.7915932875262282, 0.16255033884097309, -0.29512045971430395, -1.1223517535715752, -1.0352535460192525, 0.07427342083927692, 0.5243601030558991, 1.2660675788234095, 0.5190599319154109, 0.5304569940541791, 0.4105623393358805, 0.8333663387391043, -0.8573690848582429, 0.6734846552837013, -1.0580948287422989, -0.3153107310476652, 1.2022164990146589, -1.2239298814358242, 0.1741749265113618, -0.7922260512170528, 0.22584342333649127, -0.9988628605616224, 0.6191471882197674, -1.1471608023267443, -0.8343069939376236, 0.09300151739927386, -1.0666013026427454, -1.3731485219229072, -0.14837971115323037, 1.2764150209065719, 0.7368185153779383, -1.0685901352062506, -0.8986010939387932, 0.723711512625707, -0.6184559857905435, 1.289396097989055, 0.8999832739585194, -0.7246695153859593, -0.9976205695424026, -0.32656425720805615, -0.9743916647123705, 0.7085875374047222, -0.960829685191295, -0.04592781644762789, -0.7313721099419747, 0.06033386862731944, -0.5615119896986, 0.7284623681771989, 0.5243636279390476, 0.3881289382542557, -0.7501360825924012, 0.15319233789295786, -0.38565123221905323, -0.6320033088431685, -0.6917620029800774, 0.8139485262266221, 0.15010027677166474, -1.2110447892838718, -0.4064834467157386, -0.3200543425998464, 0.5372109662063536, -1.481575979515444},
    {-0.29084256859066066, 0.601031237261467, 0.23301639515092737, 0.643657775942607, -0.3741811134942601, 0.19993929428429288, -1.2011127303851385, 1.014237910227813, 0.15165797823176294, -0.11546018844856382, 0.37832243176343694, 0.7330407108097965, 0.4661660528750445, 0.41213990452587523, -0.7161111232844822, -0.2314301503243059, -0.18328046939992118, -0.37057207613095866, -0.20877153711171453, 0.6171121831921276, -1.137868746215229, 0.991772020086376, 0.40443395640103036, -1.2584145059104759, -0.4444815658801787, -0.5192928556233545, 0.8389427787956234, 1.2995040142699883, -1.281720154706003, -1.029441443008887, -0.5462459312133813, 0.2632239378816553, 0.31203984473029633, -0.8148922572903904, 1.045371467502632, 0.3675751875671855, -0.13291222471076442, 1.2838361909299945, -1.6057582878765355, -1.0603718554054575, -0.9832561890228066, -0.6649557914037361, 0.5902828386623359, -0.38846991655469765, 0.6140991032781445, -1.15527996057239, -1.004378821022441, -0.4189055738902058, 0.4086461385829108, -1.0743595630121854, -0.0015050466165736373, -0.6936656226520276, -0.7337670226031424, 0.4749645961739664, -0.11251447247718095, 1.092983568694118, -0.24427107272269588, 0.01778453779822458, -1.234340535053422, -0.6432585998604634, -1.0638141522465434, -0.16161420774266244, 0.43836372306261817, 0.27778681441434505},
    {-0.6085409179965652, -0.51641127446918, -0.31815158344948524, -0.8084806666448704, 0.5343320345512885, 0.6125849752208911, -0.6084999747004072, 0.9445003420505419, 0.8196753622803123, -1.2700650540193803, -0.4397943339826557, 0.4532211336912503, -0.8137113888025956, -0.5543539122465979, -1.0012342424129197, 0.5245451076085149, 0.5615712433851949, -0.5992399311656064, -0.45092088986453865, 1.052503826391599, 0.9168719213652222, 0.12647339586580708, -0.4539330808508481, -0.4117664239784461, 1.131052264485899, -0.8609845984869164, 0.04680014423661074, 0.5167523912058116, 0.867240222071821, -0.32013284184759483, -1.46446440603184, 0.6863925742147203, 1.19892831027672, -0.19145393470356306, -0.539553869137937, 0.7267422170241328, 0.07068939766426136, 0.7722756324950106, -0.22189827844346918, -0.5783447142240198, -0.875248505785958, 0.11539059115988862, -0.12390298698727117, 0.12951916728207521, -0.37931813469693854, -0.7981216381804684, 0.5946529547020126, -0.887741200025614, 0.5591864914821381, -0.0015014348237063148, -0.2891700803507931, -0.3105201409069051, -0.7648143092407533, 0.8667645505348854, 0.0720185413642164, 1.0346690323005885, 0.5092333754388058, -0.6911331025674228, -0.8000133701300917, 1.3108447854261438, -1.3452221924222099, -0.23116054109118825, 0.627227347280874, 1.0380103891969499},
    {0.9459915964946, 0.7800913255922812, -0.6570538409854775, 0.18318957214194598, 0.7651317936272917, -0.1069612937234408, -0.4655822168595173, 0.11378357629291477, 0.7479425560595844, 0.16954127201953598, -0.7754391349794519, -0.9410322140782361, -0.823820053734982, 1.4152531189724329, 0.22548982092069836, 1.2302543825998238, 1.1119027553609488, 0.37293133148537266, 1.1354219055119479, 0.04524488805330492, 0.005427388558698544, -0.14636788479938106, 0.28253952653676695, 0.132019803494534, -0.41000588112640934, 0.7828537480858967, -0.6580061851808521, -0.6263424332806917, 1.4094437626825727, -0.3859148247761952, -0.10023784200956679, 0.7866719216950293, -0.7606761442995107, -0.651754024979054, -1.0093700481543584, -0.41704096397275425, -0.15709875734213632, -0.7864884762031076, -0.12359092199460608, -0.39293114826926007, 1.0881665613062057, -0.259461305716551, -0.3091302533435978, -0.4358787183777205, 0.6734408672138509, 0.18194892800533158, 0.5765047101670311, 0.7956887005915534, -0.7981777833919008, -1.1922921995332738, 0.033747181318742006, 0.23952617621282954, 0.365631628775858, -0.4279921527357577, -0.13155082532295623, -0.8318308008770724, -0.1664332560670808, 1.039014900440164, -1.1820241981502344, 1.0989241775117935, -1.0581244993967442, 0.5955224884109813, -0.6387347898460769, -0.9340029294957566},
    {1.0902278080796766, 0.5566912903898049, 1.1226717755659519, -0.12273969473950616, 0.36563911385449727, -1.0623977642692004, 0.38739695371231847, 0.041790330995030135, -0.23555879099608976, 0.9081813421567968, 0.2860771570521072, -0.7426261371512619, -0.5095745323557392, 0.5784913877442075, 1.1889627978552286, -1.0258393623601918, 0.4563247644476128, 0.8720321569885983, -0.962587466068233, -0.9770983123889968, -0.5224032729878142, -1.1552086767247844, -0.3446697325862485, -0.5946544555444515, 0.04179252490637464, 0.8555600806553029, 0.6379908144896782, -1.0193966080555796, 0.6917421372822716, -0.5219601373109631, -0.645330308752014, -0.6238171790216962, -1.3804201191845622, 0.40748040439562194, -0.9050529299370138, 0.9763701481830311, 1.2764740692499965, 0.2979252810225455, -0.2994971588484713, -0.6559921938947965, -0.8940662391935433, 0.2580351202262947, 0.9806071061290981, -1.2944833202969828, -0.04563324260548355, -1.0445850378443118, -1.1111526131955074, 0.9452352984087904, -1.2239430588400741, -0.04653525729815131, 0.49445017681945763, 0.6238008454272298, -0.8842232541356092, -0.3395193125942784, 0.29814558084202186, 1.099241872220003, -0.07844581998471488, 1.0745224444687758, -0.42979594999338483, 0.8226112563499514, -0.21075260616662572, -1.2915664582169644, -1.1681243211049637, -1.1208927724816518},
    {1.1078254050646226, 1.201087879849716, -0.14199666829914157, 0.6766853846804699, 0.6155197050362428, -0.16061596890160015, -0.13933380446723928, 0.8489011236678328, 0.7594039075033434, -0.7257883319782255, 1.083742972575122, 0.19411308874928973, 0.035813411741812504, -0.4359363995531065, 1.0616305749745274, -0.912208071142322, -0.44479869997040095, 0.3132201916698904, -0.17374603906854208, -1.2987397104895557, 1.1328871343989613, 0.6144773957260147, -0.22134444017465232, -0.499292475315286, -0.9595054325592131, 0.11908086396208808, -0.7009622462570906, -0.1554988148233847, -0.8491713469481819, 0.8788885324071235, -0.5951537053315409, 1.1261149589084438, 0.7341545162015616, 0.28639504199792676, 0.8992589039228546, -1.3357745278902249, -0.4771577956713797, -0.47330374426356303, 1.1718535100345564, -0.4030508550652456, -1.0065203605344508, -0.9571711584918063, 0.3954115653211581, -0.3217350969324813, -0.31746237939305105, 0.6927833800785644, -0.5143020505050759, -1.0805047149874127, -0.10356931659469665, 0.7832479398611043, -0.711235851393427, -0.2781844792513903, -0.732784247769862, -0.6948828971911472, 0.45812751061143164, 0.4432032015927441, -1.0777054505614685, 1.3619616108023498, 0.5786858055388598, 0.7169346785904384, -1.0673826950173608, -0.3439268986808936, -0.28297071947519636, -0.08789699196313558},
    {0.2524450401111852, 1.0309947036491314, -1.424591058223254, -0.7776048984489872, -0.7166615591802781, -0.16862365394894788, 0.2660411957046152, 0.03883042912876802, 0.8850259514198511, -1.326959085713094, -0.7206243476997828, -0.09389185753796607, 0.04660268933839686, -1.0360576911600434, 1.2019729323513033, 0.922278644452571, -1.3418582930030973, 0.6072884377955767, -0.694406742723551, -0.2829630992678582, -0.8763447855873253, 0.21226587792191887, 0.6967526895719531, 0.6844449596975549, 0.5506071580544727, -0.018698398690162297, -0.6099716795908985, 0.7485344089178497, -1.3905540668182765, 0.21464078546520415, -0.254694632697118, 0.7247057458264498, 0.8495413045024697, -0.2085970411593223, -0.6623779873631843, 0.19232662814348558, -0.3190351563022586, -1.3398478297382153, -0.03385344580083741, 0.2944638821769891, -0.8245330534719298, -1.2634283455417277, 0.8797924883156621, -0.2611138585775243, -0.03449371580099165, 1.1287506974621788, 0.5189035848433741, -0.46476727459299194, -0.3672364066083802, 0.07202603297353964, -0.5354593564277446, 0.11275844809159077, -0.7020993651189705, 0.19975398227008792, 0.8876426124149801, 0.34430488146544364, -0.3002483201765275, 1.3190491043050205, 1.0535719840440598, -0.5071965531644407, -0.8872320316798041, -0.9864783395902306, 0.5603977327031029, 0.8178649014619819},
    {-1.0246977448051313, 0.40005620771619205, 0.4177924047247775, 0.14928591131240457, -1.0419329271091788, -1.0211672299397747, -1.1494338451467252, -0.8289562197815765, -0.02548301067288887, 0.7498359230944822, -0.15593521229920623, 1.1266693331821405, -0.34978836962808063, -0.5542934011366466, 0.19958968284487144, 0.2431028810073851, -0.07234053649052306, -1.232292665107324, -0.7733837006903371, -0.3645534919461322, -0.3380997549447626, -1.4025108229319223, -0.854974775159096, -0.6371035866385697, -1.1544133608873657, 0.2505337501659919, -0.024309128396437986, 0.7066684289382192, -0.852205939742314, 0.4634968755969774, 0.8458019223377973, 0.7228186491298929, 0.12825359927521765, -0.501634931225078, 0.7229522681310818, -0.7484759891658593, -0.32162335762724853, -0.8762178268565146, -0.8412857517769674, 0.3475149968163633, -0.921419890152654, 0.3890813428381457, -0.3872404904128739, -0.8178353874170897, -0.03648620492079186, 0.690694846563788, -0.07651473671081473, 0.012185838527424546, 0.5198845588068425, 0.9830997294582625, 1.2916902010979758, 1.2715876656424845, -0.9325453105238873, -0.5358309512536068, 0.6058764953472467, -0.9929331102442593, -0.3521372552060107, 0.5072931548576153, -0.492910449422495, -0.8207365787901346, -0.9167300551545804, 0.02637226843143569, 0.43055792834548934, 0.009484723950145947},
    {-1.296943037683337, -1.2160271863717935, 0.5928417122733778, 0.3322933957524369, -0.17801429602321944, -0.8420022850432848, -0.36404529765837385, 0.03272301415160331, 0.33651554850001475, -0.44033525849585686, 0.49068888965273766, 0.7112892363344352, 1.3225244081460543, -0.19242868680161543, -0.6723971782964929, 0.9115897746462798, 0.8557562237986529, -0.47416850758710694, 0.48233518449795554, 0.08912619605248838, 1.2627264682552037, -0.8150148720753365, -0.4353986085382693, -0.08568251260262308, 0.6155887207049812, -1.0280499373812435, -0.7169044907421749, 1.4563129461938176, 0.2501633727157337, -0.9812852997385392, 1.2633301756539619, 1.0260933399343926, 0.9200629487361475, -0.24917321057264988, 0.811089878380737, -0.234429613889517, -1.3489267585994664, 0.8557925124887679, -0.5789447891150082, 0.36401459312325307, 0.7437102772023697, -0.8570613928194779, 1.0867209672594471, 1.3312886974728642, 0.5387473082583765, -0.47985578803246254, -0.7087847016881579, -1.0859514370129826, 1.3577410149740525, -0.5652734714142519, 1.4150680095023063, -0.9403820697935847, 0.025123574574226655, -0.560073964022485, -0.8343486745689048, 1.2720658066340942, 0.5015641293034457, -1.146706928269073, -1.014756210246644, -0.9898713411469255, 0.15536292281235944, -0.17397696837356824, -0.42035184361942657, -0.1581953006761362},
    {-1.3683187640589871, -0.6793775001956956, 0.6068531069291426, -0.6889370612830985, 0.9353466896298236, 0.5395572146406042, -0.9395568943702872, -0.38938398484827574, -1.1698863692160384, -0.9473693772490306, -0.9655683592962572, -1.1788262479505003, -1.2046114801448218, 0.33572800640714057, -0.45231475256183473, 0.5532801825090627, -1.3712479234481934, -0.8707758333269159, 0.2729508285667278, -0.028252758099274515, 0.9124796803295183, -0.7583613380080354, -0.36499911180227285, -0.2464381896565784, 0.6223622696688468, -0.1208561530254508, 0.8366929455023574, 0.7876072118779228, 1.2354040623094722, 1.0707297011624952, 0.5707151566513509, -0.9996215402193207, 0.5818349004403498, 0.03304337677141708, -0.8085946365061643, -0.8466732491187475, 0.3232520744323819, -0.42063229683676595, -1.0737851653457888, 0.2646233237006885, 0.17483016935453857, 1.0161901341875903, -1.0924492743442797, 0.5167448594525351, -0.6763352395557953, 0.8991959728345846, 0.1501751414981821, -0.31442018815239986, 0.9448328727490193, -0.04141455212759489, -1.0895413939873075, -0.4160427948200521, -1.0897147715649014, 0.13837876940516664, 0.2882678433173725, -0.7045125363323508, 0.6754113483470213, -1.5526799744943465, -1.383216996600421, -0.5172790040139912, 1.2261953713125917, 1.1454692030985858, -0.668531829489919, 1.0394507300371245},
    {-0.29876508434381116, 0.3712129921628385, -0.16734251669298772, 0.8335449916910962, -0.6909859279487857, 0.3136618921555323, 1.2019389458013314, -0.6043166217554836, -1.4178849331167522, 0.9730639152515258, -1.2670705194771026, -1.1221071958055766, -0.6234005294912316, -1.1679936875360377, 1.204243527638741, -1.1961656972434558, 0.6909345229431619, 1.2797098475659365, 0.8081663598753452, 0.4982281474191926, -1.356950081041889, 0.09264147220931493, 1.225083134090043, 0.6253740115750334, 0.9974852936572915, 0.6817615735487137, -0.05568484496244976, -0.9081598673775154, -0.34705566078113836, 0.32412352539376704, -1.1045522999570656, 0.6152337192795442, -0.12289142943725638, 0.726703445574133, -0.5996552978737721, -0.35062649218617425, 1.0623085216965493, 0.6970785400093713, 0.526214343949304, -0.6958379702337387, 0.2128774308138993, -0.6802534487976688, -0.5437401953491674, -0.7619598259865692, 0.13931910597045066, 0.9661416519528968, 0.9071476802893063, 0.7069235578078215, -0.24465862746159658, -1.243045057476959, -0.15552924194599263, -0.03686065057120782, 0.010875261163120941, -0.9632309356578271, 1.1545301222077697, -0.06917115859430613, 0.11423253789995556, 1.0679817293723122, 0.21431039317802106, -1.0353949558745539, 0.3257617608743936, 1.1670726868410983, 1.0065700818450238, -0.18321671293570516},
    {0.530293920214532, -0.016752907789089038, -0.12691787587002326, 0.3300774212885645, -0.033548536070361054, -0.021415054943032145, 0.30959224300028004, 1.3894409146674775, -1.1931227473606894, -0.9535028510090963, 0.7932445037647725, -1.1033829179772379, 0.4394714403768033, 0.8163538971480536, 0.40826685771756, -0.7921829478152435, 1.1945950910599936, 1.4400132006653552, -0.6394026936779128, 0.5498976599281955, -1.0724660927823144, 1.0094517286316527, 1.2223458174294661, 0.060202658998618826, -0.7248734219839253, -0.22223645180723647, 0.25267433157756275, 0.36334752984426233, -0.645917408752196, -0.8196434045550535, 0.7143683382724392, 1.2705585149138652, 0.3041631916758048, -0.8963394494139617, 0.6124846471658116, -0.902047375435176, 1.1726797699183436, 0.13176145992933985, -0.3015750542598414, -1.1942520241549037, 0.19928250747369639, 1.074089036005055, 0.5862618192595065, -1.186610800786315, 0.0751363095816027, -1.140193578065674, -1.1039819248841916, 0.526586203716553, -0.6602810886671595, 0.43988033654845404, -0.17715740945328085, -0.10627698407142448, 1.2657217944509442, 0.7231142264708074, -0.3409176217480383, 0.341277693437164, -0.35748749222209486, 0.7959633860011862, 0.9128861505461843, 0.07964823585832945, 0.07240736599333678, -0.7686049367294651, -0.785623797188776, -0.9840438086643414},
    {0.23205781732011885, 0.8827082837302551, 0.42705776729897527, -0.8156626323998718, -0.20453278058942295, -1.0216894549934024, -1.0233330150306537, 0.76222685494873, -1.2701801439925862, -1.0112411401659178, 0.819750534731269, 0.8542161053727202, 0.34568721525056634, 0.6896190453917421, -1.1002860385713127, 0.7613887935473341, -0.16927792885939208, 0.6615779052559626, -1.169444290144633, -1.0735955662023653, -0.8530683973681877, -0.08480735426461486, 0.43327632239779884, -0.07883480212304005, -0.9797969793638508, -0.6334839700383978, -0.016908807644377032, -0.6560485443151483, 0.2693745584575002, 1.041760903679712, 0.3534578252438895, -0.5065179285508666, 0.681887338477933, -0.36724075073703094, -0.7923451958605167, 0.9964513067565163, -0.7301659919337449, 0.010232449786423877, -0.5538370341268615, 0.9422963551415994, 0.7251026998817006, -0.22020873454653694, -0.3044240139536151, -0.10123340382179655, -0.8580653024001477, 0.003895945900974039, -0.7339516602532, 0.755740700534576, 0.857416912554997, 0.3690978377892093, -0.6191906769860939, -1.0928247916427545, 1.0434247884479262, -0.02033458591331306, 0.23337475034431518, -0.9078980800687154, -0.854065379962624, 0.639849776824762, 0.7751309140092811, 0.34465763265279586, 1.227947795993478, -0.6906181756240264, 0.2756267308386467, -0.9058065707190066},
    {0.8787521676157353, 0.5506904916970411, 0.7832737038174378, -0.7509897073939911, 0.43683047500233646, -0.36641327271479784, 0.690801133608147, -0.13778182072857226, 0.8397232565204954, -0.8563129322268929, 1.2488778767213695, -0.7651334944633091, -0.3892758654448984, 0.3510582606701228, -1.4970298674484583, -0.1661871361725453, 0.16366839632324742, 0.6708248059832173, 0.6256435706825044, 0.9881198234741386, -0.24339524335005466, -0.3842320832113877, 0.12680647799860828, -0.24159048917460732, -1.1484409282429897, 1.1672315561588467, -0.8533206606514043, -0.2709086503528413, -0.5340189260149507, -0.05382260133434923, 0.9901675909934489, -0.44746176659285386, 1.2064661824853482, 1.1166007232822137, 0.57290069965912, 0.05765560853717103, 0.7649080867646187, 1.0325162186351224, -0.04677234668329336, -0.892844405148868, 0.8242843201884724, -1.4764110590785953, 0.3634037580353476, 0.1368565116149581, 0.5899859007064269, -0.9408111804741226, -0.0627192277618664, -1.0628074627917283, 0.4275396669297271, 0.5120564290817547, -0.22190015206468536, 0.7112810474705158, 1.144175716238158, 1.030258962478385, 0.1111167332784687, -0.7210342799209736, 1.199760633197832, -0.8898897569178148, -0.24738883506494078, -0.8340522084290338, 0.9892833771069484, -0.7452074768244578, -0.7780921536868185, 0.6466457332212195},
    {-0.2324364944764349, -1.1355604460384232, 0.09857462463510704, -0.45869477610424475, 0.9129284816812381, -0.6443089682566231, -0.05675470912517041, 0.27273801779747747, 1.0603913614429312, -0.6428113754382866, -0.31574133524243936, -0.9086832772158802, 0.7083881064668998, 0.07145373123663801, 0.11843918348053474, -0.5953861258898435, -0.48336930473290585, 0.5623156758835307, 1.118595602660202, 0.8189757933652134, -0.9339594703364118, -0.6358045411312842, 0.7933882343749804, 1.2339277927024477, -0.4395689147996075, 0.267841673052426, -0.7514258900969896, 0.7770002841885021, -0.24977815761469008, -0.34876623594085066, 0.9467538193557548, -1.5362265326329374, 0.963284626411134, 0.8585854859765744, -0.6283086193495693, 1.1274260702629153, 0.7880014095832052, 0.7820256126602837, -0.2913089723668827, -0.26070982064417647, -0.6795451411334664, -0.05100996740117523, 0.6702819240157654, -0.16188632681131074, -0.10461385182599904, -0.6562898007775767, -0.5383141042623701, 0.2735133862487489, 0.39394136402928015, -1.147467959718019, 0.5832708553657869, -1.0325241975600157, 0.9912641422720683, -0.10656759455205013, 1.0085819228231725, 1.1723564736986656, 0.0544494283557074, -1.183257603441261, -1.0104759859373293, 0.4845516037741598, -1.047240337070184, 0.5918393143456737, 0.17254997465335856, -0.3264520246924131},
    {0.7960883352531869, -1.2950426083325521, 0.4989668638360356, -1.1463135205929011, 0.8308627913335187, -1.032617383593205, 0.13731252446429545, 0.6135492020278048, -1.0591111995702798, 0.5120469899601369, -0.09444222599047748, 0.5497846859962264, 0.3767265690142909, -0.5737957435382617, -1.2595264562282449, -0.6210839201620753, 0.1802787660435637, 0.5898249644155664, -1.0553320151059384, -0.039854207260756946, -0.03712968898332717, -0.2783963089791448, 0.8149534678686049, -0.4308094094042653, -0.8335917202019327, -0.634781386512379, -1.0696464465678064, -0.9385681209270974, 0.6899569464303538, 0.9203241614201648, 0.29032205652707654, 0.2453958326895635, 1.199510891570897, 0.6885681385918825, -0.7768820856842341, 1.1295943150634453, 0.07718190837431065, -1.0760910150749807, -0.7337702378775426, -0.7313878189079587, 0.10506065419606735, -0.4207756715244158, -0.9980267814304113, 1.181722978734496, 0.1487143533850442, 0.5959932927268092, -0.5143221973914555, 0.49259925839324603, -0.2487636171420341, -0.02895134460422228, -1.1814049364388104, -0.7127763467692051, -0.4546064826628529, 0.04543978745920796, 0.732372173970603, -0.6032081315973132, -1.0703400138231811, -0.9034593646739928, -0.49889131269016973, 1.2700684922854393, 0.08086568912675099, -0.034522165247667776, 0.7877479659452725, -0.9262715657590387},
    {-0.5308825091476775, -0.9444698014103475, -1.0517462825079884, -1.440063006014346, 0.7550364963147, -0.6205659817566884, 1.1233918003097496, 0.19230465038146852, 0.06316703736443688, -0.2750437289496894, 0.09134888277471949, -0.7772996856914286, -0.4279990292710485, 0.3749702983616847, -1.2696680195871524, 0.7626427795279427, 0.1481488078473415, -0.2966404952697825, -1.1861896241070682, 1.1004870405796592, 0.22462499726638613, -0.6034720125387134, 0.9453173919415889, 0.6372987989097151, 1.075908861191093, 1.0312262169333466, 0.7129577092885527, 0.6858728676165778, -0.547268819430448, -1.19468758431354, -0.41294483186802056, 1.1048786830784625, 0.1734810351781959, -0.5729586286798559, 0.3126175415880102, 0.7161842413116472, 0.6684942939710476, 0.39777766586577357, 0.5812563887151747, 0.7073539358651546, -1.026175687609375, -0.9094967467438303, -1.0829381818388357, 1.1443448229114548, 0.5601103870225168, -0.36080418968568595, 0.039837364335791145, 1.2700533468162443, -0.1327496184766692, 0.20783678293516944, 0.5479613346822652, -0.2570298485010479, -0.7467412247841378, -0.7964792199193832, -1.3901345834735754, -0.005656816368959452, -1.201868787315864, 0.12840766154754005, 0.39078013223917685, 0.04837471159480544, 1.155319926490216, 0.6422752806960708, 1.090689256679402, -0.7261161683560475},
    {1.0896429468104318, -1.0614368887539407, -1.2186811598319824, -0.8894365742256031, -0.34048319825964474, -0.9834505092573409, -0.1976864362426764, -0.5604560214752089, -0.24616090791856637, -0.29514346889574133, -0.2103776774397524, 0.5222902932949481, 0.09456545371755465, -0.6768732612975139, 1.1541454389756263, 0.727621212964327, -1.1147661759233543, 0.9105775607607276, -0.6573675645689037, 1.2482315843272127, 0.7548033967381028, 1.0539850611919508, -0.23688979452557063, 0.07360655126574946, -0.7002071340636342, 0.0050584450296231875, 0.5405462849872551, 0.6870162723685376, -0.06992034468239999, -1.2900900545377496, 0.6924146355166422, 0.9062436642100729, 0.770276973102838, -1.1741302679615722, 1.0123761579488924, 0.004135180445728037, -0.7733982145709148, -1.1445715210616678, -0.30006103276736334, -1.118988039381692, -0.032055948764143014, 0.9708542163923257, 0.768511071529214, 0.08906239197625633, -0.8926498438516813, 0.6988873553569087, -1.0759413004869636, 0.0824677178147696, -1.0718601247240798, -0.6343528087902295, -0.9354913454985898, -0.5363922504405302, 0.18899860861969256, -0.6200954427787867, -0.6224929651537071, -0.3202888648824093, -0.6365094310627739, 0.1886859302945994, 0.0017726341137385626, -0.8541351838871692, -0.9426570091765584, -0.1812914026650732, -0.8979117386516978, -0.7644209949797517},
    {0.4432419118733456, -0.6314931386869012, -0.26994078169508806, 0.019635808475412207, 1.0338268757213689, 0.2583417397452057, -0.9091865344355707, 0.48188308045789563, -1.3337352847184518, -0.8148261238669994, 0.2839522658269446, 0.9977734357527344, -1.177430421254549, -0.2165963579712448, 0.5206696456929494, -0.7441392515886003, 0.2816634182419723, -0.733383156296667, 1.3077868915774418, 0.31650217907384404, 0.669265716227349, 1.0955297426027395, 1.1223830961992118, -0.6500594577673672, -0.33925431363197756, -0.8442638999036197, -0.028323397285013235, -0.13572012361464145, -1.1507970529836733, -0.34327454328157947, 0.9396565165390081, 0.6431251833440784, -0.49749424525827235, -1.2733506873035043, 0.027323169992429033, -0.5547718025646574, -0.1024904462884096, 0.6261825679282578, 0.0675083297700988, -0.07594699742956218, -0.9136198475826031, 0.2327960397337073, -1.2021656397062392, 0.6237613551474446, 0.043635702880782154, -0.706598899020648, 0.8768437734027995, 0.45751328726505425, -0.5918614192023046, 0.4845101839929106, 0.21744405110356943, 0.1930828987355097, 0.16181814085580914, 0.9955646603056484, -0.2229519189398855, -0.5780821304744221, -0.338552310138249, 1.0031077480715014, -1.0699280811468703, 0.13155235796507375, -0.20570177374617177, -0.2080998998918247, 0.4568597465501116, 0.3224697159867127},
    {-0.35164838227212797, 0.6067110566161077, -1.2505804149817472, -0.5270467540154844, -0.5219441597957529, -1.2703005871952602, 0.14289929629509343, -1.202421615769757, 0.3458464116847978, -0.020179758714927557, -0.39890271662250826, 0.22607992680790584, -1.2413009591405078, 0.5208935809650248, -0.8724930859299169, -0.1673249820836592, 0.4966186016064875, 0.2633948369111248, 1.2764507798066753, -0.13479695907396133, -0.6823184348099657, -0.5933778092799812, 1.194284671736348, -1.0456912595770078, 0.5000498156116697, 0.31291993147355224, 1.0320813075434776, -1.1084962527742148, 0.07029320635679451, 1.2141343088588477, 0.7839206353214114, -0.07450750572745031, -0.5710987846171909, -0.050680062463357045, 1.1437785469700994, -0.7161861561611367, -1.2687873350344496, 0.6952191454633684, -0.7727869608025691, 1.1959947378325024, -0.9922714699300544, 0.47982395577005804, 0.006192775468881363, -0.015613267301119761, 1.2634907050299802, 0.35342771591263417, 1.3605845093989715, -1.3025070644089978, 0.5660903216021664, -0.6370434798941251, 0.025524890037759526, 0.6872976392235167, 0.14365915592250397, 0.009289411520645297, -0.9665151818587747, -0.3783312935251875, -0.5814843844707454, -0.020509710466557363, -0.1777799943916588, 0.5511123149415265, 0.02420984283183949, -1.1465802727597223, 0.3628363547969608, -0.4743497477204273},
    {-0.8486819407185002, -0.41767287071925546, -0.3419536371729488, 1.0694970041120642, 0.47398560515338084, 0.1783841783717709, -0.8130979060385619, -1.208396575928832, 1.1694624207735724, 0.2506118328331842, -1.14545713504002, 0.9314482487727488, -0.4611256691889236, -0.7608067339482865, -0.9895560146121429, 1.2939279451137395, -0.436699451762875, -0.8776113052361587, 0.21722742113282711, 0.21209886311330547, 0.9589370009713704, -0.5880551424408115, -0.44861495884419933, -0.5856437692510124, -0.19122367553748265, -0.4249916498408004, -0.7438177909847317, -0.04825947147453322, -1.3497146062761114, 0.6250476015781181, -1.1700214251938614, 0.6438612678743593, -1.210429069896074, -0.34477783201413753, -1.1766266249228274, -0.9357610557825233, 0.05430070085373003, -0.3458021609163904, -0.534024539463596, 0.40008166937509093, 1.0565429429040694, 0.0060530580813355096, 0.9479261977598228, -1.390657199964527, 0.8943821890818237, -0.16184967797937935, -0.6838592748585567, 0.10453041810445445, -0.9257536634788986, 0.09395617048304283, 0.5695631899316652, 0.344315617742001, 0.6769045532688478, 1.0736351968503144, 0.29035552447373436, -0.14014062640804964, 1.246017533184583, -0.47625039656959034, 0.9255620641510747, 0.7617514607307343, 0.19766311189276534, -0.2678519580010129, 1.1249888083202226, -0.7826316285835566},
    {-0.595158835451503, -1.343479270790569, -0.1299140704053441, 0.2880398036462192, 0.7959016828664447, 0.5969058528712313, -1.2820258741463284, 0.986122648303356, 1.1955937327514832, -1.117583169001264, 1.092392604662551, -1.1966578459289376, 0.17774318877629877, 0.07043305014685314, 1.1147018499806822, 0.9551255724564985, -1.0140177126617076, 0.9222084475908954, -0.6963627677258576, -1.0767343660815836, -1.3315976922847397, -0.5005906266056332, 0.9912449052045312, -0.1921697796088878, 0.2319191810946328, 0.1718936456842697, -1.3270943928256047, 1.0558577644400502, 0.18878366935163027, -0.5266732527093017, -0.46235862942972134, -1.2725002881946303, 0.670523623127646, 0.6064811471301376, -0.5650141708245741, 0.4917267021016472, 0.20366035207319122, -0.45032203551209754, 0.6986473207035183, 0.8524442844692534, 0.1307429835534674, 0.35891037769538425, -0.6411655450291278, -1.3491471819098673, -1.2229106578292843, -1.1937266500970503, -0.21521408143753037, 0.7395034507839481, -0.13476852043834048, 0.7700249539530764, 0.9540445835097112, -1.351123070921886, -1.2522884622878105, 1.2268559657730407, 0.47080414186084285, -1.0205840380789948, 0.00900846141622761, 0.17188551601156027, 0.5507933718819317, -0.042493323608416324, 0.9685605337088745, 0.477889364153897, -1.0493255599973497, -0.1044850123866339},
    {0.18229312692792599, 1.1559060618516017, 0.6514683594768315, 0.08082835823014865, -0.5556470635559884, -0.6874542077677199, 0.5592035940849369, 0.8622665041031834, -0.5009579463821607, -0.694533395551925, 0.05799821485214757, 0.5866778873786466, -1.407022641458945, -0.8345435575594649, 1.0830815478352795, -1.4317913742747694, 0.6030833125854784, -1.0115178930420927, -1.2136214195990669, 1.1862325915486152, -0.029584645050774704, -0.9622327858738597, 0.7528074707688669, 0.5861178543234913, -0.40529304238617514, 0.15031991365493022, 0.4993846429189805, -1.2844677499062156, 1.341098095885422, 1.1320938653528252, -0.26301480775344926, 0.4406330358256705, 0.9746523527775851, 0.3905496295450339, -0.33156438866425464, -1.1147535817078624, 0.4263536222817976, -1.2582632907109503, -0.15705211731902566, -0.4513358296880335, -0.9995125501227009, -0.35981789315298346, -0.04526209306758785, -1.2478941019698284, 1.1246367365889296, -0.2621898541214247, 0.21263435385289747, -0.2725668375990331, -0.6057407769637647, -1.146962423925963, -0.30456754839506045, 0.963870192378318, 0.4962124020011265, -0.8941290863786563, 0.6632044616904054, 0.7075319234081394, -1.2161467938349526, -0.18056208563222437, 1.298371522389207, 0.6927574251149319, 0.2033870097894876, -0.3150983186639632, -0.7672776180127759, -0.2924040484740512},
    {0.03276150424222661, -0.26335832981226964, 0.05027949372401014, -0.855309323919743, -1.2479093129749277, 1.0010544196935214, 0.5262515034526104, -1.2180226718342682, -0.08893032908127826, -0.06535864030639475, -0.1225630468611429, -0.1439048124289076, 1.2305595181883566, -0.06460396618468654, 1.361882011246062, 0.3702777358893037, -1.0979018385502837, -0.10470238313028894, -1.0278148917069272, 0.13376682722627456, 0.5951296615256042, -0.17986038463997994, 0.6913947782393081, -1.649365819528322, 1.1336989693603559, -1.124240612135313, -0.5726773867667512, -0.050373153599315636, -0.6306952972909371, 0.9654437046022978, 0.8998830041249256, 1.0072897797437206, 0.27541707441093966, -1.1356710062659923, -0.7567139507565227, 0.5365338569815309, -1.0657002235054802, -1.056213646185189, -0.8754519494577949, -1.1654636584795774, -0.8174385824083693, 0.8169110241554525, -0.7158064539583677, -0.23247317152515823, -0.34503679490384837, -0.409497329081878, -0.8686035243492134, 0.06547685996756852, -1.2811864851195403, -0.21862129951188727, -0.8357899925679295, 0.7183926581377253, 0.8870547296476309, -0.08668888026726278, -1.0684353202672694, -1.42694283836871, -0.9133625405002156, -0.017355830921181866, 1.1553272347925099, 0.9911441328802569, 0.8004591862222534, -0.9730141745150153, -0.21209446586120773, -0.46202698697481515},
    {0.30913734863743, 0.9415436062184737, 1.2290424240647584, 0.11859351353962656, 0.5532948333503476, 0.9715569700745508, -0.6643440478136698, -0.2809284455736751, -0.461662043050365, 0.7370408532795207, 0.8727465022790052, 0.6583809352263558, 1.4398403896632255, 0.12165065632947974, -0.19608251493105255, -0.6193935489725539, 1.1789271379881252, -0.5123670874326952, -0.9794142134884555, -0.880409642577186, -0.8775207641275573, 0.7747740918964652, 1.1844726897574227, -0.4747618982351413, -0.7733830412103473, -1.2260542147661062, -0.16552979738285467, 1.4198000854385584, -1.1236911802305432, -0.8032138801482758, -0.7037893985617358, 1.268690090943112, -1.0254348790073367, 0.9273436204796848, 0.016219309088938066, -0.047010401494993165, 0.5631226299722808, 1.0721543167051577, 1.1710244416214681, -0.0008648308462120298, -0.11230692337138225, 1.1804195093751468, 1.1020445943298156, -0.7830018728213971, 0.27159616720853863, -0.43262056408410615, -1.0951804589632375, 0.6832725819030783, 0.7380985184720142, -0.5520496043664878, -1.0725290094556346, 0.29195876244816726, -0.3073251438218915, -0.3751762495485462, -0.20034693748717905, 1.1461344133432543, -0.09217976465775078, 0.422752350218232, -0.27863372357715566, 1.0144025136875376, -1.0904906048990457, -0.19164524625065282, -1.214673648756284, 0.9696806573652899},
    {1.2392080997071373, -0.043368895524866044, -0.6382743225527214, -0.7560181089710489, 0.9279072132663855, 0.5741071044308907, -1.2093199146095857, -1.155002514887293, 0.09609383106077553, -1.263218731117133, -0.9873181688338523, 0.25698673219417006, -0.015879292890847035, 1.0909793488742392, -0.3643295312396745, 0.54113232150602, 0.4001543481113918, -0.1832338416581936, -0.9767352194086041, 0.7710521567053895, 1.0992310150884976, -0.29529689951984184, -0.0290344590759492, -0.35277979911931967, -0.8811214715462442, -0.6078002128445338, 1.1012150281741324, -1.1456585165327615, 1.1106911490484455, -1.3468757042141306, -0.18207040588088244, -1.5589780284746333, -0.9512853266675985, -0.8623241532228669, 0.7908593774655601, 0.32184737465069596, -0.6234220918071116, -0.9531354667607003, 1.2095256471683096, -1.0007497011149293, -0.17964358555757576, -0.5424939565087089, -0.7889716281833582, -0.4795421149324825, -0.81980675558634, -0.3351357726583949, 1.1291285408388094, 0.2806145322337976, 0.061722345963840346, 1.1554451350855393, 0.3913492977725319, 0.5340730534772712, 0.0963647605515093, -0.17910345101367098, -0.3461779774085513, 0.2564844027302555, 1.3531441247353206, 0.9588088346925634, -0.4613695598365884, -0.05831566253067352, -0.5146447521200447, -0.9821918690985239, -0.1924575625051397, 0.7110052019775442},
    {-0.5334371122406534, 0.8754095078016567, -0.6085339273480402, 0.16115554858107314, 0.5073225164881363, 1.240931540555439, -0.6675538566769916, 1.1752314280527703, 0.7416792564949011, -0.5383886917197923, -0.19057442400893734, -1.0699174408796477, -1.1942986746512585, 0.8745169635961298, 0.26478752786716403, -0.05619605970042034, 0.48152914667061497, 0.6285881358678681, 0.6032190393766744, 0.056216383081988695, 1.2648622061409862, -0.9884175537141163, 0.44365487933215797, -0.1830748771385067, -1.1479568942430298, -0.35882383152509006, -0.22841155303905722, 0.3086005631461551, -0.4949780859539132, -0.5702799972632371, 1.222170601727818, -0.8310243092377527, 1.263504804186681, -0.09628495053403749, -1.0449147390019702, -0.5946543433869615, 0.317555662412, 0.8469152925694179, 0.6352387634227591, 0.5030895681929363, -0.39295527618651915, -0.8451840980969236, -0.07975132878725494, -0.06875819020080307, -0.8795329825938498, -1.0666248151661344, 0.9334120373021949, -1.1273374334446569, 0.24849995776056136, -0.5762261121179622, -0.5481580208965464, -1.0620023301177877, 0.6201283750600411, -0.23776781497799418, 0.028985492023319067, -1.03822343930595, 0.1906392287879636, 0.06529160786683198, -1.3068059051569776, 0.03436797924733769, 0.3626515091689411, 0.4446164508981164, -0.9505676812763766, 0.17941721496651616},
    {0.36557375723008145, -0.47207660247681743, 0.9005445229223301, -0.3405482610343583, -0.6878207262687555, 0.32755405594682807, -1.4822771846740597, 1.114347753773169, -1.0767030771407773, 0.016953611578070994, 0.9663001443474554, 0.6331194935656972, -1.6069027871110344, -1.8743406893757955, -1.0518599257882646, 0.08137538922802957, 0.46126114267560125, -0.4128736028926814, 0.04564684133507857, -0.20657115269329554, -0.7307359506040367, -0.6402006791896991, -1.4631463144566526, 0.07614417991563367, -1.3464594942429486, -1.2087118702643453, 0.5015324960187404, 0.47290684363320984, 0.8487021049545448, 1.04236344053883, -0.4104585622051616, -0.9058430159578235, -0.6875428505082504, -0.7430838586312829, -0.7087775701058988, 0.6257195886274286, -0.28911641463356785, -0.6114894864333732, -0.25507843748047365, -0.6534069690313997, -1.8161625414872777, 0.3961049410944188, 0.0704689904401211, 0.8842376687328406, -1.204579989464361, 0.002824626196485778, 0.7609133137839094, -0.6163654433892133, -2.124983973699701, 0.2344288394856616, 0.09882419882220993, -1.8354775363876747, 0.208131076549289, 0.34477322973676416, 0.02209998969420265, -0.9898682204788184, -1.4002985911306989, 1.0654658026994557, 0.4398179485396466, -1.2543302119369366, 0.9977494497870822, -0.686079967339882, 0.08634115210333174, -1.7067823051763227},
    {-0.5194673899749189, 0.8515161991780408, 0.2579012144535968, -0.00839834775192513, 0.06855221686949592, -0.3033425710936282, -0.4652022092105275, 0.28146249967681225, -1.315065383285868, 0.5579091641808194, -0.019255057202691595, -1.4206007336206246, -0.19268717040759636, -2.117847989074333, 0.9657627902972434, -0.829224415257049, 0.7272936812487742, 0.21573869025388484, 0.7112436328901436, -1.088254763572913, -1.8227893233909704, -0.8311794765134817, -0.12288260624138542, -1.7645201670470283, -0.4148474124919402, -0.15408132351853873, 0.40806642247937885, -1.199874064356398, -1.1281972934073536, 1.220497940339501, -1.3420668323681872, 0.19974624400728028, -1.3046056267264474, -0.8386289547062548, -1.713595651496221, 0.2089557721272972, 0.4228827209017184, 0.7220730524946158, 0.7107547250826675, 0.6944215743840109, -1.4319304229502954, 0.27111164122740383, 0.46244544697446105, -0.17680808835598413, 1.1138547970469619, -1.1361047078792927, 0.7611450054305938, -0.8911711235901519, -0.051631071120487246, -0.7147379317759188, -0.24966702735300614, -2.1768773028954027, -0.08308704782022834, -1.2855057964600918, -0.291981087335791, -1.268753190184217, -2.0001814005560408, 0.30783805757199106, 0.9671625833147385, 0.8351667272660043, 0.34076327145948115, -0.9614004349461177, 0.9604587783959017, -1.4929318262730298},
    {0.5430814619823818, 0.26963836476574554, -0.22198671048355298, -0.9703544663100255, 1.152402595496311, -0.37134085814295037, -1.64018131988017, -0.5640242269951666, -0.3298962706719789, -0.9603425734417436, -0.557692506153908, -0.7843784997992925, -1.4383110294463466, 0.5738227332847534, -0.7873533950609776, 0.6687747203530052, 0.9813008952288794, -0.29894026539326624, -0.7941057829055232, -0.14622589461348298, 0.5438836764683397, 0.5192318235724241, 0.060526146959535246, 0.18033480403059207, -0.6884749453857626, -0.7145636817637819, -0.5782981060345391, 0.29355484397532494, -0.04933374127167281, 0.8194772495214337, -1.264163615321944, -0.704301763315231, 0.15023213088888118, -0.018740345676050596, -1.194688496215396, -0.3019309865874836, -0.6089299092416306, 0.4294831862097406, 0.7812870222889166, -0.8504528854599268, -0.9631702500698419, -0.02614856351432093, -0.6759084051510973, -0.9681178897638733, 1.3622936948466615, -0.8421811684533933, 0.43960397028796355, 1.085419187514932, -1.4441761612976243, -0.46769061451416283, -1.2687575596609921, -0.865322493903954, 1.0134486476900744, 0.5341556844331639, -0.785413707079372, 0.131997456434837, 1.0246703959982424, 1.0088342857646602, -0.008181158631697221, -0.6409650395689117, -0.9733983217004872, -0.6631963734882118, -0.28646009858409904, -0.6373741205747102},
    {0.09569525134382055, 0.7652650543925169, 0.2351183432346128, 0.2965963736997309, 0.9036140378207633, 0.1967402605729738, -0.7243940442450005, 1.0180392105378833, 0.8232605648471759, 0.7476224494546438, 1.0613833783752096, 1.175880860082084, 0.9064265473440335, -0.6079449423535903, 1.1232836649515456, 0.3407855014988741, -0.5049008536101062, -0.3099937679248801, -1.598267672558462, 0.14178104793728746, -1.2290870731167212, -1.272936139286968, -0.6932852984042075, -0.44551249055781256, -0.5395567464508135, 0.2367780278346936, 0.755964091876903, -0.9507154125930025, -0.3110652976668174, 0.4401905500808835, 0.3890165316523492, 0.7375146999096235, -0.5651883904743411, -0.9321890713861275, 0.8997935884971412, -1.1125197104944826, 0.04835807221945873, 0.858365846771013, -1.2503880482673617, 0.6271543832166381, -0.48602443805219064, 0.8767159223907119, -0.15435826451155002, 1.348232272018449, 1.3959997694467734, 0.22828909928980182, 0.6195099446461413, -0.6599486637486953, -1.2998947379473709, -1.1077149767684837, -0.9866649898616748, 0.13041130338691098, -0.3509863332002543, 1.0223121813508478, 0.20185855043734052, 0.844127881147322, -0.4290314924795325, 0.08060226537017676, 0.48337991843408223, 0.16877777745489536, -1.03366141007675, 0.5149507431211746, 0.509797632519786, -0.9038364929582443},
    {0.16062491701644496, 0.3849179050950895, -0.00520477358085887, -0.04599918537604256, -0.38165806132754665, -0.4532653257423386, -1.0474942932329527, -0.17865520868416593, -1.2334963135768116, 0.20055898934144892, -0.9395965323753789, -1.0183387312855516, 0.4344135872136374, 0.8278549779349097, 0.2588256500627734, -0.24253335061151995, -1.090456974465391, 0.19440307633540224, -1.3026880131163858, 0.353501292848392, -0.958586465808636, -1.034136561149344, -0.41246520932174896, -1.2673517281963573, -0.3432816248659388, -0.6425790423380071, -1.142941478400428, 0.6145384100280195, -1.0104129663209733, 0.25889996929073145, -1.269641247511261, -0.37827778622251235, -0.42436780377055117, -0.9068178877504084, -0.7892389996948275, 0.7232156232859881, -1.5489149233872102, 0.3558736501144904, -0.2495404875912157, -1.4186556356092102, 0.44392932377246497, 1.1119161445324046, -0.895532915545825, 1.2497511121699738, 0.4235109529624654, -1.6081336085621687, -0.12441371026717822, 1.259435294051147, -0.579830714238589, -0.6124886368549, 0.3909746769462964, 0.3574633956476134, 0.23304757306973264, 0.8358425555704913, 0.5429741115955918, 0.04734194930204596, -0.562691265553918, -0.7250167845889335, -0.6037216832437372, 0.3269221144688764, 1.2134951918659453, -0.6465870612724484, 0.5064280625994895, -1.0348182024723105},
    {0.6820506689430655, -0.12080237159806442, -0.44249756528399503, 0.15999775517186057, 0.2518652922133794, -1.5822142425566932, 0.12031663585498724, -1.1634888183990204, -0.1671194589822212, -0.15265225519767886, -0.3300407514195446, -0.6016065529103384, -0.8033300511512163, 0.04495420516902525, 0.24505545794373115, 0.20284116593426435, -0.17036178506302144, -1.17702373697194, -0.15774292520940414, -0.013679045420966653, -0.8543708227702776, 0.7964614595816533, 0.1603041449232428, -0.7428694390447775, 0.25189498779889674, -0.6046124286699, -0.43011752385535496, 0.24555958247258142, -0.44222458628061945, 0.6204873053442093, -1.2745463322452708, 0.06914567405574043, -0.641853422133155, -1.3806083561855973, -0.8628821559304464, 0.7983308340989901, 0.4693371185919036, 0.7477425515968679, -0.4930868249311068, 0.42519919548683255, -0.012719022327935358, 0.7791925903308244, -0.9577192648803378, -0.21839892421038734, 0.23183255937176925, -1.1358719651867795, -0.511025897794023, -0.7147895026461307, 0.29630174968509837, 0.7169078244084485, -0.22711532473911175, 0.49397347609769815, 0.5202389844592913, 1.0421457801754699, 0.5521098443302178, -1.1832879126641869, -0.518436439831563, -0.10302896430724162, -0.12221211174045297, -0.9407817011847723, 0.8772918925532013, -0.0860148106610741, 0.15896639428205156, -0.5669825049617038},
    {1.441992424501644, 1.2306709702825456, -0.11816492831809386, 1.2518249120725558, -0.7844929863994443, 1.456132134714925, -1.2151515676280675, 0.17412797038884875, -0.9940148262303521, -0.7949442929235411, -0.45032781935901334, -0.5640397803507724, -1.4029781146496392, 0.35946734500098426, 0.889253194921761, 1.0284618890179065, 0.3345322651827565, -0.4176154641477079, 1.0080164094780233, -0.7603087629682571, -1.2711715725283474, 1.250393199058455, -0.6432443703981813, 1.3278655937126194, -0.882737129488023, 1.4642645176322486, -1.023331560388557, -0.2071563088015678, 0.18224632931420917, 0.42401783944970095, -1.1059106205509264, -0.9584646628786155, -0.9442890686973865, -0.7932610816430975, -0.18118005838133106, 0.21166487037942666, 1.1808378639914638, 0.830350468359046, -1.2960300566660223, -0.9340216635800622, -0.31493145296223807, 0.602976548850992, -1.0504963020055458, 1.2240437701266984, 1.4224091029890702, -0.2992800415848289, -0.07562710929046677, 1.362873898564539, 0.7405995177415313, -0.004940748614910609, -1.093716191543563, -0.6276262869112974, -1.1632872718390543, -0.810511407732828, -0.7010155723097765, -0.22518678881449117, -0.025102812624044304, 0.3041092162838219, 0.24363580975934065, -1.0504505301684794, -1.1012935034132156, -1.1775369672127682, -0.21262946559386373, 0.7771650653590259},
    {1.0535997394496086, -0.9310643473757132, -0.8573907063820113, -0.30759720675235835, -0.011827596859136513, -0.5506879335011622, 1.1057053981500107, -0.5167153255253647, -0.6552434022827038, -0.4057248332680959, -0.42334463433271924, -1.1086790368154518, 1.1874940914468195, -1.3398083417761972, 1.0346755459038606, 0.6174239962558856, -1.2196438207405258, 0.37953402363615374, 0.3501020796918218, -0.9966421899697322, -1.457534602941353, 0.7398781548212342, -0.907053442732884, -0.35596585000272873, -1.5116278907227767, 0.6934650076069946, 0.1867428711526709, 0.25795749953809, 0.5000465525395934, -1.0924363146262726, -0.004916866472492897, -0.8897768420123404, -0.9775414576479533, -1.031218954393542, 0.17223364773339228, -0.7715069044915087, -0.9010723357743002, -0.394346445355163, 0.5325171516754259, -0.21820094455786662, -0.6028453971016555, 0.040425626441498254, -0.019620291490376435, 0.8967150199714453, -0.18016427630353793, 0.3472009412682977, 1.2042655282061256, 0.040887311852600146, -0.9748085933108418, 0.7885249194619848, 0.4284747773784698, -1.3769996815092855, -0.768091351419719, 0.5330024635133441, -0.9548796554298554, -0.37750922600509756, 0.6313522125692134, 1.59743325544864, 0.25184944097472944, 0.708505159478969, 0.35658167968877535, 0.9901342127462995, 1.0710569848276363, -0.5896794142393856},
    {-0.14616530698856695, 0.04118928813915708, 0.9774269777569123, 0.7573766371248496, -1.0080281350009674, 0.7377771894064317, -0.4499380141159011, 0.463019720594224, -0.6740180833712626, -0.370334845870494, -1.0200487798247824, -0.5947335836112579, -0.7609501377155662, -1.2719458436605122, 0.30937989713109204, -0.0903322363218093, -0.22326938567900675, -0.4738325323443967, 0.27540800986972824, -0.07176445155767695, -0.9795451558048082, -0.608172559975047, -0.3585292849271862, 0.6524404332004343, -1.7223752795380038, 1.0305445308953856, -0.2594061506223103, -0.6832031028996027, -0.9746011648833122, 0.8275237464626283, -1.4933205199917583, 0.7994756551493963, 0.49202768785828044, 1.137727108022547, -0.982158699422488, 1.1731297548954025, 0.9360563788383118, 1.4396286689981665, -0.05331079600513597, 1.1644356604217536, -0.5553266181671044, -0.07698227360747367, 0.6201226999324988, -0.74924985366867, -0.1159824424873851, 0.19116053089082105, 0.5603015289879671, -0.5367367984418351, -1.1257404540665226, -0.8534793189887253, 0.27370070282335063, -1.7720616652339218, -0.371023180753164, 0.10765024063826709, -0.6883968276686037, 0.8704190981466562, -0.9660347722651782, 1.182640751011207, 0.12236810410859597, 0.247091945077367, -0.9114134203676282, 0.2074045282686622, -0.7250792364111438, -0.42408135439743316},
    {0.9066894545785187, 0.3781723370758175, 0.6824854944979744, 0.25115976932908063, -0.008053595043263112, -0.10227427227377553, 0.7703732784411444, 0.26378100057700105, -1.1209728901520717, -1.2825297887664573, -0.14868773627147228, -1.0690267686101036, 0.9470651119224294, -1.3341235968719896, 0.5548277223019918, 1.1834674897703021, -0.07270085020980732, 0.8902835935989057, -0.34009200102326026, -0.5286750973320692, 0.1733456076265508, -0.453914217924987, -0.9037553235039352, 0.7260134283729495, 0.9707309466837234, -0.42080331005592786, 0.9857659868518814, 0.4205423633656698, 0.9037018192749959, 1.0416163732587902, -0.9202032577642119, -1.0763896207644967, -0.5609161727898033, -0.9358251459806185, -0.9381762488954661, -0.07015965519056899, -0.5644635578639019, 1.3640730391099574, -0.788905694065865, -0.21299069498865483, -0.8646100767383414, 0.3606898446272642, -0.015896076862616303, -0.48045844172845986, 0.4032196551582776, -0.03674234100922269, 1.1679381877482984, 1.0339713045271728, -1.171020960747902, -0.13541141385936667, -0.6796003654549646, -1.4701929857976492, -0.8324192945646638, 0.8954411720507606, -0.9348805638363642, -0.12740078406565886, 0.9177441846251978, -1.1250417156064159, -1.059593612848653, -0.9352011938478382, -1.218084625374506, -0.5034141365034748, 0.26713337793616854, 0.26056714745405707},
    {0.9068354331140926, -0.6235869191618422, 0.42192384028076707, 0.7964056708955725, 0.31612167877795505, 0.8295065774706425, -0.5012521908764657, 0.38136098351698877, 0.27544246887285223, 0.01453866187628158, 0.23550894744752715, 0.5052966604802125, -0.33498841301818577, 0.5654587943145022, 0.1991767961324477, -0.4042152896394967, -1.055610504208998, 0.6265889630218093, -0.6278196909778277, -0.5692893931638753, -0.505816597170175, -0.10455413553502169, -1.076547128801471, 0.40715605168888597, 0.803648535918729, 0.7489497053490123, -0.25566574850957446, 0.596641369076131, 0.7711178317360127, 1.0048648138945775, 0.057945172234629826, -0.08948091916548313, -0.2025057478769824, 0.5609639157096553, -0.15970705766564158, 0.7315218772371075, -1.3802631041545927, -0.42198910019026215, 0.4077708756545238, -0.8632232527755863, -1.1508382123522585, -0.7449859560340065, 0.07285037108925234, -0.6592244450516499, -0.692770460269523, 0.12956601185525093, 0.5712112272887897, 1.0506180092038848, 1.154874120918101, -0.10095362412443593, 0.5438678322913439, 0.480002290558047, 0.5495356228929419, -0.6809189832006539, -1.0351774899513142, -0.6177141326326441, 0.008759154092467502, -0.9933359957598459, 0.7768348536706696, 0.2814550065431657, 0.3521343445877624, -0.3802308670268474, 0.01506845081548697, -1.070389548740955},
    {0.39838392317954, 0.0906248011151201, 0.18188263098427046, -1.2352583726571298, 1.3540043895036191, 0.0333914021459033, -0.31884844660778583, 0.24706129328393892, -0.8375814575373238, 1.2528104447405384, 1.0742046575755206, 0.331363587822398, -0.9652944362756288, -0.6906374010572895, -0.6515278818219848, -0.11710626356919437, -1.0714810054454713, 0.21870014650384303, -1.008968822722169, -0.0538100419442669, -0.45204783128439313, -0.9271704810486107, 0.19160972922289005, -0.7711880605647666, -0.48608761512704346, 0.27732299741673505, -0.26107255431655735, 0.2877315736354373, 0.9183716804047803, 0.32580407560122865, -0.9439144451984461, 1.3227569162336177, 0.6076018984753662, 1.0141236374811737, -1.0964762628768845, 0.47881642977886524, 0.02776182456893768, -0.16650217200515827, 0.718450516743811, -0.9315966900000822, 0.6567206375580119, -0.9582545478035991, -0.2098930450195893, -0.5600009200020325, 0.27341157869434535, -0.7094043158853048, 0.4479033194303286, 1.086256031930148, -0.8645583831193604, -0.9902938998129949, -1.1479099267327373, 0.1227895708357288, 0.6269970230377278, 1.1131636539919338, -0.16773065035419846, -1.0628919635879188, 1.1616058170645605, -0.479112869913664, -0.3258616443578629, -0.8370071901933529, -0.07140045893484508, 1.1901344286903306, 0.5801183311118607, -0.4370255276526867},
    {-0.09153700750924253, 0.10453065009344832, -0.39385029596308135, -1.0883338336994461, 0.3678766035869664, 0.3826481930024845, 0.7932584650426032, -0.9189496390930287, -0.36777415990050233, 0.7230092958692897, -0.9796605443854636, -1.0896110670027304, 0.16988833195143802, 0.08448927882759638, -0.6064297071448793, -0.3262915152949603, 0.45090142135981764, -0.4458126532168698, 0.982707806321231, -0.401116229517406, -0.8916376036067377, 0.15437815129745164, 1.1614854029426132, 1.1069713393123404, 0.0036817872031961827, 0.8325438803400725, -0.045439536789572556, 0.5506086756026756, 1.3217223330816295, -0.8712142637620145, 0.7167352553357672, -0.5718626690769604, 1.3495590716910069, -0.3433528481773296, -0.6383781203223399, -0.3506461555009316, -0.6285608600615888, -0.7170951081603807, -0.3913238778263941, -1.0454073599329705, -0.6930365895685281, -0.8645787741269921, -0.5214893044844309, -0.7227113924647687, -0.9960720620074249, 0.13183782022408966, -0.6014923912195065, -0.18490952762930216, -0.47304814558505376, 1.1765890011135838, 1.1468435062759699, -1.485520301450052, -0.2756226730151073, -0.5945374900855304, -1.017796216618645, 0.8042098895313877, 1.111164166246254, 1.173566554492362, 0.44426799168051784, 0.5678617309852746, -0.8874215708693483, -0.05405827928128402, 0.3867661752547536, 1.2433686358401213},
    {-0.03078996564193824, -0.22859319769980785, -1.1321713296700173, -0.4647464446817906, -0.6001041063752728, -0.5190400718845367, 0.9320470205234624, 0.7214652083039432, -1.4652586227034428, -0.1490150600786448, -1.2594952395154986, 0.44195524002206027, 0.3926207950183094, -0.8270353298605901, -1.2137171681962353, -0.5339833462184289, 1.0736085613187711, -0.3433432705624168, -0.43479637273826555, -1.0592528093534026, 0.7314253969165996, -1.2740285521610257, -1.2984281811283662, -0.26652559345477445, -0.8718853288967087, 1.481382113657247, 0.8304561538951921, -0.23596959104720466, 0.017276923319776444, 0.9580323711706235, -0.3069637968588661, 0.05308066425422539, -0.40335977171667603, -1.1554101913930406, -0.21734709022132717, -1.1806296209361238, 0.2591454545145984, 0.6960577874219948, 0.3773816154194044, 0.9883596844759104, -0.9694674540571605, -0.4510719779384448, 0.16636198382093897, -0.20296468427539996, 1.1103524659309658, -0.18106015067127137, 0.9423396956882202, -0.3214795585883739, -0.4527515145431617, -0.6564404312898443, -1.1452320216247454, 0.8201618626054603, -0.2572268149968467, 1.093459736401256, -0.7375108366485714, -1.1100717871629273, -0.3162915218850886, 0.9196365140604414, 0.5862131937372044, 0.20137904100667134, -1.0491668490119919, 0.8994196000805883, -0.7447927694264799, 0.8619308134306781},
    {0.5988204917242468, 1.1276297981919314, 1.3633273329514828, 0.3052727906341064, -0.5817157097378429, 0.35479087476747867, -0.4382747901174514, 0.1681758288437214, -1.1084431512517448, -1.1485541631964298, -0.3446391007641596, 0.5413725345760432, -0.9518738813341114, 0.5898926889069082, -0.9694766797081604, 1.0147533779816473, -0.31714181282751996, 0.18184243170320202, -0.3298148905968106, 0.3554154973218902, -1.2240911450232472, -0.31984604434891256, -0.6565973242605273, -1.0593952387512993, -0.4261637337775266, -0.3973463585170006, -1.083711604228333, -0.7465606496671605, 0.24227715939437827, -0.1812733796429293, 0.7652433915887852, -0.8711227708184116, 0.9722563617441373, 0.9467044890934724, -0.5839816011937147, -0.5808590179500838, 0.1887109073012983, 0.8706282108603182, 0.08474872255197552, -0.8715656814450734, -1.001946347453889, 0.603570662635112, 1.3452087234290298, -0.7678873152173302, -0.6580319606583057, -1.168344728856442, -1.4539751032409471, 0.6035052132128058, -0.3509494870620186, 0.44361022205658907, 0.6912693516470191, -0.09408839636061897, -0.4290678644048746, -1.202907394172673, -0.2463839018044134, -1.4333937426679457, -0.2148193738355234, 0.7901949086052256, 0.962847982561144, -0.2244006655135103, 0.4902274833803004, -0.5986341167685333, 0.8555743224925217, -0.3596299843411184},
    {0.9821078665459836, -0.511422637776512, -0.2670479953769508, 0.22453555930065613, -0.6063841894993374, 1.043411860336366, -0.7635297093066691, 1.166040561893004, -1.3569035077098186, 0.6837384751536851, 0.820047041367268, 0.8254446635534807, -1.10790035611871, 1.027603967003829, -0.5426126294257543, -0.09338741153930122, 0.3654694444509575, 0.48472525984739323, -0.5926637338298529, -0.8917192478506324, 0.17714564906207567, -0.44935077624548164, -0.08580226329178964, 0.22523659264025836, 0.04646773394728321, -0.9931865703118737, -0.16919432949945792, -1.2985962673917135, -0.09347145269712318, -0.36804838277789437, -0.49493723107169274, -0.08640368618145201, -1.5375210579743048, -0.23232855031036592, -1.271249756838101, -0.0008711987384202897, 0.8269408037563653, 0.07464537805953254, -1.1084458721613497, -1.1236917544183402, -0.4997778679781237, -0.011471095875283392, 1.028595877133821, 1.1176193970444432, -0.7254994389044936, -0.8691748696132343, -1.391897409056861, 0.13897374471591428, -0.11410045578204923, 0.6761607208795005, -0.46205119074955975, -1.4407266538301895, 0.3695581853813684, 0.13239435740785652, -0.859824460601949, 0.8573890780816967, 0.3303499233473521, -0.14437820140016194, 0.16058988261224108, -1.1469256835750083, 0.9345376225630545, -1.4386573545039072, 1.0905233473794216, -0.9752098085325326},
    {-1.2718686543729019, 0.9787779099520318, -0.32893722973559203, -0.03372105398633936, -0.360289533272157, -1.3094536682832318, 1.002916164834753, -0.02549739013349094, 1.263380157125686, -0.9208661699190117, 0.308531085563701, 0.8438411190209234, -0.6849473746003977, -0.8578011373847536, 0.15047989744939677, -0.9214837844037544, 0.4733757765264469, -1.2301683049119054, -1.5064607641786991, 0.30178497554713624, -0.49166128024132194, -0.11641759128011453, 1.2535114223069457, -1.3013976936917084, 0.5602870852506966, -1.1530051342381844, 0.5891135356234095, 1.3709686977568485, 0.9760077805221976, -0.005292264069735284, -1.2008571204387786, 0.21897739750660342, -0.9953320752566883, 0.29891174991330244, -0.8182891198764609, 0.4926791831037618, -1.7024552806203102, 0.3396299450842592, 0.886021588735305, -1.2628913506580897, -0.06341372584590012, -0.573427011246758, 0.7952226639233211, 1.163472319546202, 0.2053088626630831, -0.6005854443228956, -1.0601773424165097, -0.8983578586362102, -0.3180153384436502, 1.2262040453488328, -0.8143783299277237, 1.2039346776243949, -1.1485692167793409, 0.7796481248899628, 1.1610918333964269, -0.3391166334501993, 0.8585081316498832, 0.3091953984154048, -1.1183037498032753, 0.2762346579746056, 0.7029894998510036, 0.2897483846755798, 0.010674757976163799, 0.8828446990544481},
    {1.202928264783059, 0.8313403021312996, -0.7655019253437487, -0.8717296133090329, 0.6065658982217842, 0.5148182662524438, 1.0328127804945202, -1.1711877121377419, 0.293462008548596, -1.285011815185234, 0.8941193637472113, -0.7352324621626196, 0.42424675592330646, -0.49009492225774376, -0.8032700946842245, 0.11355325172949071, -0.019546942051835863, 0.9368719187919002, 0.7832396599228626, -0.31947923085365354, -0.911209616857596, -0.6641291150746662, 0.4942190529091369, -0.906222642183917, 0.21814599209842211, 0.19740968485892965, 1.1939533933396838, -0.3081128878728783, -0.9723432763215955, 1.0698225898950358, 0.9155586035918578, -0.9183126038303691, 0.1570277990939068, -0.2594034624889721, -0.5287373891254148, 0.36411993484920774, -0.08046935054047373, 0.8075061301242787, -0.8448981973269356, -0.25948269107532473, 0.2423891541407467, 0.388865235418394, -0.33265157143922464, 0.4533704844827283, -0.48192983672062384, -0.19291271841160998, 0.598695260953942, 0.7281026286485469, 0.9784378324399993, -0.364041182937011, -0.10700627040550677, -0.03560821883212459, 0.030283986540519538, 1.0904789855667587, -1.0675128538059901, -1.5774351609275492, -1.4527115859608333, -0.3390007148248681, 0.3630320322410567, 0.08265280345505924, -0.8537067248207612, -1.2284088747683806, 0.6381146995644335, -0.9006365304811275},
    {-0.6919344140977549, 0.9375665634927797, 0.7291513533007027, -0.264015507223417, 0.11114895593701937, 0.7438925195063306, -1.1901130792299777, 0.6927249068059204, 1.0360839761553933, -0.78663506526932, 1.0397770269413709, 0.2554125399733034, -0.09503637676023272, 0.08370988765279218, -0.8941727191687254, -0.710745453715101, 1.4729242639935949, 0.038837170525494395, -0.6816726352186234, -1.1147011739407062, -0.002852368369741788, -0.1421327978971413, -0.6228458806492276, 0.5570117115314054, 0.28565105514555317, 0.43971448061239815, -0.5414981432207897, 1.1470163740557477, -1.0592928222420774, -0.2002692765888737, -0.0018837525133043509, -0.8701195315200118, -1.2402130885555622, -1.2601886133933067, 0.22566434574853594, 0.005317070957170443, 0.660883918046456, -0.8164423197489988, -0.8145554283581615, -0.06759279726220978, -0.3883385102704921, -0.726387340155106, 0.564930199004677, -1.0179498209822562, 0.5332965698441164, -1.0064180215811056, -1.3661838048212884, 1.3646704530019376, 0.7875084043375334, -0.16557382682022356, -0.8104663164953475, 0.1841574702477886, 1.3693212234949277, -0.4147062858248001, 0.2083521157088458, -0.19429114775176853, -0.201743905327802, -0.8116098266135889, 0.01874120744266272, 0.08498232845532815, 0.850390736279717, 1.1372090543790265, -1.2370750823354184, -0.16700922690621023},
    {0.976728423023969, 0.471930118095432, 0.34124482646547744, -0.707887322423024, -0.9171593168453597, -0.5970342878355157, 0.6821214021710935, 0.4412902158058363, 0.48088525354758815, -0.9683229852047711, -1.229485342243147, -0.7582719872437724, 0.8001252098960332, 0.6478163423449473, 1.0745081090256619, -0.6606114530441624, -1.2293092773585366, 0.34605831765874545, -0.40303980194676253, 0.4959210442426341, -1.4366523673821114, -1.0026306884663339, 0.0782365711070966, -0.11413906871227912, -0.45187754559150906, -0.2897226431242174, -0.6176210955748735, -0.11856246624370977, 1.1646054516446345, 0.8017589423962411, -1.5543557729062751, -0.9882213301985575, 0.050739973487802174, 0.4206563857844546, -0.18913047563713759, -1.302233122640539, -0.8604903557056971, -0.5464962489987943, -1.4380741839892512, 1.047651302716746, 0.4726477843178335, 0.8396214927922271, -0.3387687261130147, 0.021807872415364075, 0.8942888436004223, -0.4148894960917357, -0.7271717837273844, 0.8348970323468095, 0.4523764053976514, -0.49896018220681676, -0.17254667409051508, -1.1373310363315685, 0.07877574740859533, 0.49137711774582765, 0.20891227983067012, -0.25693367789805355, 0.2773837403961084, -1.2262061987287787, 0.05001800684812402, -0.999278515501323, 1.101549669833607, 0.4100883559077579, 1.230852367912736, 0.052480608908305124},
    {0.503703635527093, -0.23773553305545853, 1.1475367774358674, -0.6204856234332476, -0.8853036474478418, 0.6264220447038954, -1.1454021982887035, 0.573933493388106, 0.5637854471965021, -0.6542244575874145, 0.8925798405991359, -0.3308481138160329, 0.8872855234643849, 1.1746934885569809, -1.1950330345130378, 0.2502971307086738, 0.6535844067660199, 0.6770500975240703, -0.1827132213519508, 0.0030091427057596628, -1.0067556363517542, -0.39611365210735666, -0.123843339994252, -1.5142875430198126, 0.1927335035169581, 0.2004553004726313, -0.9486123427683849, -0.34378184099995734, -1.0384686205701879, -1.365943237706297, -0.9309290594329913, 0.27103961496391626, 1.4146694838733698, 0.43688681562882026, 0.2664963127110421, 0.41808876108389254, 0.9371108965325742, 0.4013299261172085, -0.060969968429693204, -1.165564110514434, 0.8377810476175241, 0.3993899566482087, -0.6055653137771642, 1.264847744558409, 0.06349937938156011, 0.25075580665618086, 1.0085180563762115, -0.40869343125711843, -0.23208057807388865, 1.3208106798376558, 0.38702074378419626, -0.5288602635214795, -0.5268012701585796, 1.2014729660821666, -0.6826547465619897, -0.6615435099172714, 0.45202786542887136, 0.3941717650898977, -0.8052703417705394, 0.43503372700421267, 0.41604369913912514, -0.721685234592956, -1.0484910791316455, 0.5807372119969426},
    {0.14612476106587247, -1.2015499638555327, 0.9466379405046755, -1.137395981837577, -0.7904983452591676, 0.08770668043547813, -0.7972140989792414, 0.33480344273373513, 1.082434863753923, 0.11462130946224226, -0.23890542205381646, -1.33781371576228, -0.9539419049977004, 0.39810986445065544, -0.9392850155881264, -0.7030079639716472, 0.9094566733420884, -0.8276400180844291, 1.3123721413273715, -0.3096307683353574, -0.9362343145081816, 0.20227067989843037, -0.8657923695730814, -0.484852518913463, -0.7105280997587292, 1.18269469327719, 1.1124494507644265, -0.9310796349545318, -0.979717466989723, -0.45181303418335067, -1.2630645120874748, -1.2127739563667204, -0.7717002731896093, -0.7488568424879363, -0.9773206395311456, -0.3955898394305623, -0.07459412324714082, -0.22134126544510394, 0.3290489957110317, -0.1634003550231511, -0.047441471318821045, 0.9565173429236011, 0.673519132934023, 0.008368604020537573, -0.8748652745039475, -0.5299215487658631, -0.4178967829754626, -0.1177950652396917, -0.5659861220795509, -0.7528293807598412, 0.8624476239506111, 0.16136044563818033, -0.04624729337942618, 0.5155297083793466, -0.36688129466335473, 0.19103381320523122, -0.5668469469677776, -0.024617198406339153, -0.12027517898460048, 1.108170085798589, 0.29983838298117893, -0.8376960163129505, 0.48349224085838005, -0.17976251722500333},
    {-0.8864410105193138, 0.8230670448153272, -1.0847805212603563, 0.4576182572708152, 1.2343335899820125, -0.3457447702986718, -0.1196072311709512, 0.6381809098302561, -0.5988350425632252, -1.2677889137329488, -0.5979445763113379, -0.3279528080263484, -0.828520587383422, 0.5914364952287622, 0.4548043650204966, -0.11529031830873365, 0.6636984870227775, 0.44053054577172607, -0.6460955238310122, -0.5459668009999157, -0.7991932406424094, -0.5269453035732692, 0.16243664491276583, 0.532164750529229, 0.10298121806714754, -0.6345804201178454, -1.2433349859498526, -1.0426615843127272, 1.2224066760088979, -0.8219970219624223, 1.2557539133605002, 1.02592131561853, 1.019895850955713, -0.49629849960086375, 1.0022408831676126, -0.30709669435297293, 0.9065093574204486, -0.7859599830522329, -0.47050574353923313, 0.48612031519481147, -0.8935910137938845, 1.0746948433573347, 0.8528963737683496, -0.8516027850118256, 1.0881620264582654, 1.3315930055624778, 0.34359749988288624, -0.08785702542479466, 0.7569126416689327, 0.0019944505349799514, 0.1254926100740075, 1.1956932994445235, 0.5025571035727748, 1.0114692323572916, 0.19261616489021063, 0.7600549397126285, 0.44115675208406085, 0.1810893687968494, -0.5043517813409545, -0.6478621299828368, -1.118860240844517, -0.6906543651516006, 0.292944568134448, 0.9613176626201548},
    {-1.243055693349945, 0.7278105951348338, -0.7213495066005847, 0.3006179111761596, -0.01112388173248946, -1.1384920389285005, 0.6053938215851934, -0.06624126926739228, -0.10201203989033607, -0.6707436915240592, -0.04784312370139355, -1.0880311829049296, -0.6512768046218258, -0.06844158854669759, 0.12967119394910362, 0.5716154180300451, -0.13048639604990245, -0.9010645207725043, 0.16305475366113745, 0.2225111323309778, 0.14167480197405222, 0.9758719322429662, 0.6141694713005073, 0.8466139624267804, -1.3639594775422548, -0.5207278956273786, -1.2239968576211746, -0.7274377219164597, -0.7489242649009795, 0.9405102050409352, 0.8636377101210487, -0.2915386861366734, 1.0267544518515113, 1.2360559265050688, -0.7970271691064058, -0.6797774912147012, -0.4087698780710136, -0.9472311674166108, -0.30268116954438135, 0.8654100809274855, -1.2107748634695361, -0.2059752667728451, 0.22192602970250863, -0.9870832380646857, 0.3578634070089606, -0.10563927749034514, 0.9694831846113897, 0.4812199608873008, 0.8971986962251158, -0.7917952466740573, -0.9211581936993789, -0.9267248477980904, 0.3275372517085586, -0.01278888560878733, 0.5920534363400737, -1.4210238915907094, -1.1832744129278858, 1.3459185395995241, 0.46283703047664543, 1.0211483054042942, 0.7512532251181001, -0.21969845792433465, -0.03522911677595538, 0.6996022352488424},
    {-0.9013031158717855, -0.9982836095474973, -1.184859616469104, -1.1254174522065603, -0.7413063235713031, 1.0162638079624244, -0.7106191500433633, 0.6655353205816263, 1.1168170938701414, -0.46106382879213587, -1.5567460437528602, 0.4548993385788059, 0.37456328107101994, -0.7888726627998611, 0.7484663979528308, 0.11835410197174658, 1.1582244918858149, 0.4673575745957118, -0.7507029351396882, -0.6980218707176569, -0.30170385691508567, -0.5931536427269974, -0.9139019551611889, -1.2327490950551292, -0.13338162992429678, -0.33230082948170897, -1.241815989561335, 1.0815963219111686, 0.2836135116533118, 0.10242551112987941, -1.1802496374614229, -0.7002421899961755, -1.0477585300382755, 0.9784049801197223, -0.45247303400484407, -0.14482886942376677, 0.5715231631102089, 0.8216029021421228, -1.1564135180607964, 0.28965150772740716, -1.145816845736733, 0.9232231396079794, -1.2548914633875998, -0.5934205558898846, 0.5065883760237344, -0.5493108822076785, 0.21742966459875965, 0.5144555215578455, -0.4630451623908251, -1.2429088778024784, -0.4890610568461649, -0.11868517306087732, 0.06147435057197733, -1.2994675403733411, 0.7779013216460274, 0.11262022287806053, -0.4174546836490284, -0.2146529548366643, 0.3793220937930102, -0.9680188398174431, -0.7622565917470937, 0.10353657081718898, -0.4466059792234853, 0.40125649639505656},
    {-1.2300603057619204, 0.5762636007742155, -0.9035528095460529, -0.06732300500557929, 1.1095702839957187, -0.39212845089942977, 1.1877025714085425, -0.3170862940161232, -0.8031705865447636, 0.049320291544195524, 0.09971604161307933, 0.7273979670738501, -1.0144172269962315, 1.3799501456598662, 0.6110082140967882, -0.15437567962674023, -0.9248015886065164, -0.26524714731101046, 0.42587070457678644, 1.4364975121227428, 1.0776041649550232, 0.09957053082412569, 0.04860969633284225, 0.7152522634139473, -0.9633445587076551, -0.5692952120803249, 0.89199349791658, -1.144211234047844, 0.4486963696027632, -0.3320807848227102, -0.7563879508996721, 0.017360359389671197, -0.5505548362553295, -0.7994381247827449, 0.8892412309170625, 0.9095205493598747, 0.06796955810866943, -1.1255613282984793, -0.8225771571676573, -0.44799172153011907, 0.2788196866376019, 0.20478528410262384, -0.6958741968753971, -0.9259346529057, 0.8534543793914542, 1.0843184278822593, 0.26070205061358126, -0.5194539309093101, 0.09717396520117426, 0.3440153110973747, 0.03878239123816924, -1.0782740179849815, -1.2036746351195287, -1.1801311050889722, -0.3039667183059138, 0.20629445115826556, -0.500593793211432, 0.0629546804194465, 1.2651335246436783, -1.310397800111112, -0.19963756074829309, 0.3480796255026012, -0.8563309402142872, -1.438734273354298},
    {1.0644184783783328, 0.31018618614989, -1.062827334287484, 0.8985445758411293, 0.011754121113085655, -1.0090048409783239, 0.004586810162923502, -0.1555358191324317, -1.1112032951324498, 1.18921599122856, -0.5320327734371393, -0.8884108778692841, 0.9604072986906022, -0.08482586563120148, -0.6866325611823698, 0.6589971376823027, -1.41360597358582, -0.9243486988443229, 0.9028443123646316, 0.6274137857005607, 0.9211171004539322, -1.0322335721654954, -0.5851973305077349, -0.8640558283876235, 0.12312218562717452, 0.6037630943772199, 1.0362958162340228, 0.42739982291393785, -0.8784644189656996, 0.1347723927215706, -1.5817354252567488, -0.37374458979910896, -1.0844453783975447, -0.2541266033573197, 0.27976857762920077, -0.03861805349166184, -0.41342027966710454, 0.8628690395077179, -0.538258481140014, -0.8063128545647972, 0.5000596051029713, 0.843921944165555, 0.46297540390216013, 1.1382095538618873, -0.9895525588067275, -1.1709019791138207, -0.07139327568720846, -1.0262976175990255, 0.3020460513363675, -0.1299501368506245, -0.30095702931648255, 0.1866759131749668, 0.7294297516949777, -0.011801757092770654, -1.3099412136276694, -1.471718236352071, 0.9886774562120046, -0.28747399376637883, -0.9515508714296986, -0.31296425959740903, -1.0887014637621664, -0.032601138251205905, -0.5718383533630744, -1.633485102138798},
    {1.466150450460603, 0.4472865058567391, 0.27392819913476657, 0.11287346571458848, 0.8299865999600593, 0.6273837105650182, -0.4807833331252126, 1.503858690021538, 0.16084502478446294, 0.9707232525787702, 1.262169663353672, -0.19219514560509382, -1.2225323604044798, 1.048102005019815, 0.79115832259748, -0.3412586944955887, 0.840276456348063, -0.009198584223789974, -0.03147772919894839, -0.9561110670927923, -0.747796499897379, 0.6543804218192686, -0.21703537969584655, -0.5001928746657895, -0.5903201873212218, -0.38778223947717216, -0.26683101974758505, 0.2569154226988894, -0.6520279726030375, -0.11704274641459807, -1.0812600177799412, 1.496851120730294, -0.8397609006725343, 0.40113164731549134, 0.004245415438474732, -0.06404079414633358, -0.2925107140967641, 0.8295292800248749, -0.7166683567198335, -0.6663367851852308, -1.0657622589618239, 1.0433289271057813, 1.0677257094984829, 0.6938006183481743, -1.1721208226489175, -0.9068673044428434, -0.6260440698581061, 0.042791343352361955, -0.19711149427676927, -0.9259854897867212, 0.7967417001960018, 0.1851711003883493, -0.15220747601002585, -0.6599341097186684, -0.9374215936974272, -1.4735582254126462, -0.8083064752241992, -1.0903899424245875, 0.9496312658007728, -0.22463577019278172, -0.33847343130151725, 0.8054668746837651, 0.5656614927338326, -0.40190175714917137},
    {-1.034357101136203, 0.5676902321730115, 0.3375843527594303, -0.04667228663002077, 1.3781006572311603, -0.31398925008977363, 0.26700771742666396, 1.1037787906209453, -0.7722551097007334, -1.239752171533497, -0.8024401755690952, 0.19699579199383516, 1.538757530411141, 0.8979745471793057, 0.7235044300480323, 1.0732252382873504, 0.6889344438672128, 1.3821209492026074, 1.0322399179296462, -0.8329853589975751, 0.1160568645761252, 0.7494241894827712, 0.7463920306202804, -0.8737082990943932, -1.1677549929944047, -0.22636426967749815, -0.04019705258319793, -0.9706795074455506, 0.9135937509330639, -0.3163213698756384, -0.29674535472197505, -0.8564303358133183, -0.3404120461073335, 1.3230230655738204, 0.5027661275936708, 0.04265239775185743, -1.186169885158561, -0.42308105485827063, -0.6797482186859269, 0.25874227926409044, 1.2665029213659742, 0.6597087307311846, -0.5419259549496389, -1.050542739109079, 0.8606490504462092, -0.6370633175344363, 1.458136204403875, -0.8279388943703856, 1.0544947883226345, -0.6038610263750492, 0.9334204696888946, -0.6016391017452236, 0.8745649035597977, -1.1559540250680962, 1.2395102085359027, -0.6649722953170771, 0.5693334237173618, -0.29530611403109513, -0.412321671169533, 0.8013627988802029, -1.0217288372585385, -0.8803829639194752, 0.28935054955845185, 0.1012032263249405},
    {0.035700204347772345, -1.0314337833602931, 0.6360460694291782, -1.0468588316146659, 0.07807019592894263, 0.7937629113924899, -0.5461447224783392, 0.5843444252142184, -0.41293155497278794, 0.3293232672026085, 1.2214316453993743, 0.40011804361882003, 0.957684215172967, 0.6114167136854859, -1.4532250340150012, -0.4626656012023241, -0.6703072300392369, 0.5191871561036696, 0.4835382235849757, -0.4217801055842576, -0.7852508157274828, -1.0757348436240708, 0.0023162148505667074, 0.006082626694679669, -0.8870467724898995, -0.5740421195250374, 1.2091555013069015, 0.6613943618979401, 0.8983493056054843, 0.45781250938638823, -0.17298485685825216, -0.4224953491881016, 0.1022425664185131, -0.10196002672610359, -0.3152964953456646, -0.8385937693815955, 1.3143580381824802, -0.7944409501358861, -1.538114663749244, 0.8480913446380546, -0.3460637666884745, -0.4400573239450301, -0.9122628796967124, -0.19985515216864186, 0.07658793937205523, -0.4316047860031719, -0.979878238029586, 0.16643359953103168, 1.4254622828229124, -0.5599641882751576, 0.6806441091761704, 0.8851633172972015, 1.2355801326409144, -0.06753022670731576, -0.23743336708334087, -0.8007977728675506, -0.16224852073103205, 0.4628461148211412, -0.20098132545275532, -0.9744449181000752, -0.3483873222828939, -0.6485095817049684, -0.9162543656664406, -1.0816964358082573}
};

static const float b1[64] = {1.9901243997188622, 1.6678941007809656, 1.7465756382760196, 1.9362786605020863, 1.6689787678440369, 1.8429714467397837, 2.027220597006521, 1.6437537418409607, 1.7887267990496918, 1.8535062378378468, 1.921315802223344, 1.3267070856455734, 1.915651382163257, 2.0702481806694624, 1.9311985687348538, 1.5086208111152222, 1.718252312762872, 1.677623384280845, 1.8402813774869726, 1.4052859686792365, 1.7471433648899706, 1.925660106406279, 1.9965145182433885, 1.9733527649409366, 1.8540543638452895, 1.9404571149555736, 1.9020011438078608, 1.8798758118157515, 2.0665987047571504, 1.8773814265225164, 1.8464570948781278, 1.8514502700948974, 1.7917596362238777, 1.396961362780799, 1.5308462147146782, 1.9654998866563764, 1.980185324139188, 1.5730063582029477, 1.8156040386889807, 1.6296827574197408, 1.6927916104961196, 1.7443066802657954, 1.3041247013444244, 1.5393079552144235, 1.861074495349952, 1.651182802286243, 1.906245195757807, 2.0070022253520947, 1.9463286613426098, 1.7311140018872546, 1.9747963134342412, 1.9010947884921223, 1.9255188450537026, 1.4134216657291694, 1.4423809516573618, 1.906506271220941, 1.9627407789866482, 1.7767563250008984, 1.9567785224354877, 1.8882327126926013, 1.5552467697131065, 1.6697157456877652, 1.3424232894100052, 1.9243952494188865};

static const float w2[64][32] = {
    {1.161104209846144, -0.43819287254213646, 0.6193209760365327, 0.8851836704756586, 0.6955156375523829, 0.14319118131501815, 1.7998681894382094, -0.9355663455395481, 0.8534290639482238, 2.0290309509420648, 0.11053475439535132, 1.7267783302751036, 2.39660032639473, 1.9393522741824916, 1.9043691913484764, 0.4403829107654966, 0.7087268219244878, 0.5684974722369283, 1.064523357362091, 1.5978995805413627, 0.7728459518607306, 2.367036415199984, 0.30023189700966985, 2.095016783109542, 1.6718955939762594, -0.17284906395457117, 1.009532119882519, 0.5135294137808621, 2.1964872098334305, 1.4309987414895187, -0.9007650820159465, 2.036597497694448},
    {1.506199214916774, 0.5707020642186819, 0.14325306761082826, 1.3331537780309264, 1.6644480430592579, 0.1983881204682226, 1.8835942509704897, -1.1121330123240922, 0.1314355975863134, 1.961636592158791, 0.21286791849381545, 0.5714964737456091, 0.7006988183760153, 0.871393449581482, 0.9784831868777983, 2.0050435802940156, 0.8176545413632418, 1.9781835263741605, 1.0910916157993267, 2.2911838480506628, 0.5386475357847694, 1.0895126699904751, 0.1005667493143257, 2.5087397563096574, 0.8058168186417334, 0.8576736583300703, 0.3655506189211851, 0.6633659439443899, 1.5367099837294846, 0.3901742978274202, 0.39687094798698563, 2.0386394103245515},
    {0.5275785613074181, 0.06654633935050923, -0.3045952871335765, 1.5360160016596496, 1.5384074094238853, 0.7144837129866332, 0.9919093797643483, -0.982188033222491, 1.29955124489092, 1.4041857553232635, -0.8276487728417588, 0.4607206722356217, 1.8608640109256054, 1.307469822394141, 2.268107860524201, 0.39070155240766935, 0.8997386856556756, 0.623659205370613, 0.7839003085172994, 1.3162943434051175, 1.0477934833390867, 1.1271569117119342, 1.5950916550909386, 0.9334848033787299, 0.8397473039821785, -0.21416929171651647, 0.9592206857130571, -0.3203022656206686, 1.8787054465757462, 0.8423835762503792, 0.16494955375506581, 1.134058934351243},
    {1.210081277601155, -0.6389867352552983, 0.5724320654638404, 1.4908822093528151, 0.7848266928864455, 0.4403513844045037, 2.422639088298651, -0.3074489853035807, 0.2947544031006018, 2.5395255771554557, -0.744259268023564, 0.1458967673457934, 2.174698295280612, 1.914351335973367, 2.0169302808120153, 2.1027095367391855, 2.2454374856311827, 0.5664754089463723, 2.1201037812393078, 0.5857774105217776, 1.3926566143105796, 1.2192723955718012, 0.06230265758733822, 0.6802521075965371, 1.6579028200284227, 0.669928669130516, 1.399618665612149, -0.6498587024551268, 2.456121047564271, 1.4871856618430996, 0.03131955345636556, 2.1646194014935722},
    {0.5196563926089766, 0.7825634718307667, -0.41813283161353987, 1.0115790168592371, 1.5038175917355479, -0.43575652310854107, 0.7500644800398264, 0.31494925858681044, 0.6192332538601808, 2.1158901527801195, -0.2242624671994323, 0.18979926325783392, 0.9492033714051582, 1.9026369390037112, 0.7191621038325022, 1.58599916061374, 1.378614057513719, 1.156450498420536, 2.240388692391194, 2.1684051532615483, 1.8184418381252023, 1.9858933432243282, 1.7461460279316072, 0.7804244950638232, 1.7754875625621662, -0.8535131256911512, 1.8556016217315663, -1.122020369309671, 1.420084523603585, 0.35863793287864854, 0.3527479203589277, 0.9995897102492048},
    {1.2181479604366219, 0.3480572946397834, -0.4254253165862942, 1.786555463026409, 0.5604555791874867, 0.1464613777654999, 0.9617060135794204, -0.44490690348477474, 1.3791592160969077, 1.605638734581093, -0.8583869646372936, 0.6847025598776708, 1.9968130071885268, 1.7604153454656488, 2.3717506454653994, 0.4354160779772711, 0.6632947635498648, 1.7847788040562873, 2.3975051367402216, 1.1773496369123904, 1.7575334705755346, 2.272698491790699, 1.395480052103129, 0.6806910079942817, 1.59079903760999, 0.2973928746801944, 0.8104647706253757, -0.5981170404418009, 0.9305902969698883, 1.5231835867828005, -1.1232930815273923, 2.0142731711199704},
    {0.1906629669942938, -0.6917415789776264, -0.8727181661943278, 1.9292398437857223, 1.9677212773043182, -1.1482631683404818, 1.2399488800076206, -0.5996462442750474, 0.5393608411806876, 2.2983132884704274, -0.3043743400791002, 0.7503136581406709, 1.8000790964092714, 1.3999703707997122, 0.645465157869552, 1.8781691842248314, 1.1213573007102933, 1.6373741354183227, 1.4682254161860793, 1.412256306038015, 1.6448536671713145, 1.7260378427794287, 0.5450152444316911, 2.1256079245518125, 0.3236431749835531, -0.7263207675994615, 0.5545891811948794, -0.9425251087632166, 1.0289715780197404, 1.1089917534188913, -0.7676976288772351, 1.1592720220204806},
    {0.6358424051850562, -0.43028715432177156, -0.48977966705575576, 0.6376773941207371, 0.7526404809161402, 0.0049786155554065745, 0.7555842680388206, 0.3037139481177765, -0.05112361201170426, 1.108984468678592, -0.5545565471570338, 0.42044953101264454, 0.7410674447351087, 2.04408387386277, 2.262016775174233, 0.23648444278018974, 1.1895263029680143, 1.861267567161304, 1.8995067729850026, 2.1119665956492244, 0.6594977510024805, 2.4814452717867344, 1.3460830321166584, 1.2498435756157695, 1.024198419459695, -0.39499896798102035, 1.3659760203846198, -0.9430490794242337, 2.3164414697343982, 0.6089112201334649, 0.6469005437032634, 1.8420535460540757},
    {0.6636327562435077, -0.28738377202473486, 0.6897304999271809, 1.5539312059948236, 1.7661684153728037, 0.02794159419164975, 1.5258441973871337, 0.2421684137743684, 0.9378366957902147, 1.9849555140096673, -0.7825220722997408, 0.4618414326040013, 1.2404013876332647, 0.3808746170510235, 0.5755208282199028, 1.3674217077142687, 0.9105765312732286, 1.3862659175779823, 0.8540663463012291, 1.4427665035245925, 1.297509971498498, 0.8057663706085708, 0.1479656948418499, 1.9990230659239197, 0.3407628728229873, 0.41428757794013404, 1.9438231871103493, 0.1007091991162972, 1.2958931630429977, 1.9536503313492273, -0.3358958120336363, 1.1971719142313053},
    {0.3743239430951216, -1.0019793211306705, -0.16229948493025512, 1.7084041376975305, 0.8636510476934541, -0.22765013636355708, 1.656918259546267, 0.06976174533429755, 0.6911510435368783, 1.1214088132187905, -0.6380291995912556, 0.8896119043500709, 2.1646914964979906, 2.0548711970347067, 2.037486438974733, 1.556672956008026, 1.6313847560794676, 1.3184330519895382, 1.4060130656962282, 1.8975718793630667, 1.6728617261897822, 0.9811831137989873, 0.5978190853718931, 1.3391214867715724, 1.207256584993405, -0.5917911838228395, 0.4957516519534151, 0.24219378487971988, 2.275228864137915, 1.1913314687409853, 0.0387371663676452, 0.861481630858343},
    {0.7545629159278852, -0.07948086805321508, -0.43647629158299145, 1.7359322838160975, 0.8496738475498594, 0.11953368369951843, 2.2212320000959047, -0.7213261287821874, 0.3002435102522731, 1.410503585770051, 0.6701412127873263, 1.432665226346525, 2.4212924738200274, 0.8212481433263333, 0.8196088504291564, 0.7061714465880423, 2.292495324889782, 1.1782892695564255, 1.3896259798542256, 1.8194807066481224, 1.034393644942655, 1.319325855308976, 0.7000950305783663, 1.015192669469756, 0.30832318586432267, -1.1047435152721796, 1.3486982594830152, 0.3724604243501332, 2.031974218659225, 0.7226718391613159, -1.064122923407162, 0.5801830501001884},
    {1.4661616883428659, -0.3076786989648281, 0.059756688531386784, 1.5028551311619793, 1.3311208132503518, -0.6500169512065299, 0.7433280395893036, 0.026558769621957926, 0.23070808635743908, 0.5867196279906173, -0.10060478167579363, 0.678044417069192, 0.7012947353922779, 1.136486749030309, 1.3434407661728038, 0.9448266173342126, 1.3967213697296967, 1.3900964313977597, 1.7416901273739962, 0.4967759043562769, 1.3119620367861546, 0.5699585351443703, 0.06959396058654758, 2.1129262277781415, 0.1764989683439041, 0.08171568321032528, 0.482986268704865, 0.41682137475865416, 1.6895314810351625, 0.5543235647984501, 0.28227785182432297, 0.8566210762949301},
    {2.0377790861950826, -0.3264936408995099, -0.47554513717799096, 2.1350762886898664, 0.6215476365953179, -0.04430204484077589, 1.9262282175825078, 0.5762893593731058, 0.3120450504154578, 2.2472535506546185, 0.2693887637549547, 0.6434798701546439, 1.0163429139929903, 1.3065287460533919, 2.2654386145849634, 0.9996613855233839, 0.8980747851903009, 0.8610369729340486, 2.4644098477256886, 0.7476597916220987, 1.6295408971078063, 2.20237645056953, 0.0009434414179347772, 2.1067398143242593, 0.6522732114538398, -0.9445762918384487, 0.8905717491753429, 0.11179856028140304, 2.392229176671667, 0.3269750353660085, -0.1984204423697351, 1.3309774557963066},
    {0.0952675735603682, 0.907801830672602, -0.27584325411742405, 2.3278372024155884, 1.97320243776195, -0.17833154103061474, 0.8438938278952594, 0.09209698547856765, 0.275758222504522, 2.3768966058276337, -0.9196567998772884, 1.475750819227058, 1.9262536635674092, 0.7282377612904526, 1.710133918139869, 1.4140744270823338, 2.483243972727685, 1.8216397533191198, 0.8521784473356361, 0.6939160382697517, 0.34006795988835775, 1.0274092251613645, 0.24993835603507206, 2.5393283348231126, 0.4060599341260047, 0.009619542308912817, 1.3367497159041983, 0.356134598668434, 1.3038040155061938, 1.6363995571723282, -1.0352095662448437, 0.4378920970425978},
    {1.4201115537771325, -0.6487917478362255, -0.24039853829984917, 0.9151931843598778, 2.129203809543763, -0.0540327802144845, 1.3712437678049259, -0.8653777090897763, 0.7469232755791938, 1.1469506193694425, -1.0701949376743967, 0.27252136424441425, 1.2256782474970631, 1.6751023643051637, 2.214920632514992, 1.4546076214212025, 1.3497680960245773, 1.3944150531077348, 1.2624729214916561, 1.7225928904931638, 0.40939514162003143, 1.76249388894669, 1.6902446790744268, 2.4818588718281536, 1.0153839366741426, -0.6665416025865533, 0.37520753665106404, -0.4091112382369492, 1.5755218589320736, 1.4094203657532782, -1.218960192725008, 2.130805280365291},
    {0.9719636078280728, -0.6763837351124009, -0.6295791735941091, 0.97133253610203, 2.044527106024567, 0.11325830088435644, 1.501500994457598, 0.6745849366742743, 0.4239045492681098, 1.5583655903419549, -0.3623678594999718, 0.7328759655704309, 0.8249778070612558, 1.832909239893065, 0.7647005194256518, 1.1893622442408893, 0.7970591670831713, 1.1497471309948497, 0.9384883806602834, 1.996748918817566, 1.012061703366705, 0.9223960750849297, 1.5183542826906384, 2.3793459956059095, 1.5562165482531505, -0.47259483667628593, 0.8139581212003522, 0.4245019067860375, 0.620472675993513, 1.2207397708454217, -0.13527101966769847, 1.3376048764797133},
    {0.6404112973862864, 0.5570815789099068, 0.5462161227668829, 2.023581919460731, 1.828902068166015, -0.9643783373393955, 1.237083207870086, 0.5756077207932321, 1.4881100863234198, 1.4005102911390703, -0.19164237482165547, 1.1265517949393697, 0.7301037370168406, 1.9594701453639036, 1.1048910856768361, 1.0855956896461054, 1.345987526352761, 1.4775204408329912, 2.2750118727829554, 1.214623607432418, 1.3086767280706966, 1.8118696821484042, 0.5302792356382834, 1.129567197466371, 1.0811243528977998, -0.46162195916888044, 1.9781532281348224, -0.3854529417161449, 2.006293201685619, 0.7099335450242888, -0.2559793068350413, 1.507181375433673},
    {1.5623390498564529, -0.19495389173812164, 0.3778265457193687, 1.738906557498205, 1.0017842130696841, -1.0517490777847052, 0.8441240718255102, -0.713478871625558, 0.6023442896462624, 1.9405475674680344, -0.6650477835896562, 0.6303906858331506, 0.9438242285210584, 1.3405609339002176, 2.061329650859178, 0.858128360664313, 2.117778444634634, 0.9296580313058606, 0.5636355157173863, 1.8524330157073008, 2.1508357103923954, 1.1482617036909861, 0.6643306370331247, 1.054233246510271, 0.1712507553257052, 0.5370489083689703, 0.3708039731102418, -0.0889226871730383, 1.452959625129828, 1.9172453794121016, 0.7108153273606452, 0.44280259497256674},
    {0.21612074863244168, -0.06087035921074643, 0.04885746839578872, 1.02667310670761, 1.7746981031887943, -0.05146316133634341, 2.2697992956011888, -0.1262520186858915, 1.5929441841126901, 2.208419276947293, 0.019467224405409385, 1.2657365475803986, 2.028753672876165, 1.2308093010663288, 1.8245431096727476, 0.9594788213880996, 0.9898986063544478, 0.6685784497461535, 0.8532934314799449, 2.227726598201346, 1.773380586249689, 1.620895648967814, 0.3961706601750795, 0.640975539198517, -0.005059038674334365, 0.11220442625782494, 1.1352385074300633, 0.7769890193114678, 2.162587733702637, 0.5766521318167921, -0.49265721460701273, 1.8876254812522981},
    {1.4498820830736827, -0.8390081385798615, -0.6029504198638054, 1.7293250010368362, 1.8908379541046576, 0.4343357015752233, 0.9403562106477212, 0.6897905447024356, 1.2562590678061465, 0.9336655442050467, 0.0659518717778713, 1.2685428555202856, 1.6604173747477382, 2.0297354634759226, 0.8845745837528912, 0.7583038472280392, 0.7692960644791778, 0.9947880959384804, 0.67814286734932, 0.7360567390797731, 0.9572027741602003, 1.2385754939597104, 1.5231174019381786, 0.8067653527010271, 0.722848959774592, -0.34801841927146804, 1.9830495789251616, -0.30994001995175985, 1.877491400290458, 0.6426903866246851, 0.3101167269435684, 1.6684630598674415},
    {1.858938956817777, -0.8112006533149747, -0.7394263011669922, 2.004652897581145, 1.0974105677965131, 0.3112242162141438, 1.248718381631135, -0.3177167417168087, 0.7896716300194982, 0.9728160379524576, 0.09640421548639502, 2.088102792327407, 2.376556244826402, 0.4568655400357173, 0.6741220277104323, 0.5600898226707536, 1.7616648452318944, 2.102839140746908, 1.4840538859885515, 0.8727733201877546, 1.369856211263464, 1.9901993896028194, 1.4922296551120766, 2.2386410080186847, 1.4257034459120397, 0.6639843289162494, 1.166960329500743, 0.36523579021669805, 1.0976760788516629, 0.4383624521886506, 0.5987319399924889, 0.904595717762874},
    {0.7277380630469306, 0.7628544614720056, -0.9242280320625422, 2.5072146260003945, 1.2026987966957328, -0.2334176747115685, 1.7568340419538981, 0.19356758223995427, 0.4791320903499866, 2.0823886694614084, 0.17999897439026488, 1.525919900904661, 2.1686581128475972, 0.9021134492054373, 2.0437545890670474, 0.49789687804573024, 1.921901483357876, 2.1454879896867634, 1.6172523032533361, 2.0432349115869255, 1.9950625285753072, 2.382586729271337, 1.5763092034395287, 0.744017786585522, 0.736545369734094, 0.43211586694169657, 1.8312934665174725, -1.1134248403022602, 2.0850655200666006, 1.5522934280275915, -0.19315676489585093, 2.038630670319032},
    {1.58911592418794, -0.9646716515816972, 0.4074137959476222, 1.894231013040572, 0.8005558326456474, -1.0245941151638056, 1.8417377224747928, -1.0444001783861023, 0.22688868391240952, 1.5187999428799337, 0.36945262365506376, 0.625854878142817, 2.1976526681006865, 0.7286534691574882, 2.285545113456916, 1.853593142366956, 1.7943982955826765, 0.46490956706806186, 1.8844661391981479, 0.46548522511037793, 0.7960508935225948, 2.0182009740943307, 0.8635439120887445, 1.9152069667513263, 0.11686509558000356, -0.14784088569003526, 0.5976786255133518, 0.06549459121684544, 1.338782058939671, 1.8874272095359534, -0.2302605389519595, 0.9661270352420307},
    {1.7553132047393332, 0.08135641060657656, -0.1594473863245407, 1.8972743682935571, 1.3146247735164682, -0.6090327991125458, 1.2686075318149608, -0.7098077080582558, 0.0727933460782965, 2.509768987354138, -0.5234856976007377, 1.182725584854411, 1.928735834551979, 1.9406724322008013, 0.8809647294044343, 0.7398303377646469, 1.366895987273737, 0.37171709184830354, 2.2667145434043356, 0.8478485823028904, 1.8175311720888394, 1.146971520358577, 0.8921339003944403, 0.7193514820840827, 1.305258461978741, -0.19351558659017093, 0.14886393602954717, 0.2623477969040516, 1.6957835887396404, 0.8120896005397982, -0.005887166871914569, 0.6703333010439957},
    {0.9961550938821501, -0.3283177647638821, 0.14503300960069063, 1.643507692801305, 2.0020121069774715, 0.4499319226576125, 1.900999038277922, 0.23738281917591575, 1.6254202075897697, 2.1572063588408295, -0.5687209755091724, 0.1959009315435648, 1.2778899156501349, 1.075544471698433, 1.792218754531754, 0.6849917877658548, 0.7297296956388176, 0.8998002802458486, 1.8900560409943916, 2.256139997542566, 1.3905888342522719, 1.0323892302542703, 0.20558603003247838, 1.941169896575743, 0.15769029839419565, -0.9785654361867268, 0.41820237074103406, -0.02440558110255426, 1.3170755948698492, 1.3046338283120174, -0.7065140785743106, 0.9749547027406641},
    {0.9128254628565473, -0.3796948802201047, -0.37999677533051496, 1.4506801791181074, 0.7574554650829541, 0.20088221561831573, 1.4844364904359852, 0.5827184815732697, 0.6712646963260281, 1.3145752293969228, -0.8152031882842135, 0.3297422712876588, 2.233373058692434, 0.6271419755560561, 0.7961098950582894, 1.7922361942621938, 1.3132245059827112, 2.0156779209485967, 1.8075414445196145, 1.4702709218278338, 0.26953245223521005, 2.125133488890509, -0.10117031817217305, 1.483758819943439, 0.7274925261671489, 0.7322864799421901, 1.7514271596565694, -0.017362546907589323, 1.4737276270660298, 0.526064464747379, -1.1566040225981342, 1.1786864637756487},
    {1.6491937894455448, -1.0561940918079724, -0.6008792090429182, 1.7681693716211904, 1.3584704787539723, 0.7279565582876278, 1.2277735377516816, 0.16266202733547838, 0.8514936458922563, 1.4538596186062982, -0.040296633241965155, 1.0265128012933808, 1.1216878158904633, 1.7246144150901974, 2.271723434958377, 0.32538069697551564, 1.6943561062966612, 1.705638290417519, 2.0566796806014627, 1.1141872643478736, 0.8044097804589804, 2.3951921723499128, 1.8067551293744197, 2.279840158983056, 1.731397074366113, -0.41516739830393556, 1.5033833197022626, -0.5347665355074673, 1.1943097196331711, 2.064017826904512, -1.0446947231872834, 1.2475730722367468},
    {0.6868034393732515, 0.024205710448481344, -0.6371328476148144, 2.3550733103134927, 1.3616071444497686, 0.38807765755974405, 1.547549105109679, -0.4582151866417772, -0.020369140131426444, 1.0494463172419946, -0.8086397846822798, 1.4190043754980048, 1.7384474957959508, 0.9184080696721981, 0.9600203241745808, 0.22671706250618623, 0.7440341844153628, 1.1877788192380156, 1.1945050044943903, 1.0073005486482545, 1.2638580906632142, 2.1980138100319055, 1.3965517329007537, 1.2619352410655658, 1.0941545469324625, 0.15832742897068577, 1.611487032247323, 0.5420588160508089, 1.1261460648432917, 1.3201837185554102, 0.27924483719097537, 1.0851618459207615},
    {1.5851475946924445, -0.5635525944401264, 0.10254087430374409, 2.461899014019331, 0.7786374016557887, -0.6874256674968017, 1.3111161036181538, -1.0341042397747457, 1.0419862779437083, 2.3356755542485885, -0.7609210812108553, 0.6641069197990999, 1.3563577194707788, 0.9870643338396223, 0.6520766442158797, 0.7054043792078537, 2.4560316505622186, 0.6223712341019805, 0.7622950374940075, 1.241859000933568, 1.1831139732263287, 2.4358798573866633, 1.1928667066170373, 2.339360926406915, -0.06081637561993695, -0.3518242073617599, 1.5169514656274619, -0.25615025948193204, 2.253409628367889, 1.73383815830576, -0.4565913369800049, 0.433162974545026},
    {0.8799711029010846, -1.0847074448736527, -1.081557352581957, 0.5022361824424717, 1.5105065402951032, -0.7861899039756555, 1.075062520514395, 0.047105505030806336, -0.19056410502830348, 2.225279213656558, 0.724200333810508, 1.1653596450197854, 1.4098047788254597, 0.24354257792485587, 1.2533548504687855, 1.7494814348552354, 0.5570124844363481, 2.1765233100091805, 0.9846739059867916, 1.3155944545329084, 0.31111572748334493, 1.9131511038732818, 1.0460338195797476, 2.2558616970932084, 0.6500345656166143, 0.05595136202800357, 0.24780820094721726, -0.7375165353219627, 2.1714560085448915, 0.8794710919654968, -8.967232747300956e-05, 2.0912545797599633},
    {0.6492328087578368, -0.964902963265267, 0.5269294384744423, 2.4830837073560046, 1.1163222713321344, 0.346872116785311, 1.8414637828489548, -0.5376163097356451, 1.3839354235542225, 1.9864775123015317, -0.06992455127168816, 1.806434177918991, 1.770825859951099, 0.37777887594418413, 1.3835302332258392, 0.567744985537831, 0.6635000710492991, 1.2249781418050836, 1.5674196038043438, 1.7120722447488725, 1.734161365081147, 1.9323467661610865, 0.7076270424666511, 1.345532574719603, -0.027261190412870947, 0.18340340533943097, 1.1206946292098519, -0.28694084560985217, 1.0193134793074974, 2.1646060758507217, 0.5206753559920145, 1.2417000758463719},
    {0.5121657492133621, 0.08353791715398919, -0.4639351526945102, 1.492548367015437, 2.1422893104450145, -0.9568948836370708, 1.5439643413373567, -1.02935020179143, 1.325938252497441, 2.0700632557891523, -0.4647892502684393, 0.6932652516736044, 1.2691385049518047, 1.0783928997331997, 2.213319482975752, 0.27240226995695266, 1.1494591426447736, 1.5696100185302682, 1.3967536091704813, 1.8235858618619705, 1.2036798033773266, 1.322267317488974, 0.913890767425325, 1.3711047929631797, 1.4864132856855583, -0.39035143091531044, 2.020535342674409, -1.0647282318398665, 1.498845756042046, 0.44312266458733685, 0.6744768450836137, 1.5974469002168266},
    {1.4119527613746348, 0.15266869691030654, -0.35526588082237803, 1.2661751659021103, 1.7276521746206341, -0.0236513462492859, 0.7091115343528903, 0.08286303336639415, 0.20015883395463463, 1.9856562228794579, -1.1002155904916604, 1.6037259667982111, 1.6553271229854805, 1.467023492118057, 2.258325421853072, 0.46913280456878975, 0.7600991192638551, 2.1973966818113366, 1.0342415430185368, 1.5170848923332811, 2.031532658343324, 1.2084539304577468, 1.0993039911323284, 1.583657776235675, 1.0774328226781817, -1.0193196641230329, 1.7641813873793089, -1.0956971302106828, 0.9978867187296945, 0.5408988051404703, 0.4656283634392016, 1.0881765627292934},
    {0.8635464994993727, 0.47379312332111617, 0.29659270839136276, 1.9000940614544128, 1.6887718729755221, 0.3642469559566772, 1.0892954139485056, 0.22126826037443073, 0.24930780145838796, 0.9331421297834909, 0.6754292279079415, 0.730085143753059, 1.17891007309058, 1.6480008065305203, 0.8385011328060283, 2.082804486191367, 1.90462863855224, 1.7540731839380725, 2.266306492100162, 0.8323308815498145, 1.5307264255584256, 0.9709956429776236, 1.6555942704605109, 1.0984819139565996, 1.5301715526078759, -0.3357503657218147, 0.6497590989935859, -1.0593812584645146, 1.1450845628621684, 1.8842691782261147, -0.6134932168345208, 0.40980809827934417},
    {0.6809592498748784, -0.08922781298113805, -0.7030214260450298, 2.128171864500478, 1.401762415390862, 0.25837553014034154, 0.6627844932937641, 0.003693066740889354, 1.1998050181970121, 1.3954817680606186, 0.2218161280071145, 0.40553168838071463, 1.388707572025417, 1.447124179801515, 1.870408712330045, 2.0871812312824103, 0.6254737469983135, 1.1463610197546974, 1.2779910873677323, 1.2037228269775475, 1.7635590749976862, 2.3558999809590637, 1.7263034293347514, 0.8402241134771717, 1.4164483382517803, 0.06561967449788161, 1.164150410449768, -0.654263159142691, 1.0568808071100873, 1.8571922219762567, 0.5737819470864715, 2.2094870308787122},
    {1.8846352287857293, -0.7299985834566896, 0.45876527491825425, 1.187381740245416, 1.9313268062956936, -1.0256646111525993, 1.2133568169143563, -0.2194206072515747, -0.05043136310141545, 2.132369860937136, -0.5339647740325888, 1.3178694411876284, 1.1870511513048971, 1.7096219492807456, 1.709222108465273, 1.0811187311566657, 1.7845935960335604, 2.119854436651636, 1.5322629021885854, 0.5200919906444359, 0.5384172601734165, 1.4495610056996193, -0.13586258248849428, 1.4374178744019201, 0.7040441050625182, -0.9164557379048468, 1.675703526062101, -1.031195568945238, 1.7472805746974573, 0.4951724324534772, -0.3340404503074206, 0.9450690499802097},
    {1.4844413974782347, -0.8541642645113363, -0.6067519515057949, 0.8106283200599294, 1.864475293400443, -0.09979584921290126, 2.195289352077634, 0.6411220304301952, -0.31218437798926046, 1.291285058362679, 0.4553133346484251, 1.4710738802507115, 2.2671865645533336, 1.6664887667719661, 1.6261485779469307, 1.2737325799130692, 1.637950454707332, 0.9634784668982493, 0.5047615980334819, 0.33794220823288035, 1.77907670843074, 2.195021179433392, 0.3941847350166045, 1.9673284485684073, 0.49853051288863376, 0.2286162008222688, 0.51032240321659, -0.11313777389271563, 2.1079764962911236, 1.6074127274164935, -0.25633466498211266, 0.7739707101787352},
    {0.9096263347388878, 0.28672089895510305, -0.8223573994521982, 1.4771475873416802, 2.3348092298903573, -0.6853073474262696, 1.7009193583178221, -0.4563790409634612, 0.39035063460077934, 0.8121824872337584, 0.5225142682038507, 1.8452644516391674, 0.7191580397015234, 1.404543398735684, 0.8124437258035839, 1.947175950154442, 1.7899252838739275, 1.7296676297626843, 1.5144962241475803, 1.6654238030029005, 2.1783456440077376, 1.476101253895205, 1.1022750264579857, 1.9303919697153542, 1.7853464265274177, -0.5935186972170573, 0.3268793835789432, -0.47900222767237055, 1.696510229461505, 1.6510508395399621, 0.16656269264475645, 2.0007921663579555},
    {0.883686654570702, -0.9450022294423953, 0.633250009010278, 2.2132103566034256, 2.3016604012204236, 0.35630931466302435, 1.238595335165707, 0.04156093292623529, 0.18179134583004342, 0.9471740805727284, 0.6675914617812898, 1.7329724458454838, 1.7617208803095294, 1.4311864674145771, 1.612182140083871, 1.783068107747878, 0.5813138583375311, 1.5599131665426533, 1.4687462947445715, 0.7415008662537541, 1.2787325122159716, 2.1318614078627403, 0.20367190798162088, 0.9308101536924988, 1.50414933782839, -0.2417331555100045, 1.053459286870113, -0.2597865053363185, 2.156886918423632, 1.9989792297368871, -0.7045780793477383, 1.1720958754533097},
    {0.3104578527764976, 0.6886929111892056, 0.1021814414998735, 1.0839247754152952, 0.9536455130452446, 0.22245760713138885, 1.5349503500169306, 0.6514867622209587, 0.17264837741736194, 0.7600384273117496, -1.0036173615932698, 1.303609418876733, 2.308765287637089, 1.6941514776439086, 2.0192937894769822, 2.0698800608983494, 1.5422105297724875, 0.9979771229260593, 1.437643224378011, 1.7437426239243405, 0.30066267613456504, 1.972563365342412, 1.5630511503490367, 0.5588400934836831, 0.4522094862472928, -0.5835252466559896, 1.3161373374740921, -0.47148142028060935, 0.8223521984576063, 1.48581538085739, -1.0092119813007712, 1.63432241111599},
    {0.7307532168150265, -0.5960298305309055, -0.49334808804084906, 1.156532129932353, 2.1971346009339436, -0.48251443297550906, 1.8436863518206552, -0.15772233972386457, 1.2748578418497436, 1.9019054914715872, 0.326704906480799, 0.4795242072924005, 1.9087016836861515, 0.5582135201380088, 0.7626918774367477, 1.8520124108649896, 2.440866402078572, 1.2144018973794775, 1.3010833658842065, 2.1354491177894426, 1.0602042899178241, 0.7684511628235962, 1.0850311901215433, 1.3105667539284551, 1.3912102411958915, -0.5339155126620669, 0.6848583688408396, 0.5449344634810139, 0.873199389902448, 1.295207127973398, 0.08258123696094237, 1.2162997601760732},
    {1.6198449731275384, 0.1417226785586277, 0.40817032665099845, 2.03911164744259, 1.0613353911374073, -0.6916663268528569, 1.7114898039207702, -0.3912793021686467, 1.3155666184467498, 0.9641312895838444, 0.2951856049657412, 0.15914499279815697, 0.6630149152057817, 1.4851996648003891, 2.3189422136970017, 0.6324781882398365, 0.5474628308262234, 0.768781469958954, 1.914926682821591, 0.7497771301470145, 1.6986714711619102, 1.3331886975521554, 0.1618021755667194, 2.0877636752423223, 1.2611760467909259, 0.0785550897653436, 1.3556925171577614, -0.253758668849985, 2.418874034337487, 0.6441241179173574, -1.1610696010445685, 2.0736874354165735},
    {0.8712663497652114, 0.0014970119528859409, -0.26225559728899245, 0.7397333216812395, 1.873717476082275, -0.639819800621851, 0.6347987626073426, 0.23983017771836107, -0.35460131502103465, 1.0781322728191693, 0.01998353887256372, 1.8095288699522891, 0.622713740915511, 0.36261453836338703, 1.4124892312492556, 0.5067895825956074, 0.6349455312031647, 0.5141327522939403, 1.896101472255083, 1.194287261877798, 0.4269592669355636, 0.8526049157453124, 0.8066775741675557, 1.8042085948205082, -0.19157426206590927, -0.9900627672012218, 1.871627990309522, -0.2920193367741151, 0.9602279722069542, 1.0181408495485664, -0.7697360192135052, 0.9140922403669348},
    {0.4084462023968288, -0.9379243806787718, -0.4380803971500381, 1.4348649940900613, 1.0396115633236513, -0.6614831306651324, 1.49445860911215, 0.6292205331527089, 1.2577488426224808, 1.4888997185442558, 0.14626426407078927, 0.42608491970828255, 0.758388952488044, 1.8433080525461358, 1.127313297994415, 1.5458114979523607, 0.5625670293895682, 2.124745683786608, 1.6685557703751315, 0.6892102730921719, 0.957922418927238, 2.418005717611531, 0.8946069449159456, 1.3036039403722537, 1.5370707049766121, -1.065481526550317, 0.6095012362998067, -0.22170295922651595, 1.2510372284393005, 1.4844577071734035, -0.998421664182166, 1.999553818372046},
    {0.2824994063266141, -1.0242508974000744, 0.4145140126234003, 1.708773891910786, 1.3026036537879884, 0.34465246117507053, 0.7912307297951806, 0.3046623550277251, 1.2591837769245842, 1.551920328958616, 0.12175570154795799, 1.2824568694538947, 2.0707010844944835, 0.9748871476862238, 0.6774876122074168, 0.15262434388805315, 0.8744920283037018, 1.6732139776700352, 2.2100700680697503, 1.5241933910652483, 0.345344434537557, 1.3591680278741523, 0.925363595214716, 1.4368023871727875, 1.0894520026169277, -1.080241442751657, 1.2815483592014978, -0.32414681294945646, 2.3455402641765244, 0.3700649237540237, -0.755058817262381, 0.6381241683908975},
    {0.3458849913261829, -0.6307462867837019, -0.8484707138842968, 0.7666454128590275, 1.251897425175631, -0.21220019003092894, 1.348582537853153, 0.18036428996725903, 1.341463980120735, 2.401100951239355, 0.0016111795401123922, 0.6598914337516423, 0.5814120759711809, 1.6534846539981356, 1.6921825148427736, 0.63709265072332, 1.1620280648126147, 1.3804483138210177, 0.7405378387716364, 2.0891001791538364, 0.8623780539825934, 1.1211701376882528, 0.014321079702827652, 2.2091710973053362, 0.9515803862666248, 0.7201024057655365, 2.0562317374555557, -0.3774410597696387, 0.9561592214092931, 1.0709543932054015, 0.07772339840321822, 2.0406371689891905},
    {0.31968667253297134, -0.7898221183023849, -1.003498295405529, 0.5264589014445897, 1.2312649155356745, -0.692808360544486, 2.2416980100026715, -0.19992603510251208, 0.9423311994352268, 2.4411863071525914, -0.2185717573650727, 1.9363148606943013, 1.0711334391931293, 0.8297127379447172, 1.0406862352089437, 1.0332250541569918, 2.1369898583010465, 0.3785971032564706, 1.0695866981762399, 1.7545533285076786, 0.5104175480596614, 0.8813889271473593, 0.5480658462560529, 1.9259663034338108, 1.3108279953461568, 0.6905496687992926, 0.40713851121960987, -0.3299761880848967, 2.1324437263514295, 1.8494603552687443, 0.1001052351877651, 1.5038930621568671},
    {0.11113862708208928, 0.2584728637783035, -0.5547172428510264, 1.7833682929789987, 2.03227726448181, -0.7193886974394514, 0.7954551164411083, -0.7253106735466959, 1.0248827258256055, 1.9027138528045138, -1.1311364068347831, 0.2504955931286742, 1.9252427585401604, 0.7638899287445456, 1.0996574012132727, 0.9030391211482413, 1.8589780391129171, 0.7167656086433513, 2.4415212594002584, 1.1616268851595877, 1.4240841081597821, 1.9210911011318643, 0.6521767775824331, 2.0119794120298335, 0.5296751677044104, -0.8861888375932117, 0.5364345409579698, 0.33189904213246824, 0.619385487810917, 1.7239646897956684, 0.5436383931755508, 0.8907350462057622},
    {1.1529909674662917, 0.43311002269375404, -0.6593846618096809, 1.1954865254393399, 0.6638834588318059, -1.086230615926423, 1.2339207694223242, -0.6137531012025481, 0.5575170013420737, 1.8447704860228633, -0.29516294284149125, 1.0943506220926185, 2.121383870135162, 1.18312633053048, 1.609811712112428, 0.9494830072370245, 2.246319341771037, 2.0423441849311996, 1.820385058582395, 1.2000617409351069, 1.1747754472630314, 0.7672499286008905, 0.336585188885854, 1.83492377925721, 1.0243634025768606, 0.7717139064894242, 1.9207726483466558, -0.3699886565658354, 1.8385722818822106, 1.6476722827089518, -0.8103037683393407, 2.273230243285944},
    {1.6610137748926808, 0.9233980731955931, 0.22676512400154622, 1.2046563834557125, 2.019726277538891, -0.8074980543849286, 0.7115136840615037, 0.31839446176951186, 0.7917407873691398, 1.72561261673819, -0.345184235359243, 0.6817031520503621, 2.037719096581669, 0.784185976349697, 1.1815295553098435, 2.023883266446385, 1.373543224166904, 1.2643081071919768, 1.078501578627618, 1.0871730032641778, 2.047698104952388, 2.4180943994002755, 1.400657843205252, 1.0514739472170753, 0.40786812092498126, 0.07378518121013361, 1.6956186847791404, 0.7303296644489236, 1.0102460717230446, 1.4514705061299573, 0.5862208671662962, 0.3453752084158979},
    {0.6376693917031312, -0.6161959060327526, -0.5438856165734942, 2.3876621987347217, 1.0651890051702917, 0.06636009624728387, 1.8132191042367731, -0.6434023466494592, -0.11044453510000185, 1.1542693329230487, 0.19151271939358522, 1.4512603668042832, 1.8848052799110853, 0.7512281158140266, 1.1652586538273089, 0.9642465228597688, 1.9343553458778082, 1.7943714382153662, 0.8774842768921937, 2.3144263672919405, 0.9579796442555336, 1.7475568822745666, 1.6127391494379562, 1.9031968211943253, 0.7079735795525192, -1.0559664259538282, 0.4775816597218401, -0.416912819190136, 2.3941909273604995, 1.1077947459799977, -0.9382007587829769, 1.554578237497127},
    {1.4194544858352707, 0.8531538062169637, -0.05052246751507136, 2.4377940721804543, 1.9430115978090696, 0.5267581300860433, 0.8549787939984176, -0.5489174791313273, -0.36401102187173867, 1.2651719598585456, 0.5484144975838332, 1.0863511856586816, 1.8237667118703234, 0.42558048196418324, 0.8886677690461061, 0.7391820279723638, 0.6533319620562557, 0.3854165640477878, 1.9112197586363753, 1.180444458900074, 0.491557411947837, 1.1270602659229003, 1.762356376397319, 1.715913349097206, 0.4755595729213062, -0.8164483964320418, 1.1102776543986415, -1.0496945159263917, 1.351221109566214, 2.223783793937422, 0.21114396510792452, 1.435196804295379},
    {0.020553385429746367, -0.9291027268961719, -0.46353272108510485, 1.6343699593136103, 2.2400350601448786, -0.024499963183763938, 2.1880837272798943, 0.3518795616470034, 1.4863177429632195, 1.5808041726924347, -0.08205586819941159, 1.0468512174712494, 1.957818827558984, 0.6464251844849644, 0.6904598952471506, 1.6452124505348624, 1.3317496836265157, 0.5381040014854138, 2.428050454394234, 1.1909115262757763, 0.239207031736079, 1.5696231635253322, 1.5003368246515423, 1.4203072150788658, 1.0942346568183905, -1.0991754320902378, 0.21464596895472754, -0.8168803270655149, 1.9512893304078005, 0.3448476986728597, -0.5512875302526573, 1.0976862004336518},
    {1.675510396947544, -0.4303890220415552, 0.40607319011395054, 2.372888524701636, 1.080628001045107, -0.19983432857207947, 1.3003006931730958, 0.20495416738191377, 1.4318453022344801, 0.8109481365010159, 0.7235253917327569, 1.9151925017079259, 1.4774135939819226, 1.5971023814682035, 0.7845093701076211, 1.5216409803417472, 1.7284460685542087, 1.7276867564618805, 1.6977728249684925, 0.46491262416199947, 1.4966403881570132, 1.3088859212319384, 0.37433148464513377, 0.7224896676668785, -0.03082778489123969, -0.17088533984016144, 0.7248024174073092, 0.10739562549376336, 1.2669690258381023, 1.7836807832290231, -0.22817244794060149, 1.3480188541909015},
    {1.7090962430340244, 0.5180958662936317, -0.6031878537792029, 0.9404947870056944, 0.836399987509255, 0.04288047373266948, 2.065565049869351, 0.14117079984181996, 0.6463749459975897, 0.994812031030359, 0.49190491720926005, 1.4728024540569398, 0.9568341846278612, 0.2837645621415302, 1.082243010860491, 1.720878333406264, 1.870470875648095, 1.5660280509970437, 1.628974219180033, 0.758387385688989, 0.9314702138701147, 0.8887934195719454, 0.25365308335500875, 2.292771379051192, 0.04327023273150706, -0.7917472095737491, 1.818247174995537, -0.7269734537290176, 1.054635428878265, 1.0316751111553164, 0.01594142211138641, 1.0415128234255069},
    {0.7839940968802149, -0.9651396693229252, 0.7583010297684105, 0.6893086893534514, 1.48390469937261, -0.5605107474243969, 1.9173634489085984, -0.5644467053757322, 1.2057932056739145, 1.295015687706446, -0.9080760409638584, 1.3880001931998014, 1.5286093459707502, 0.79465358365355, 1.3816804078397138, 1.7398302434663857, 1.6978096398362796, 0.6773724235113853, 1.4182178275870057, 0.7281658956858773, 1.39134082132211, 2.1167316588529173, 0.9626555321745488, 1.5011896361911798, -0.10180910380736444, 0.18382256545005243, 0.1995290926227056, -0.43640332155338096, 1.0730360059238413, 0.8691947392310063, -0.9000968460327307, 0.38435795328211825},
    {1.50519499740435, -0.3294472869617901, -0.443083466066275, 0.8395023335028473, 1.2185834890089497, 0.22167878037232236, 1.7833249623827276, -1.1534764062126035, 1.4171654694469997, 1.7759205767283655, -0.2346987688308343, 1.57704989874512, 2.098085967688835, 2.2697246061577574, 2.0882564816410456, 1.6446135619044204, 1.7554302413668572, 0.7714956301871061, 0.7585870459433802, 1.3070896151236404, 2.1676182499522128, 2.2540990996561505, 0.32079353265715227, 1.7512683953667882, 0.6534928742356401, -0.1560122899533327, 0.5461635117580603, -0.8621976516094328, 1.653351301662405, 0.4329633904682714, 0.22479584590324453, 0.5625330400586441},
    {0.5380442100192506, 0.314413066582635, -0.09563340298977574, 1.270478439635483, 2.2062512170001205, -0.25249802899829404, 1.3926253555663644, -0.5398057013899591, 0.23964588243524812, 1.394774337753518, 0.5712346319068331, 0.750061413686603, 1.4413179935336908, 1.227342170553762, 1.4216405473851284, 1.7752906849427104, 1.8505728369456858, 1.9815120593380222, 1.0166050235408803, 1.2639757068237143, 0.9084269550211648, 1.3886400817579396, -0.10422937391584637, 1.249894464721622, 1.0212979152883104, 0.1266125962624576, 0.7610382346546182, 0.39080847804674923, 1.6137811408254388, 0.6600029396182555, 0.2716819697830167, 0.33825482302732807},
    {0.8467423246344635, -0.5918351337931635, 0.5454083219885391, 2.0093706892306367, 2.159889142889553, -0.9222756095556235, 2.1823416942885805, -0.3935533070110626, 0.37912610362350546, 2.2040354198726235, -1.1101315360490405, 1.6064502245831278, 2.287904464423423, 1.1143008977625373, 1.0745619836383726, 0.32495188649743156, 1.5495073174583385, 1.042336980033299, 1.071368575869828, 1.7932447462576702, 0.6133876771387897, 2.2764719408999796, 1.541802533789561, 1.3868119245628951, 0.10192810121479667, -1.0079084063864785, 1.1666727238294996, 0.29544521116534506, 1.1549114909247484, 0.38875666237482115, 0.599378107566893, 2.0148650652380384},
    {1.0144179206103194, -0.07553282744451534, -0.06578458934013526, 1.4417184849455063, 2.358317842593718, 0.22173301549214575, 1.7801660326224447, -0.23484299388795993, 0.7850111795288459, 1.797459693581005, -0.883774535288192, 1.1239938729717351, 2.1795920100568975, 2.081821141009088, 1.6409707422704907, 1.6953178341551203, 1.277040997842408, 2.007075258641358, 0.8310491693688979, 1.3146362066896644, 0.7340172893895426, 1.6804656166432719, 1.6480143456260088, 2.503880793979423, 1.3053634530557106, -0.617684314415249, 1.9795546044085162, 0.14528579081690202, 2.1513071340097505, 0.9506728938393552, 0.09805127408039233, 0.8321362013264412},
    {0.6291131038763934, 0.7588509901404633, -0.13413586853717166, 0.44802120130079237, 2.4399002335051687, 0.5651470558451058, 1.3883636179208272, -0.2551105940047959, 0.6495081560370548, 1.7423087328001867, -0.15770483537171948, 0.3820825899713265, 0.7285825557533034, 2.0276685868791224, 0.692171637502914, 1.2786218975365855, 0.775713990373549, 0.46934338192231595, 1.757852929210861, 2.17557180969698, 0.9568704502182056, 0.8473773706265246, 0.7689093621959648, 0.9649704977448371, 1.2405256919957797, 0.11196912103060788, 0.15436662446075314, 0.22026287838376649, 1.7997595701374176, 0.9932334131066017, 0.6312393868205634, 2.072651196305661},
    {1.7465068527529968, -0.27222253613301683, -0.1253838244313991, 1.4522188779415144, 0.541711334712539, 0.47901168633250346, 1.8166677388438803, -1.0234547650786212, -0.0615014507309045, 0.6839894164866742, 0.41033994737899315, 0.8748854841349624, 2.0270535345574876, 0.4458109527976492, 0.7307217300261478, 0.26707013619193504, 0.6765193583535228, 0.8419089739243052, 2.1663502988550833, 1.8477043756379479, 1.9426265107676093, 1.8353467220926099, 1.4336173496542224, 0.888333615682913, 1.3102343526888625, 0.5794294922487481, 0.8459799523741275, 0.5185588542908757, 1.9763319896939486, 1.5738093810530862, 0.38844833123145206, 0.3577097059432508},
    {1.7415524182825095, 0.5282827941185931, -0.2760196873921435, 1.2689621806206877, 2.3057057333464925, 0.3289615867744523, 0.7505562724592655, -0.27756468903872034, 1.236371031518057, 0.5846186977921398, -0.42166282281584294, 1.0910399768192334, 0.9610751402198788, 0.8381581808589598, 2.3788308833609584, 1.212845120468694, 1.6031215896407123, 1.8581409080339746, 2.331362360068744, 0.3003914790060209, 2.1207908621085925, 1.0479753714219604, 1.5036806266373326, 1.3446673353621574, 1.5641158866666267, -0.9483112144529707, 0.4454814481605074, -0.02429347548845965, 0.6154999615494788, 0.7816649547063652, -0.505268679600926, 0.5376411892870201},
    {0.1614607924680896, -0.9160236405865005, -0.7081614591756099, 1.2079754415573876, 0.8891107368807424, 0.12794050762083756, 2.1739082050872987, 0.46743234691688673, 0.5426768887705421, 1.8823669997281611, 0.4655888701037298, 0.4748388318285796, 1.9556974279246282, 2.022783784971246, 1.6636009908309477, 0.5307629566131644, 2.244607047914117, 1.6764490102159066, 1.2594352475116684, 1.8817435044436615, 0.6545799157894888, 2.3200793769282577, 0.10432305857038224, 2.4444629633063424, 0.3335943249400895, -0.06397597420099348, 0.7733323111117966, -0.4715554784019288, 1.3172460154242156, 1.9702839825685707, 0.24450259103828156, 1.3470814753874005}
};

static const float b2[32] = {1.203161008331221, -0.18786053621251753, -0.2922333456791641, 1.6570105912782096, 1.6690387008363063, -0.27064625611273024, 1.6312338123257475, -0.31679219341621295, 0.7512225954362332, 1.6917163313815065, -0.31853853448525615, 1.381420344752854, 1.7059046412156795, 1.442016946361883, 1.611630935101459, 1.286538234189892, 1.6992139097796544, 1.4103962284860636, 1.7114041685595278, 1.548518319500544, 1.3809903524291438, 1.7581218333875954, 0.9468400856759417, 1.7936800687482217, 0.9404928862944312, -0.19018547921280357, 1.3191385653274412, -0.29428040563312186, 1.6451303575674663, 1.5614983175064174, -0.3753265004283071, 1.4357619842766736};

static const float w3[32][16] = {
    {-0.018555994563796106, -0.9786505694891668, 0.01870258438744024, -0.37669394672633805, -0.4996002827706425, 1.0194521422000453, 2.00991031528627, -0.7882116678853415, 1.854148011182048, -0.7651141486174181, 1.2594157693187256, 0.9821952251467739, 0.7746358609414122, 0.5285142755671075, -0.8720209816846525, -1.022646848474177},
    {-0.008436335118602818, 0.5458516222522486, -0.3380814441643197, 0.7994434275553942, -0.0027055824904164785, 0.2578273951893652, -0.355894969205133, -0.30132296379267137, 0.19026641533723646, 0.037436153843583016, -0.9343775731535213, -0.26642374700710686, -0.24406561770792026, 0.4911561243691456, -0.2208283831895097, -0.0714128499496449},
    {-0.30053511005803774, 0.23472151199644656, 0.8191488378954291, -0.219356821582238, 0.24884509206957633, -0.5128420790921372, -0.36370404245871213, 0.145401573336735, -0.022006496508283544, 0.46297122902580695, 0.3665832518614412, -0.8013533394997103, -0.733131444500366, -0.2027886720652011, -0.7903560321531894, 0.09449661943505887},
    {0.6985048360687651, 0.41210979188923214, -0.4232626524597076, -0.6676597852136962, -1.031178954754411, 1.9556857358218356, 1.2140059844261113, -0.24349207361757783, 2.25750416700984, -0.11874598576081807, 0.816358873634485, 2.4506074990306255, -1.032633545446991, 0.0612893064715052, -0.029886484112610124, -0.4140851479315926},
    {-0.3118000865446687, -0.46787380030065995, -0.30676957491820417, -0.4816365272712315, 0.17059305859287258, 1.7524626811661608, 2.4792406925005377, -0.9908005670121535, 2.5109985734407543, -0.6335576518724326, 1.7136635068731811, 2.3807171587011884, 0.8171378290969955, 0.6620492089495192, -0.7966678014080594, -0.5666260509470995},
    {-0.08284767691918131, 0.21769150037014287, 0.4463023863072515, -0.8943166128617809, -0.7010910774629622, -0.6272648590542671, -0.739799384750994, -0.10516650209361098, -0.7530999216924795, 0.3154799553700103, -0.6316678964365766, 0.30050629116656047, 0.2184671883102171, -0.6555828637716125, 0.28178261267794646, 0.46322651986045543},
    {0.12214320859998229, -0.2999994123103241, -0.8218645079810227, -0.7721590536563151, -0.6569759896953643, 1.9227786085645826, 0.9387318260965982, -0.5575893457995529, 2.038194391808125, 0.12398266001436226, 0.7408638570918518, 2.419935298863457, 0.5462594566425155, 0.9032102240830733, -0.028611851863633322, 0.4103510000821489},
    {-0.30351206031654526, 0.43691238220176626, -0.5616378749557438, -0.8527834375304929, -0.23980547055800083, -0.576925641789866, -0.38289549751738544, 0.2307820874372688, -0.20184287641966503, -0.00989119873887816, -0.32116721542608473, -0.8116008030572759, 0.2108086045883701, 0.09751963002315661, 0.5182105312931153, 0.6762275435631432},
    {0.7266659933196645, 0.8477228128830601, 0.35575467230899144, 0.6125570749335988, -0.3626724777319904, 2.204224129881431, 0.9874171558233742, -0.39264531361506355, 1.0443052884670332, 0.8876209067053377, -0.016177054663014424, 0.9028406805900538, -0.25160367970958536, 0.5376200236630201, 0.5556849273750991, -0.7508280648656378},
    {0.024664976994411655, -0.9588262052471963, -0.855009993408229, -0.5120031266444997, 0.6041185054686905, 1.2856510222922513, 1.5728530766441644, -0.9118134178407734, 2.729459386065232, -0.45574201446356666, 1.061631959174578, 2.4742814853976878, 0.8642060116948673, -0.06013988629732946, -0.5451760463294623, -0.9891575920085667},
    {-0.9029037790229146, 0.7369699785119675, 0.4314066367738542, 0.367282984237739, 0.25870737386368925, -0.12728016361583375, 0.6884086730899379, -0.09632700626975972, -0.0957230690854078, -0.38677311768269285, -0.0261651102214162, -0.7086385576091493, 0.37928539324369254, 0.7670534010172577, 0.169921132245661, 0.5452539801693375},
    {0.5627573762358838, -0.6623337483051653, 0.41071734741103955, 0.08872327131632288, -0.5974210456515925, 1.174080861805284, 2.43973683225346, -0.2505778750093895, 1.9077311022981984, -0.6753000827354811, 0.08217932160360586, 1.4256105652058657, 0.5842283613714389, 0.2549862057903067, 0.19146901292514493, -0.9755601896063893},
    {-0.8928844543681326, -0.6489202175084171, 0.6734181713588024, -0.5141964267315987, -0.4330962695045558, 2.072154506245489, 1.1355913546270646, 0.043313520593737435, 2.3288992323027586, -0.10788986852641921, 0.37450863039690374, 1.5473691468828128, -0.8386751687989095, -0.26616336752394637, -0.2994329544699076, -0.8995051987574463},
    {-0.4519232495245679, -0.23373110568247968, -0.718140815947033, -0.6573740021714226, 0.7922934651846849, 1.3378764462735306, 1.6785757894567719, -0.36881587942917815, 1.5747101876466874, 0.8343440952810405, 1.3288717799713314, 2.0971948922672596, -0.8802271424184286, 0.2887065961896603, -0.9510961286941367, -0.6296465652239855},
    {0.1983898493679372, -0.8520623175941051, -0.29991004326258086, -0.555881943979124, 0.3346656818221264, 0.9657146404798501, 2.4616582253077044, -0.47129565416066443, 2.278935820643881, -0.24565710563401078, 0.6664643932600564, 2.0196026712190838, -0.3198536645369072, -0.7716097710870998, 0.11642941603816721, 0.3074544406657659},
    {0.48589199969635655, 0.2983266262603648, 0.7119625889895119, 0.07620645494070269, -0.10075238590670586, 2.2644392422664743, 1.8309854780589125, -1.0280486031317615, 1.3937744070515428, 0.7288971187745817, 0.1421132792050409, 2.422627612748246, -0.9827514430493633, 0.15137213146033873, 0.579923362213722, -0.40435667959255317},
    {-0.6847715863377966, -0.5879189401384859, 0.12277562100482395, 0.09955649578263327, -0.7734279362895933, 2.4027071409646292, 2.136518991825816, -0.1284192205525847, 1.9847998575272359, -0.13564215834517113, 0.6449096898012385, 2.4069291240749076, -0.9317043995970951, -0.23649919007678027, -0.7672205207898998, -0.7397857930116558},
    {0.5965924921586175, 0.47381553263065046, 0.42760573424828596, -0.006332940348434794, -0.1506421303746506, 1.6988911552741541, 1.4250418665081523, 0.7722685295916367, 1.87145541438015, 0.6352970177561255, 0.43811356850668676, 2.126730563690259, -0.05498112662686138, -0.1549561816156163, 0.7053921048212526, 0.10252825104878911},
    {-0.4432307212456296, 0.5899046408745338, -0.7882130407722253, 0.318570150967609, -0.9359141126199679, 1.4014858771151195, 2.0886441040473898, 0.6173286550745686, 2.2289797132024267, -0.442706006177304, 1.0722362249087338, 2.09235907761636, -0.19704103718732627, -0.17657548464912304, 0.14036970029178705, -0.6505139021803518},
    {-0.7793827681842209, 0.316498487298283, -0.29972431379895326, 0.45585229133273214, 0.5145967014545946, 2.703289932495146, 0.6820428192032728, -0.3469698320836614, 2.5279619476594526, 0.21188660109975269, 1.6742159710500901, 0.9963543180280267, 0.47396798290347825, -0.9890282805362818, -0.46918133913299487, -0.8681323609208926},
    {0.8126088766787852, 0.036306397606249576, 0.7699425973506804, 0.7765035569340205, -0.3574614963770984, 1.2415335694355385, 1.8735256142399017, -0.27166763093053453, 2.7348742525005107, -0.7951353573167848, 1.6985426747327874, 1.6103987754711568, -0.219352494936249, -0.5500146284320396, -0.2913192402132907, 0.04618333969850116},
    {-0.3487608917499118, -0.023552195992197326, -0.0963670533348989, 0.7032443408130499, -1.067587557371432, 1.5717493907889117, 0.9339382348987421, -0.09069951027643032, 2.095012617870908, -0.8616672905924059, 0.375071287503257, 2.382368298377274, 0.006703290091862989, -0.915334039442658, 0.18722904914251032, 0.4766543218260317},
    {0.6847752342759366, -0.5182307146146286, -0.24303985027239933, -0.45258318891759675, -0.8736584795281577, 1.770540059610383, 2.16983747683749, 0.6800022935693856, 1.4074816955494351, 0.8725307941280265, 1.4029812289887682, 0.7669617675756495, -0.03811918667219659, -0.31118410611159847, -0.6393092814360681, -0.14541917965822967},
    {-0.5817127858844461, -0.49413362318772064, -0.88688162173329, -0.36477420280538664, -0.6065715671056587, 1.7651694504626096, 1.7916690788179332, 0.6620139432214577, 2.1769605082692256, 0.40977917281140286, -0.12260884914731805, 2.2291100658966383, 0.15381961503646763, -0.3574191543816199, 0.43149878828591176, -0.08731500439273951},
    {0.46418977707425624, 0.8347785207159344, 0.11402890793972494, -0.8739456656333329, 0.751416553560311, 1.9715464486266818, 1.4460482562373584, -0.9160283167586997, 1.0237479572905612, 0.21057632207561922, 1.2230122291301522, 1.454600497000039, 0.1426789746245859, 0.9026050218524098, 0.31391399196524306, -0.04898842235742527},
    {0.2531497215199675, 0.17577576530769803, -0.5176244461637945, 0.6669934594451669, -0.8102043976297618, -0.5576687595889936, -0.48783602367574097, -0.9125710499298566, -0.09589798882326868, -0.6901299339481416, -0.7833990027529694, -0.008118246543324357, -0.7437788556069247, 0.6653808409634316, -0.28861524062145294, -0.45818288959278813},
    {-1.1182616840825832, 0.08558341951925487, -0.23312666284535505, 0.1917849644752584, 0.8675020155356032, 2.3620909802180705, 1.7791432344802718, -0.4559132557110143, 1.5291066553737114, 0.2375194484128718, 0.17667540871998968, 1.1289637440863702, 0.13907911979701226, -0.3780571852411692, -0.6914013346668915, -0.30461101212112773},
    {0.06435405901219637, 0.9117487069868078, -0.08176338998098129, 0.46808573344005666, 0.32648606937810043, -0.4694440456734014, 0.5690411594523958, 0.433637028781033, -0.323523810309227, -0.5057747777145991, -0.5987876163054536, -0.5337052935928414, 0.025712373380916757, 0.6374498714958332, -0.5504495977275773, -0.16517228930958905},
    {0.3675582170486423, 0.22515635660384345, -0.093568198533667, 0.2844084538327064, -0.8198841307437099, 2.370530586090931, 2.33965710718587, -0.2242798787387005, 2.432881449771251, -0.05242761121741255, 0.9010264339592453, 2.2440354610186377, -0.35664796686850725, -1.0241457391049604, -0.07200315903281683, -0.675297830574102},
    {0.4476900305291309, -0.37238387795460454, -0.7766044673284348, 0.3988211596108805, -0.5113297547133553, 1.391096791142515, 1.436029589750629, -0.6261831109957525, 2.4885677832475497, 0.4938849152581441, 1.5616043460977986, 1.3873962639344573, 0.1589268611899241, 0.549437176449957, 0.36058788168739286, 0.3522257753060493},
    {0.8039326876985047, -0.6850735947257389, -0.7216445450535306, 0.11002260874389343, 0.6759609019048013, -0.24956821241434698, -0.6739174535901796, -0.6073478671956111, -0.6695589967263805, 0.04391469571795249, -1.0596255295223567, 0.19987316500708222, 0.2176344082831093, 0.5042005979585689, 0.41771197372442914, 0.9138595482573754},
    {0.27280306653465997, 0.7704664175065323, -0.7237822501540845, 0.6778163589405711, 0.14445195806084032, 1.3450133864483764, 2.402875877594368, -0.9157457375915531, 1.7500252566134618, -0.38991061219148376, 0.6152748664546692, 2.5594862384792094, 0.05164738717906686, -0.21014480894993556, -0.5039263437248843, 0.21743513618220658}
};

static const float b3[16] = {-0.19159078533234525, -0.14534306071265599, -0.15064545793825032, -0.12636971927694599, -0.13101758138121375, 1.2317926313285565, 1.0185557335659183, -0.1151381465124235, 1.2598550448330375, -0.13863794449982175, 0.5450065784259319, 1.1165698332928562, -0.09623566007946102, -0.14305480041469992, -0.01907119553016521, -0.09445021040641183};

static const float w4[16][12] = {
    {0.6341136945587553, 0.1045408992554366, -0.8825996315130491, -0.4922958985425273, 0.15190217887270083, 0.8318057394737636, -0.7607835528584174, 0.7781100211098175, 0.02035731523685848, 0.101584179325086, 0.36552130659873283, -0.4289341970050923},
    {-0.06753747134308105, -0.7314807436280863, -0.2994849555036527, -0.6392635771167724, 0.5190436839183947, 0.5597359335820472, -0.037018184237180916, 0.47757678183455987, 0.6194694514310741, -0.34525319812840427, -0.06627407918775537, -0.2313070235906358},
    {0.65121703269516, 0.7642390632530255, 0.901113633930553, 0.5727805580450701, -0.6921458855916579, 0.7341274882821417, 0.026881482758703425, -0.1396333190072931, -0.7477228457015539, -0.8100286085704596, 0.37843570719939823, 0.7464820922915933},
    {0.46534213688655013, -0.6513681647196926, 0.20299163177947693, 0.5906746069804413, 0.7922886446320884, -0.712065407402381, -0.8412083335916409, 0.3280527236743618, -0.24201783789682785, -0.4793994454029368, -0.16120821189628934, -0.008328606672619346},
    {-0.15399241482599618, -0.6153491010174821, -0.18399466857461355, 0.29817321235080757, 0.6247554401303348, 0.5789332263054356, -0.4372347726171162, -0.3970379140275026, 0.7081544267769687, -0.30488753877892877, -0.5010321582699253, -0.5131737361060302},
    {-1.4703385407266258, -1.0019991477993182, -0.7422360588080538, -0.8464621709968634, -1.6515101837316715, -2.0803087385551877, -1.5629206217204212, -1.8444864018164981, -1.298693533976696, -1.8135933998200873, -0.6491236689722911, -0.709123140857562},
    {-1.7473235776008496, -1.838628166723794, -1.625033137788052, -1.1756952983734894, -1.6233271585585087, -1.5732091303061901, -1.749987565804651, -0.5938418747142865, -1.1769946752322205, -1.019085420143461, -1.1277569821498021, -0.5380307511171593},
    {0.4290891914474649, -1.0164793868209308, -0.3957044584729258, -0.7578830594966444, -0.023498127859233886, 0.6293502959933837, -0.6268970138944135, 0.09604202772520633, 0.42355684391515047, -0.9445917623136624, -0.8623620744157902, 0.21193212119463678},
    {-0.6416329220253544, -2.069341599377755, -2.1940634939062016, -1.5669363826725724, -0.9816968079186706, -1.8911501731738767, -0.31342715182947417, -1.6391853847699587, -1.4974874252780563, -1.7370323670446723, -2.0262143535442907, -1.4541606606616373},
    {-0.47273344700161185, -0.38836458631379994, -0.49325457330942213, -0.4833392589689832, 0.29773141066375847, 0.757352668478208, -0.003194838361919004, -0.310342544446906, 0.45011655701493075, -0.02830717120812007, -0.6609380823133553, 0.17876220503489848},
    {-0.1470466311206475, -1.5040473266954137, -0.4288658282528508, -1.57826346933299, -0.633852302191462, 0.017197514149291656, -0.9695936476346387, -0.8426789758560991, -0.901103192540021, -0.3768036575572058, -1.1853038917499998, -1.945997444957671},
    {-2.146320215763788, -0.38663392442890476, -1.14090439865878, -1.6604412465411598, -1.511641692050839, -0.4938681249441152, -2.063872783294626, -1.4731448372303237, -1.5784605258316213, -1.1762544093901097, -1.569318819653618, -2.2812126764821925},
    {-0.16827214809039476, 0.6500242938810754, -0.7014864847956784, 0.024685368070666975, -0.9635774855432385, 0.6902634955648808, -0.08149401239833763, -1.078657895872087, -0.5634526725650392, -1.025455670890212, 0.6497458821489209, 0.3000614359994363},
    {0.3763191636163347, 0.5838436370601653, 0.6529744643084917, 0.8888043292519608, 0.383338242177047, 0.07174693095400773, -0.4902450281912125, -0.3015442278848628, -0.07855368704296913, 0.04839573802598731, -0.1024945268187227, -0.5543742042517119},
    {0.7944942051357126, 0.2458122040808213, -0.8743014539644384, 0.47374226887093307, 0.6086783513870924, -0.7731865422014313, -0.4925727708086469, -1.0100651606055453, 0.033814537005847266, 0.5834759946586133, -0.08211822685926214, -0.3908021744961865},
    {0.6141928544900281, 0.8418605787818553, 0.5370243121176775, -0.1434559496924453, -0.8027158959996735, 0.8697837895447594, -0.33627524976294243, 0.9547728753458125, -0.823936428571229, -0.01875288549588854, 0.28571287649000054, 0.7573634439169449}
};

static const float b4[12] = {-0.5137981658967834, -0.6519201982529204, -0.8462472201494935, -0.7549313926137776, -0.5943546388165454, -0.5323375033948761, -0.46977514796226927, -0.8003533803932067, -0.7318491375934457, -0.8538882072338239, -0.7269531588122783, -0.7476816435850013};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
