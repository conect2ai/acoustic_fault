#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.5509907582451747, 0.5999150709817849, 0.6080530322942599, -0.17340460490348308, 0.45527672357242444, 0.501230521233916, 0.47673504410001233, 0.4740345822156857, 0.26494867413799683, -0.48152792385390086, -0.3830238854412428, 0.7007939653691192, 0.12110004575807311, -0.3754345767577782, 0.5881055616992494, 0.5807716755987318, -0.6214177645173383, -0.18401582813757772, 0.46530948792211346, 0.06100427652918275, 0.291367416429395, -0.9842993194451916, 0.5785436923894643, -0.4032296483684821, -0.7232474934023392, -0.20128602930921435, 0.27058523354854325, 0.7746548886407825, -0.4161628353218709, -0.9169459973648959, 0.49541183553512075, 0.43827368664806177, 0.5784165584960477, 0.5153826910056979, 0.628185503963336, 0.14194963087555837, 0.4331488983947583, -0.3187086371910189, 0.08185979542548016, -0.20494020768075924, 0.8847455531317098, 0.326470246072833, -0.07713162323548083, 0.4272212286124684, 0.5317259483641744, 0.23544036669301718, 0.375161237641494, -0.769690015654024, 0.7591530067019614, 0.018681524568508464, 0.1123326375283821, 0.5293651299650158, -0.20063575403827907, 0.6066251583119546, 0.3907081726112166, -0.290128660981242, -0.2741968439516912, 0.21760108483756252, 0.6048806817342345, 0.6564270711846174, 0.5554284037383455, 0.5068226769352648, 0.6729967776105334, -0.6094716266100648},
    {-0.6989676513264094, -0.2765969432619258, -0.8381923352907737, -0.8331413971783315, -0.20282010808595613, -0.5176601090102902, -0.6892417112783947, -0.541587890442653, 0.8720750930404063, -0.043618270526486556, 0.7828685795891388, -0.7423002603145898, -0.928053194462212, 0.045665506430840025, -0.3580211323511996, -0.06448391169384345, 0.6582405403841172, -0.16357865843048364, -0.18799330467240047, -0.4420278974954729, -0.30789784503490103, 0.3508059068317753, -0.40443091870568526, 0.4781596140200134, -0.23348701088549081, 0.6295790182592692, -0.2231588936367709, -0.663124295256468, 0.34744605201021495, 0.06770357098468834, -0.24902558198238148, -0.41407424500602186, -0.8226014588256864, 0.2176896832973577, -0.6096192135376968, -0.16018643863955662, -0.8572901653042614, -0.26250025466092924, -0.04474683542483617, 0.7230450283106838, -0.27812621745578225, 0.7731399692821285, -0.2108980085483433, -0.3928691448170106, 0.6265088650336528, 0.3437408090734704, 0.06325241479903047, 0.3076035475712487, -0.7308795572834728, -0.06134112702380119, -0.8430096698484988, -0.012667400102404896, -0.3859504034585233, 0.02428438569802121, -0.28243818640693646, -0.27236533339915014, -0.33502705158019447, 0.35130085706284, 0.18428354183341503, -0.012564673890844449, -0.36266735827412355, -0.3836140581586205, -0.13145077183449375, -0.2808283265905572},
    {0.779291136748831, -0.015341965227964315, 0.0414236297730233, 0.19708374359437877, -0.8096223870763662, 0.7593715100216679, 0.250469543913103, 0.09098265860580107, 0.19597601939794976, 0.6101452474757153, 0.41387209679469344, 0.46422841427878525, 0.7180724422209813, 0.1445923504206837, 0.31709147880650906, 0.13281584224088622, 0.3322625232184342, 0.9743223050099125, 0.25233378478284624, 0.5100628135813831, -0.07984061760007774, 0.40913709961905104, 0.03706307743870855, 0.886317787614322, 0.7955358580040462, 0.48967339825866557, -0.4153283112861334, -0.029912479150381414, 0.9926982353504823, 0.987079588823738, 0.4504072937066753, 0.19193545858334182, 0.10327003518073646, 0.30597922470560907, -0.2148508147242499, 0.2646971447231909, 0.5340782304036243, 0.08148670186712603, -0.08445961574045444, 0.16819017096834216, -0.212518332970503, 0.30636889504956577, -0.046736834050655894, 0.26702296659033253, -0.33980357789685844, 0.09882999298884268, 0.2900817004726117, 0.8347999119611691, -0.18131999065572996, 0.6035595761035856, 0.7474564459587993, 0.6548246410958867, 0.5908396333883753, 0.5853624443343144, -0.33381186988633504, 0.7015581445996527, 0.2280595008008683, 0.317547990643679, 0.007144400700784342, -0.2650208858723349, 0.40590706447884456, 0.2603609244102009, -0.24012398408894317, 0.8014746153530615},
    {1.0737227450342937, -0.013253384587275131, 0.5465026696594177, 0.874381125968735, -0.3482989255925382, 0.481626284565091, 0.6241477005137416, 0.6590867181033914, -0.566694866093377, 0.24907878168245517, -0.558063506988504, 0.7223969467848513, 1.096303953464008, 0.5521322113701134, 0.47397561303032343, 0.7207127268793451, -0.041780954140888525, 1.0504228600266208, 0.627672001318088, 1.0338954981848198, 0.31046470079780697, 0.22790880359425084, 0.7889795399766815, 0.7038837244111481, 0.6818101932354503, -0.09544795383430422, -0.03731584791215762, 0.44415745134194823, 0.6838803723772531, 0.7968228056095747, 0.5695425514185088, 0.34511494005536353, 0.8038196964151082, 0.10818869211268087, 0.1888540849038413, 0.20487314588684624, 1.1021133795276508, 0.7953007456138594, 0.44694649263526026, -0.6659117223178792, 0.045065304105901434, -0.3414733861982314, -0.44810750919769543, 0.6712175927573942, -0.6388829146648489, 0.38908844848682056, 0.6051818213531135, 0.957374708161334, 0.4553711804127115, 0.40969402393569515, 1.000313493402984, 0.9273895914765529, 0.7495204226102943, -0.14928368432090067, 0.2813652266169361, 1.0281072147385437, 0.872996780719013, -0.6204118851178632, -0.6216463112672164, 0.23192993657034747, 1.053799910298391, 0.06406973580773517, -0.23309142946102127, 1.0274323806820522},
    {0.9255102068334335, -0.33311883798917796, -0.24102114014638973, 0.829408670063549, -0.8120337718012743, 0.6667723361219734, 0.508809107278262, -0.11982712561379565, -0.2742204388800213, 0.9264252060236777, 0.13896218677047276, 0.4171044595819348, 0.9014643573506047, 0.6208846358573129, 0.3061310393286439, -0.3315866588753562, 0.9022227238067342, 0.9181607785181914, 0.15538886326261295, 0.8311673890772873, -0.5506229044596908, 0.8352804824143628, -0.04113031909484499, 0.4668365286877726, 0.7814962735719486, -0.13362730731358236, -0.21024416061925327, -0.47221953617826556, 0.6564852665020453, 1.1143737004008896, -0.03674921226563504, 0.5152160083285962, 0.19706758036999003, 0.35413809863090867, -0.3791139425014567, 0.4223099593978367, 0.5739505202719837, 0.16473467054103214, 0.16512786937622884, 0.1381189958927099, -0.712395724832245, 0.3998077712561214, 0.5078188761502345, 0.019408032526860273, -0.8357608428773005, -0.5779396162328656, -0.17687243164385077, 1.0509770702824792, -0.00928402478417394, 0.4715635813924324, 0.4899272178732741, 0.25591313547948263, 0.6237695213163358, 0.0021852373988013167, 0.11621678920297822, 0.7597554950337412, 0.756661604541756, 0.04109694435325557, -0.15158465683738687, -0.6663873068238092, 0.5651237746499118, -0.41450113657039533, -0.07443481074644123, 0.8463692117408306},
    {1.1334462745320744, -0.7764773533763791, -0.4761702606405381, 0.5535920946154522, -0.5751312024709427, 0.5781386566260199, 0.3418919782507267, -0.43170844623502636, -0.6358091565351687, 0.7123263645537666, -0.24885941477186652, 0.1447981044809362, 0.887220014087946, -0.3560772719627128, -0.6661271595869188, -0.319577736793851, 0.6668784775483818, 0.8619803629575943, -0.45846601749517235, 0.8486282198320785, -0.5909885307529926, 1.1771047013601503, -0.5563671127351765, -0.040162517830174924, 0.8546231119160631, -0.04315364022694763, -0.14401822809527437, -0.7945568322849015, 0.5848954087961724, 1.205753938076952, -0.7895330221028538, 0.39968357550822187, -0.2718112573598373, -0.3160681564027294, -0.7313243511611455, -0.7037728149920571, 0.2934233074344647, 0.3353812045613539, 0.28894890511223015, -0.32487337064891403, -0.40581857538900323, -0.485865181249123, -0.15240291923872154, 0.6624654846633977, -0.9361448517617188, -0.7282643199592205, -0.02371728588289325, 0.9627656764126643, -0.6230144366813481, 0.010334449738606984, 0.5119964876813172, -0.30005549319316044, 0.2736089213884894, -0.16090030457656967, -0.37193395820182434, 0.49274764220950923, 0.7975394154925779, -0.4270119289219804, -0.6650138685810586, -0.608107695885914, 0.6547893857087386, -0.1714077271089885, -0.9242545320881954, 1.0359970398644969},
    {1.097509676987101, -0.4490998058337301, -0.14369643582302918, 0.6495841286373872, -0.41777595079306096, 0.2644989967552903, 0.4166750071315799, -0.4680418976881277, -0.7188637262742197, 0.3724784737147433, -0.5667734457337389, 0.42342446422279445, 1.0708522044607933, -0.2860499260351928, -0.357067908003218, -0.1736629148172389, 0.47910414085185493, 0.6361375867450053, -0.31211232081699675, 0.7236085011085703, -0.33228655561218395, 1.0179044182533268, -0.3280232118953809, 0.018378822908849568, 0.9961245544790277, -0.36377545953260876, -0.6100532578967854, -0.7516506049392166, 0.3217694667611085, 1.0428788822334722, -0.49564367328247544, 0.32636670730185, 0.14843165562510502, -0.06076675870144454, -0.7740087410700528, -0.6585180937154438, 0.6378201472075588, 0.4745506331675296, 0.3719860144494337, -0.34346037669092755, -0.6238832776824157, -0.6909807648220914, -0.46271551661928934, 0.3454114888803011, -0.9635924240451179, -0.6374249560680605, -0.32759808089332176, 1.0436578141417672, -0.7100414660434529, 0.03519106654052917, 0.6004947770785302, -0.18086159790224537, 0.38126897913635854, -0.44262887568713943, -0.7191212732981853, 0.3949437690818532, 0.6835887330422881, -0.40139616430399255, -0.6120482561359193, -0.9087044125143897, 0.6478022721326722, -0.46391501576128946, -0.6826469248526997, 1.0703470864025177},
    {0.7951630953092169, 0.008570826157523083, -0.7023189168486834, 0.5070631205425682, -0.3292183350761997, 0.1896622825683876, 0.3685389375743792, -0.02302587688202011, 0.03441287537751034, 0.63347953409771, 0.022436581862933815, -0.18587840621798488, 0.6666129890063183, 0.38219028930030957, -0.19555093885918085, 0.12433982035831666, 0.4900100873411024, 0.5392820972924488, -0.2513820181816169, 0.48747649108145585, -0.2491486032230121, 0.8865624849035685, -0.04863115275973649, 0.1708614711192469, 0.7971732714125002, 0.4714803342472246, -0.5815309628323079, -0.6188359840540734, 0.5758539799563211, 0.774666003149461, -0.2445492408004006, 0.0014482361872935538, -0.5967318230394454, 0.5238158940061957, -0.6767444899293712, -0.06629625234555789, 0.333022186998489, -0.04990047964593392, -0.09104776160108306, 0.24830504748505644, -0.5186977820650633, 0.7186906101908126, -0.25800551423435175, 0.2289068090840135, -0.3431781873365364, -0.6678418939415858, 0.22760499110152224, 0.8898883684626782, -0.7359617711108872, 0.43981927574135404, 0.423745682440991, 0.49226298412129765, -0.40582053079650454, -0.2792675395259612, -0.3882430827988139, 0.5155903453376147, 0.5482237078327219, 0.33898265402593664, -0.2788140952956612, -0.5419919723367522, 0.36355245854494556, -0.5556715102106172, -0.234036213255561, 0.7444292426996411},
    {0.5256973961030071, -0.04208468604353822, -0.3505285638801537, 0.07368454362095542, -0.05184814709084836, 0.9154398542224437, 0.4638316820323555, 0.35600162607934793, 0.6458340296945422, 0.836544423538999, 0.1675115799393877, 0.09741343142027319, 0.6255437195606542, 0.39702636239277017, -0.06008552985865065, 0.5193949389294286, 0.9799203906677304, 0.46413990695321394, 0.3518968951118755, 0.7393944770444739, 0.14951630645519878, 0.8599929390919329, -0.12036837602646785, 0.5677186641332148, 0.46223832914660246, 0.6143966742067659, -0.08216472564913327, -0.5153692571165911, 0.9030469501717013, 0.6696439284076127, 0.17052756613834774, 0.73096491138875, 0.03893807953379533, 0.5664710854547638, -0.10618913469656142, -0.330334168848719, -0.03283169928089289, 0.3849209850779911, 0.13130700158325453, 0.44995114254380236, 0.15229327655065666, 0.9245510857890263, 0.34812191412896104, 0.26278622831474546, 0.16719815519570227, -0.4024734071754164, 0.4591765528419749, 1.0229932788196885, -0.6723421874236323, 0.22800560617237295, 0.32494892145055, 0.5966290539577374, -0.11756327276863399, 0.23757928440716267, -0.12427454158538814, 0.44921383666143333, 0.4768174687767332, 0.7627988359540271, -0.01963719702388374, 0.10236444730912674, 0.5029235815204942, 0.0813898985043642, -0.5567614780353305, 0.3043748349363451},
    {-0.8627510847561269, 0.034656029732145315, -0.8852151090180219, -0.8360129016645096, 0.06387849287780943, -0.8310350760622375, -0.5083390875067333, -0.46063870283940184, 0.27438413348771695, -0.42723764902607375, -0.22023061045713824, -0.7891574343596681, -1.012425946511282, -0.33605768936136343, -0.296382055290469, -0.7235137848918078, -0.08817113259882539, -0.606479025175868, -0.6102221291051783, -0.8097854962364619, -0.4815467225540459, -0.0317640556433987, -0.4842197133332859, -0.3647435751576527, -0.5525121917931825, -0.27771815784926146, -0.11429397940341506, -0.49496869350583084, -0.42309152637168435, -0.6333089182899213, -0.38876957395769113, -0.7744052432508949, -1.051546741440567, -0.41606307099257467, -0.5110344546103185, -0.9846093717760862, -0.9387797932704248, -0.6153615453909855, -0.46932759701347, -0.027615373744509147, -0.4526196414436967, 0.34621158475176517, -0.5059252530188437, -0.6651731094024347, 0.6028298885517909, -0.11739880834164064, -0.011187148682103487, -0.1052752045751991, -1.0053523743953918, -0.22906615425980248, -0.992076547339692, -0.6484251124497106, -0.6236986470458736, -0.6067094700496511, 0.1567656470859053, -0.8252201776301424, -0.7295946579883548, -0.14842268914009327, -0.36577940988055374, -0.0994220843275794, -0.7687602170712273, -0.639808670569601, 0.08393361254816824, -0.9579011607113443},
    {-0.3172546360833399, -0.6853959828733336, -0.32481795998739615, -0.033065300893401, -0.38993962943752775, -0.7987893742828437, -0.21276802275245157, -0.13707868926300817, -0.32334783848187637, 0.1275217490123702, -0.5966349138040351, -0.27265313604918584, -0.4687948648077661, -0.7184225357114521, -0.7208833896751603, -0.5790388225689783, 0.07707530470634727, 0.030431073525036604, -0.45843902458883795, 0.03747521494494771, -0.5374972615122755, 0.39493799646257, -0.14286177477905376, 0.20713491274009832, 0.10470988580151927, -0.36741838833777724, -0.4528087038132862, -0.6602452012177416, -0.4787233789865214, -0.2253485270214327, -0.40531518635453706, -0.6537890603603596, -0.16016572251333613, -0.6639874110305277, -0.5578580802442087, -0.6257907979639358, 0.12204501347352704, -0.26855575403193976, 0.12897529935941, -0.4333758402800186, -0.4075930423167667, -0.33320671704491056, -0.7020239110714467, 0.06355183637871784, -0.4528165229425298, 0.11383445375216263, 0.24693090452720454, 0.004696068480195387, -0.785284646517345, -0.5969128357327248, -0.3213391993894875, -0.5337380332847901, -0.2937191999185751, -0.38677374206470594, -0.08705985929975259, -0.2999617117377805, -0.41865925740816673, -0.5276306394547651, -0.5494289235853034, -0.1131151483076786, -0.11275682240701616, -0.6820201706303088, -0.5070225687905692, -0.6125564239214478},
    {0.1442906150428734, 0.4950461804674693, 0.48083448316684724, -0.08558830325772855, 0.7596244290271875, 0.1990892250844143, 0.10716124406638197, 0.8103485159713699, 0.53243391903523, -0.250502351670067, 0.34034491652618454, 0.6436975725831304, 0.14624846367115377, 0.4646298804254616, 0.5670170825999994, 0.8676792165496393, -0.29797991246967476, 0.7139283888803962, 0.9305957128979204, 0.05088912288735472, 0.6561019222767033, -0.2534083044196686, 0.5625537289574316, 0.18313601062005777, -0.012436787862636247, 0.38577504797383194, 0.7913175148647836, 0.8569719580994385, 0.8296580002462274, 0.4439713455675802, 0.22548945989228886, 0.479237376342114, 0.3948750147583507, 0.14036062832940857, 0.745712194972061, 0.6361132225131184, 0.3400487612092767, 0.5031235246381083, 0.48623873503266646, 0.14683942618362922, 0.8916766114470779, 0.17894917590423795, -0.3269500587952354, 0.17553592523730616, 0.709389557799952, 0.5390956103994993, 0.0718988177220332, 0.5567298345942447, -0.00910983800020688, -0.3038346177891771, 0.09985102632277484, 0.6672900592055041, 0.43707006770191764, 0.5887611175075425, 0.5497986223934558, 0.4474973039116988, 0.5300874689627948, 0.26567085179646643, 0.27205773555410445, 0.5600841321456853, 0.25026218781249104, 0.4781728732430861, 0.5053588132887731, 0.4901135837589715},
    {-0.8180719355928722, -0.6679258738909023, -0.7998648985689542, -0.7269603683711603, -0.338204830418591, -0.4780211301722349, -0.6897983985956873, -0.7631287711003332, 0.20454609386944672, -0.165072669098271, 0.3403957593178329, -0.8062788731237547, -0.8552277524482477, -0.7934008282923352, -0.5671196701391675, -0.7189164823779174, 0.41554989643682894, -1.0259517797021502, -0.7890284748905663, -0.9749050787949565, -0.8711806388526486, 0.3407743377453658, -0.8749733950463326, -0.6670852567979254, -0.660028346277009, 0.5252267337269483, -0.6500230388109951, -0.4606366613705996, -0.46577818838115764, -0.6349221382952779, -0.8099197244670566, -0.6473331547189285, -0.8409536311091916, 0.1801107422298071, -0.7342145833937953, -0.6695774593818916, -0.7839471571308393, -0.49783397080173686, -0.4655779561949211, 0.19144456518204106, -0.20891239677623924, 0.24873422291739147, 0.006230809154426757, -0.4797552186333251, 0.4969648247086728, -0.2752499300166313, -0.49493184108423616, -0.42663423016374363, -0.6069678328505488, -0.6534415757579051, -0.6534125593253759, -0.6492045487187287, -0.45137978917706084, 0.1947362649763079, -0.8617626680193804, -0.9887831041005897, -0.6181572253596568, 0.7337883926261047, 0.20217099001529815, -0.8871352195923934, -0.9993595232761074, 0.30655295905797625, -0.5361499827639096, -0.6809146749827654},
    {0.7770530006281684, -0.38067910842971653, 0.680946251740526, 0.7833923945338475, 0.7876275401244046, -0.5504407085976566, 0.5874121813071078, 0.5833998954236232, -1.0027439240176512, -0.039435698482002735, -1.1544442575901677, 0.7889049221721686, 0.940024124332094, -0.06230512761818188, -0.49974644123005474, 0.7179724549109878, -0.6533938717896828, 0.7736856229210426, 0.6719399842730475, 1.0633258266606733, 0.5772203153052471, -0.2894264073883333, 0.41235629391264184, 0.5511398031940377, 0.6588450457172715, -0.6296515676925721, 0.5466851967729645, 0.49061140632206407, 0.1818084442119845, 0.6119928906082206, -0.5455578544632647, 0.5115763817243979, 0.5753878282184458, -0.8580106130467835, 0.10291496454683155, -0.5938207813614549, 0.8979640593207023, 0.9683930371033693, 0.6089449643615051, -0.7258058481103601, 0.45295551060713335, -0.7807650098991756, -0.5680653342402793, 0.9080438759264005, -0.08020832662349817, 0.6796877565627395, 0.5603793158234129, 0.1454370514321942, 0.49052381436958964, -0.4236753663660604, 0.8805587569871233, 0.6220389744082446, 0.8392967479155864, -0.662718241744935, 0.35432639766028146, 0.9274319630044361, 0.7277919848222347, -0.6084713691848015, -0.5065467590253308, 0.3930992200282099, 0.9141060348506015, -0.08874321608344735, -0.14761370996869896, 0.6005103592876091},
    {0.9300599556208307, -0.48139581443597174, 0.6405884538089208, 1.0765166112235731, 0.6179346428121246, 0.19570019183707094, 0.7977631517753144, 0.6217205514882668, -1.100382625846502, 0.1368099682478369, -1.0655228956593188, 0.39678906727825686, 1.072665930741349, -0.4846059220617811, -0.8877533933234482, 0.5941395857218842, -0.5790495663209974, 0.6067841195608664, 0.5534847751692146, 1.0887631048717645, 0.8062015281172866, -0.0498827741519657, 0.1071767308011869, -0.4821133580483563, 0.37919494609083326, -0.3892265370868569, 0.6894281875999672, 0.21780542505743783, -0.09691355678110475, -0.13883175931539302, -0.9812011409013022, 0.6737569980749368, 1.0214716624305185, -0.567525320683902, -0.13114191854845023, -0.06141194781092145, 0.5337800321219385, 0.9428629640684634, 0.6369051812019783, -0.7894312063099214, 0.6276273509658301, -1.0798516991036502, -0.06625588545491601, 0.9186207675033603, -0.3517088327615307, -0.11744946106758228, -0.23027105983414672, -0.5175416708457479, 0.8996042657827588, -0.717929643299808, 0.6712342579225093, -0.13215474176381403, 0.23983008771859135, -0.4974217671333495, -0.4017616516683612, 0.8802789793480021, 0.8945302217428671, -0.6463113035004991, -0.6356825589228757, -0.36671809691565654, 0.3600437110998502, 0.4133827225170886, -0.5052435398453616, 0.6034730149911041},
    {-0.05667286409534384, -0.5775614571784083, -0.3350358415951057, 0.25511965497561795, 0.461813816903752, 0.16579951600794143, -0.4774013895287623, -0.48786249103677537, -0.5281341927184137, 0.15322671316757414, -0.29591242225938597, -0.3906261721452815, -0.31667657832158097, -0.7240875134374758, -0.8975726527705266, 0.028006744557049688, -0.4260897164573232, -0.8335738714809757, -0.48428311272498936, -0.3788202952855704, -0.4129832176417837, -0.0008114952725779575, -0.7819824234972954, -0.6898805063080736, -0.20930065092422628, 0.1749486456117024, 0.3382259356977001, -0.06608245607032977, -0.9039054747155542, -0.6578900183234595, -0.974404420392967, -0.011639956351037707, 0.18707310535397312, 0.05294036489688692, -0.37885504058999936, 0.006843833770139486, -0.608070307407938, -0.29399504647886393, -0.1237565847830084, 0.34883472561491013, 0.2553222821369569, 0.04058686188264901, 0.2314850837472654, -0.0589364424323707, 0.01306568293254031, 0.13229150374620469, -0.835005389003591, -0.7486720968595194, 0.02979301438476286, -1.0307856056044027, -0.4129476344761716, -0.8495375846387245, -0.6496880193839496, 0.07409744792801531, -0.8668547992904927, -0.7126704599041408, -0.38089337423696096, 0.020085126135602063, 0.5529485862395052, -0.77702913872379, -0.5358811394057831, 0.6469445042069599, -0.8261650423823566, -0.6872064431076551},
    {0.8885467559116146, -0.24006643688951432, 0.23157260495207063, 0.9281067740590102, 0.48478105890976875, -0.28510144485957756, 0.661190620904319, 0.7898136961535124, -1.1206394959545865, -0.13627923271006281, -1.081656211256383, 0.5625135577218219, 0.9969071195494118, 0.2343714516815493, -0.927749695255018, 0.4483965151974491, -0.45477854631370507, 0.7860667432278474, 0.4979093611232034, 0.772746320777306, 0.8024873562521581, -0.0023183275678344004, 0.5971517433385151, 0.2113595911432506, 0.9980306558741827, -0.746656338408055, 0.7555110388733991, -0.3043058024617239, 0.3929733660609787, 0.8937864361568341, -0.7401442681029302, 0.6526750355887188, 0.833989914661927, -0.6305508586828292, -0.45934706058093694, -0.48337628282793205, 0.9163851492059034, 1.0801729617912723, 0.9544297723611069, -0.8788008776958486, -0.06933209980291534, -1.0391374399943794, -0.789117401801721, 0.8341563662200888, -0.7130811551719355, -0.03606330941390095, 0.5257494044960547, 0.11866079529366419, 0.15585878338977424, -0.7767707398328758, 0.9473693435159487, 0.5564687746472987, 0.7507779360995265, -0.6092759730877694, -0.1423562573435272, 0.9193405023297907, 1.1103919484053255, -0.9741723655021381, -0.9721617490753512, -0.04604139493472396, 0.7403202585891616, -0.32670254478852945, -0.761307922986932, 0.876709609143272},
    {0.428414060271345, -0.587816470024183, 0.26270793014716576, 0.5663742588043453, 0.6007040135495504, 0.027246204381856532, 0.19510607608933975, 0.09254808451931412, -0.9328213439335703, -0.18773982951657936, -1.0486750870093475, 0.10905280966295186, 0.6191483764378247, -0.2839949955614767, -0.6775516655983038, -0.11111475077250799, -0.527961239158094, 0.28550685004087817, 0.10241733813008637, 0.24271331199265025, 0.3823976027901941, 0.28266987959465145, 0.20480747117097498, -0.502565050029491, 0.4751510082535281, -0.2856324878998388, 0.5717334217878859, -0.32456893117327745, -0.18287881730785174, 0.739705104635449, -0.5185197418875004, 0.34551426193988244, 0.5976993149478724, -0.8831762533896643, -0.4509474675818267, -0.583041063461507, 0.18766878117636654, 0.6575222998236289, 0.6939684463081545, -0.4312249800152446, 0.1953895323007116, -0.5156721254899957, -0.36192623574503524, 0.6398993950986134, -0.29022576884017953, -0.24113261253430107, 0.12053659261720316, -0.1492530705414205, 0.23784416954838009, -0.8826315048557695, 0.24816253423654872, -0.17382350944117164, 0.15748305904940263, -0.40624964718768286, -0.1868085326393067, 0.5415858532755329, 0.6312521028360836, -0.37756463963673065, -0.8288971478662672, -0.45242230397022776, 0.4535803597335245, 0.30096840968619715, -0.588781321337544, 0.7538622894898064},
    {0.4798848468201448, 0.5845632209372302, 0.5855799777631395, 0.7366405963005683, 0.2634873215075559, 0.7137550786255342, 0.7518983584494388, 0.7432860276253411, -0.16374929457794254, -0.17064811452004844, -0.05983696264910201, 0.3932000429825198, 0.7129118751995667, 0.7310622932989712, -0.04741708406333175, 0.625957147250993, -0.3195408851520509, 0.25846850133369176, 0.7991660318749458, 0.529720889602485, 0.30731918466721286, 0.2789391676764117, 0.6535264054650031, -0.253449762782511, 0.4874814664098646, 0.5422235339786008, 0.5326664053676418, 0.45822941149717905, 0.48664309646625115, 0.6553905987074803, 0.008921701015502876, 0.2632124143465809, 0.511400425093101, 0.47523695749837647, 0.6773008015294356, 0.7913752379769763, 0.535720115708939, 0.7744444500424148, 0.52585188776071, -0.040350012621853226, 0.3275866615230352, -0.004803958917389244, 0.03819470554284831, 0.6710102602270044, 0.11159842891562707, 0.32327013265339877, -0.33352003508141936, 0.5757760744427439, 0.6601934388508219, -0.05820526516826056, 0.7939012668865946, 0.692897732712296, 0.11587292281201357, 0.48502878092477014, -0.07730019185513312, 0.6631175080387409, 0.5651946065475553, -0.203028947049823, 0.3009487421607295, 0.028657133255157653, 0.602604932164063, 0.6340893335391005, -0.41715692793099746, 0.7872693597040024},
    {-0.03761384820247648, -0.15407963148690773, 0.08705788810481005, 0.523061322716299, 0.461711354182745, -0.6736914486198295, 0.7599439516246359, 0.5667127229400654, -0.338404599972551, -0.6324999429380419, -0.5038585678174657, 0.4910868272021111, 0.45229983831893217, 0.15400276845673702, 0.23793742873494964, 0.2545092443209278, -0.3349187082862023, 0.6765491662187865, 0.23156851079683238, 0.7729961176236607, 0.18014695229278868, -0.23841824065900935, 0.45252052246019014, 0.541544928527297, 0.6743807582342369, 0.08112242745654102, -0.09032413522987064, 0.4589536996411736, 0.36091870001374665, -0.12382690833778198, -0.2185540524700818, -0.2298574872016128, 0.06968657627574346, 0.012180549663134092, 0.1866444586580566, 0.08699131507169997, 0.4133360441906127, 0.4207283990997232, 0.7867110878561802, -0.21906735260120366, -0.13280620874141427, -0.5347924167368148, -0.6693466434498223, 0.7300579970040723, 0.19914788147190068, 0.32062931632793024, 0.16521253680265055, -0.1429399271907585, 0.40288342984638736, 0.2437581319272977, 0.7526728185474452, 0.2238083589912733, 0.7846924862339074, -0.4178993912684253, 0.2584181867101511, 0.5798241811472891, 0.5895870033664852, -0.5675427866164906, -0.16921541499194026, 0.3753097814659118, 0.7756735032402189, -0.46643547199497715, 0.00539330356552327, 0.47241532136416226},
    {0.5989526603034908, 0.2879885135903864, 0.9139034509080315, 1.0223044988410164, 0.5445263963717749, 0.02495712219877779, 0.7401527559565063, 0.8642482148828402, -0.8367404409306881, -0.47399099591806504, -0.7674961553833389, 0.37551054892807656, 0.8422690315400889, 0.27055179522089334, -0.1521533270979528, 0.7628575852249674, -0.3393631211235316, 0.7199758526404741, 0.8873982385115555, 0.629396040211251, 0.5939110049201021, -0.2470345788079873, 0.811252270694771, 0.058077857788005637, 0.7923175366269508, -0.15633210943451514, 0.26301055892706926, 0.7463323305110304, 0.005541369252174419, 0.1502554318701407, 0.18557623287291503, 0.4191582204090167, 0.9096614016938958, -0.11334532215233055, 0.41838328750332754, 0.6732787861581442, 0.6736466345171791, 0.8244226412389759, 0.6846199924243268, -0.061804708540381365, 0.744231577053183, -0.9032587074879291, -0.012009778738693347, 0.4895134516710741, -0.3548035762172783, 0.23560852942764435, 0.2860323794200268, -0.6445898501777616, 1.023435549035084, -0.2533382700690038, 0.7433040873493805, 0.44204928117198394, 0.9300694279805227, -0.5326891651630454, 0.3957090483455183, 0.5265388902728652, 0.5401511922667261, -0.6101972072745879, -0.25162431012763664, 0.6498082820775914, 0.6299924681350496, -0.1302237567859324, -0.08013137262120686, 0.6958091616207872},
    {0.17206240937217981, 0.4049001728232898, 0.49522784862679364, 0.9954026744495005, 0.6633033815704631, -0.9500819264610363, 0.5520411377040539, 0.25050958036639376, -1.014929863947924, -0.4180165077583091, -1.1027441646143152, 0.2603020082149885, 0.9132213852102596, 0.06932296351570058, -0.12057744846459569, 0.577765747454362, -0.48878874619740686, 0.444883688646274, 0.22626399659243687, 0.942823257436144, 0.6769670172191629, -0.3484054914171311, 0.5019855473264773, 0.6775230143831991, 0.6166334283707013, -1.0160617236235072, 0.7803043952266869, 0.4978837520655021, -0.10984282525958518, -0.2942253107044872, -0.40727057199245864, 0.03168145030720762, 0.3691837443934642, -1.0441939955850275, 0.4018680865141898, -0.27988738229341803, 0.6916677725683608, 0.7057032271350253, 0.45764402150797934, -0.6158196621529906, -0.10465994893562514, -1.0350164478896176, -0.573046733834645, 0.26390179040326983, -0.6978634022331056, 0.3264288326656912, 0.5517568849808796, -0.26973058843649195, 0.8027028527027985, -0.29333147835583834, 0.6504813269298986, 0.24733666968792584, 0.4646029134105088, -0.7779058473805571, 0.7342817260232296, 0.4360214791467666, 0.6654354742684577, -0.8799015779403377, -0.7701062318579782, 0.08519568366121329, 0.6885550297627899, -0.6249775245850723, 0.4623137284063191, 0.18969849870462993},
    {0.02215717959834733, 0.649997733607423, 0.3557020025805024, 0.6784439385836163, 0.8145229069887273, -0.74350795011058, 0.44267991246805005, 0.4198809175642014, -0.8062499791422124, -0.4066513636374148, -0.7142553582467509, 0.6280825931656631, 0.7103705789387554, 0.42033438878933094, 0.2555300132149827, 0.7537598141684713, -0.763600940402945, 0.3199829446577894, 0.750791888112719, 0.5672771245067993, 0.7849499366912085, -0.9052824604514494, 0.7099358226787599, 0.5581558739270756, 0.6719720024678452, -0.1806105567220335, 0.14038543812600135, 0.7467657682936993, -0.07801569405492063, -0.37209568109629515, 0.12608116194498734, -0.0405418816791331, 0.6821228021714875, -0.48949120752558206, 0.4948112495010463, 0.19025935521701842, 0.6905517289805396, 0.5819626219282004, 0.7403343932371804, -0.22630560054469542, 0.32939054411580204, -1.1081755425248674, -0.5810312016556279, 0.23100737826370707, -0.0544675594156819, 0.6778723133156064, -0.009514899958995123, -0.7340995560676744, 0.9432900007063674, 0.12257392241653652, 0.6821508355561299, 0.3847248127766555, 0.587150622955745, -0.779795307771754, 0.18668388273142464, 0.614553213060096, 0.4386784691795535, -0.44007334829652545, -0.02767881054134953, 0.3577216168406839, 0.3992325370366695, -0.14259854266437044, 0.28926386144005684, 0.19544179547591695},
    {-0.5358321981905539, 0.6568573397943429, 0.34850500166020093, 0.4117411157753122, 0.5340912574105275, -0.9495718133251979, 0.19065578284121212, 0.2699160783592048, -0.47839716588339964, -0.1474242946745728, -0.1480211641667282, 0.2030906987357433, 0.13894027005028026, 0.38960447266247994, 0.45566976755071226, 0.35924272299065896, -0.6242307082233306, -0.057725108084314664, 0.5681402967036849, 0.21705067067885794, 0.5834098241251797, -0.5008909245538511, 0.5873416118840112, 0.5666477356908134, 0.5390990437224562, -0.564477685867813, 0.1043222475147912, 0.17453003530231395, 0.00099026448034952, -0.3822303703517347, 0.6211291870915301, -0.23013257873527662, -0.16215510950934467, -0.5903472262572363, 0.6126509339206407, 0.5938816831298526, 0.5870889644376093, 0.569126447167184, 0.3284598278212982, -0.35840908715282627, 0.042012172311748926, -0.8644010028860576, -0.3420246885260951, -0.22614768204632174, -0.27927241068522046, 0.62869831110307, 0.38066758375096293, -0.38395329222022834, 0.6061356785724604, 0.8731232405676341, 0.39318391932124586, 0.4065987333130795, 0.5637931780692195, -1.0072070596866212, 0.8202429431100037, 0.1861600200639077, 0.4349846882341268, -0.749822712871681, -0.669304548003416, 0.7192415025113325, 0.15549362688672796, -0.8801086898246994, 0.5320081988966855, 0.20386218870386041},
    {0.255393751693153, 0.41152703690021863, 0.8345300075418467, 0.9038938032364767, 0.8027799307469675, -0.5396253868889809, 0.9346607367638502, 0.6788176995715894, -0.35266282418324457, -0.32799315042886684, -0.7934350562151662, 0.8499409686578558, 0.8123673256191011, 0.44661074586559085, 0.8315693075934807, 0.7751419208120673, -0.7411486442643115, 0.7512758123994387, 0.8902209327262578, 0.9928905437820933, 0.8369446777404467, -0.6715481518466202, 1.075963838163691, 1.005715962727066, 0.881763983981308, -0.3930165697500691, 0.15462346577000827, 0.5778824288105129, 0.5955062388658164, 0.5394282820075478, 0.8557389771624729, 0.13309469579393096, 0.6935303329414539, -0.24317352773732584, 0.6949625502446383, 0.14242540756883143, 0.9415384177716749, 0.5662001397580249, 0.9538236418247779, -0.428025083557083, 0.3929951149489496, -0.6448419017840579, -0.7020558168761666, 0.35946362767395135, -0.027786332440439983, 0.6548911872603288, 0.8935921193300539, 0.3964541983144017, 0.5869664425745639, 0.7439165151350758, 1.002077635642812, 0.8543889381185769, 0.9950410127943152, -0.353998173771866, 0.9805902737067131, 0.787847342902252, 0.7734210458289005, -0.7529569815320066, -0.551028999793817, 0.963600184997126, 0.8208787548596372, -0.41791459771746525, 0.5675720217585352, 0.863729002067673},
    {0.03176540674892361, 0.8881640760225846, 0.5767471978426969, 0.18754413991332783, 0.4768277449365345, -0.2964171155552333, 0.4765905428116948, 0.6917086449295732, -0.11760807795069127, -0.3642098127703155, -0.26209356381126925, 0.7005424595646565, 0.3443648532712582, 0.9571335378220301, 0.9661213388354813, 0.7656118137796271, -0.6475134231582985, 0.7492354601044782, 0.9167257672361707, 0.3195003100586278, 0.9224409541180262, -0.6833740096107472, 1.0094720720512906, 0.5249595044184329, 0.3494770358378956, 0.11695271502160752, 0.16845203894510513, 0.8626809240517187, 0.4597877531725361, -0.043161657775907324, 1.0517255076198666, -0.0002154327279437502, 0.6562784927020715, -0.05861674228844366, 0.8183616332224107, 0.6343572780167502, 0.9169088167491619, 0.7540540206717774, 0.6275351422378525, -0.6285331906722952, 0.24221365309053206, -0.5133864686280025, -0.39591876039864016, 0.3997424284841851, 0.18295463897127226, 0.3831662964178038, 0.6101270244686862, -0.07303724929638018, 0.7053900176578779, 0.6790828558262445, 0.8336819294932406, 0.8972688991680813, 0.5495828507645311, -0.5566033220190856, 1.0235124596773137, 0.6861260340124362, 0.42242689786105786, -0.29251938714186554, -0.11228050032755388, 1.0010471647342138, 0.6941037634452353, -0.48707505542237395, 0.8414856642038812, 0.49928082332215024},
    {-0.5437088931375097, 0.50627873909217, 0.6546987312214008, 0.5779150942979923, 0.7938335188130698, -0.8751517197502419, 0.4484519369598565, 0.6174149040433997, -0.6818576347583836, -0.7734979619493072, -0.8668983238609627, 0.23068823210782932, 0.40003484771527387, 0.4725154593382151, 0.31649009539849704, 0.7090469236564341, -0.839670971279357, -0.004149532109662527, 0.507863299828979, 0.2168895856339992, 1.0072158258807853, -1.1313864179298128, 0.7028811928095127, 0.42197097033654757, 0.32569648397159756, -0.8546867391133383, 0.29411196069837675, 0.5370914962752383, -0.18057231358871226, -0.7731846421754419, 0.2765528691514278, -0.21537274171930865, 0.383752944652151, -0.5725795463154727, 0.5421781856561559, 0.16011176194270837, 0.35198281621328376, 0.3959633849377649, 0.3406782978033303, -0.9367237379043225, 0.39066745383098256, -0.8950124098204757, -0.5664196617715378, -0.17659067484625485, -0.04088527871685701, 0.12987351970946814, 0.6247509923046307, -0.844282225115973, 0.8332678134218453, 0.12887033615368135, 0.5839106787452979, 0.3155063315828993, 0.271633334988517, -1.0782596315730084, 0.9745319853111142, 0.2067075854116575, 0.5273675118082459, -0.861529717251458, -0.875786970802274, 0.8274494010388947, -0.20502165246863047, -0.9013148433317335, 0.7503395562415425, -0.16643511573173939},
    {-0.13585117884196346, 0.7679978184533214, 0.5129275356822303, 0.0187657401021868, 0.32320453136918614, -0.6414421813452309, 0.31723351516782283, -0.17152072394104317, -0.2634554983712462, 0.2487192341942683, -0.32804026961919514, 0.5737671032470969, 0.06578858523842354, 0.7402424463349592, 0.6184488492726343, 0.17194091306421055, -0.2492072326664127, -0.031759345543631225, 0.49543518214890814, 0.35344586671670564, 0.4114533771065166, -0.31523786112642693, 0.4797794809145, 0.7287353567776811, 0.23063058316915505, -0.05902457888869699, -0.705839494353529, 0.214772024361164, 0.5119254491197777, -0.46727290731950116, 0.7598197875327665, -0.26810543905396483, 0.34932170523069506, -0.08465170587104413, 0.48725894908714035, 0.19171507133704602, 0.6200067556485742, 0.5584170457953541, 0.2873712671233112, -0.3087769169931391, -0.43549546617659934, -0.6280144544155319, 0.22349696031909913, -0.44710014469805426, -0.2956773371049557, 0.30826244609591374, -0.20746239023663413, -0.12336445591900491, 0.7109550007961906, 1.004808948066892, 0.5521171531455116, 0.5439531479624571, 0.40250403212185526, -0.6915889639980496, 0.7027225318334295, 0.2971992419618851, 0.012275711103083212, -0.46572644921676104, -0.25203358010442806, 0.49517228527267715, 0.19780745719764908, -0.8003728375249946, 0.3805341971573888, 0.24249768711113173},
    {0.5053630301006233, 0.5150205007818227, 0.6970669035454492, 0.9421960793782664, 0.3604522660079381, -0.5230234809292943, 0.9744042102449778, 0.43086358517523315, -0.9860781045783671, -0.4745655580681224, -0.8357681001417707, 0.5489281321614291, 1.0526370438722659, 0.5771560911389261, 0.6039657289100553, 0.5658222567141263, -0.4993295490025518, 0.9033391858564287, 0.9387679175520215, 0.7418074004834324, 0.6484025129968839, -0.21377100699550383, 0.9614561945244771, 0.6307792345997218, 0.8657881628416528, -0.900112248069111, 0.40908676417243967, 0.1648513650171887, 0.6169368564741043, 0.14520612868594518, 0.41187798147723215, -0.007452177615008777, 0.676950623294757, -0.5325965259366302, 0.6755819797273569, -0.1242568952961305, 1.0543240149983344, 0.7083177312442287, 0.6031615825156955, -1.0352785718257327, 0.24807488235537195, -1.1664373600533733, -0.8521494604898721, 0.5225738904956856, -0.4393589213838387, 0.07132554743608872, 0.4744789824870822, 0.07258632538563801, 0.35670917325517687, 0.4371206573828987, 0.9398955143092522, 0.8444355318997124, 0.8993007383415492, -1.046438365886033, 0.9402107331339421, 0.8396065639502422, 0.5975561534579811, -1.148576134452808, -0.9668251289321805, 0.8622003861442518, 0.6776240006737846, -0.9122160426123547, 0.654331406197756, 0.6351331425657554},
    {0.6855374290513156, 0.6187823092512013, 0.41318003515054047, 0.9652242168355368, 0.4233778006690115, -0.4187624918062628, 0.7898629615710732, 0.5737252386922894, -0.4269703135887611, 0.13031645003122067, -0.6929211594300533, 0.7657000081354323, 0.9722745053813213, 0.7754454453277139, 0.039930572035358165, 0.8052464994854615, -0.47721231085659666, 0.6622463214214656, 0.8954015902688434, 0.7048223512568202, 0.8817342809803946, 0.19301050282112087, 0.8783057232241528, 0.37509814040757666, 0.39078008536199027, -0.32909994290598515, 0.5434769744221786, 0.017798551668822653, 0.8117684606923248, 0.34774215699852934, -0.20679606697723263, -0.04656150309468954, 0.7277851432804179, -0.49194581058886244, 0.37041178991659157, 0.36023211776676545, 0.5926757678304715, 0.9495694205147902, 0.4552773278463499, -0.5663483725490808, 0.5281449169954782, -0.8685256252060153, -0.26844847680936584, -0.0396480607727903, -0.28890695739858613, 0.0979207899130901, 0.10605434319950201, 0.2067273260306174, 0.23014964481220268, -0.04519596559090001, 0.8066201106148768, 0.6467562535247378, 0.6508131122888818, -0.6550612497475602, 0.6912374289097454, 0.7076997595157803, 0.9221888623417495, -0.8379861727614643, -0.4642350827319679, 0.21583184085771012, 0.3035252504249865, -0.23371271047241587, 0.44436421000844006, 0.4801569251926322},
    {-0.9577878728544038, 0.4048979502131666, 0.34504631056629176, -0.4441284870117192, 0.06026346754502861, -1.2585512860827153, 0.5008839851160621, 0.37683910213517613, -0.9171210249761594, -1.082182460736922, -1.0651346710251004, 0.17008588865451507, 0.04723534191907628, -0.8242033438321598, 0.24715220759946313, -0.19767898694172606, -1.0423736077808547, 0.1112241416807591, 0.3834453647319475, 0.3038674569513081, 0.32637046442566015, -1.0396056604193284, 0.5454396640932055, -0.8584292829752087, -0.4530790161860089, -0.7863156499043201, 0.30422543066710944, 0.3270714125164501, -0.7101121916478832, -0.9028439810341011, 0.2531663962329699, 0.26792221304541813, 0.3745257555569085, 0.11729196065178617, 0.27307058937253753, -1.0008239940383434, 0.5239177316414704, -0.5185289699307533, 0.3583751745572549, -1.243802000681481, 0.3616870127917147, -0.5381039785481989, -1.1242681823321232, 0.44181233113802054, 0.15386768905506545, 0.2707257002436966, 0.37565300660173606, -0.9653008857002572, 0.12043518808212987, 0.2650096127295153, 0.4937095921835754, 0.23954366851387157, -0.420327869124947, 0.012680972680991637, 0.07360444902559538, -0.8678783761156005, -0.47891573336814647, -1.0267272454863063, -0.051645660585872034, 0.47431961194639216, 0.2898521403459059, 0.22584542350148196, 0.16417706001813967, -0.5290398603366379},
    {-0.053974395959844344, 0.6180871519240095, 0.6544697735148336, 0.2898572458406733, 0.2707868747249765, -0.7686746223296748, 0.6542261670955003, 0.9150599668687627, -0.24104233637291286, -0.7469936245647611, -0.9339621589301368, 0.5325837793244017, 0.5979732119781465, -0.11223325832199785, 0.48614528247050914, 0.3560693133621773, -0.5532909243050289, 0.5303093153369725, 0.6072782542569557, 0.8417085067315856, 0.5489888807305419, -1.0894985110040338, 0.7646954290308892, 0.209577537757095, 0.21668269477412663, -0.5804438643603888, 0.3820263519020112, 0.8136259922099484, 0.4491936828769212, -0.41151950747001764, 0.5482092531910431, 0.6469580167008694, 0.6581639406964648, 0.138923642726894, 0.7425472190947927, -0.340015554923839, 0.8183153592391048, 0.24941155905288342, 0.550058626955676, -1.0507522008037895, 0.8190971417355316, -0.024104478955915765, -1.1180930860399887, 0.7102363303856867, 0.4742824118008385, 0.5218432791014597, 0.7360706309717981, -0.29432100994584376, 0.5574344043385889, 0.09067711982507823, 0.7057446254680342, 0.5727712958756045, 0.515694571773512, 0.3535273812751597, 0.5653928804783789, 0.41153246864988113, -0.004340410633632685, -0.9434158077120061, -0.12036155125964183, 0.7000005389056916, 0.9459488009412509, 0.28350063373368706, 0.6334024738644751, 0.3025602831072472},
    {-0.5129431557224369, 0.4828394433226606, 0.35112665116408814, -0.7484365574929561, 0.27124773981006817, -0.1638003672589485, 0.39773833133141673, 0.5172847473489731, 0.11539401791356531, -0.27048235349059185, -0.23995082068404633, 0.3294419006942645, -0.22150035604924712, 0.005658001224757863, 0.38234242646849703, 0.32501995983736226, -0.7939672797971029, 0.0944413499998643, -0.027038565855608973, -0.17356700089281019, 0.5354480440345007, -0.8752088338918546, 0.03323251283385512, -0.6751136119495929, -0.2900994038701748, -0.2904986387443443, 0.5946760873200828, 0.7201651068404675, -0.3387478661607776, -0.3723147619667701, 0.06044091085211343, 0.3452040865580579, 0.31274106625219944, -0.08935822401614772, 0.10482756023964507, -0.47899158690839455, 0.18399579519758655, -0.5475617650885201, 0.5504886013625119, -0.8438432631163425, 0.6188423455446866, 0.23304985616026114, -0.4898617598531685, 0.36001296170124747, 0.7008708964399044, 0.6979286826186547, 0.26068071584381436, -0.5518046943302061, -0.10451929437817611, 0.5778843990092667, 0.02781752653845281, 0.46395651292467693, -0.2989834922354971, 0.4846438661916017, 0.12353541363902096, -0.649049419157084, -0.918730090176976, -0.17586380780487237, 0.6568350043737363, 0.721131319403376, 0.48765523824907486, 0.6349561607953776, 0.6767696592835838, -0.3966306538903497},
    {-0.48423419673280127, 0.6764576096092184, 0.7197559869688561, -0.7732217706816542, -0.21790281279240925, 0.17214662507988307, 0.11814706855886696, 0.5596566099988993, 0.36181195667792143, -0.20754355121534887, -0.10959839152737752, 0.29772015709783445, -0.3631746059215929, -0.13710039707120095, 0.6106925322802061, 0.3297127174976618, -0.7936173272207466, -0.02014329499353583, 0.44207605852570203, 0.16247627382005847, 0.3079849230288774, -0.8051589641686328, 0.3602757195760015, -0.09408249860591976, -0.146471525490931, -0.5204366426509628, 0.3285007382548455, 0.5843666198249553, -0.5751632842312095, -0.3997044112128564, 0.6028140522193656, 0.28221460639390455, 0.29439832924622733, 0.14748182980540603, 0.5249454826755198, -0.4807968987674581, 0.29847144684451343, -0.7989838073615857, 0.5347116535434301, -0.20708659376274213, 0.6758338022175515, 0.30708011118818057, -0.09840325041394991, 0.6545960278836443, 0.7627147515990788, 0.5208843031782517, 0.46459084849060234, -0.6869368981438608, -0.14022180416643015, 0.3523436432666647, 0.4281783732394812, 0.28684493184148285, -0.0650622475320279, 0.7036150242604612, 0.44239791857050037, -0.17449100058335545, -0.3256171401144748, 0.0003989896423472462, 0.5397847517618193, 0.733146469862976, 0.5291417386482393, 0.6741763725579476, 0.5851697898124548, -0.2931798933401892},
    {-0.3713949073407454, 0.8030696541851391, 0.45564445405962906, -0.38146485080107245, -0.3081720189513976, -0.5453237630904016, 0.3955819863205028, 0.1940816275933478, -0.05038645008127581, -0.3313881576769389, 0.022943441224418683, 0.21990026327959472, 0.055850835306246904, 0.32100025860753495, 0.11632074206100285, 0.48715196481729756, -0.1691541566595773, -0.2494520057898829, 0.3854995273495731, -0.11081202967596993, -0.2183575528263664, -0.4275876467467428, 0.16141587086513146, -0.27257911234190974, -0.26012763897831825, -0.14551595976194592, 0.45544854261180223, 0.2159251221058737, -0.49353906999578323, -0.26290750134177693, 0.28286843926804883, 0.25884313319127566, 0.42414969868343727, 0.2702466620277077, 0.5378662550565101, -0.40219105980427294, 0.5625920137258097, -0.26943742138558513, 0.5339380768397975, -0.5528446368272428, 0.41279614323682307, -0.2847287210720745, -0.7630745718306549, 0.6750069972074502, 0.3609303939867924, 0.3800149018499039, 0.16498058505050442, -0.12409196930196223, 0.1546739594937773, 0.22222419839274404, 0.3294568935114173, 0.664272231406408, 0.3357232970457305, 0.04241329374784177, 0.23718501519471447, -0.2845527320646544, -0.3465351515752853, -0.45091335014711165, -0.1443718196664246, 0.6520945022162092, 0.18302948367776384, 0.5299451416093364, 0.3420802506966342, -0.35276602111156896},
    {-0.1511859623274325, -0.06111202973747648, 0.16512589296117838, -0.611345721335287, 0.24579564791043584, -0.10647909858268427, 0.17672251550115994, 0.17222228347388255, 0.08929033154246212, 0.5015974725713714, 0.10417372685270251, 0.08647231511094271, -0.00036645373355878705, -0.42140873866548184, 0.28069909177504815, 0.3364416927497444, -0.09737065929025081, 0.24738406731110296, -0.22823740213196764, 0.4465174967225636, 0.48244124549372003, -0.5237802441483224, 0.6526646062660153, 0.19930427075677828, 0.43968307995927663, -0.1118425911833044, -0.08157401911385098, 0.23472058577261323, 0.1534203296316776, -0.08424239873008575, 0.19746085038521313, -0.12690309611884176, 0.21409386775427544, 0.23514268464406363, 0.5451527450166573, -0.40232917232346865, 0.6637479809429672, -0.18127698080239374, 0.0628225785319477, -0.5590022985972926, 0.3737288827207404, -0.24147472753357474, -0.6742845146834184, 0.5056162707235502, 0.03941191591557864, 0.16629609766701905, 0.6378027976081079, -0.23892257373927933, -0.40877639673567084, 0.4811702166157603, 0.4485195975229031, 0.3602923927319562, -0.03015222615168892, 0.1034785381033489, 0.2467983853346374, -0.10880423644759185, -0.29847372951383055, -0.12396295205685902, 0.09932986329948308, 0.1474072051767393, 0.37459065717975615, 0.17761560230720677, 0.4125388154457795, -0.33001829248121783},
    {0.07579286020315366, 0.18885217359852763, 0.11774469691980677, -0.533050645211929, -0.3289292079683071, -0.057791405984934, -0.2538458835158096, 0.456799754681036, 0.2055325876327349, -0.06747412620292216, -0.42907322364774414, 0.35742360506999055, 0.10109445686479793, -0.5252738197195848, 0.6108601319831262, 0.19277925150394953, -0.32981634132377013, -0.08759643518596481, 0.06796480658936647, -0.08591848197756498, 0.3031678487693966, -0.24495656034397595, 0.3162898045820202, -0.004214890783204529, 0.22327267638933662, -0.2945087572083671, 0.2747377256994984, 0.08989265878344896, -0.3527586087650746, -0.5449991823068178, 0.43168837186859743, -0.22734112026883, 0.2097903317713861, 0.6582875322447984, 0.7045911006264889, -0.39756025672253364, 0.18251887912577291, -0.05807979828832454, 0.5314554493262682, -0.01695823258534201, 0.19884844156553813, -0.04241930355003415, 0.11175981901084067, 0.4581654337423833, 0.6801637635890592, 0.3615172490690392, 0.5581319331195681, -0.16979878073649302, -0.3497889671588227, -0.06584615901675829, 0.19562779343345407, -0.06977492607842112, -0.6707140338903028, 0.5149094626381177, -0.19322413642772965, -0.1346161322196481, -0.6195494060530049, -0.454611221767161, 0.7072876937335199, 0.2625486537925975, 0.029008649392365738, 0.1466425880751196, 0.18994999301283327, 0.11264515500982106},
    {0.2113660070174439, -0.12791995708173798, 0.1752099072369767, 0.24594832597851193, -0.16272791062100772, 0.24959475223229644, -0.071603763876649, -0.1371648971763981, -0.19112213945946258, 0.3069691683608867, -0.40887805465114013, 0.5003987926157072, 0.1993711497292132, 0.41970040253430174, 0.38730513091496144, 0.6889726379636553, -0.7530491541295578, -0.17451282492164685, 0.2784588159467313, 0.17517550167963636, 0.35325449526472064, -0.1060969121626195, 0.3005469822755199, -0.1959341293049914, -0.19353254202207967, -0.19909580674833766, -0.20692387984522587, 0.6171815498234697, -0.019762370404097118, -0.08709019974331858, -0.07596269327898217, 0.5592148425634834, 0.5636143324033475, -0.6402906246917605, -0.21859535579434433, -0.023446909904359593, 0.33165909346456884, -0.01278107418112694, 0.06630292906016655, -0.01517830009750248, 0.40164313164053195, -0.04138925236173706, 0.4192545226559732, 0.25072757635817405, -0.4557633550346758, 0.021187976462213296, 0.40842231173395044, -0.38927263895888053, 0.127224575837326, 0.32126086696161454, -0.17930219593466812, 0.2691792018690549, -0.1687389845867073, -0.1255810171882379, 0.241849438024827, 0.22183050047102898, -0.06937809348731452, -0.6032741630320392, 0.02115514938170079, 0.3946309638310281, 0.12621229250179236, 0.5713607054847819, -0.09417246743630937, -0.18207717174501956},
    {0.32539295667429247, 0.4199384276294912, 0.04963702802205902, 0.06843236450494644, -0.17524647570781926, -0.5092910151657413, 0.11325269796315264, 0.38899766074225833, -0.1443895045321677, 0.6429401417995174, -0.3276423588008054, 0.32467753084731465, 0.5502204453049345, -0.35441402969623675, 0.29366530590655515, 0.1574541735213435, -0.6031329335468025, 0.35470880914380015, 0.4829983509985003, 0.7694616572291526, 0.5734942655317037, -0.534031516069189, 0.6639555432329852, -0.158709582681566, 0.6218765153968826, 0.13773980593966936, -0.18880754871515418, 0.5555380696967815, 0.23617798312325466, -0.357692224137223, 0.37370214485411707, 0.6205303755829683, 0.49069017092780826, -0.2426601434943158, 0.24754497936961453, -0.850035172666924, 0.7214092373281473, -0.15312741491835477, 0.14270329401663284, -0.6201591376405594, 0.452684703012856, 0.09475043649948298, -0.09312377499011176, 0.7970939132755417, -0.051354716192737966, 0.5435087597277757, 0.7256510385404836, -0.2543829013223854, -0.32045216612964844, 0.03572303038626094, 0.25542783379429446, 0.30325502204066856, -0.06746298747692453, 0.11530146335180551, -0.16017245016911427, 0.7041330553131567, 0.3547429584740934, -0.6069753742976156, -0.2721316172126552, 0.14983413559267092, 0.7329579193870299, 0.14619242441299143, 0.10210379300676904, -0.036097419392267856},
    {-0.2035188399051664, 0.19085700135448735, 0.49035548329328127, 0.07520165384593076, -0.22172029138894547, 0.42545967393934964, 0.5758348603541456, 0.5996533162896442, 0.3346824107349537, 0.2888900421196869, -0.5314354879742468, 0.27745752882681174, 0.32470053305230107, -0.3001783498568064, -0.14450886442720123, -0.16456288753950096, -0.5703168246200144, 0.1376899679937429, 0.47261710580383415, 0.22737063139562627, 0.4965480120066899, 0.44309665840919144, 0.5644900473653937, -0.41634762273289094, 0.5301247158211113, -0.3434490468350313, -0.5405369597727339, -0.08501580014907642, 0.07271907084735367, -0.18398285460748245, -0.14447103460930386, -0.09440843869969426, 0.21664227318927756, 0.37657344815993604, 0.05183114426487672, -0.6304271648956828, -0.17955231594718984, -0.18965678779162037, 0.0689051040752802, 0.3204227460970546, 0.23877366820141752, 0.3145473562089073, -0.037458482301284964, 0.7668590713333845, 0.3634713622267154, -0.27249321146287997, 0.390127063275215, 0.3804318620752552, -0.4860850591960588, 0.41903736522051765, -0.19776410607083247, -0.004365377621294856, -0.3118040070019704, 0.1967911760994419, 0.08532267849498665, 0.30049581303862954, -0.35847217285664584, 0.41169274934911165, -0.19314800257789644, 0.20676704733506412, 0.21539086075962607, 0.021257218633491552, 0.2898077613660374, 0.2925991012164673},
    {-0.44117072649237343, 0.5936375504862523, 0.03697966278721217, -0.005710069038554027, 0.08641817191238894, 0.20111286409189566, -0.04240353216142231, -0.051853306850177014, 0.603056303609749, -0.7197632803773252, 0.5231938532125859, -0.001508988889753738, 0.15289505818489843, 0.23999301340180768, 0.27993716254177253, 0.4185255288561723, -0.38196439767517854, 0.15527731681629606, 0.417597601985804, -0.3325395497932793, -0.17328450872894133, -0.4530259446799335, 0.3363351936257504, 0.20242962197427056, -0.5710932476776814, -0.2925507812785681, 0.6157254012123365, 0.6229675065530366, 0.40541400232154295, 0.2015321744415571, 0.02804870237290316, -0.11277136129803668, -0.20185563915577698, -0.602242554821722, 0.36606374509716255, -0.11955107902740886, -0.19053317300861936, -0.1785377159865734, -0.1953855454333406, 0.3514339839333066, 0.6860929226955594, 0.4936684222067964, -0.4372547216270299, -0.4189800995036712, 0.3965569046485078, -0.3003475549684508, 0.11381619246961609, -0.360635133120321, -0.3719184097534798, -0.46690429484782375, -0.23799111972434853, -0.128266070580459, 0.47134725949645623, 0.2532673417890198, 0.3309881316922513, -0.06291956968176445, -0.661254923169973, 0.4726964170538351, 0.48232912061487865, 0.36921176899409497, -0.12879156313041806, 0.5385534042766542, -0.019804494441038666, 0.19327403692614878},
    {-0.11144802967589743, 0.3774426358275758, 0.0361115035981902, -0.035957325068745105, -0.05752001073257726, -0.13912165102790747, 0.017434602145624072, 0.4620783926150607, 0.5404018951616999, 0.37768607335848764, -0.02934066386125549, 0.3404901835664523, 0.2760964794254579, 0.15958764859971744, 0.05835133226093642, 0.5454665395128238, 0.040536670928281275, 0.4484366840423319, 0.6195993132234477, -0.17057726711216992, 0.6026675551225353, 0.26016627244063667, 0.6303194161742712, 0.21809406129334763, -0.21332391744039045, 0.12297009902637095, -0.4907844126679044, 0.11493733245116672, 0.3161769375620619, -0.14544603709188933, 0.05152271287830404, -0.4249898933971438, 0.39355407520690333, -0.22447517336540493, 0.6344252418919233, 0.23051032770586183, 0.2102701526420897, -0.13044374355489158, 0.6591711486589946, 0.22181900535204782, 0.09172877637738253, 0.1007587572507092, 0.03516632956042371, -0.17627522850354846, 0.7975839191851696, 0.2848006458649259, 0.4645558251295913, -0.464190140069664, -0.31630676230991717, 0.4281496649132125, 0.3300805366109079, -0.22120360270503145, 0.2934216772985307, 0.45189068611478417, 0.10747148823700853, -0.0322495197457942, -0.04691849305195473, 0.23673031849759849, 0.8213425407927719, 0.4758821876570868, -0.10491774409404811, 0.43245125309130467, 0.04910577766626084, -0.45995274124860785},
    {0.301150665884428, 0.3079169534290193, 0.15281522818863655, 0.509189146658909, -0.045351416731565404, 0.4882385358111714, 0.7373160304291739, 0.40392766349777864, 0.30233245523281127, 0.22834368418196938, -0.6169260686341531, 0.42381714306988816, 0.5987827608455502, 0.0216707037792384, 0.18860733091864343, 0.5612284212713156, 0.13146301445705796, 0.4202437611771752, 0.544826241473519, 0.26598271620377334, 0.5066116867959006, -0.33875325346742075, 0.4906480537463087, 0.03550792632240367, 0.5184182009637069, -0.40109310307882134, 0.4945237123465136, 0.534599234270088, 0.34366882489893513, 0.20628028035254756, 0.38045534695864824, 0.012090030313187701, 0.4188430056425965, -0.2613309570730342, 0.6070337674689462, -0.22425347400406856, 0.423453085302169, 0.4700842807802296, -0.02348418206813263, 0.07876961182147184, -0.12430864820294, 0.028455128695641076, -0.022814170647288506, 0.24524511638946023, -0.5490819862513433, 0.09925925047798981, 0.16740446824529273, 0.450609730101348, 0.03468703638638069, -0.16449554394286867, 0.031298403824293816, 0.3690068733960687, 0.2701712054135615, 0.03945827271039815, 0.3613238496473823, 0.45854429594903373, 0.7186238613538045, -0.17630940201889775, -0.21599547476490333, 0.0288361538967243, 0.4863849066637347, 0.4017962157929473, 0.25302164281256556, 0.44062886266413875},
    {-0.3436335922909038, 0.5691972318068939, -0.5788595777163568, 0.04269593181499912, 0.09900485744320135, 0.2825171457705016, -0.08811728770470428, -0.3316507497486185, -0.3862267940098092, -0.44025810918917363, 0.0484265834610276, 0.12073963741062696, 0.336002219185983, -0.5550213479309982, 0.12727450060790996, -0.27235459083661684, 0.21520802219917667, 0.18420446932597567, 0.1100984023529967, 0.19018458071178415, -0.23873056434657097, -0.635863751239099, 0.22648283486220833, -0.10192041804221656, -0.351245418452297, -0.29530779901546383, -0.02244489228960829, -0.23689656416671961, -0.37570477127079877, 0.05139549649744174, -0.07540365405034864, 0.32208166300371144, 0.3010808337776569, -0.005940776023754213, 0.22943580085786278, 0.33295768208179904, 0.019930932462554576, 0.012587043046160472, -0.0517118565898675, 0.1010913584773705, 0.5148804120551973, 0.01252725544223995, 0.2031018477498575, -0.2097614417184357, -0.0355015330025534, -0.10966246667493869, 0.27379392715358064, 0.03939225568700324, 0.21990164423319805, -0.07546857618928024, 0.19680086660552634, -0.17979778658584206, -0.20534919190228987, -0.11735023974404546, 0.07969421259410658, -0.18381473802698503, -0.11954513794637425, 0.16416653759164443, 0.33834658983545046, -0.13590687940217344, -0.08557304380140648, 0.11027936748774993, -0.012397916063011272, 0.20128655342261792},
    {0.4627829858263014, -0.16244456168495824, -0.24645246375634505, -0.2766707223680107, 0.010085718408566698, 0.3290671735493577, 0.40198799733770146, 0.6547924771532175, 0.06707483090916037, 0.21594354001928617, 0.5745947664893127, -0.1431754901847485, -0.05427405599328639, 0.31332825834781897, 0.607719999405946, 0.6689994672513597, 0.5003048058227708, 0.30310756613326484, 0.19999637112174262, 0.5602692913229631, 0.013314945130696046, -0.3356176776362365, -0.009853145862183882, 0.409610300764028, 0.5472976252133576, 0.5991883692094222, 0.09931363829260266, 0.7058411419490206, 0.10255842492131424, -0.04673431213796497, 0.5207081558422608, 0.39191178118065645, -0.3420764436468789, 0.38596439031522667, 0.28176703733696346, 0.2732028741087237, -0.17308272530642868, -0.3371181429398149, 0.7253886089556106, 0.7371198439786042, 0.5111631571362895, 0.2817226665422839, -0.32850710717665943, 0.2708219703997155, 0.5563197788428476, -0.3127772178066829, 0.45804098180288794, 0.022288614180984077, -0.4338092390026401, 0.12511531011924792, -0.11196521177064213, 0.42622970763821255, -0.041214703732354814, 0.45128684821395926, -0.1257551131370136, 0.11287331650238389, 0.22107619988628263, -0.07693158018500965, 0.6675090229631259, 0.20425310894661497, 0.0674903076569756, 0.3926757735100869, 0.34846450687819525, -0.27368189436429396},
    {0.3104904094438782, 0.32891381787388446, -0.16639924147412893, -0.3254532120067677, 0.19744834084688828, -0.5337350437609515, 0.39699721575376035, 0.6857070771656543, 0.07896662942838417, -0.10587591225373127, -0.47077104027833677, 0.33088272594457424, 0.5394024715963117, -0.4053898481427854, -0.03542817790980238, 0.3529530103411462, -0.015851923218297946, 0.4192056638887422, 0.17397493566833727, 0.37026539049218077, -0.01496523364631552, 0.017898583733780272, 0.3173666692195698, 0.07969002096933857, 0.39006449920584424, -0.4331259105473038, 0.15173743052227606, 0.0009614580642996213, 0.2479545492381661, 0.21460823645259064, -0.1075555819031659, 0.6468759964038575, -0.26491934251672, -0.33268171776249095, 0.1887724612342373, -0.24512348835548703, 0.43633922972994865, -0.06207772433340662, 0.4569538872075058, -0.056269446754658024, 0.07991473880800655, -0.3391334371705853, -0.5089053892500205, 0.25950454354239705, 0.35090752526893587, 0.2705568502080013, 0.37346870341081867, 0.010148494661380287, -0.03155011434392973, -0.05461889216724994, 0.06762388507291588, 0.5135492964438099, 0.28373827265001905, -0.49699956995837075, 0.2755666265624852, 0.3562758974988397, 0.5718162039943834, -0.5003495822892983, -0.6250153494548291, -0.29717520486466276, 0.2247437405947793, -0.7063194539530765, 0.357950300719888, 0.3625434916570242},
    {-0.267331466705525, -0.47861672510970166, 0.0028256365967019833, 0.21866421485408552, 0.15823555460782265, -0.20431013736815445, 0.13353340411555917, 0.6816893731517323, 0.17499956640286518, -0.23434233601117924, 0.36330424366999275, 0.026711634422459163, 0.46588173486655426, 0.31806813059821687, -0.004564497873477915, 0.125175640757159, -0.23918658098956289, 0.432005345063594, -0.014861973162823271, 0.033949357478451486, 0.33798591668579825, -0.4745479383463, 0.5235226399300066, 0.15920718783825819, 0.14264795004855182, -0.14551265595027407, 0.1520782870324563, 0.28049765400902, 0.5820034989055088, 0.4868357444181299, -0.1968227777846301, 0.7089970496403428, 0.07559869020516355, -0.3621411889248232, -0.046870222492485084, 0.6635206607473076, 0.5175757051814335, 0.00857823543346226, 0.17777246295138274, 0.07882048218270493, 0.29691454486309027, -0.20417485131286617, -0.29884512442326056, 0.35040656555619515, -0.28192076283131506, 0.577634559156769, -0.0037700986415613222, 0.17487099652116025, 0.46349288091844, -0.38897073671330057, 0.4496555760620472, 0.456313503306128, 0.06438163448480955, -0.2504553164296238, 0.17173478318008017, 0.7620470477591964, -0.04855562022350811, -0.10790944895147712, -0.30467452429280484, -0.33333074667768525, 0.13491306555364443, -0.1307689974407819, 0.05196492305170471, -0.025615860946199547},
    {0.038225655535743835, -0.5067423432253376, 0.359732669031016, -0.03688350540600134, -0.40629920714285045, 0.15434529368547925, 0.23677949912969334, 0.49860851622433433, 0.45131979051778826, 0.28655016699202424, 0.4599277173175053, 0.35692304737020075, -0.15361377552883226, 0.055040626209196454, -0.22888488258858816, -0.05614319150659315, 0.17689794242716195, -0.14021382225861706, 0.19249807763754911, -0.29004660879636746, -0.595228303106473, -0.2931873284806188, 0.2455397758662016, 0.13583398774971112, -0.012217210091145373, -0.040058894706361516, -0.22776995018643217, 0.3726205259356974, -0.4718293791806253, 6.911298419544172e-05, 0.5614505519481531, -0.41401635631567163, 0.02564776761982728, 0.22147682769653043, 0.18056233384464307, 0.6262563668964345, -0.1104602260064734, -0.30907599105816475, -0.07210504066208313, 0.23442853785001805, 0.48918345458815243, 0.3019277510786426, -0.3758488090292456, 0.242980526134903, 0.22671965031438887, -0.09649254741442702, 0.5071433237335147, -0.14326377025899054, -0.361386241592634, -0.09778314047944267, -0.11301658852912301, 0.25508892161790225, -0.06497956629106866, 0.45543724646617273, -0.09859315692119745, 0.21482264162375156, -0.022184914510687857, 0.4316066533251421, 0.17450041939636496, 0.5090062277252151, -0.39960159049325145, -0.009302533921246296, 0.16856147931702772, 0.12364342522091373},
    {-0.2692150628212805, -0.6808340377593873, -0.47011348090691424, -0.376609585077567, -0.6913536133662577, 0.1800827389955023, -0.28142164778481626, 0.6083596141101183, 0.07895029235932763, 0.07354684002222492, 0.44563383991321454, -0.32212231380397305, -0.30716381244061025, -0.12571629401293982, 0.27092408325177114, 0.6486496224626901, 0.47165838344932715, 0.3698893446798734, -0.006506278057956608, -0.16042723074442938, 0.14667427621054646, -0.41047637976100926, -0.1309347297210735, -0.06372131299503482, -0.13578610985516998, 0.11352443470045379, 0.5159895104096031, 0.3589037728261363, -0.4970816917174916, 0.21116207709256676, 0.3336637539220837, 0.4423741267296191, -0.44460532682219334, -0.28014923364895333, -0.3457787626391311, 0.41295782029793565, 0.03543310764938296, 0.03111768275268617, -0.3451228555812021, 0.570803801909336, 0.231648517293644, 0.4510210807590786, 0.20231150437534448, 0.4379898157387202, 0.1488612915916624, 0.4418585357640484, -0.09138500893228978, -0.2921720843467701, 0.06423888697010459, 0.02800720391332203, -0.261166028643756, 0.06206801832075029, 0.2781066509704181, 0.42437998082746364, 0.37514898175826095, -0.3797263848796196, 0.11140533812446207, 0.6125562544157475, 0.7322620057883384, 0.2634117005916624, 0.18546324602695535, -0.13033250702707638, -0.2700457635215098, -0.4689088306642727},
    {-0.3485769419315847, -0.23279515901036674, -0.24815583521789059, -0.4879678760415684, 0.007310749062865938, 0.44370074110646457, -0.22074527917054185, 0.31561259732812513, 0.6019196842393915, 0.3732184632223225, 0.3993770621203266, -0.01358887783018023, -0.08194715686960063, 0.28750936240666863, -0.29622916517073106, 0.30108732047715575, -0.20289554808945445, 0.3556716057315004, 0.6067235839767255, -0.27243731958268474, -0.2201835170402161, 0.023716659097416104, -0.019868812894054545, -0.08621072806797868, 0.27748996148841015, 0.3867724497422495, -0.32866388093038323, 0.3106052432001635, -0.27735657580599865, -0.009904776000168248, 0.4417451817485552, -0.2774655968696481, -0.5222014606088806, -0.005323639616820383, 0.12171129751621496, -0.0977154976520542, -0.022852397617195562, -0.25657631648675533, -0.17309530676357895, 0.12340329991697678, 0.38882916214338215, 0.25581191537480286, -0.11446693400097205, 0.05119078708196823, 0.265657571059192, 0.10310590229513437, 0.023411409562265575, 0.4335973992418961, -0.5897921165359116, -0.12770974720091327, -0.06416059343090397, 0.294698560684588, -0.5169106489144814, 0.6779519746337456, -0.6364952691903795, 0.3834113099130737, -0.49093377839152885, 0.662180847382896, 0.4731188346019665, 0.5463649800807834, 0.5034918957522971, -0.09121423235765186, 0.02298805945175936, 0.13992485519929695},
    {-0.3530406760777569, 0.04296373445151947, -0.26173773328892336, -0.06629334400351758, 0.1537890659142842, -0.15571750882642646, 0.42505535661856, 0.03172315127575485, 0.49484218493070053, -0.30319723351914013, 0.18488573339557962, 0.40369501305674704, 0.39992890473347703, 0.579166219182429, -0.0031320337653707757, 0.7203057248349595, -0.07310770257806888, 0.546153537331425, 0.13392810793507837, 0.3819742272546987, 0.03648317949974803, -0.631969220022591, 0.5325380661842789, 0.7251608430240113, -0.07189509452215792, 0.7156745811834109, -0.5980985817098191, 0.1639638914075361, -0.27049026068755155, 0.3497640167762309, 0.09077669341965502, 0.4063370781349826, 0.32549282114841716, 0.3806670942418505, 0.16683578235747407, 0.1940869603120549, 0.5391372357267247, 0.0610585396152672, 0.033327936216192774, 0.07575644703704344, -0.4233752210560439, 0.4747643355981948, -0.6647185547411527, 0.08760491702889033, 0.5460367013658188, 0.40867352516568867, 0.17060854299725517, 0.6630912637639377, -0.30557229066257696, 0.630056370001093, 0.18891333022391787, 0.09828113607107837, 0.5028248100586477, 0.5227229591476286, -0.025660053167420538, 0.49860795959681836, -0.3193801094818123, 0.4796512890360833, 0.17066742358798317, 0.4694062077678305, 0.4769563683178273, 0.36549754816092633, -0.3371810354567539, 0.3124989680629446},
    {-0.1372166380619698, -0.29471095758145355, -0.07756650220951368, 0.16171824803465618, -0.41240939933086407, 0.6215061916448723, 0.335089231923736, 0.3801587712428332, 0.3547589515089878, 0.17943267353910347, 0.30383821243370773, 0.049318931081517775, 0.38357928498454624, 0.6005759504002982, 0.022028639232074446, 0.5918288564597776, 0.48897323508504975, 0.4794995883158249, 0.6452064343370623, 0.49434304092653364, 0.3679412139722926, -0.007137877780486524, 0.5365018222230822, -0.1591060204611487, 0.3714347141207588, 0.33692845968384316, 0.5108799380156129, 0.12618554779809218, 0.6152450331543007, 0.24663065308983706, 0.31075939852028317, -0.2679746593961607, 0.34033240195639575, -0.5013311395245197, 0.18282799214277137, 0.48369982030937175, 0.24356524560789788, 0.09806246362662176, 0.07776886424150835, 0.4485796893581651, 0.4865995309701521, 0.17155545409582798, -0.6470939925533419, -0.3649365389181362, 0.42267618813424296, -0.33934477991622813, 0.5684479495934043, -0.3261109946935441, -0.14126970196812524, 0.5012712342978249, 0.14993842426802542, 0.16084892924161098, 0.3121938115260541, 0.6661585888370877, 0.45936957973709497, 0.4133588623512875, -0.12367541344067463, 0.40517847756803593, -0.14633789624283147, 0.5289866418122307, 0.21854960474274376, 0.07357587907523229, 0.060379896438389334, 0.3128327292129176},
    {0.14535763845338512, -0.13464381842052536, 0.2346855127336636, 0.21049040857334686, 0.5503003930753109, 0.2028638730507273, -0.05618143363024258, 0.15610515473555966, -0.17212819878070917, 0.2525091586370768, -0.37222588704572485, -0.10275092562680868, 0.33549908551860175, 0.029195830558162737, -0.17620504008698168, -0.005559699337296758, 0.0028204315340623833, 0.4053327617299998, -0.15791820262013181, 0.0851727741452767, -0.16746934264602462, -0.07358588636966124, 0.19162629592186717, -0.5890533835111422, 0.5069084887001424, 0.3301591798129586, 0.19864926350563644, 0.5900628209001518, -0.13953937870665706, 0.10644461291196992, -0.049991561790038226, 0.6135764613135869, 0.126267058335346, 0.01549836063420433, 0.032685378232173025, -0.11943644397485897, 0.2974728801636106, -0.3120108421513394, 0.5037959130682945, -0.35866426217827296, 0.3610343390435893, 0.05826911293395671, -0.11211621041967408, 0.17728488533621906, 0.11416905197942581, -0.07314068190632018, 0.40669510716628615, -0.05104923511536335, -0.4513103475744263, 0.24267788396605672, 0.09980336881527727, -0.14960677474064263, -0.5348852232454377, 0.14771155496465513, -0.07717822734438683, 0.2624700485936563, -0.21542422898238836, -0.017489643172519595, 0.6997126122041651, 0.17580736756084986, 0.3205528225660211, 0.07938994788561814, 0.5519700038831142, -0.506964718431997},
    {0.31119486073642433, 0.6371475982110669, -0.17012065357288234, -0.26942330738191383, -0.32452386639600306, -0.18060270400352552, 0.11007180084228788, -0.24119622216798262, -0.4948663027055352, 0.01592829641582463, 0.08079430813093373, -0.19491193429855413, -0.20447085533054904, 0.08161119605855428, -0.45345784088918456, 0.7515098703056711, -0.3419370193621755, -0.14688812033946563, 0.308739300914149, 0.14786030350231327, 0.32624079717910787, 0.09453499247977219, 0.1723760504405723, -0.16269268158058756, 0.3896189414320581, 0.20633709650703755, -0.2984530392246714, 0.2859055721390046, -0.2727684974606452, -0.3162863196588276, -0.053990664084168874, 0.10356678107388406, 0.21254970194322725, -0.751945004493966, 0.31831900432435073, 0.0752692819747715, 0.15888311117211099, 0.5072706870419138, 0.3418353321851936, -0.11841819006617908, 0.2883679610865294, 0.006438168926195487, -0.6125218995639736, -0.40340523856426663, 0.001504490540681008, -0.36457778494318394, 0.15060497633556694, -0.19134589294522183, -0.22313371995990283, 0.07218506164993273, 0.1317780026198992, 0.2662096557744739, 0.16918688571574036, -0.6069672097779182, -0.4358172781634799, 0.166441687991197, 0.07245649589978584, -0.23973352603870876, -0.23116928111385457, -0.002233366156870723, 0.05988519704959614, -0.3618792007196046, -0.235459906137693, -0.41689031751774674},
    {-0.2584621443871176, -0.05621919659992587, -0.13242798226149471, 0.6053191394595336, -0.3435987097702005, 0.2381403356470094, 0.3999598386977232, 0.116210198470683, -0.3308312210774799, -0.3551025523101286, -0.21027100012755542, 0.26465047275265347, 0.3541107601096768, 0.26858298284117615, -0.4924685361546844, 0.19605467823611916, -0.5383887039916283, -0.0802677334144412, 0.5604561784839455, 0.3886372605981911, 0.06705815390928438, -0.3844057872292312, 0.14696636228044505, -0.24645862155038703, -0.2630971807227899, 0.6069272680589752, 0.3507771929106638, 0.4019240689488657, -0.07688470554857514, 0.11264371774699958, -0.1651346110684625, 0.6608590110128769, 0.13338748423852373, 0.4987382426598351, -0.17390335004974394, -0.6037107766398471, 0.2875361513813966, 0.5349179040982338, 0.002563830830046199, 0.0029377830651068043, -0.08413843515201402, 0.19229340657743507, 0.2520665730659761, 0.2422913975199985, 0.23956529929675444, -0.028884997340704797, 0.43936845967287425, 0.020723478599275584, -0.11955082584251175, -0.4923588535365974, -0.10809375116001455, -0.28061017729150795, 0.33432717295395714, 0.0427064470378016, -0.2856155220509093, 0.2662323388472938, 0.3410124841788235, -0.4869873751797621, -0.3588020116967878, 0.28815778811753534, 0.018284114895251325, -0.21217748716878657, 0.08129194194370445, 0.2847530660131548},
    {0.40708181841737706, -0.2131758538795172, 0.3070144027237037, -0.23133506989521693, 0.07454662717920374, -0.5366818606067821, 0.3474545628301994, -0.0007097113631083974, -0.022298750244963115, -0.35686332848997243, -0.11887831801149468, 0.15910563211688017, 0.30002077927562826, -0.29206214389082397, -0.42394234694769684, 0.375262417209261, 0.47861967715325165, -0.12243388915965431, 0.16490751287704228, 0.06474618194042435, 0.14461034422968777, 0.03623590855917135, -0.1750420701637498, -0.3279726155303083, 0.6313539658288618, -0.27154178522532507, -0.7136787852272398, 0.1712842528702184, 0.5086166402458825, 0.25340021308917315, -0.17882785015460131, -0.6166837332677544, -0.17252180964000424, -0.33582994857004816, -0.4900773420741039, -0.28858651656702866, -0.2165043674652685, 0.16418903080358238, -0.37185956581868945, -0.06782036801670929, -0.3727835656422257, 0.3765697225644754, -0.35514112685138266, 0.40881442757906883, -0.14326664589312418, 0.2859862762272092, 0.42983667914809953, 0.5055901466373657, -0.4894789013360212, 0.06422693697759237, -0.4608612005997319, -0.06351072970755652, 0.02640594222235512, -0.535117813510568, 0.1851994212056003, 0.03198007034926912, 0.18718903793188388, -0.3010281102694514, 0.022452003860289574, 0.4332852435411975, -0.05639455571344339, -0.595648082765877, 0.38662452154346943, -0.4303965047371118},
    {-0.0077327533022562255, 0.07435752311819421, 0.557047967224427, 0.3549195750240076, 0.46527358793386303, 0.13233996440510432, 0.3308580599032997, 0.2754272666135761, -0.298565885466188, -0.1523870587289882, -0.034285165029767674, -0.09176277077777215, 0.0997146685822469, 0.20693536903420517, 0.33381304484985547, 0.5456482522878838, -0.4454198400557245, -0.07045665621745704, 0.09533778612130982, -0.20290242197707292, 0.3130192021217927, -0.1976792278066881, -0.03475565151020617, 0.28580589371480536, 0.0768243149229489, 0.17273506727869975, 0.038830437011676065, 0.3717632608995508, 0.376581570841106, -0.030439575072502223, 0.12931081220999907, -0.09361564769357889, 0.14546244784961143, -0.2774736956198988, 0.7585843797085361, 0.4688919142408204, -0.15024383345031553, 0.4479781138071808, 0.2583756895771851, -0.3576115196892469, 0.22225111935323438, 0.16180077399187465, -0.36471912584313926, 0.0724531251522934, 0.4994828438953804, 0.22687083465277197, 0.05047640022857929, -0.08318424243909216, 0.2532352127100058, -0.29851219797286976, -0.05968313683937907, -0.21005413433035172, -0.09982713047754846, -0.3901348292043331, 0.2870465960273242, 0.41864970010460917, 0.1543309902989583, -0.3760680238065711, -0.49578847248844216, 0.27149275484981955, -0.0055613713148534565, 0.2746997735329947, -0.07510758542941263, -0.031401964584252914},
    {0.32238759291841707, -0.2576179306563122, 0.3987883365997868, -0.18677864571766703, 0.5515382865573043, 0.02375357681028418, -0.05380018816606408, 0.2798476594957846, -0.11162959008636823, 0.04483126687217368, -0.11683289577026477, 0.3753611763345376, 0.6801123833699197, 0.5092258206704559, -0.6189471745607605, 0.5315707260464471, -0.08413073244635616, -0.05411240524273995, 0.17547059691184633, 0.18945104896896744, 0.3078994013745024, -0.20520006395495716, 0.574271170182974, 0.26893263785489846, 0.07056268489747936, -0.1932105534045185, -0.1377512079132576, 0.5214502615031257, 0.13704322748777992, -0.31532940488805705, 0.12493111326879668, 0.4704417837770318, -0.04120757614156737, -0.41970782410996815, 0.06718829278684942, 0.23286474141335026, 0.3652466682824917, 0.7836878737575721, -0.06279806202209633, -0.09754640367793194, 0.45351696415609166, -0.5051284930481594, -0.027011780580348206, 0.4631718742155606, 0.3150751375487262, -0.5201780531601369, 0.46068851200118943, 0.037108448778454026, -0.20995006920554612, 0.042490924441804356, 0.38837158010682254, 0.027354040469309737, 0.4490769988807059, -0.38100971983167536, 0.2606547197768043, 0.032942994159533286, 0.3978287970620398, -0.10193105746077756, 0.09743601472082136, -0.007583454924123983, -0.24326523850590107, -0.767118459909475, 0.4997159879610012, -0.11874343143675622},
    {0.5686065734081276, -0.18253671202736668, 0.1743707665869377, 0.361380980214462, -0.16451710225995858, 0.22710044135537188, 0.4281565754727262, 0.7773395492031415, 0.4693546966826498, 0.6119897439924947, -0.25146415436293024, 0.3775295784741261, 0.6755116467018726, 0.7192012204785954, -0.28861158127995934, 0.309016779156705, -0.6499889752155047, 0.5324104134622784, 0.7566759193212192, 0.6162428034186511, 0.4678839868962009, -0.043638683024119246, 0.379955014506202, 0.5555992815971573, 0.5158354144908958, -0.5132129120188621, 0.15758920149752714, 0.5744021793043775, 0.16537716654813375, 0.3494674020895068, 0.4346096158681557, 0.43284871531332114, 0.23559562079352253, -0.023928629738739427, 0.32156614952567614, 0.5899259040153029, 0.2525386244935722, 0.5232173698382824, 0.8469537965108933, 0.052127011904441994, 0.19106052472824403, -0.07240485669708384, -0.127246597226942, 0.7189826956283907, 0.05042744726844522, -0.1136593604036451, 0.6565338717103442, 0.20128367180106654, -0.2903148665879327, 0.059308552172357275, 0.6282316311908813, 0.6345284313323712, 0.47699461894252054, -0.09465735227331612, 0.517777516927673, 0.8457787802509381, 0.7854926291707754, -0.2781045680522122, -0.2881878763094762, 0.36506945048766026, 0.7889344221864267, 0.24565353742062046, -0.03798890945353638, 0.7538654483196235},
    {0.2922868628471935, 0.06944339151332253, 0.005758828116226971, 0.48847944696178264, 0.6436880495976017, 0.4809387721160667, 0.1629303860626868, 0.2222711953323234, -0.43441227500252055, -0.025847585614343457, 0.07393775949692735, 0.14535611032272863, 0.3851095047574403, 0.08388381008099165, -0.25220722857525185, 0.5659812585184321, 0.23312671056629827, 0.28188709785606725, 0.35610688426240755, 0.7129697174728193, 0.7327303724904715, 0.17503125898672198, 0.2202661016898489, 0.5015433555627867, 0.13586798608736267, 0.3385270522696281, 0.14132442588868155, 0.2068684966722808, 0.3532605740812223, 0.29897919963821407, 0.422790883279871, 0.07149310513486065, 0.3873132680979304, 0.03516634528490086, 0.10650053952648571, 0.26528136709918926, 0.14570171330450438, 0.427887243830348, 0.2299418362751912, -0.5935729876912444, 0.005474628171117443, -0.35289103952791706, -0.25737181854514923, 0.4958686557707968, 0.13942608542480067, 0.20506027505331845, -0.2089959774988859, -0.0864562090737131, 0.26138211726342403, 0.21623665290666558, 0.3485172302183786, 0.5381985578745966, 0.6752464171732682, 0.015700522305241903, 0.4753569814039567, 0.029695104392542315, 0.6815093112621305, -0.021488205120029653, -0.087062992800048, 0.39475529592283526, 0.004296957915309982, 0.036337876490872875, 0.4019602669235715, 0.36807551109080583},
    {0.5090115446897757, 0.19617372101660613, -0.4053269551792441, 0.2296355448904755, 0.09432737284150566, 0.22714687581107532, 0.17851818654548182, 0.22171832788739457, -0.034772231255320016, 0.05892653815318415, -0.06928126042661237, 0.18230867409022283, -0.1892990758384129, 0.14931598782866404, 0.2041389569838579, 0.13627516810133639, 0.39117568628021493, -0.10214532054697918, -0.018260785054732605, -0.07308032921169813, -0.004441991187424483, 0.27683988816796984, -0.018086199580553436, 0.43695008643952377, 0.22092141185945477, -0.1636145321964099, 0.37072210517759296, -0.28194848912741166, 0.4978333015366149, 0.2770325905032403, -0.13895755137001325, -0.048936458469136974, -0.10136578400138833, -0.07221417117084397, -0.08698508974871397, 0.45379099970793824, -0.2740660663432582, 0.016335302038728745, -0.3733048629516141, 0.03278349306088141, -0.21440126120547892, 0.13911867533111083, 0.05722431916135935, -0.1075060466821924, 0.042185155360411515, -0.28900376010917683, -0.16859307980320368, -0.24246183456474588, -0.37926584275702163, 0.06600026881529868, -0.008500289104827414, 0.10929798251539337, 0.24460480689359201, 0.008301275294182444, -0.09750981648833262, -0.07563555583391258, 0.022860954408810256, 0.34710368614059356, 0.13295679730384063, -0.18684314179714953, 0.19678231268474802, 0.060195535709907794, 0.29056598793289173, 0.2683427443626139},
    {0.07222872088083228, 0.3920995341608404, -0.23061936878890882, 0.06271299374501285, 0.13309257770591967, 0.30783049709282867, -0.2800657300825222, 0.19658835178888798, -0.38503153353037806, -0.2671188476779991, -0.11147992609032578, -0.18651084686576228, 0.17419290613774646, 0.3327077781613153, 0.006880040301887686, -0.05741889022638675, -0.03051384757187804, -0.24175069636211505, 0.41689898611351617, -0.1587240013066733, 0.15879980231305835, 0.446147059693409, 0.1059608358345145, -0.16431124213200812, 0.04110782787224174, 0.09299759233446786, -0.24046149394675068, -0.00383795740358835, -0.017894082387212417, 0.35444370013341675, 0.05818307440047156, 0.2613313190742015, 0.5134965324935433, 0.7098146954421719, 0.13549559514069312, -0.09732103760018884, -0.033130497796131586, 0.255270961436919, -0.3082094630579482, -0.18256841668649296, -0.2310567184657176, 0.33758270442851507, 0.4983804544692949, 0.40187350024460244, 0.054262126651080454, -0.17216426771825794, 0.2641059696795577, -0.22500246777949748, -0.0977689423512132, 0.5562824303038454, -0.2891276611791295, -0.237153111657091, -0.05971162847366164, 0.30546823167522563, 0.08813731747257408, 0.391683258819173, -0.23396325871803436, 0.344889077265648, -0.18506056283355643, 0.0467020433701079, -0.045633753429863755, 0.014241313505373793, -0.33139969162536037, 0.41320387778522233},
    {-0.5079121310024693, 0.19829108974577345, 0.2951900493416593, -0.19906510813707518, 0.1700591640723275, 0.2656339060264674, -0.030811639106566945, -0.008147073606030751, -0.27250376967943896, -0.32552506261658026, -0.39350024236895614, -0.29652066369528474, 0.14475714941868034, 0.5227867124314468, 0.3060980123359505, -0.1400334411104275, 0.1383906280580593, 0.22371440422254052, 0.22873301685480052, -0.19628105295944995, 0.4392385428601571, 0.34374841496167086, 0.13215755452201597, -0.10158931795857266, 0.3033461898855432, 0.3901567585595622, -0.05267100734808165, 0.29824646725294196, 0.11670086505968531, -0.19704101512491884, -0.11281372243622961, 0.3194943996970249, -0.008863308161692021, 0.05908234264389051, 0.3792150784871515, -0.3114689074675144, -0.08996242675772413, -0.2742375086613396, -0.10427384358862671, -0.12189517254092185, 0.1294764768798739, 0.07245318637482295, 0.39426596195894636, 0.37539440380504213, -0.151635461266101, 0.2079733890444114, -0.17334761593277917, 0.08408603255730666, 0.10829033935145055, 0.4614656323876966, -0.3580227587511231, 0.35126008797104624, 0.3776771467888979, 0.3136229788318557, 0.4660181096222176, 0.2895704674092459, -0.3141359950726482, -0.18917103870848193, 0.08381155748980744, 0.10968516332320859, -0.25676582346544236, 0.11006135450446163, -0.1934744340826386, -0.131410371829653},
    {-0.1952981583406562, -0.34777358327902147, -0.12132775197621629, 0.15599757887805765, 0.44420559752397965, 0.002879776670445804, 0.18255407534901988, -0.21327666687899927, 0.028145034389633772, 0.4958404038194058, 0.005742572629789173, -0.1045705661626033, -0.1922863127010859, -0.3668663124689655, 0.09276264708620426, 0.09943784939802282, -0.09888556809935842, 0.06018163497994698, 0.3877235396144173, 0.30766459108747346, 0.3002470856999447, -0.35485063927637794, -0.24681283388425282, -0.02498257211526125, -0.02882470512972517, 0.5209860621013374, 0.35290188927425686, 0.39323707541124825, -0.002543393065148123, -0.4040967742841693, 0.23646514353201137, 0.1058420798335469, -0.2084845663882577, -0.06809659193265663, 0.171143852077005, 0.44190075465723955, -0.10715605448390296, -0.5591468827087652, 0.5456971600129721, -0.17681444143693176, 0.31836354089131574, -0.23131543022147807, 0.043403651599696766, 0.01537615667125274, 0.4213611034812924, -0.07157219677856436, -0.10395277379732298, 0.37994661607389757, 0.358384774965165, -0.07215521596374751, 0.18623595462290285, 0.14253988425939307, -0.049033612702217885, -0.0631655349867226, 0.40394768865902814, -0.22016475834082858, -0.06955079702262089, -0.0959198832819611, -0.06503909811215712, -0.11154638049538315, 0.006780609059514993, 0.28578742054929107, 0.4263262519495743, -0.1732679025927473},
    {0.21089464980343717, -0.011806321521565646, 0.11347841921239182, 0.2730965698700971, -0.39054148473564526, -0.033591838425692105, 0.12793044338545506, -0.2909236906380838, 0.4123925402847907, -0.2038302342020503, 0.1950315984308067, -0.11837522810388883, -0.14543541254831657, -0.3829759900394212, -0.39963264857481634, -0.3917634881142859, 0.151870256796567, -0.2432352474178115, -0.36694080184514316, 0.4153064720005455, -0.3310602093977079, 0.2844016822868156, -0.31780629951549233, -0.1334632181912748, -0.3573799779627975, 0.20918569625947914, 0.13405420084340652, 0.1904783005105787, 2.1701783885418573e-05, -0.4855407276318612, -0.2377889546325183, -0.4008778576480356, -0.378032337361034, -0.16880838269491677, -0.22809015213905845, -0.36559352602405737, -0.2048808231546477, -0.4892031148230494, 0.43823940645167003, -0.12177123633144953, 0.42484444944910793, -0.20742030313699603, -0.23331868423665325, 0.11064794493643329, 0.3153651678287742, 0.05730553613035254, 0.16150567060022758, -0.2261913416610138, -0.34219426581835877, -0.17263612831073863, 0.31744569581097487, -0.1607127056429826, 0.06262134475549655, -0.38774079563371644, -0.3113010185068386, -0.10862291643441267, -0.006993886042046541, -0.2539682129883951, -0.18977127877157637, -0.586219367449996, -0.1140286110074568, -0.26737229248422695, 0.08004779801279308, 0.0793663528573938},
    {0.10678529994786967, -0.27384869977429854, 0.28484610508074143, -0.05382743398308473, 0.06903812759628758, -0.2596400601035118, 0.11183234682189451, 0.166913617465548, 0.49571179218670164, -0.3691350614901554, 0.21244065571577836, 0.35471496099957467, 0.12396102410403184, -0.37875117275385556, 0.46035161614172204, -0.03226235528962689, 0.39754335951153874, -0.09194549697413827, -0.3674633611422212, 0.5004880330626292, 0.28258334241853705, 0.11250075244137385, 0.20595066952313956, -0.22006435696513413, 0.20188316096080933, -0.2562990412719741, -0.415269439576847, -0.20747570883174626, -0.3487024452590063, -0.1761650675709261, -0.06130319443827216, 0.18746581331567053, -0.11240992185274304, -0.1942335156945747, -0.19640897588878922, -0.5161830165211727, 0.20310019432191723, 0.08854615394715394, -0.27577460542057, -0.01637902721489909, 0.476698730501288, -0.3214693789568251, -0.07338589084682168, -0.4196553973242904, -0.23834839243856848, 0.510042741411305, 0.6669746689347196, -0.231337398213629, -0.4525276566529225, -0.3166422141220731, 0.4996239487397489, -0.23289476790029343, 0.4305382655141152, 0.257448606031038, -0.005739543304762475, -0.40785682557716296, 0.2916273221685818, -0.4814241066111913, 0.029600654604889243, -0.23110601133006037, -0.259475991851748, -0.5535687583783383, -0.019197128081669883, -0.28922069165057834},
    {0.052804338438101, -0.08320080500071281, 0.34758045079625505, -0.32680070976429515, -0.268594386175011, -0.3134981672872384, 0.4536533724970053, 0.06546387979217025, 0.11011966517600771, 0.05904274853000731, 0.05204308806783942, -0.2507235088957506, 0.16027927688536958, -0.38515214458099134, 0.5134084785840475, 0.059545113574715466, 0.3406275773609983, 0.272391946133171, -0.10241105835889724, -0.11981771695487528, 0.2188256560014379, -0.5411166836618184, 0.08389456810700512, 0.2332310335851832, -0.1692227331543552, 0.3381217430050246, 0.16411578300211457, -0.31639265664368527, -0.40251401247991764, -0.4666620693913134, 0.4263777836889532, -0.0771964749852359, 0.13137492411282223, 0.10407676415129392, -0.46681947281579617, 0.2404811237495869, 0.1003382056118312, -0.06657494286832077, -0.15636744343746303, -0.11165186045754981, 0.4216436380414028, -0.24692913366908187, 0.21634538376137735, -0.30146276479595063, 0.17650316560522294, 0.48585209051924766, 0.20544221245760438, 0.4060788485739541, 0.0723864328486991, -0.15393078750551334, -0.3446713960870655, -0.38282806166609284, -0.31287999155519935, 0.05319196033031092, 0.005178094017206403, -0.498504014154232, 0.11814363067052193, -0.185699264510277, -0.06887666589550905, 0.5346769877006352, 0.02756173833038076, -0.319920275471383, -0.2767306930859512, -0.4526646793698742},
    {-0.36602631190737417, -0.27150507654356754, 0.07005250061923053, -0.030967309481683532, -0.6063722781625174, 0.006905313901881376, -0.20612298927514508, -0.22726557028455063, -0.3433601035666117, 0.49330681251139613, -0.10318600125021637, -0.2842676903827559, -0.311086126862898, -0.4838965081880712, -0.3451575320541046, -0.31922537287928787, -0.03077865848558023, -0.38281492271313844, -0.2606678217086837, -0.07396311462856987, -0.04094769314519586, -0.5254799552656599, 0.06631388964737871, 0.3912707952091967, -0.13399920240271201, 0.23690261731653142, 0.3311015083422572, 0.04195691805776479, 0.24931882801889996, -0.06894865917796915, 0.37680447895081365, 0.033799834195507486, 0.10850033493618422, 0.0765759038896453, 0.23669482541085968, -0.06372368949636961, -0.11470148517350516, 0.21903601056315714, 0.20153920773565323, -0.23206401342545954, 0.15302937042276218, 0.012076144634097423, -0.4603889114034737, 0.049069733901527246, -0.21428450014181508, -0.4002871470809318, -0.23231108426883554, 0.2479833924765403, -0.015186408472461279, 0.3443587896933231, -0.49424930186620697, 0.0465193398642055, -0.5921394344109846, 0.17217812145671918, -0.16753117294162798, 0.06277155330476321, 0.05364673936134691, 0.062360301874645856, 0.25391423767936444, 0.42118938383459714, -0.2432239604948605, 0.028937477304420943, 0.39296497057649316, 0.2259395525574387},
    {0.3385816111181392, 0.00321109083694549, 0.06465647771934606, -0.21525160771953683, -0.43469571679446456, -0.4467498576724742, 0.11293282123813414, -0.5427427478438749, 0.13055494784141114, 0.19368483291834146, 0.31920056005423164, 0.09412116967021637, -0.05825416633059586, -0.3745655005254875, -0.5553881965857297, -0.5783033485957803, -0.4252490078334949, -0.06538207968959248, -0.4156461000009971, 0.014216182048093098, -0.33962709356439885, -0.2819346919388838, 0.1558696993929056, 0.1487646003738356, 0.0852534595354498, -0.404132045735301, -0.31502738020360416, -0.028419285227099633, 0.15801735621649732, 0.1956109876376989, 0.44235278403778766, 0.4978213490911773, -0.20028524057453387, 0.2378976675811465, -0.03422945721237443, -0.21025433204956945, 0.18588277229627567, 0.057287081810919356, 0.4203838977391135, 0.28353109292014744, -0.1050023325089306, -0.4854122818314735, -0.37048009684064326, -0.44409766271036033, -0.4361745085406079, -0.45961145121944624, -0.13330266577449523, -0.24028100098168306, -0.029736803918069175, -0.15158570509186284, 0.01602757805689838, 0.35658426865662207, -0.3243492617391289, 0.13539149684627663, -0.4253407181463204, -0.07509366242950158, -0.36362366293149406, -0.10939766896462813, 0.18241363876392389, -0.36302977350463517, -0.18382374941358529, -0.19015230727782553, 0.36342229230767287, -0.13183042221589153},
    {0.11959543713812298, 0.26350055555735075, 0.24979408338215148, -0.11527747558313509, 0.24433383494099462, -0.023470699858479185, -0.44714711731099754, -0.3197734377143735, -0.030874258661211077, -0.3882074151724989, -0.24681034891321102, -0.16703149475384071, 0.12874982489558784, -0.4024342522113238, -0.5730520000889795, -0.36030324615330056, -0.12492357551098252, -0.37036773538668205, -0.39701132481966483, -0.43501614709451597, -0.05772159629206975, -0.18192289259366368, -0.04280188013678019, 0.05071154751627861, -0.360803097367649, -0.4870025195488354, -0.14848421579105567, 0.015413557381729684, -0.26777783574842756, -0.01464302473254291, -0.10703733811891812, 0.24099414675064118, -0.49361589358517866, -0.06802353626314137, -0.15583549330032517, -0.30550791872885436, -0.31476728381459895, -0.14069799995757928, -0.06242954769381667, 0.2658786899060789, -0.4492224042214378, -0.10989306322970357, -0.2865544305293963, -0.5397383216879358, -0.5966046939089548, 0.013741582677996267, -0.03381093840915667, -0.2572239148998877, -0.2660602858184365, -0.4212521389243494, 0.15429594487384374, 0.23672511440127994, -0.3758988603750215, -0.3488132665324545, -0.004843748729513644, 0.13486911508441785, -0.5773241287057551, 0.03303621263025206, 0.12443539634217408, -0.241987132383489, 0.10957634058493798, 0.03287082630037339, -0.5559407884742887, -0.3144905314683568},
    {-0.44635956863294257, -0.11156608964786119, -0.06449886768233824, -0.0823825439212422, 0.1588239753722714, 0.38595900475754413, 0.02853411215137314, 0.372411644530859, 0.009941341793253771, -0.1536869224743967, -0.20461608800790632, -0.21671557063268718, -0.4313271694869032, 0.39417087155407093, -0.01305827223705345, 0.04868109679639167, -0.09998742213782412, -0.12981182937780938, -0.3413200285739543, -0.33900821192646124, -0.2974883200248097, 0.029878700781100005, -0.2522254225416119, -0.016468412189638258, -0.09223996047437419, 0.22491846923398542, 0.26598049596966095, -0.2987087334970318, -0.45333710086019624, -0.2719573266291749, -0.4244338122605007, -0.49472690219334825, -0.12294617443990927, -0.4741192118260663, 0.25134864949829844, -0.48838262085696627, -0.28617477434778343, 0.11530523111015886, 0.2557806180331493, 0.23344945490663577, -0.4348777682593127, 0.23501456812949148, -0.3091129277925251, 0.4090315655500314, -0.2424921346854588, 0.003061319022742886, 0.26318655662859963, 0.38219542889834207, 0.36638178466759264, -0.30876943377646976, -0.03267200853406066, -0.2758207988883393, -0.11189958236922244, -0.4108032980592771, 0.20877790674578323, 0.15617652929369985, -0.6138534718686764, 0.2857057672461673, -0.39543959900806164, -0.2621180497862305, 0.07767067633401772, -0.11371988974230703, -0.43288057344713426, 0.24551146081298741},
    {-0.004959433483255561, -0.14524904081682372, -0.3167177498283526, 0.07256801006020963, -0.18082467656907036, 0.009513257516527302, 0.1251456626039661, 0.1748979423023168, 0.4338531727998183, -0.25605863129894496, 0.35019390872179046, -0.2559691762295969, -0.1640168180958493, 0.2247546591467433, 0.04702913642734416, 0.20199885775367155, 0.20903697400495874, -0.221591941074367, 0.10713634265686761, -0.3114479546763335, -0.2840732912438634, 0.25782234286656397, -0.37121321901041904, 0.4071692543175392, -0.4013045048849341, -0.18188621965320417, 0.04346798494572625, 0.266478734228801, 0.379046502792918, -0.09220353301873498, 0.39388416436606283, -0.4093398927643125, -0.32339892302109524, -0.22901718081733266, 0.33643094249847433, -0.18209531211409302, 0.07276125529971225, -0.04457654234544394, 0.11079141851436204, -0.4903234401836949, 0.2802297712911316, 0.10600808724108156, -0.20329015870631242, 0.2836824603596557, 0.12789413348311626, 0.6869705593958004, 0.12419774543910803, 0.52832414459472, 0.36354690076155627, 0.345805856816632, -0.00896526154751839, -0.2446351284013882, 0.3102968068836982, -0.06707485746489573, 0.34958809193599655, -0.11644043860249646, 0.05437134188870845, 0.328181574202118, -0.28942649855134367, 0.04593527852739296, 0.3800794747507169, -0.26726730059120374, 0.13031558143427469, -0.3503224948053747},
    {0.3846253163184892, -0.015844256212480794, 0.10149127852459097, -0.09781980776108, -0.010260898305140577, 0.4326750513064636, -0.023219691005020165, -0.4330985354876937, -0.3271254816352856, 0.16857526905547915, 0.17821149862390082, -0.1520334102055907, 0.1805859599448094, -0.2930671400774761, 0.26092379195491483, -0.24675941672093482, 0.13735166905316248, 0.1564988897927802, 0.08561369202911413, -0.19702428696191113, -0.46112519237205596, 0.24782818215813587, -0.13675144537861308, 0.31367865647621557, 0.3549600130086321, -0.44177432816898143, -0.5055017696306792, -0.11643323789544856, 0.43910912421297604, -0.056672891089316155, -0.10196431343447218, 0.4464806933687289, -0.13826783343032092, 0.49411350559291767, 0.35123609995399774, 0.3721992366728274, 0.3398866891704015, -0.01501727932272117, -0.039594027179940115, -0.2290523723516776, 0.4919831773897616, -0.431539638016226, -0.15632508564244071, -0.2763067400913881, 0.009106809189347628, 0.3749885293487368, 0.025425781254586926, 0.19739487851762647, -0.32614697756985755, 0.550826943627102, 0.29827755655087296, -0.288756040521446, 0.16438388882749755, -0.08602721928850865, 0.15987519397703842, 0.4099151692340829, 0.11280241453845032, 0.18033459254425446, -0.058106786936641265, -0.3415431573568685, -0.011579581697758787, -0.21844286501660343, -0.03992652393921563, -0.018932795022016266},
    {0.0627327496454209, 0.06299209922506763, 0.23583784500394187, 0.28873041246856734, -0.054009195000150716, 0.35291968761561043, -0.1842474635139347, -0.39520523297250354, 0.0760927157352578, 0.19104000919901043, 0.34557050510445186, 0.3195198063674636, 0.10221841282508284, 0.21123070271985686, 0.25037242952077476, -0.10885839364090039, 0.30936889998796147, 0.09155381705517067, 0.023564278826806444, 0.1946284316869679, -0.09658462640738488, -0.009871546496011038, -0.2216026817788929, -0.34585982921512076, 0.18719962094810438, -0.020914071097526077, -0.2893203182221158, -0.18158783898914194, 0.07994980095968811, -0.1814337357116967, 0.07551629665157719, -0.22348306112094826, 0.371426068695046, -0.1835545542898784, 0.2925101038645227, 0.0654719516366521, -0.2809743081948938, -0.2788017054626948, 0.20518673362219264, 0.41358842406921537, 0.19463208492918316, -0.09934210507262066, 0.35928971013050065, 0.027044102933127145, -0.19508628555569404, -0.216837617001984, 0.03299577392360765, -0.3829414402259164, -0.028220833067230285, -0.010765746312183388, 0.11052737535168682, 0.37074057338876254, 0.3222953348445722, -0.2151844395477102, 0.20506861120415196, 0.135896681375184, 0.4383617612221814, 0.04400982990705063, 0.0443433376727455, 0.42698336348373994, -0.2826323759204604, -0.02051609875942314, 0.5369042298927642, -0.010943114722099736},
    {0.24294769948336628, 0.019009473302924733, 0.23859466928731726, -0.14891821394737242, -0.11828299865063154, 0.17789845883001115, -0.011591318176598557, 0.24068918819866816, 0.21140738686853397, 0.26794844176833327, 0.25442594660906764, 0.20699173564409556, -0.08958569901461694, 0.2789805637877539, -0.41056532093527875, 0.13159010113268674, 0.057740341861621955, 0.06657434038558024, -0.07898368627842099, 0.041388028815563464, -0.19732514085359346, 0.18980044298382348, -0.1549843056411424, 0.02510370311674621, -0.12539014138546706, 0.4281872410184317, 0.5102832123632615, 0.20296921186995073, 0.2038884366939706, 0.11947972271265894, 0.33605248211732863, -0.03125047849608384, 0.109200518808048, -0.1097002129453361, 0.21484563053234135, 0.42418877154742474, 0.24276825766561763, -0.19465592837626416, -0.24443091248904297, 0.35544438643305654, -0.29739914054905936, 0.033074701856271226, -0.20677597685671642, -0.2649990388150379, -0.18163889729160287, 0.21264249947468183, -0.2866586636361198, -0.36440129281879596, 0.36400242269824645, -0.44342957530166327, 0.01940470284092541, 0.17464363151476764, 0.4348300524511634, 0.5137802403965918, 0.2260483321972401, -0.24647756090267883, 0.2740724700988559, -0.04443506878630173, 0.3041923854396986, -0.019326772364527012, -0.3093955344657832, 0.4216114765237878, 0.3319343665762168, 0.0306709099287447},
    {-0.3253576946068845, -0.21530475029877477, 0.2524154510267222, -0.357240227603804, -0.2132296930542004, -0.05909244291333605, -0.3097540242041925, 0.2910074888321159, 0.2886468064431726, -0.04276188786492366, 0.012963279849133928, -0.09662632315010859, -0.028655699204995215, 0.20345238004605243, -0.18960364723771805, 0.2122916282042991, -0.13222314472850802, -0.00859544789173684, 0.4301487606227841, -0.1444587449473648, -0.20464595356839088, 0.32872157962865245, 0.13500336140151903, 0.05873322023864019, 0.02611983934974066, 0.3792152061322025, 0.06787272165683039, 0.5435117911275589, 0.0777203394701191, 0.21046441364551258, -0.0010756745209639517, 0.23193581102353655, 0.03465398387935659, 0.16730363639292634, -0.23741702796572833, 0.18968341855456936, -0.16156698282913545, 0.2969502559215445, 0.01507305672031221, 0.216538537171842, 0.3361687093635528, 0.44106859744681803, 0.25141492596200005, -0.4104459225213958, 0.01846714831092613, -0.21951385756394584, -0.30086001273631824, 0.02090609087452622, 0.3748398214701696, 0.24655267097156552, 0.27205038626743705, -0.275295688847272, 0.3317480991906387, 0.5392478377876827, 0.29857261291876286, -0.263706531670706, -0.09433942197128058, 0.2916576238349828, -0.07919728856243127, -0.0009219603742529287, -0.14769641607006387, 0.4441468596728774, -0.12279923702281782, 0.35111537138616583},
    {-0.03147215690334879, 0.07823540847718355, -0.26674049866907673, 0.2503729629916134, -0.2978339694896133, -0.23180217301415343, 0.03265615186593333, -0.19127846549827385, -0.14772495901030894, -0.3451845598459822, 0.22640825839316944, 0.18687044952402426, 0.13451819202580764, 0.24110566949219744, 0.28738869481195445, 0.0396261078932811, -0.13260119196523892, -0.27175876738181093, 0.24118585346250684, 0.1284791258539751, -0.237864591855678, 0.08307428410465854, 0.28784040210913575, 0.1298798655719156, -0.21776277507215833, 0.1479616455847349, 0.144969520689791, -0.23022564350777253, 0.4713364049460227, 0.4274027849894113, -0.210500664914173, -0.2378982913872916, 0.14675835351285213, 0.09798673336422307, -0.6287053736372886, -0.009378475928653766, -0.37613599663159525, 0.5289561981384467, -0.0275670917948073, -0.25746127337259445, -0.19226243421368158, -0.0355600461090211, -0.1852632330415154, -0.16913075421363127, 0.30602381916915045, -0.6962662808948915, -0.26362280735806154, -0.4020613557868218, 0.29339426143737274, -0.2164506517081801, -0.15305253544179098, 0.21867552774886342, -0.06355812352225843, 0.0889784039094105, -0.005332621823924416, -0.3869917190528926, 0.31692120665957046, -0.10027560446240648, 0.32912233374288274, -0.07873138886870368, -0.2963388085119942, 0.22298643742021226, -0.19754261439004758, 0.34687730682062273},
    {0.3876801272348036, 0.06903087669899594, 0.1458026049795806, 0.09705243747826449, -0.3209793629509999, -0.30896608833846284, 0.5470767162952052, -0.3806732351500514, -0.050111306262693146, -0.22696496059074636, -0.3363750571694915, -0.18411447045802068, 0.13763441709649427, 0.3235934018316668, 0.23895075128340681, 0.06171900783640865, 0.30883934081247094, 0.3960919845653433, -0.38554625192195935, 0.46690759807274884, -0.43230438074920174, -0.15131286919175052, -0.18771227822025674, -0.40055492014919153, 0.23627296466643036, -0.05905539665913844, 0.37057622594212797, -0.44082726996973726, 0.19308098413125926, 0.2757939736913229, -0.4150990130997025, -0.7185848616720422, 0.28935940708332347, -0.03858549480551456, -0.5170365196036144, 0.044542543354142976, 0.23747896599173826, 0.19973912607890812, 0.20492124645197865, -0.10828731472851524, -0.5867431273725378, -0.2485861583442364, 0.1629250184518664, 0.020685535631666745, 0.598843742164448, -0.3331367556016614, 0.3844662762710649, -0.44352514464999493, 0.3739200918566346, -0.5418736153853819, -0.008440591945277576, -0.1490787544371058, -0.45698598370215293, -0.05279669906899285, -0.18093485077708063, 0.17874002515182513, 0.20188625888419884, -0.3468724563785313, -0.3836167158505371, -0.3244477343392653, 0.04650861329232441, -0.025394120880892802, -0.37760201589756304, -0.34183814695781445},
    {0.300498815666301, 0.4428660770327382, 0.21181011862649654, -0.20643759748434534, 0.4045532671985054, 0.20939366199650053, 0.19059500877195001, -0.035511815692510565, -0.4795325507826764, 0.16398748026223248, -0.1516941625176304, 0.31265313781286247, 0.16666762247029795, 0.36091567606672637, -0.28256560968523875, 0.43953343155963376, -0.0783001422420422, 0.07519669929424493, -0.15751433868323023, 0.04078825112850183, 0.07057794777162711, 0.09249593347692699, 0.1725269585838294, -0.38499863688214936, -0.04868615973224535, -0.0784400375306516, -0.40043463005809404, -0.2379644850831515, -0.545925076735465, 0.27911941124620027, 0.012240140646169106, -0.3886189792645791, -0.22437402447940813, -0.19135681954475, -0.11254321436685329, -0.4665230942730184, 0.26843863609154517, -0.03890988271821452, -0.25340654766894516, 0.3475028220676158, -0.29566805407399194, 0.3012256933770529, 0.26422453376944627, 0.4367911569970079, -0.1083406828484312, -0.28514978125714957, 0.017439475948130646, -0.2640320751597116, 0.0961724310416194, -0.45160456598431764, 0.12457190435200559, -0.2555723139537542, -0.3712219927675263, 0.1701369836607153, -0.16473267336801406, -0.3914387044880082, 0.2124701820682905, -0.4185963645374332, -0.46776949880242774, -0.017534777655052132, 0.19936968171536348, -0.11965598601123871, -0.4587394251699312, 0.445403683589829},
    {0.37101053128821554, 0.1952847559262175, 0.07966367448142156, 0.07737222282355818, -0.16106308847717768, 0.09599486091897934, -0.09414713474630337, 0.36457360662965266, -0.07727729447409458, 0.21918491926988393, 0.08282149446142173, 0.26651441525748154, -0.2993178102122096, 0.02859419406196381, -0.4921703783611296, 0.4504462842820003, -0.4283538684655193, 0.34842462538433033, 0.5237652866022847, -0.3063631021758551, 0.10379830479059732, -0.23212766775285568, 0.582100377296574, 0.12920336397592372, 0.05846461994594711, -0.014143760388168766, -0.3680582235738297, -0.06340447621425245, -0.24603786356492385, -0.5154219586586697, 0.32186279044881566, 0.12107697698580719, 0.02265780882920925, -0.49819583121875627, 0.1742028110359317, 0.12734606881591123, -0.1496042692401476, 0.32008694172751445, -0.5350095116778597, 0.3580648605164256, 0.4182580867564688, 0.03612011146084267, 0.1739098524215862, 0.38372937908390153, -0.2633300896682116, -0.1683886882252955, -0.1672010156051404, -0.5016408990446161, 0.0835263960940243, -0.18685599777773182, -0.17887417116478216, 0.3037253445922797, -0.09298216299700436, 0.20672245171287962, -0.3729105891815006, -0.03311591953675903, -0.14290957611942495, 0.03400489643778906, -0.20828731707072157, 0.3813099499164506, 0.354050552110427, 0.042235344034897565, 0.07120253588756299, 0.16978004516107037},
    {-0.2753308989460107, 0.47988163360969927, 0.021459692030030522, -0.3576093565026425, 0.10860868762881064, 0.07895213367458113, -0.1649422431316215, -0.3354102423462858, 0.05897159908832447, -0.05932711059563899, -0.06123466266488319, -0.20231589131078606, -0.18962810665236784, 0.17329327539641337, -0.36029245684452993, -0.2595884639045627, 0.1795071463081735, 0.006411238610745909, 0.14377723846630283, -0.20282123715865008, 0.28607531416626303, -0.07933734970714035, 0.38759656104325485, 0.31366542551163185, -0.3239108035646972, 0.13034501369017923, 0.24329417217251076, 0.08678445637790298, -0.35029510990936913, -0.24336929205383032, 0.2705622923570119, 0.24595977040881753, 0.28533963336938123, 0.06540956013086231, 0.4938377889361322, 0.06011999684995659, -0.28138043809219726, 0.06976655969495482, -0.5178739722346538, 0.05730300701000899, 0.40910664588325085, 0.39087634074699446, 0.4777630099296588, -0.14152588051281395, -0.38078469842480056, 0.34614401036033837, 0.10016055290764436, -0.36558685020272297, 0.26412597384013303, -0.11478291418938548, -0.38072717995700817, -0.1939138999905931, 0.4024316961755796, -0.226669016877301, -0.33460688986906506, 0.32246288671180134, 0.24383561681406862, 0.14462168920381724, 0.18226228538039949, -0.08211873769621619, 0.04395731964776468, -0.18520700812769997, 0.20701196728387708, -0.33122226677082744},
    {0.07702389331111702, -0.2699266258731973, 0.27306996236796527, 0.2682982288760091, 0.05020367801883052, 0.15162515645293057, -0.23858344723526942, 0.381299165384506, 0.49647872077480265, 0.014507999843993723, -0.18602090511870592, -0.4080076691643342, 0.2424246393879665, -0.145526288211724, -0.31303659012922763, -0.22304984575741194, 0.2448424721024457, 0.1856327603039935, 0.279458318853774, 0.34387236579325564, 0.2550470221085936, 0.16831259924420278, -0.2307628216581145, 0.13106518692811692, -0.13647601440102777, -0.06926007601119635, -0.03779660922285162, 0.15767727619057678, -0.03279415729958423, 0.19233320476255303, 0.08202154019187108, 0.43895870994825775, 0.23292008661129102, -0.4064339921341901, 0.44602462257364006, 0.2127615181720183, 0.4192941401732927, -0.20210358696201283, -0.22364624131528835, -0.24197587120136851, -0.29155200666202563, 0.1310352221933882, -0.3204783603976774, -0.04428715618839157, 0.13327674991405147, -0.42917359094882895, -0.351294373360812, -0.021292659111689437, -0.19646198891664476, -0.3049815280721311, 0.05127071599746194, 0.18739772553883796, 0.5252555710726994, 0.20782067686841343, -0.09837231284847246, 0.1494601572691327, 0.47294118813208574, 0.3474140222173794, 0.2118291872466802, 0.017823178172406962, 0.4248108041540961, -0.06971067530751358, 0.07232089689913693, 0.2896066799357437},
    {-0.28031598104464656, -0.21174649361882245, -0.047564518180229255, 0.306672778599947, 0.014547539246732983, -0.41219331867711817, -0.2449571224008037, 0.4104578845934632, 0.34985537270057837, 0.6354638980663877, 0.10529986590347527, 0.2942540726490474, 0.05186289123593697, 0.24645492148329773, 0.3056465980520926, -0.15620830120994164, -0.050807401869599325, 0.0625631109162894, -0.42337505605212744, 0.3190394223701988, -0.05128389297264214, -0.04539262231647069, -0.02214727341649819, -0.31921817142091546, 0.08453494414555009, -0.5274794868843243, -0.18503169774543796, 0.11762596780048118, 0.4073369634768925, 0.30810438402657614, 0.1857943718666935, -0.31949110120164154, -0.29713996968756823, 0.18913721241921072, 0.15161537710180356, -0.38973532137792527, 0.0025103992255669184, 0.27956091334904914, 0.2394478098129451, 0.12231172810411581, 0.02282074538156148, -0.21578291562203314, -0.3025448779426288, 0.1666587069954032, -0.3238739734967966, 0.41682258303781045, 0.30744757328736494, 0.5490206326983733, 0.2545890977720394, -0.140305497085517, 0.3912775974886307, 0.287151972268175, 0.08280974717669354, 0.023841709073281637, -0.23790182778856092, -0.08031077187341779, 0.311961935318979, -0.05771808826375257, -0.005895517822254265, 0.22889288161833302, -0.24420094835880743, -0.42231012864350376, 0.1743536461545928, -0.4470789959356833},
    {-0.22848962848923665, -0.6053843918956292, -0.21123350704718927, -0.18389323683753592, -0.1461912833630866, -0.33059974414414456, 0.2177125246943005, -0.04553832377726217, -0.16925041452462744, 0.15753833501800543, 0.2351620999752824, -0.048589676414397404, 0.06357623472971359, -0.10712572675331694, 0.22974188623083402, 0.20630720599059815, 0.10625051102713334, -0.38870311190115153, -0.43069123333301906, 0.1966414950635043, -0.45138204962827083, 0.013098122962954498, -0.24796667778514728, -0.35918797525258866, -0.345128262585603, 0.05140646893479137, 0.19165635730437508, -0.12473737854217104, -0.2793284466953716, 0.1646383174660263, -0.14081337348697542, -0.0679589719175751, -0.3354965085188652, -0.28180831930657907, -0.26644737193025986, 0.14000239083501917, -0.3027879226148853, -0.46853029140296604, 0.1619554161965175, 0.2928720661511948, -0.43877911035617934, 0.049355576954005706, -0.19037609505118402, -0.26699864281278773, 0.3387468261161546, -0.3053485180165061, -0.07705481208236944, -0.24102447458897813, -0.41594328124546576, -0.3846203150772885, -0.05846838578618294, -0.05035879177247147, -0.21469510461279856, -0.4261214211625968, 0.02462573254548207, -0.4014075972831896, -0.2938712586923045, -0.12287437329523303, 0.21080293378992468, -0.37577369742499006, -0.06328558053498637, -0.06372809085152356, 0.15674636622555882, -0.36088205650105426},
    {0.4354969086382607, -0.43080556347043325, 0.19813223265596283, 0.2997382218955412, 0.21757816964660626, 0.037810714072976634, 0.09614150786356865, -0.3135985074212537, 0.29640102006432784, -0.10188442616501378, 0.2677354528018464, 0.051786937772785833, 0.06351101612023373, 0.3770052072582141, -0.07171726567860673, -0.09124394141050893, -0.4054256435759311, -0.18384762597787133, 0.07583216858090386, 0.20387554366075594, 0.24537448654971106, 0.16059131858918668, 0.10784345384933883, 0.1976959203249483, 0.13905272875168806, -0.2459852385032787, -0.2786758529817721, 0.14658026296566526, -0.10352923416150812, 0.09266501017719096, -0.1925963008822115, -0.341083206235551, 0.03124302692781152, -0.5009806906674279, -0.1316390703874844, -0.16449995399095427, 0.13210574407729192, -0.14597433877501734, -0.058609341145201506, 0.254022643713865, -0.3651900206287378, -0.38751885398790537, -0.3045695416067659, -0.08610746989740102, -0.39644940636926895, 0.17760045159426519, -0.31744652980764115, -0.24804294041971775, -0.2461410319394774, 0.05167155157263013, -0.27450800451284424, -0.47306024761134824, -0.2075415091210751, 0.2598327631069793, -0.0341868480133449, 0.17062578606808254, -0.43726785406886043, 0.07303121388850499, 0.046731949475902104, -0.18197681023342163, 0.4103453002445083, -0.45974620157686674, 0.36200017250196337, -0.11175020404206758},
    {0.09076628191530028, 0.3291363592013811, -0.033796893313272125, 0.016767079875317857, -0.1296372586142478, -0.25282293633278125, -0.06537710703463744, -0.048829825170043334, 0.31086896736685565, 0.3941294739304993, 0.06650711879045917, -0.08418001365704261, 0.14379658720037186, -0.6806040736354778, 0.3071088632901818, -0.2918187661813148, -0.3519101942177047, -0.3421315748956322, -0.406535366146581, -0.038042467496017314, 0.2634188650200153, 0.1938365339450506, 0.0784328566757482, 0.029626017118856957, 0.2794862801930649, 0.2780044011033685, -0.5241679987752609, 0.09834995099140972, 0.25799054328121135, -0.2596414180380417, -0.02089184033817502, -0.10425335661668839, -0.3067478487945795, 0.2652461547283319, 0.0026477409151297406, -0.6497636744023277, -0.13189591486405033, 0.019514403485901447, 0.32537857397420356, -0.15037547719243238, -0.2895324506973517, -0.10794637559580002, -0.5942868765978107, -0.398988991005412, -0.2412613997778783, 0.42569770845458527, 0.23044815576958308, 0.24826447502313986, -0.21548775258393266, 0.05381084648378152, 0.07595500541620075, -0.010118701527818191, 0.10540058382640247, 0.4323328737244354, -0.3990768353918416, 0.33016681735151004, -0.02221559206950632, -0.1846808803189228, -0.05177313289909016, 0.12553785565669168, -0.2727088529478784, -0.3367148956208762, 0.440138497971142, -0.0979000890255867},
    {-0.45353813693491984, 0.24251183451886157, -0.215538640566411, -0.39220072565057357, 0.13775605834758758, -0.1949336722443102, 0.3315262369087154, 0.1379758844250453, 0.20877685163681925, 0.015431359263577197, 0.20199433062177957, -0.23904143697842467, 0.06189239168461825, -0.6110633703302161, 0.030991029279093064, 0.29999518558687477, -0.3587122443673704, -0.047638355849653286, 0.23232910842691873, 0.14179623561249294, 0.37880904003454646, -0.6739820348215143, -0.1382190217856127, 0.4380968580955868, -0.020068540376935593, -0.02960981974180631, -0.3721073382476973, 0.3574754983010959, -0.2832375738622418, -0.24916427071625202, -0.10748303257591633, 0.47074167670836026, 0.017297981252595265, 0.1703530000019323, 0.3719857788475008, 0.23999581146312418, -0.1565464372669736, 0.21616178992534138, 0.20120027773598279, -0.4727475283410047, -0.2671424342740821, 0.0008293874983003633, 0.0790469015752637, -0.3171470981740536, 0.2638472811993716, -0.059604901319544816, -0.3830696028184506, -0.15820542651500352, -0.21948295355438827, 0.29695415911912276, -0.1755364699159994, 0.4587685727357943, 0.19829717734583144, -0.5758174655924141, 0.34581492077141934, -0.3718629828436505, -0.24637013305199923, 0.06260299449405575, 0.2823366505016422, 0.05793335065866182, 0.224686377972867, -0.04876407756987329, -0.1368910820395096, -0.30538668774826677},
    {-0.23124043737059033, -0.2645432320435228, 0.12152022871766627, 0.1685608911320863, -0.19528030218216547, -0.23128389881951014, 0.24217860022602059, -0.34582352227108837, -0.45885919629197236, -0.10668740314957033, -0.406402697503445, 0.1494269191999903, 0.33350038211615574, -0.019577040628679643, 0.22550432036212908, 0.28520999325980456, 0.22921310349529014, -0.06181305676779806, -0.20944705770173452, -0.25734613247570826, -0.19824270962443616, -0.4318504924489263, 0.43945428012582743, 0.5203264787396893, 0.06327468351946781, 0.3408749846771878, -0.3557093116460817, 0.18282485741350826, -0.025681274598532512, 0.2920486295664677, 0.004257727646810531, -0.10331089514806935, 0.33620478824319233, 0.31966082798361656, -0.08979417254145668, -0.41205224473714624, 0.015462550672836767, 0.37096751244510917, 0.2799165851079099, 0.20522647290883503, 0.47014585129822, -0.2836253460271753, -0.2038938565348827, 0.25701844342708885, -0.0812532172045509, -0.014662025670017046, 0.3730195264101667, 0.17601039099263316, 0.33525287863833764, 0.14297433793426703, -0.2672381749328489, -0.3647072879944428, 0.41126777639124157, -0.35039887621981985, -0.28929576223901504, 0.16743257284210963, 0.38812874678643683, 0.11529724008189601, -0.42706492014689423, 0.29906614989606933, 0.33635482663667005, -0.05158172004918208, -0.020016563305812137, 0.4019709323248969},
    {-0.06044512836585114, -0.32613837724407346, 0.054199576754443264, -0.2945825670192338, -0.4007803245154999, -0.3911576330209062, 0.0872633058205897, -0.4155160130224423, 0.22357620830177613, -0.37011694867698713, -0.15580972793599096, -0.05621594698712075, -0.3456681192724847, -0.43415982700647243, -0.4529366156906341, -0.10780802807658395, 0.272025740932259, -0.2607590529679014, -0.06094003941811574, -0.4412755469773791, -0.31015878551059767, -0.44358371663045315, -0.30757674714488276, -0.5388216289804983, -0.6290460870232727, 0.09402530135312055, -0.13363205995287344, 0.15290752613193767, -0.5185501956926065, 0.11082096526644278, -0.17815598892163167, -0.2207605464438004, -0.21386181213840622, -0.27787088179917685, 0.07196639462981574, -0.3138252428343624, 0.16586610520531608, 0.031364158295605404, -0.23587128733149298, -0.06593932226027772, -0.572973973022216, -0.38694098229024054, -0.5364670327938933, -0.14645216188544, 0.27982339134080014, 0.09139440143135621, -0.0334689993006645, 0.0842682181764936, 0.22421895949175477, -0.39646941637839933, 0.18359500194077777, -0.053947872392756786, -0.5296234733916713, -0.18177176662273703, -0.237317619591188, 0.24427511596985418, -0.6413266234958869, 0.10428244689252608, -0.008646921812310237, 0.06318818804826458, -0.07063551642525781, 0.17838882579818324, -0.4680160986536584, -0.29787915387471237},
    {-0.3347777271112994, -0.12456968742104542, -0.06002413895590731, 0.22142853144763963, 0.3526302838894504, -0.1761489116083946, 0.3526075584710856, -0.08497796391991798, -0.45783760144752095, 0.45023508275688656, 0.0005489984956976613, -0.032465901692903844, 0.24879705500020313, 0.40127245911707654, -0.1054412588604202, -0.1174184537458635, -0.2988734532620645, 0.4534176128206077, 0.37611030655555366, 0.17144385387932926, 0.26414939660078646, 0.00034905431202646294, 0.10765092345060359, -0.45500249692301725, 0.2759253031485965, 0.06667970706124818, 0.29853660554644373, 0.2136731774596266, -0.5467469085772487, 0.3316089393349855, 0.3942610226904814, 0.21466480946315206, 0.2101477601968328, -0.34217060414901057, 0.3824150788315732, 0.17515307047308665, 0.15837451892877258, 0.24970771011130213, 0.28309766141701653, -0.2844769810577461, -0.36515655371086786, -0.2024653583480185, 0.21843452454172604, 0.16594670367671707, 0.4787157588407901, -0.3843949076466106, -0.20904458460346984, -0.15440660150509397, 0.28605472216292277, 0.05609755018711805, 0.300429879948247, -0.42418903738731584, -0.29284552338151065, -0.29258088023934437, -0.12823175962461397, 0.2651645588041906, -0.3069842693737965, 0.05383751287012089, 0.27542499397371767, 0.11116442202320409, 0.2943884294293992, -0.29036383807273325, -0.12127674874048475, 0.20803591787434986},
    {-0.8638185978279875, 0.2824719269412665, 0.36612408795395973, -0.18430364739450536, 0.1270948295464655, -1.2146753698434611, 0.2725124375110297, 0.4192063211142902, -0.8594426508456482, -1.0628989601823897, -1.2010618680963971, -0.018218217063114987, -0.1133904165100729, -0.582896409645843, -0.07717327907574645, 0.17662208879234953, -1.0819225330383861, 0.380183760954129, 0.167861405322138, 0.346149892904027, 0.647248093517394, -0.8657309840954583, 0.5897091536820853, -0.5230353238856126, 0.10739781466279404, -0.9645512716459579, 0.12497816745307908, 0.3414350688316845, -0.731515367960927, -0.8503015170851204, 0.0007727576680343948, 0.40152832951127093, 0.22051964964215934, 0.0717898865626165, 0.27501899083713677, -0.8688499123115121, 0.40407867499971056, -0.4874451191914641, 0.4373575664489991, -1.2893524955446543, 0.2718187175180778, -0.7181075352663763, -1.2686295462723358, 0.5216197960852517, 0.25009174783329113, 0.0923895105112311, 0.5000870597470605, -0.9463743324613936, -0.12369877909711921, 0.22039856681199751, 0.40847850913363914, 0.21403030814937563, -0.004272184937449893, -0.34055276429859416, 0.40715445160405694, -0.5649516019889541, -0.031051835453318754, -1.2249343093446656, -0.1491701553264766, 0.2688335387173746, 0.40183667923864896, -0.098945184078489, 0.2027082824321761, -0.45295027280240746},
    {-0.33363582773598444, 0.6224208219268104, 0.6141862458616192, 0.43808922059244937, 0.561369720609369, -1.090816332874306, 0.8226238371752304, 0.9020507229861656, -0.3526245646738888, -0.4789608223595876, -1.1166512480968174, 0.3056113149423639, 0.6066651142320765, -0.012387247787012395, -0.011401829549264173, 0.37192660070179245, -0.901126166477252, 0.6490981354329997, 0.6031472177994508, 0.5707308925301112, 0.8432750976287141, -1.02693005819501, 0.7021982890588404, 0.24290637404570456, 0.5061451143839331, -0.8878760491576382, 0.6658158682510501, 0.5080879240129147, 0.051145756147707964, -0.5826739371683147, 0.6069285629388051, 0.4010834895348209, 0.322557357752023, 0.07497389577753277, 0.6692798342523986, -0.6500104566957668, 0.5697840535432268, 0.27560985964136, 0.8187316262525354, -1.1574749072626218, 0.47572291682982015, -0.2293623603684602, -1.2406745597690976, 0.7437295483605749, 0.5280168329508322, 0.45835753596928663, 0.7687847102823614, -0.4254869032721254, 0.38903516598462257, 0.08281253931389937, 0.563702267756437, 0.5261815637447825, 0.22516986462342015, -0.34085703983950866, 0.6021445856333381, 0.3985233937721174, 0.16464941165943567, -1.1727349048751385, -0.6478509377093412, 0.6696728119509, 0.5319087834741727, -0.19091266706525611, 0.7370237562881434, 0.18847481543590333},
    {-0.24646937973878863, 0.629295337778083, 0.1409163011353922, -0.6170786480792056, 0.16784890571169667, -0.04198379850972856, 0.3147068902085637, 0.40324520607169034, -0.15243368836914142, -0.6370127380052673, -0.2147819245450068, 0.5272501196560809, 0.06945575499129851, 0.10855252982571474, 0.5536175846126324, 0.09503686950242379, -0.8558299805334431, 0.10041739989666643, 0.27001799616575944, 0.0840944608959135, 0.6468793864228957, -0.4328472996098443, 0.08967965946116452, -0.5334866990724436, -0.3603773487819695, -0.5213876623567556, 0.6643346373591886, 0.6858147339145155, 0.05046129531041291, -0.18936810836730258, 0.060331390119250095, 0.22329251929177213, 0.47943895989095975, -0.13928565873199966, 0.3321095347534576, -0.42544675406679955, 0.17037532762017082, -0.5740126516981824, 0.35464720846321196, -0.7441023977179606, 0.5266524869076995, 0.34002756241109233, -0.1337567379437914, 0.2198456023650795, 0.6648732818159021, 0.6253237560099009, 0.5866686414657482, -0.166427250791742, 0.1221986235621842, 0.46208607802098417, 0.341530710481865, 0.10788705563804887, 0.016353676845651036, 0.14141007684495852, 0.3920557121900693, -0.6456754473040489, -0.8732643922026444, -0.3269836386478612, 0.5497881602555047, 0.6262985696389151, 0.2534668573412541, 0.30912870317789576, 0.7110418202123574, -0.3530103147353701},
    {-0.6934352908983967, 0.4413609458316247, 0.6498600507844947, -0.5866732487977296, -0.3010814074574723, 0.1527736359155644, 0.18299685373153188, 0.4597960782108618, 0.09276016123198962, 0.10102102173464855, -0.05122108038147324, 0.10884959480417242, -0.35697896795802697, 0.059813152257534925, 0.43845388539575963, 0.40147927535239175, -0.6283685680398629, -0.004466419579832675, 0.05239535399288818, -0.24056161598688722, 0.5439986497032009, -0.5095448867084237, 0.19584929779430477, -0.30388864145052047, -0.14728444518627243, -0.6923438535953317, 0.43420718115401175, 0.625797803395995, -0.5669219691350138, -0.15093167273528965, 0.34287719515159665, 0.27302859176597477, 0.29113511104533524, 0.5501262401171867, 0.38171332924852314, -0.38002110927229044, -0.1479810283653065, -0.5385254430707025, 0.4320662874431553, 0.0708549682079262, 0.5574666098558237, -0.05194145833503729, 0.16029905307276712, 0.3506304102208719, 0.5518899955637396, 0.4044969765312505, 0.645089907304616, -0.4675255825120054, -0.13661617594320108, 0.3114127142454085, 0.11283936578257897, 0.3105232817733267, -0.5093262458919422, 0.5771178959749121, 0.38013900396277894, -0.20050807865423503, -0.19914112174511497, -0.12776386120111838, 0.618424069768185, 0.47404606781546077, 0.01608876978629242, 0.5996055184625665, 0.3405309345416462, -0.3291366257470092},
    {-0.4682318157736225, 0.6493733920227565, 0.529525701759892, -0.46738987426678347, 0.2738542146249095, -0.4669236642159827, 0.1267100579683745, -0.13343843062965408, 0.1656845632484906, -0.029544439341838705, -0.017017931950862056, 0.2947403247969508, -0.29605757084793416, 0.19605384837919565, -0.005324126361705412, 0.48797426573250363, -0.3266979339710094, -0.336704870787007, -0.01149384348828523, -0.2495867097476915, -0.22940123885570057, -0.5088842582581599, -0.14652781363083553, -0.25866720832613477, -0.47670348234031795, -0.06330182427652915, 0.45999229894782334, 0.06634975424540876, -0.5307691388517296, -0.5434192069580287, 0.13720711835084287, 0.46614488968727913, 0.35918346293770625, 0.2656476385959325, 0.6353318791599516, -0.22677020678177132, 0.26298922916257217, -0.19902766126148608, 0.476804335644066, -0.6844908598288112, 0.42532227162879543, -0.0507278889611418, -0.6440982381332685, 0.5291970553951246, -0.08736942224038464, 0.05004522507078605, -0.1427538309831043, 0.01716980124542214, -0.016331706637538287, 0.3229207309497683, -0.03513263923202581, 0.536956608374753, 0.4179719044143447, -0.3249622290599246, 0.6058829556500782, -0.5788810877162336, -0.21752473052940727, -0.3227380042886203, 0.11348202797445299, 0.2809399905370601, 0.29920093283427085, 0.4110434710697435, 0.6356165333139888, -0.43572301839996175},
    {-0.034559255266575634, 0.15110146856923298, 0.10197491260129186, -0.6389220854024084, -0.15753828172575451, -0.5235132691395518, -0.11467000796665212, 0.2200243068885974, 0.29338496334534986, 0.6177235322492515, -0.18985283279521664, 0.1104746367476701, -0.28569849753514714, -0.5260984801561718, 0.009521023154439767, 0.4129296747905816, -0.1958456123939742, 0.25586162284882985, -0.26976530614019506, 0.4166152212999366, 0.5675074668514245, -0.23847824668802176, 0.4317150241006336, -0.3331201057800361, 0.36828809048732547, -0.6288769482587152, -0.058127851956912314, 0.3290871766562236, -0.0028956619046899093, -0.03600756465527283, 0.19668341625069616, -0.11468775062886405, 0.33100504225387023, 0.19776071774112472, 0.2046017425188426, -0.3423958457112339, 0.5632736108097037, -0.5012843938212342, 0.11627715677534924, -0.5294639378136641, 0.2412999109170634, -0.13490963559646063, -0.4387672059139106, 0.2965045505386559, 0.1500885199384156, -0.11460869017538962, 0.5741592794961893, -0.19095455322613214, -0.08409613414462856, -0.113553090153274, 0.43907674417662496, 0.017035603919525053, -0.45492852696740715, 0.034938199732036296, 0.23103549700838122, 0.04026726528116359, 0.10488151736820767, -0.4341575027450057, -0.13453733576554722, 0.09807762379015406, 0.07908078938025853, 0.38713689466041495, 0.4846792749621436, -0.6611247113154717},
    {-0.06381002440805202, -0.024477475069466365, 0.11078335149771569, 0.15064817661992483, -0.29149383153437575, 0.3185465331071099, -0.3489339517410358, 0.24151771073947953, -0.3161396051774794, 0.22134067624401815, -0.40318418835680897, 0.0468327995277565, 0.23167678687023432, -0.056194336922062924, 0.6402574142955746, 0.47933613383967405, -0.5997225716089639, 0.3370561848382831, 0.4272543547937639, 0.2926781416055276, 0.10794040077879048, 0.19211405720514604, 0.11542177271161666, 0.013889695678529618, 0.2589994498951453, -0.501942031927815, 0.5901612009911593, 0.19507639702484705, 0.05195199401677583, -0.07326730194806044, 0.5172939461178594, 0.09341106983123061, 0.22362288023413085, 0.6470892888815284, 0.5850372291096538, -0.09856221648424696, 0.11557138276329199, -0.06165649732450986, 0.6876265294736222, -0.12193916424902171, 0.23328489306603406, 0.17002636820329822, 0.35609669640535757, 0.5468104088389941, 0.6656243385465548, 0.620978214769551, 0.5202121530801762, 0.14162821836971062, -0.39217264921004097, 0.08350930755292668, 0.1621212012969188, 0.37433647171226186, -0.5478080644378021, 0.4268199886973302, 0.017932265061540928, -0.015348581055604011, -0.3709866751578605, -0.4678649725516349, 0.505757556387802, 0.14214132138403943, 0.23148202237682666, -0.016362322249059445, 0.343995891188982, 0.16792230364379476},
    {-0.19314642846973926, -0.22849859722477106, 0.23265346426318406, 0.2957861148701219, 0.03717200481228473, 0.011666288056605975, 0.36605821043673886, 0.1637343264774431, -0.4597782934572118, 0.16492398251326057, -0.45866805722845644, 0.3078836337439796, 0.08253947976373921, 0.26235608761540286, -0.044041236808012495, 0.6976833464964126, -0.661537162954048, -0.0011220150057762357, 0.4455821857072055, 0.32628546495674204, 0.5623350516029044, 0.12671974787955168, 0.5325028256413705, 0.14680049981293594, 0.12810780893844295, -0.5328511939955841, -0.32866121499219275, 0.4377103452151877, 0.23961679890730392, -0.20135123173201097, 0.14023364690364556, 0.6337359683560921, 0.28915037065592336, -0.6694322416803626, -0.3966945785325983, -0.2059036300411167, -0.021767875987425293, -0.13532294893292005, 0.002950324728677835, 0.02836773039408417, 0.1645062720370327, -0.3219499463066121, 0.29288374711764276, 0.23535765035159137, -0.09280690007108817, 0.4638640397765593, 0.333104913065449, -0.39114530419258364, -0.19007581063643098, 0.3079067652118944, -0.16944641163456273, 0.5403354232565067, -0.43141106602903645, -0.20149476718130158, 0.4371971970856572, 0.016051045482811114, 0.05092167695895035, -0.4433749390841809, -0.27206473035464546, 0.03734950438997127, 0.5305459533754966, 0.42970964156801444, -0.29720064650037004, -0.29629390963760366},
    {0.08674243515301391, 0.23459259036521782, -0.2156468811262086, 0.1541671554809409, 0.2569519502804544, -0.6732341079517504, 0.408573284244338, 0.5873260932877309, -0.42844329617050003, 0.5869164718681135, -0.4390644256879799, 0.027107457787224593, 0.526574735010472, -0.4310751662134207, -0.34501098184230444, 0.0787355658694419, -0.7384836447710538, 0.4139526752032631, 0.23466223954964321, 0.7340021749714356, 0.41896879731683573, -0.4886151610161986, 0.4310567758038355, -0.21036016138895494, 0.5168513278407398, 0.1143074581835471, 0.10989582972635109, 0.4092479182514359, -0.06342460665762681, -0.34108071354627034, 0.3006806507816595, 0.5266317640638987, 0.2657375752582643, -0.2602849715193206, 0.24024299100866775, -0.8799293515688407, 0.5087471997872302, -0.029974893365188125, 0.3724071187086862, -0.6041264740229807, 0.40405958818295834, -0.05656356216509442, -0.6428946643900797, 0.5921635589375952, 0.28549557643532386, 0.4670421719054596, 0.44657786819970635, 0.04176962795643716, -0.20774275161759506, 0.22070858359904041, 0.2250698256109294, 0.4671762250983863, 0.16565806065768396, -0.3701223692234919, -0.06626250190322176, 0.54590366989858, -0.018589323332762205, -0.5544882636551567, -0.17548406683056264, 0.5169261811867545, 0.5397966547314054, 0.38597887239595163, -0.10771214441032728, -0.18397828356342785},
    {-0.007636103100468264, 0.2433252704141772, 0.0331764071500555, 0.05007043122657502, -0.2678236825616547, 0.0977195986873976, 0.5701867078491908, 0.5758588781962344, 0.1999982539782155, -0.019173184286142748, -0.5511138763837355, -0.1841233371304423, 0.045414568543680374, -0.5335715417138405, -0.24027553198792378, 0.07109868746853161, -0.3407470433016389, -0.20059773328299849, 0.3467136023774854, 0.3728520759817105, 0.36625529051584454, 0.34871790482506465, 0.5211088793027814, -0.5907496451707245, 0.5388259154616843, -0.5513627655716281, -0.5261795432260286, -0.041114270789436407, -0.29155820197649535, -0.5233315648345291, -0.2576935671047602, 0.4448263107233611, 0.12203512862951281, -0.20567272118397262, -0.36661871452563305, -0.6500393234540313, 0.06283813871859452, -0.24441707472367827, -0.049952382823611294, -0.11950344898245466, 0.2553554458806681, 0.45947776368981375, -0.06262109788902524, 0.7570441939284724, 0.11544065070588128, 0.11790694911090106, 0.7007436129643522, 0.31595435026032187, -0.376799132664844, 0.3389966174430129, -0.2713841499647135, 0.22841529864588445, -0.5171129980931086, 0.33849978282079646, -0.14708064252260025, 0.3355563278062492, -0.2027291334487377, 0.38523134170006323, -0.26096246224284475, 0.351401797923537, -0.11952093796408252, -0.20514559504972218, -0.11867754696370986, -0.08926032145525942},
    {-0.008689851838006895, 0.5364596181169998, 0.13320048931487286, 0.10172728616655392, -0.0919129437823088, 0.12890314500022768, 0.3396373026598835, 0.4174276381465787, 0.44354514087413244, -0.8326570939091542, 0.04264256250776162, 0.060795965922349066, 0.005651944817620579, -0.1060728869674735, 0.36626512782928783, 0.25517914958336285, -0.5461461968315346, 0.2862548808207917, -0.023294913991345916, -0.0035875936413826363, -0.04393053478219291, -0.2849400619338325, 0.10154370204311029, 0.08646375729973509, -0.29795197236100895, -0.3129151742034675, 0.537612796004007, 0.4955660464896255, 0.4198286976475937, 0.20485426309123853, 0.17248765484452203, -0.022098521481223203, -0.4246389065622971, -0.6405449189072694, 0.4345121072860199, -0.38645526488922216, 0.23488056170885527, -0.06067000190146652, 0.11097656246633462, -0.09754154371315482, 0.6137893187901853, 0.3989642854306911, -0.6637282129664724, -0.3183816674551602, 0.041660204567200855, -0.6311057257770221, 0.3691081988133564, -0.44984532497320384, -0.4104332193463399, -0.3717462054777853, 0.09849917200396491, 0.27520988638215677, 0.5089621459029567, -0.2830389459705108, 0.002033086436818291, 0.24146289027471565, -0.4771625543267346, 0.0203915947738812, -0.22856445403371076, 0.16979038747679065, -0.016706217628542977, 0.24709582230348137, 0.010395698481989011, 0.1626713915533652},
    {-0.3356465280683059, 0.4581624840648985, -0.3073773343171882, 0.14811984518225843, -0.2560943330947681, 0.015495446620867439, 0.30182957592196114, 0.31717941737103883, 0.5926956405719764, 0.4474103192999626, -0.26922136691945503, 0.3443306746635797, -0.12143779874230594, -0.022452411344550366, 0.19351696993281203, 0.1548838078939179, -0.03997639118079147, 0.12603499392714262, 0.5488206732336851, -0.2601454013214957, 0.5914051040059649, 0.24897414362710435, 0.3942874415179375, 0.25819854844602314, -0.21798503841654546, -0.20469993594850502, -0.48775030146817033, 0.2192525275350627, -0.18464098927390388, 0.1089216372837019, 0.29030974048019653, -0.21165487162788413, 0.23244487878039938, -0.16382526461589783, 0.22953162945133843, -0.22715559503148372, -0.196480447889041, 0.17017412075708377, 0.6474420809259288, 0.4500998522649994, -0.0855239850397715, 0.043748618691493185, 0.07867448812219603, 0.06179012871288726, 0.5478533667262954, -0.25493939751395384, 0.4188675769178075, -0.5883157940415077, -0.33148459198814917, 0.5788213010931423, 0.14483585099204901, -0.16100055689386453, 0.017630094335495103, 0.44217505958122577, -0.1411631532525146, 0.10049323195042234, 0.0683685506985205, -0.14943208682656897, 0.6682898682935485, -0.0005312346698103304, -0.29448372770669917, 0.09391623809827306, 0.25208341437386445, -0.20178489968760296},
    {-0.20810010626711267, 0.37458339076288355, 0.27002394801519325, 0.11396348570542221, 0.20625265827939457, 0.12418655683451449, 0.6504173325082174, -0.0008321807713919655, 0.4281378459237533, 0.26059397622828456, -0.4727350377138893, 0.24636283288923538, 0.11484528578898738, 0.08516952727232012, 0.17062695780799841, 0.48284839986494604, -0.5315869052690567, 0.38786042355818257, 0.1662384048234319, 0.11469408106906272, 0.4787330188209958, -0.4224473975662507, 0.30252610294315835, 0.1845633159951293, 0.3770961847397736, -0.12840240363787944, 0.576735883687937, 0.45868385618016194, 0.36591096616799007, 0.05417126264694426, 0.2919632296229583, 0.05807022721389388, 0.22597984575451155, -0.2173516301589637, 0.6023364883541743, -0.21210470101807236, -0.09425802148568681, 0.14599295728654998, -0.286530935640435, -0.007557149832562583, -0.4268834608207619, 0.1972409324679725, -0.41440526945559353, 0.14260487606701083, -0.39522210120685247, 0.3421387546130956, -0.18028114610261237, -0.07651684301663594, -0.006816885187905125, -0.2161189128387995, -0.34854806678079514, 0.47334777804425865, -0.16834827917662307, 0.1885878903036918, 0.1814378980779851, 0.48098943314346587, 0.6290272202780621, -0.20465150520463693, -0.23470653491520208, -0.03254013852891498, 0.360473870022855, 0.0754158210193813, -0.1358714270298051, 0.35487468467544814},
    {-0.3311060079966399, 0.4999777511010267, -0.5590583405675783, 0.035750433398210324, 0.2258388833487997, -0.2278946844556968, -0.07851140564471824, -0.30210669583055566, -0.5874728584336013, -0.23767066875835405, -0.026524501929047577, 0.23255161524908963, 0.12995838726017828, -0.7602495894872724, 0.10451237019508872, -0.16254103210506407, -0.06491953094594007, 0.09392652409103668, -0.2049502710971389, -0.00375360991581121, -0.38480046474953195, -0.6107685709261913, 0.3034598735040208, -0.07050349286982138, -0.054458943198592825, -0.4256203048271333, -0.1879045766728096, -0.3905585711767193, -0.15653423119832272, -0.027094678894072334, 0.09735312699869937, 0.2173353208701042, -0.02203672430792508, 0.1290082801244874, -0.2511569096618658, -0.1965547388141001, -0.03652189214876999, -0.15382170666084638, 0.06328952731622964, 0.249108202077941, 0.277976529999875, 0.05767013925983169, 0.2511300457495313, -0.20509526490496746, -0.3756033778326825, 0.2309356090014593, 0.3152119146292227, 0.07109662909039888, 0.395134428809018, -0.25534875211905994, -0.02905858097371173, -0.47331723573274914, -0.36340035024754636, -0.08249120548448174, -0.10650015520443125, -0.2969160194545551, 0.03884624879594232, -0.18920719639062455, 0.17728608142589192, 0.19554091155994588, -0.1471209461867953, 0.15151245156621762, 0.20009978143922588, 0.3074013727912456},
    {-0.27417663248450774, -0.185288325840363, -0.4339078102925963, -0.1561463502243407, -0.19585068668282393, -0.3724415951873511, -0.0665549274568381, 0.2299134496333689, -0.1398123104137394, 0.5220132796405123, 0.45862355698878404, 0.05322510101217619, 0.10422831685224689, 0.32644760999849, 0.20993371655777132, 0.4110557004610069, 0.24810057002211883, -0.33998154527873864, 0.1343960519294996, -0.08368378227032056, 0.19702274250819676, -0.4744173389303504, -0.32714788504674536, 0.2689180058157117, 0.17344583497004262, 0.059032998454699816, -0.19452974786431806, 0.41986295481304875, -0.231895617823599, -0.3602287620223071, 0.46056902100492875, -0.02146496621244195, -0.4964629118580473, -0.2764881558053839, 0.42313837670851046, 0.1517340606505286, -0.4803861274976007, -0.36840060058037044, 0.2850030431399053, 0.5632839570724857, 0.4513580418132173, 0.22699995516260993, -0.30875082548388627, -0.13519688944068808, 0.23296222614678241, -0.5263539781594023, 0.2933900826241223, -0.3110491001897048, -0.44068599325012703, 0.12250737586507524, -0.46188074806319707, -0.15152077306828443, 0.23115269096129015, -0.012710452315573089, 0.10285681347538962, -0.29547833111474175, 0.10722247545701312, -0.4627998792675941, 0.3978003506747953, -0.22830609615567818, -0.2129178047330643, 0.19178101981152132, 0.3728500204562248, -0.2608424298113464},
    {0.051473653242953644, 0.08044748951293727, 0.13233234000359584, -0.26187531060032004, 0.5192423653139139, -0.5893690550695126, 0.4718507718051036, 0.48448627755294116, -0.2974323108742794, -0.4108552267742438, -0.5834199734906216, 0.4281562794636881, 0.4806108005841325, -0.7091897770851301, 0.06852687654589079, 0.3329912855539828, -0.07859689162993436, 0.1087634765203495, 0.275509460075339, 0.19527451978937857, 0.10565448394932238, -0.010564179188916013, -0.07678678663787414, 0.14912769176819404, 0.2436256394524383, -0.5854841285267237, 0.14151102005650681, 0.10202022688717713, -0.19501229949634485, -0.16817694887424636, 0.08307045409236252, 0.5385262721011652, 0.20442575243060637, -0.6180448362850989, -0.12372247966015842, -0.3402465349879644, 0.5481626365350937, -0.2998885847637127, 0.6444589089247951, -0.30053932419955565, -0.3960340562716518, -0.28978378287673684, -0.16167788066083572, 0.33712526246499946, 0.09526497483287658, 0.2737205292258093, 0.37737957999754906, 0.04307248269022895, -0.3286638443669425, -0.44958742187074435, 0.01695530670294908, 0.3372294860320142, -0.2833278593313398, -0.6587170398971249, -0.03143746855033365, 0.10616401175528282, 0.4936530430565469, -0.6726036437399937, -0.3644989256961283, -0.3822167747880344, -0.12352243888242102, -0.49074568057346435, 0.1999431227729504, 0.17174966323355897},
    {-0.6700987732149828, -0.3640187360447142, 0.23996707903761685, 0.18119544132885282, 0.18718156302997258, -0.8682393012745491, -0.2383898631995942, 0.45143680310970113, 0.24443976047013355, -0.6610840707156768, -0.0258478922724632, 0.2182122304188283, -0.10534174538313439, 0.03140401428138628, -0.11346983808481202, 0.02052399012363713, -0.16974864037969528, 0.25889938523533507, -0.3229804033096041, 0.056177115156431257, 0.18407539097099618, -0.7452215172516803, 0.06281781195414989, -0.18680478220318392, 0.21371390400238705, -0.2823750468230401, 0.07876402672840871, 0.39593261965577026, 0.07892792971857293, 0.01577687701179238, -0.3742053126037293, 0.5259664694805252, -0.37760244592357506, -0.5770852910502764, -0.4278336449116672, 0.48789190834879853, 0.4844740989654668, -0.04943381825074149, -0.03660806932987128, -0.5045565817234479, 0.19555478863829745, -0.22982410465710557, -0.6112622694571552, 0.15524583203282777, -0.19952338633692296, 0.5221197740895251, 0.07208442883353831, -0.042014202246629065, 0.2982677558383533, -0.5494743573493315, 0.25572819625793053, -0.14258987294837625, 0.09472774819310664, -0.6495767894892727, 0.007866182774280868, 0.5809797731371903, -0.41669107166266567, -0.44614633063201065, -0.5277965119713867, -0.2750907601168542, -0.09363239603776867, -0.09201949548293227, 0.45062816273897116, -0.5003312420932375},
    {0.04009879569752848, -0.5658947332146601, 0.43774804405523987, -0.18939364243848011, 0.276378451368014, -0.3654545887750162, 0.19852265635831737, 0.09767844298664335, 0.3401425718454257, 0.0954432880254952, 0.033582298508163605, 0.057427138242681204, -0.36271624825978044, -0.36272699320459906, -0.4208571712571152, 0.24491777791531993, -0.04188760921147854, -0.14468374262652672, 0.22567352357487583, -0.22208959326864053, -0.33097068125172713, -0.32873163683582757, 0.01760290980582292, 0.14681570659609797, -0.42933721441646777, 0.07364535403746515, -0.3814267568587654, 0.5467246062199878, -0.6731921234574146, -0.05172743774280365, 0.5662629690506293, -0.5265820308230604, -0.22086849405078823, -0.28598621531536794, 0.583081724902341, 0.5912202002969864, 0.05510643140785943, -0.4636732786882871, -0.2543530868362242, 0.013913040751767681, 0.28787069204087146, 0.3082408235498857, -0.5978218747629906, -0.17634086225781653, 0.15596462504380884, 0.3336317004048469, 0.38345472029065797, -0.6002320838160219, -0.022992349763496372, -0.27259255127896387, 0.02016345369054026, 0.3065457029784879, -0.3349316216983365, 0.2170147227424795, -0.14333752576241265, -0.23111508441105888, 0.10473520422433279, 0.1517208144104617, 0.31945631865536234, 0.49710382162481276, -0.4095611748490005, 0.2903586153717828, 0.35928560271679677, -0.08458394562377043},
    {0.0800888352026065, -0.5809563539714734, 0.05484141319861642, -0.3502674352586115, -0.6453223636426524, 0.17481005017616716, 0.011387438611500596, 0.5954565555201775, 0.22299490657161322, 0.20883909726020286, 0.16167253681940513, -0.08315486696572041, 0.2052152794313302, -0.2506667007709586, 0.22850362816146474, 0.4241563569496268, 0.19879834643258024, 0.3976625201493885, -0.03191150191299822, -0.12760272018061566, 0.023127816539663157, -0.20171633962662983, 0.23274349991188722, -0.350167401124606, -0.3161022074062682, -0.45521590760032105, 0.4806123696250112, 0.4955127160739343, -0.5367162297678885, 0.018350142352362698, 0.3551431474669593, 0.39767646638194243, 0.11978139422528684, -0.2357897472918006, -0.49312865461535427, -0.10983613005015358, 0.14401312619476866, 0.20025197428600958, -0.33928566815261324, 0.30799212224121586, 0.35592398078137033, 0.3426390464023144, -0.2782812212164942, 0.0581970650843382, -0.07028680187112127, 0.27968826820816234, 0.06620364868115754, -0.6103644550129045, 0.17333006923619992, -0.3836539132979934, -0.23907608249775364, 0.08723109468767057, 0.20843902083166382, 0.34719965557959515, 0.4436395768474442, -0.048007756219907396, 0.16146178928818486, 0.09431402523962144, 0.2513833490647625, 0.463631518237875, 0.008470767873016182, -0.10324257092097949, -0.15844344898677037, -0.5297879197382097},
    {-0.5823247206791645, 0.12505401686297032, -0.2740778039787796, -0.47715366025793005, 0.5457568364025692, 0.1285675373944341, -0.47541146469021994, 0.2782619681427982, 0.5706124091651672, -0.11652697774777099, 0.18394419506042556, -0.4084919370720531, -0.18141722939192212, 0.5120194844271536, -0.40660394406614603, 0.5727723495206672, -0.34259716839862847, 0.1493129602396994, 0.19206593214839554, -0.2613227670718809, 0.17930903905981221, -0.21359732882952523, -0.20496801525878033, -0.3675124887377855, 0.3905967902690389, -0.14157157121446634, -0.539926987964694, 0.07529248096683043, -0.27253104132758, 0.17536879482574694, 0.4861693663651842, -0.11490534558438936, -0.6117027908602932, -0.4444143584286777, 0.01769065611569948, -0.13514303844435901, -0.0756935608446552, -0.3616999683895414, -0.5114859899779352, 0.1501263448022332, -0.02381298267118411, -0.13987059272811264, -0.014745652721502068, 0.3723756514939771, 0.03498601233637191, 0.16973074336630958, 0.0641855734728352, 0.1347074938524573, -0.38003759124749664, -0.08636922819232991, -0.1811215231006094, 0.1684990069704202, -0.451857555788922, -0.012236602192528291, -0.4913912295697427, 0.3180020802598865, -0.635467439219962, 0.43673384752294203, 0.13164055787940604, 0.5182531155864399, 0.35161597649151183, -0.4191601684198594, 0.35368931215736726, 0.24003711247263265},
    {-0.39881470346742665, -0.057513263354460595, -0.3849612433543802, -0.25030464484143855, 0.1146378619523978, -0.4483657174822554, 0.30281413812471303, 0.3139553277427592, 0.34521069876903376, -0.23444090921594016, 0.24430552231588804, 0.07896399477856782, 0.1580585970929053, 0.2954442034920333, -0.2337754679333176, 0.4888862078563715, 0.1723699468915667, 0.15915808704553544, 0.03247398655186673, -0.1826166964768014, -0.09468618933635962, -0.8387229814312114, 0.4536140861806334, 0.47542819200441333, -0.32571468173442053, 0.4161637990763703, -0.5339868991984061, 0.4651630987068008, -0.3668249881716278, -0.265520630195266, 0.16628064238099713, 0.16883206985298377, 0.4355865106126791, -0.11072478372774493, 0.01940734604592042, -0.2673094007922043, 0.07000644771558559, 0.16717503320619517, -0.08771074285293082, -0.13165531068172348, -0.6144451792158813, 0.24385041874849586, -0.7403312786053474, -0.3960002036588869, 0.09297220289070393, 0.15278075404859376, 0.35656410114667114, 0.3875021259250391, 0.019504882506937434, 0.5694843080088328, 0.10583456627186023, 0.08747339058713711, 0.44007504672420134, -0.025394778601764218, 0.007170446381877591, -0.09286544493830051, -0.11213452128897038, 0.1760414285824925, -0.02983990114117593, 0.3860442165376331, 0.4338280769785245, 0.37962711546481404, 0.18830847303739168, -0.26037230052784965},
    {-0.4414253787988465, -0.2327176412629353, -0.22570610741016656, 0.09159528291218924, -0.47174993392459197, 0.5007114096135049, 0.004847697917486595, 0.4431398700244112, 0.4802638139064441, 0.5765894536536483, 0.0016922181362739352, -0.29318679402776815, 0.04878362233530208, 0.2250639113019752, -0.15171017808376733, 0.5208481107022538, 0.5211012550475089, 0.40752236974483164, 0.5867812962689312, 0.45466227422818717, 0.19997673080380335, 0.14367830870410261, 0.648909821282344, -0.33219907791759745, 0.3979973487042702, 0.5126894089896294, 0.40904194840104036, -0.04476686451717954, 0.03306917186902785, 0.3090195372005285, 0.6191793211207428, -0.34929191619529437, 0.5064027246053318, -0.5260815215845575, 0.3070652920051224, 0.4585597246273726, -0.10713537328287372, -0.08154425631861888, 0.44529003506684534, 0.3664000802666021, 0.25412624754203456, 0.04239083230612608, -0.6530602500740418, -0.21321014072616754, 0.2798891081355436, -0.6087500962049421, 0.7609056483791609, -0.41162177055983606, -0.41386510948641037, 0.2526213961564457, 0.29987829447684683, 0.22417799003173558, 0.19637638856087208, 0.5920990866242104, 0.23283118023060015, 0.4289463899794599, -0.2060343074408464, 0.44873424225649156, -0.18976747592121568, 0.2477342413155813, 0.4508934798285039, 0.09392768933277194, 0.39575674548668155, -0.02524601635161633},
    {-0.2492719150313128, -0.0977806293538271, 0.4177543710608525, 0.113550451615851, 0.6250231608397737, -0.25489173230518425, -0.07790301086132781, 0.3416612649487822, 0.1457661356618006, -0.0501243787544676, -0.04136441034100496, -0.19884195412246325, 0.008856628845464318, 0.450260066949131, -0.34299403563247244, 0.19617553583185252, -0.01799009982302308, 0.050138619160734955, 0.05152863294852317, -0.05269389132896949, 0.06734667633091518, -0.3535893483411071, -0.05329670899788706, -0.4807311937479019, 0.3542618009592836, 0.13461756113879872, -0.0848234225370033, 0.417819278054915, 0.19735691905174665, 0.1120016566891669, 0.47560340629501724, 0.5089453854227362, 0.14669566284001687, 0.20221740711948974, -0.019906823078063164, 0.04992377687786371, 0.29662725808260765, -0.3644278041596753, 0.22537179827579132, -0.2118994371235184, -0.04513537584767512, 0.3710218091941453, -0.3583019165951857, -0.025344036118298795, 0.37331498958448056, 0.20148451853812138, -0.017079171254642284, -0.12605510725970556, -0.1785518674598706, 0.5187535002161794, -0.25345110521515457, -0.26780926031185803, -0.3609450628802625, 0.4150642371977497, 0.17384755167244412, 0.10401770160719517, -0.20371888470565566, -0.20773401575999276, 0.8033802703451923, 0.3227935598900744, -0.1504497284842686, 0.08817864430516653, 0.6647288638698284, -0.6708651149207467},
    {-0.0059892440019499015, 0.6436630064303742, 0.26784461029000173, -0.40210029626790234, -0.25101087299385744, 0.1583906386044727, 0.320911782983849, -0.29616921328552, -0.29861702706858895, 0.05149039179584749, 0.08886274708157421, -0.4162619663723395, -0.21935099848671902, 0.09843122306987868, -0.45553491602059704, 0.7024643839159374, 0.06401292856448217, -0.14385686916499574, 0.2955864044516504, 0.34830111374207023, 0.2502029164762039, -0.0600098790574282, 0.20702976516917704, 0.06264342567952029, 0.33471057548984784, 0.381312653974332, -0.5521985297182792, -0.19274666316984732, -0.26467566767768214, -0.4165251705778946, -0.18525386296019955, 0.48634116344382183, 0.06219968911445505, -0.8260156850439534, -0.12980232581543147, 0.14612717582451937, 0.15321700194492377, 0.029077115193664488, 0.45707554588419386, -0.16328170033138456, 0.1414673166368036, 0.21276884449744493, -0.47735745013306563, -0.5213888723304805, 0.10999387124009734, -0.4265964141135863, 0.48250159049515573, -0.09377881337242118, -0.41274457498677586, 0.16536995373485175, -0.08672682320690422, -0.26245745322922537, 0.2856442400002207, -0.4088499872875133, -0.40654991817466996, 0.012213034440687507, 0.08886943921900974, -0.020389173027360947, 0.11931295654841938, 0.13883245193134366, -0.26841732001404406, -0.4144606565267997, 0.10131645310477877, -0.40645932160775605},
    {-0.4970612485091753, -0.044002999404739326, -0.09725937707897941, 0.3584241786650179, -0.42621490320666033, 0.055713934729678415, 0.3845884346532985, -0.23594706248960726, -0.45964301522823375, -0.2834498083347597, -0.39898398028200427, 0.1016089421348493, 0.11991789429812351, 0.18472597121334555, -0.15862839566674689, 0.48790925903453497, -0.41563114725719674, -0.17078033139677262, 0.43478453059272154, -0.06648111076863544, 0.16593808219129305, -0.4010996608139185, -0.2606971816878739, -0.008676503339672468, -0.2876546575261681, 0.4568023566684989, 0.08744433273118501, 0.3493682001680065, -0.15020504825798012, -0.023275194139717802, -0.16669096733957706, 0.5418052063600364, 0.25020069118379956, 0.3416947211798903, -0.3843632249991437, -0.4926495148999613, 0.2719385048203658, 0.5654070358094069, 0.29774953982545194, -0.4176883414144669, -0.1285109152553337, 0.317092022348374, 0.07322953887922312, 0.015107704362768362, 0.19076595914702593, -0.1437277264586812, 0.27847780827069507, -0.09858760120979788, 0.20435043246669757, -0.4817386956298099, -0.006956864987629515, -0.15862966183389393, -0.025732581916870105, -0.1259361610111365, -0.21162295423478228, -0.20003763808691385, -0.14089846626099564, -0.6422316473217059, -0.23640650851112383, 0.05087107727801661, -0.040352844727311904, -0.24146296705769923, -0.24793023346968007, 0.06987365708567235},
    {0.36668354359982624, -0.17722920005977194, 0.1171233890163889, -0.34046262357318674, 0.018696647058753322, -0.5475986020468594, 0.4929845665468514, 0.0032913340169367575, -0.2272302140669186, -0.38509125279368, 0.005017205650157138, 0.13403848947822583, 0.2708978905831219, -0.4644246877939238, -0.37022691570115207, 0.3691761430381527, 0.4829960621412466, -0.32402985233220927, -0.05655482382614329, 0.1472888600534829, 0.2805779610779235, -0.09020135603648506, -0.12520812118523464, -0.32607285338725467, 0.4778980553193174, 0.027368462955224812, -0.47947705072697666, 0.2109705322067972, 0.17151908717055564, -0.15213731783478182, -0.42205431831846024, -0.5062923036453514, -0.41532719665965234, -0.35957496587992666, -0.29375595680763267, -0.47057931625555105, -0.12324616955046176, 0.09753165222675349, -0.34763487034085966, -0.49863779489563703, -0.415192739778305, 0.322830642798676, -0.7145920931416468, 0.38716918064724243, 0.007064326121992204, 0.19954567445399593, 0.4918506478548797, 0.5643706134348808, -0.4365688966939548, 0.10143093149041298, -0.41545510930529517, 0.08769345855076206, -0.14142448684200556, -0.17475546048066445, 0.1720342298552057, 0.09298591395428683, -0.25717224071351863, -0.5485882695185834, -0.025770331403734248, 0.4090629724067102, 0.034332087309992036, -0.5825395153357605, 0.43112285398852473, -0.4982858787863552},
    {0.1801347283656924, 0.15072186419125994, 0.3432339955753135, 0.18772579726242938, 0.4337494880166711, -0.1935627677466483, 0.4699984455735905, 0.3983847135563299, -0.3472618026281046, 0.1459922973678285, -0.11920214027532064, -0.17193795887683286, 0.0999569218486796, -0.11524403680980608, 0.12768958158872837, 0.47481323600564146, -0.5596085422170465, -0.11395838680599661, -0.10591256808763401, -0.34709176343130504, 0.18257913620084884, -0.6413986990605939, 0.15193053052656294, 0.18131988510683322, -0.2906282504109266, 0.3580447580481772, -0.1828962654411487, 0.4849700515042968, 0.3852999253416297, -0.4766834177962047, 0.4139632608558724, 0.26366997698186545, 0.27758133342763114, 0.19675961450984145, 0.5925607409175493, 0.4417057538934892, -0.01052470901453253, 0.4251186640447113, 0.2705364760319614, -0.2511183758936411, 0.32223448508384267, -0.19690587203850157, -0.5666939304197754, 0.4456338374669991, 0.39139222313684474, 0.45131613771431167, -0.10170433822897754, -0.017732813558142404, 0.05242166772491834, 0.055815092270546394, -0.26363495585062946, -0.18343522093259096, -0.3774537833088439, -0.31741789534959497, 0.19148369944024718, 0.05419542656172669, 0.1830881045356334, -0.24919339750861133, -0.4643005733183687, 0.4790675810268096, 0.15424533314670819, 0.4821531175085685, -0.1984609135340959, 0.2668269409853013},
    {0.008730809858056451, -0.31926404368056494, 0.2959941023538904, -0.32815399772480314, 0.22343504021986565, -0.18453218782728054, -0.4695508609096398, -0.3124009897199507, -0.3625442542454684, 0.21880029842859514, -0.27309608808876484, 0.20801740415527062, 0.31155560556148565, 0.2430525387199656, -0.4217370778703135, 0.16954771136035354, -0.2790276310525427, -0.30434672806165336, 0.022177866926924118, 0.027552153978488158, 0.22504990095918745, 0.027935070534956044, 0.5278466466921461, 0.15466359775349847, 0.23074406870251574, -0.2732292635091407, 0.12661918914448242, 0.511957343174777, 0.2520430061386212, -0.6505605157268513, 0.19088621929250787, 0.2517228678264302, -0.5431892228022205, -0.6211309268766976, -0.1500417488319503, 0.1639831600526349, 0.024354172231502016, 0.5767945435436688, -0.09143345734089577, 0.09215090099517778, 0.35399767641756513, -0.28049749499381504, -0.18595097047265607, 0.25702480130574734, -0.01593247174979355, -0.4062151958646895, 0.4461524270272326, -0.10784557264018177, -0.2517979750654192, -0.19390031284216944, 0.3657351852264868, -0.3264744538261569, -0.01655569378797286, -0.3787179962827482, 0.3063087229668976, -0.06716494182258909, 0.088948286900503, -0.2758124728156897, 0.08427246805737207, -0.1646228003622755, -0.3360218858603422, -0.7143545024591643, 0.2255546090850556, -0.0022346537993703994},
    {-0.11815631321592272, -0.32337660429243187, -0.06132441243297959, -0.04145067039521751, -0.5352222831316638, -0.002588457606418297, 0.09964888839434335, 0.6589435227991759, 0.44838125020167663, 0.33486118826462247, -0.3800580870370499, 0.22475904821348563, 0.09278878904994077, 0.18182672626876645, -0.44402879514968274, 0.18519498540536922, -0.740520855084871, 0.5926820213635596, 0.4827867179324802, 0.5574374768801584, 0.1250311862764678, -0.46236314703178016, -0.005457418620607191, 0.5650115359931974, 0.44487156034403297, -0.43508961323495693, 0.21180436501108088, 0.3188310526681882, 0.38602016042944426, -0.09157730321544277, 0.5334383450257751, 0.640242477674913, 0.3343470521496728, -0.09782636461654298, 0.4949972004275022, 0.09272958080490686, -0.12185454048307505, 0.47387501551719163, 0.458963572831397, 0.027592464494277016, 0.285299710310541, -0.42199672407705147, 0.14553743481480982, 0.20411804935831376, -0.027054021942366894, 0.2150119156328559, 0.6615048636828179, -0.10501597335431843, -0.5454764037208717, -0.43657465126494616, 0.32303064243553553, 0.5052089242191613, 0.21806097649952808, -0.38443901469409225, 0.2714043235754923, 0.5007080198078455, 0.24965985149319617, -0.14722648929998325, -0.5344520041762078, -0.11475548401421545, 0.4651910790267062, 0.24296822128957613, -0.31170024358607273, 0.12500022560788684},
    {0.401495624559311, -0.11045323246437473, 0.03561817017340752, -0.008342339772784419, 0.5212662532467732, 0.10554022525288755, 0.18546632355065903, -0.09367037938519013, -0.4580310531459539, 0.3449177049070109, -0.00037541183617585114, 0.16767677155250507, 0.32530102585698895, -0.12722887029395788, -0.2782669210512043, 0.4651923606163244, 0.06530404485730257, -0.02695631946056681, 0.3457872542896921, 0.470616035121677, 0.6679114611227284, -0.15739811390975667, 0.000615199605536523, 0.028949530635361563, 0.25991883706959573, 0.21950696849113596, 0.008198581888850575, 0.21515215655792233, 0.05836928089904285, 0.17844704493441144, 0.02209178137548538, -0.08429177302882322, 0.3085808667847156, 0.166793452639704, 0.01617227872127739, 0.21265731466500865, 0.16339517353869717, 0.07758669789380489, 0.00886304928942627, -0.4117561374760885, 0.22568155269606177, -0.06117077862736596, -0.09659792069262588, 0.12732877972574821, -0.11032574959848827, 0.4450703115306195, -0.3840301146265725, -0.07196487231642272, -0.26246597391279475, -0.022217670263987317, 0.2785968756598941, 0.18872248262149965, 0.3767112572756763, 0.28123087775435346, 0.130248831589119, -0.2445305194678345, 0.44001740512800175, -0.04467936847010517, -0.23438200027767228, 0.477021143887324, 0.02406849427693612, 0.42853116409262665, 0.19100858417896616, 0.45152190669521003}
};

static const float b1[64] = {1.2060110918141353, 1.1440236859867974, 1.1239852828892212, 1.1583528382338328, 1.192718139560115, 1.2606741237907273, 1.116902410788537, 1.1616865402506276, 1.2151993038816769, 1.2471938816383739, 1.2574807983552485, 1.0117814155056404, 1.1953512940166828, 1.2019865758278339, 1.210430556829238, 1.170479039625868, 1.234555553530539, 1.184162576413842, 1.1351091314566115, 1.1405803657812854, 1.174630437097423, 1.2633142546060088, 1.1571535077101462, 1.1265193039008152, 1.1908199418731722, 1.238492948063908, 1.1899236524381749, 1.145266894629158, 1.229354541242765, 1.2131229378421904, 1.1808540563293735, 1.1905358732629412, 1.1369645307260556, 1.2718199882206602, 1.150549250032822, 1.2151638342460902, 1.1749613979137703, 1.2014642248856606, 1.1980292365883356, 1.2612702882500793, 1.1391392641690583, 1.2292678993789936, 1.2314628587794145, 1.1318097316731857, 1.1850016731735185, 1.1562342113794166, 1.2049668631530575, 1.269225249018532, 1.2039365790443233, 1.206227850054914, 1.1312193200471148, 1.1079804052106876, 1.2115587654267908, 1.2180718881688115, 1.1585014437570178, 1.1997752994371251, 1.1888806467759756, 1.2207371171333543, 1.2036543636251593, 1.1406552683867004, 1.1678454021590694, 1.1607066163997959, 1.175147620029806, 1.2184840281126097};

static const float w2[64][32] = {
    {0.6026297116986226, -0.24186423009329086, 1.2090956082759419, 1.130840626212333, 0.5855252145875729, 1.0549721187358787, 1.3835321613715257, 0.6246494664245289, -0.1568795342365362, 0.955016998915789, 0.4687307469323769, 1.0050105880389952, 0.9521382464851124, 1.0963664492949288, -0.061333349155261715, 1.2694140777402791, -0.05198762293403327, 0.9624002634930554, 1.231603257820972, 0.9737527632576027, 1.265891110823331, 1.0373703460559844, 1.2336897665590367, 0.432811084763994, 1.3034642974533606, 1.1289385189251866, 1.280456552585246, 1.1465505420453663, 0.7602803073453468, 0.9128906895850085, -0.20658137907812174, 0.4625534327913778},
    {0.5650670089437205, 0.13518668902380776, 0.8933665700088391, 1.1665189448264108, 0.5362906454731077, 1.0307502085243134, 1.2571557762112333, 0.34335723969810505, 0.05358208380306516, 0.7955084525908103, 0.41146778945882945, 1.1674239446185448, 1.2280699522824212, 0.8768275115813534, -0.24044744176909943, 0.839738366224279, 0.16392422388702252, 0.7138733316741176, 1.008620139316814, 0.8360586892728105, 1.2012777113039077, 1.2764728963588703, 1.1491393748450132, 0.28245691107945337, 0.8239690057537667, 1.056497847135075, 1.0301520119291256, 1.076588018864962, 1.0380652995196291, 1.1334082857200092, 0.0467558626922487, 0.75330323236946},
    {0.285979195103952, -0.044794058841122364, 0.9785470493177453, 0.8629615135071781, 0.5021224348386426, 1.272081102420271, 1.1312669881550648, 0.41286086304020664, 0.08175341816121404, 0.9083596423711222, 0.5591356296215264, 1.0836785074464514, 0.9092552774102386, 1.07599346158055, 0.07466567367606908, 1.0521281974399392, 0.003989961466598063, 0.7879902221181221, 0.8703865053905083, 1.155089451591166, 1.258565473485306, 0.8625343726992751, 0.9096831880719393, 0.03888006435507954, 1.0869418253282632, 1.0989761834607465, 1.0100583095154585, 1.2266973467818176, 0.6880232043362858, 1.0945045750123705, -0.2574239477040172, 0.34193122812864035},
    {0.3720675296598575, 0.08143095538542146, 0.9289435418664451, 0.8858510357089271, 0.9827733436587235, 0.9639631910715929, 0.8646489356592408, 0.4816821562381567, 0.14438165201006126, 1.015404858911255, 0.3336466976274905, 0.9197790064082251, 1.005402858502114, 1.2255617182253542, -0.2302741257989316, 1.0316785295196713, -0.17603894813545118, 0.7218347077602495, 1.060347319331693, 1.2813102511312133, 1.1026348869960425, 1.0357825042256048, 1.0876060901262976, 0.2030688301562639, 1.283514372862247, 1.1537999880929897, 1.1112247492815486, 1.1332451579992153, 0.6847589254752242, 1.2035464885291016, -0.06937379242595129, 0.4583929065051157},
    {0.5045297694668228, -0.0938137162106267, 0.8462255213637075, 1.072863253685029, 0.8602941380409687, 1.2311039631338427, 1.220087308973889, 0.636914355946832, 0.04969070701268691, 1.1695632473302295, 0.5353712266606906, 1.1376908945413664, 0.9268512735352523, 1.0538540260040468, -0.04735426548103519, 0.9507815608935161, -0.1400268888192377, 0.7313029004540592, 0.9090098104880903, 0.9395646178110431, 1.0147825595393294, 1.1621221575846497, 1.026053451867147, 0.05042491605311191, 1.2358918641054657, 1.1034134917429124, 0.8853615304092516, 1.1753213924022206, 0.6531753230244944, 1.220539867198562, -0.14363740378411277, 0.7209194349286994},
    {0.27470525405300417, -0.13395632543570585, 1.193817219057217, 1.0376280177557726, 0.5727994262393693, 0.9262667385683627, 1.354180694486649, 0.7355202164424769, -0.19655145601732932, 1.2106491822964722, 0.21125990513250215, 0.9351996103847988, 0.993469367672695, 1.047697039141878, -0.15214330232348086, 1.0529537347600106, -0.049638384405609255, 0.7311097944756483, 1.0907507892421975, 1.3178918574783052, 1.1059091236689857, 0.9400316418787973, 1.0125766901338198, 0.2743386443953842, 1.1901330442275628, 0.8877925767590186, 1.2371280242021032, 1.3242358914803662, 0.9940318423292099, 1.2362476366824795, 0.17189228350238955, 0.5035602567377456},
    {0.22518158461697715, -0.15655761500676726, 0.9929727367548455, 1.1904575317434491, 0.750910636527037, 0.9513146000380174, 0.9029323227803199, 0.6669563085189502, -0.08678794240502792, 0.9590851279821291, 0.5245508152702021, 0.9432812607458696, 1.2673398119916672, 0.9725988885614012, 0.10585123410662825, 1.1322530720689707, 0.09702887274498168, 0.5638112708913413, 1.0467397129693337, 0.8902351317663808, 0.960289092542247, 1.1160463805266796, 0.9159939210701065, 0.1260009619867559, 0.8863635699709433, 0.7715690161437614, 0.9719032675256465, 1.2991424164003609, 0.9870761703038733, 0.9751280204693761, -0.004834824822703744, 0.6335599998230195},
    {0.31378500257390385, 0.07847438140944482, 1.157919444455963, 1.14884208517114, 0.6496808807897884, 0.8481084354170504, 1.1680020516524416, 0.40338101983292524, -0.27044392351523494, 0.831744228082841, 0.4245121963269976, 0.7386991805353282, 1.2330826164079638, 0.9646458328099217, -0.13260112222449044, 0.7614714316015588, 0.05549365921354394, 0.8360009803415267, 1.1675440306400906, 0.8794411629256097, 0.9711827982239555, 0.8513580680875661, 0.8049857986426673, 0.1475023983950216, 0.9742890210696717, 0.6986538221116947, 1.0691114681433336, 1.0715840557621767, 0.8612100645468559, 1.2455137210300182, 0.11828507104056853, 0.4372444075980055},
    {0.5169983024132451, -0.14153303507506168, 0.94825390962846, 1.3561976961554483, 0.6814354373233907, 0.9873398787991567, 1.1149108997939357, 0.37733185437754285, -0.04804514322915375, 1.2815163428483947, 0.6025381010287932, 1.1950740393689954, 1.2868487922155398, 1.268092309514751, 0.032756561507737876, 0.9207618596125516, 0.13138060762773193, 0.6975173228652655, 1.0355127256228138, 1.0646747097540348, 1.2251505502480138, 0.9744730615797838, 1.0761750774140577, 0.4106987626004766, 0.9440087957196984, 0.8345727619553527, 1.2879819441929423, 1.1021913532429335, 0.8770442963399305, 0.9541196523848162, -0.24298345358375756, 0.6604898233046843},
    {0.48389557810131106, -0.27379968515135644, 1.143919135606817, 0.9660717304027407, 0.8683520474807764, 1.0186421723686239, 1.1033120412777018, 0.8144498380471832, -0.22625061517738615, 1.1700385080955136, 0.3626649252649927, 1.0416884882032331, 1.2825473049009848, 1.276578841623718, 0.042530985099481174, 1.1485787677125663, 0.15083459828799742, 1.0077266909334246, 1.2034255905598197, 1.3105901213159816, 1.0296493855060196, 0.9605682964466068, 1.3165901591586437, 0.44073046460825266, 1.3380144654847683, 1.0918353936132976, 1.0036459241753148, 1.0462438697563636, 0.9159868455733728, 1.0352403787454183, -0.2038905420039258, 0.7943389604031419},
    {0.1793957070342473, 0.03379733355049595, 1.0056450552148786, 1.127408241961619, 0.6460517199401041, 1.1483045667682534, 1.0663018637216808, 0.5063824973801332, -0.17151116586200507, 1.2142264386017088, 0.4840823693611905, 1.1235287359641826, 1.3759129200242233, 1.3784311681402983, 0.0374730046689083, 1.0761077019463543, -0.17157387698989193, 0.7653482373519334, 1.1108169902554075, 1.219229516829348, 1.2947085271281547, 1.3098813493124266, 0.9040638832668316, 0.1777158643790192, 1.094631017704602, 0.8737115487224432, 1.1723256245693032, 1.0252935432199848, 1.139907329153513, 1.343431644558189, -0.036888686321644666, 0.7550076154000237},
    {0.5814273701571838, -0.16922633455086408, 1.0337509056106697, 1.0775165599730663, 0.7494522563255409, 0.8975729939959405, 0.9067789546239712, 0.595266136813196, 0.17669927759372095, 0.8404120556098728, 0.1084516171891826, 1.0413635729528505, 0.9098430455150063, 1.06339008507164, 0.047203765215085174, 1.022141861961889, 0.03399084428597435, 0.8311554949765837, 0.8517622493633445, 0.9837050783739035, 0.830077793560242, 0.9454748266239859, 1.0133435919637341, 0.37580680673505645, 0.9920414680603212, 0.9231724678955107, 1.036474455622433, 1.1767974643438877, 0.8008427492538456, 1.002607064910179, -0.0289606457550252, 0.5619442147836599},
    {0.3009908051575423, -0.008448675893891915, 0.9188423040825562, 1.2569243629101978, 0.4573399798036112, 0.911004828827898, 1.1840289048224748, 0.42724603884366535, -0.13184219537004147, 1.0331871292122061, 0.5375603068172734, 0.8119837174327124, 1.2844840976751866, 0.8587025294595378, -0.19441502069183553, 0.9975697608829401, 0.10166519899107841, 0.5167715836830081, 1.162703929823283, 1.2292314454277955, 1.2180140163633837, 1.0276529301085138, 1.230725519816332, 0.0019321495294323822, 0.9752814968005067, 0.8891348304162964, 0.9926019246679559, 1.196538980502382, 1.1310650429857074, 0.875082194834963, 0.031272666396602394, 0.6717846535454528},
    {0.5650823927792306, 0.01316629916788206, 1.2283893375481298, 1.1786377964402388, 0.5795882118863332, 1.0739569276556369, 1.140754920801637, 0.7220194798174736, 0.06727819904987137, 1.304811827684678, 0.5254005529267831, 0.8734274655450126, 1.2427839603576563, 1.1363490544456019, 0.0728208764415614, 1.1875479794046595, 0.07728010490428912, 0.7099395807245038, 0.9448778662347228, 0.9889342782070265, 0.8932456414214475, 1.2285929147356591, 1.2052435572355877, 0.53680634281659, 1.2552142479457227, 0.6855793697841465, 0.9474775372497872, 1.125045012871573, 0.7447089256687065, 1.064526059052681, -0.2396012480290804, 0.7527266192595568},
    {0.3367864372509815, -0.2767494221275766, 1.1147570981598773, 1.2674737730533125, 0.6697157691305885, 1.2148537882957338, 1.1940175984383288, 0.3122977050618966, -0.10008732984066042, 1.2999492881171666, 0.4829953942425778, 0.9243405618851299, 0.8652254495817263, 0.8433458506547048, -0.21526982649751517, 0.9003329613667788, -0.24890766035152181, 0.9454528229329142, 0.9056145522574599, 0.9623114445742443, 1.2607463557223864, 0.8709612836245773, 1.0574491713880882, 0.29160971463435614, 0.9909783457937648, 0.7282248283063704, 0.8851675317859944, 1.2335898394226783, 0.825801597769888, 1.1263513512752463, 0.12857169617707986, 0.3841656155723459},
    {0.15383895102020817, -0.012105262667226469, 1.0928037460251525, 0.8549651644230511, 0.48827840309265935, 1.0150402921697959, 1.1415547268373425, 0.41104811091717885, -0.19176303398468278, 1.1805983230334571, 0.26710649713534673, 1.1765314762826444, 0.8806732852348428, 1.0157893655845933, -0.04310517544122917, 1.163237682127908, -0.058113353916425525, 0.6532056642973584, 1.2625187064532197, 0.9237371559225243, 1.207512608359824, 1.2323433888501636, 1.202708352822652, 0.4682662903749336, 1.0326188079441827, 0.9773301686123747, 0.7936723583376047, 0.8471042357924223, 0.9643245758209658, 1.016873368400131, 0.135414540458466, 0.44808882829777696},
    {0.3794837455675021, 0.09773911414467981, 1.0835448068262212, 0.970521535597116, 0.9038448864355711, 1.194515022743002, 1.371957581437129, 0.7987948777768461, -0.3137515184579622, 0.9756869729685906, 0.21233254199389182, 1.0259411953982907, 1.2730133100126142, 1.2214950581014654, 0.0459439824649875, 1.0981155140832353, 0.04839261693647042, 0.9526033221605482, 1.3970248607687423, 1.2139626957185543, 0.9539934679210886, 1.1857665000708066, 1.2365020325498444, 0.14198744002734814, 1.1263107495839872, 1.2623392932150581, 1.0893814847906393, 1.432685291705309, 0.8795959396449102, 1.0550732634300692, 0.0815845434891754, 0.7486441691084106},
    {0.3064315109899912, -0.2692654920330267, 1.1095872668022975, 1.1841921377512947, 0.8302171442340912, 1.0047440365741385, 1.0320950203017076, 0.38418072345798643, 0.10850465474397927, 1.005163724757742, 0.22892979318807194, 1.1500312150741538, 1.2424717613863425, 1.1320062664316637, 0.0862334424517422, 0.9757934680559124, 0.16658154764090527, 0.5562045474888649, 1.2225244507405315, 0.7968038586661713, 1.1440308693562233, 1.0333234023463282, 1.1695786002586217, 0.24759021110868967, 0.9384614731450057, 0.8325319118834449, 0.993596604325512, 0.8930221838943281, 0.8558732157228245, 1.2674999127307804, -0.23414214368828595, 0.5995830068646498},
    {0.4459613296444953, 0.07982286370649148, 1.145100726006908, 1.1621518834515039, 0.4378961963575874, 0.9658389431424165, 1.1800189454456689, 0.579889248358715, -0.09375038578578268, 1.0269812945074779, 0.25417038005790743, 0.8593392029387096, 1.1295508978149402, 1.1805160643656267, 0.13216591297100982, 1.0663739770572551, 0.06991178379972939, 0.8030675036204211, 0.8712286306170818, 0.9549176541499969, 0.9434650425658468, 1.063816109961396, 1.223123205922047, 0.41614013905590413, 1.2568517104440136, 0.9632443983203903, 1.1508846018057377, 0.9756152606629819, 0.9222224641815433, 0.982728973422394, 0.19240329248557775, 0.6290084111448978},
    {0.23332914353817077, 0.14499875957090633, 1.0047841721718054, 1.0861165401272652, 0.5421954892537887, 1.099475029179391, 1.3167437295047975, 0.36521416148152475, 0.14871906903104365, 0.9172692175369417, 0.17883161790284405, 1.1868003677891545, 0.820639938288512, 0.8695247119347046, 0.13183819727635496, 0.8308347013037279, -0.039061066574031134, 0.898706924514227, 1.177473770967863, 1.2104056552608058, 1.133164642306909, 0.8599497940254943, 1.1948565574349457, 0.4766091037803177, 1.0272832674341574, 0.7795278228361511, 0.997444199014879, 1.2261194568238099, 1.0106531496516795, 1.0306823129105902, -0.25800577608912084, 0.5456199342024651},
    {0.1711960797708327, -0.1296970832878074, 1.128125080565958, 1.0346965646899187, 0.9079431989396667, 1.140220299602247, 1.1159292751847605, 0.774733314776384, -0.14550860785918443, 0.929560297463827, 0.49541024063758693, 0.903168188884309, 1.2267621978550625, 1.212652010066693, -0.021255093473958805, 0.7630891100051567, -0.20792412354706363, 0.502542027833859, 0.8937507824048273, 1.2049895960087973, 0.8764601687519255, 0.8894063599724379, 1.0001023655810057, 0.02516426528782348, 0.7626997981509317, 0.9309156283062228, 1.0699133622476833, 0.7948024692560507, 0.8554764632874771, 0.8784537172590926, -0.15986329738931038, 0.5807116770542279},
    {0.7570251027445066, -0.008225473607038129, 1.3897137268231623, 1.2114527111785682, 1.117713748430311, 1.2576657038766335, 1.059141690849466, 0.6869978653951044, -0.24020337317428608, 1.2064183139069848, 0.4376390724147441, 1.222253953937698, 1.261917974200139, 1.2926314873635423, 0.02047734987164808, 1.340970896261739, 0.09424966993519253, 0.6494924848505691, 1.3864475341650389, 1.35026154974022, 1.153848670077146, 1.06067753491295, 0.9578309446962932, 0.15043100966678183, 1.3736119587339524, 0.9970462399141504, 1.2771815412294207, 1.0063752788775113, 0.9998631311064737, 1.0453651331340568, -0.03493201308304713, 0.9810511659039659},
    {0.11279505408922728, 0.0035547762046464334, 0.9615204046954696, 1.1550832306086734, 0.4184102790266198, 1.2609352584940567, 0.8407988769842113, 0.5455462160388117, -0.1297746541888991, 1.2336455146307745, 0.2207863090251391, 1.1011230892825452, 1.205970469808072, 0.9102180597750958, -0.10775690812035653, 0.8829521624091571, -0.02118004362527307, 0.5191408152389781, 1.0492826887386704, 0.9018074356477986, 0.8451513160824944, 0.9076562127583668, 1.117664785647692, 0.10418806890131334, 1.000542651273042, 0.8252946000212996, 0.9148052410924793, 1.2564200355513293, 0.8239072353821952, 1.0767772344805209, -0.03680817377292484, 0.26427401759444435},
    {0.43599364918624184, -0.13271298539882528, 1.0544481879782075, 0.9011858208227896, 0.7341459326194171, 1.3085191349534375, 1.2419720109139607, 0.6710435269650388, -0.04079864333238226, 1.0593419545194367, 0.622713549976893, 1.0240242663837171, 0.8219752824190915, 1.1665246222471717, 0.14186621758077195, 0.9922535057711893, 0.0368876588302044, 0.5654138012420961, 0.8617753163788219, 1.2862536317913755, 1.004266450977464, 1.1569114442537214, 0.9398827130648654, 0.5144251387280608, 0.8660026367575272, 1.1702075464771833, 1.0802931131110365, 1.2968098702929034, 0.7606303769248882, 1.0408576470588595, -0.05207715078399247, 0.593051738465282},
    {0.19785600351221896, 0.03686163018002074, 1.1375285043574794, 0.9896362483060677, 0.8601157513359485, 1.2801188397165089, 1.0642843993209588, 0.822310378675183, 0.13050969128960435, 1.1861088844797567, 0.31297439360920165, 0.9290477899448515, 0.9513737062837914, 1.1544878212509813, -0.0248961112481975, 1.095037323067555, -0.15595823218503108, 0.7876057865477063, 1.2616306883230348, 1.2494441990948242, 1.051994578342827, 0.8887304011193459, 0.8459439836796736, 0.2483210454374227, 1.1843913391384717, 1.095618328251558, 1.1314148612971413, 0.9673537248618388, 0.9946728155720711, 1.06736770332187, -0.20826933733670608, 0.711584781325083},
    {0.2534942386762025, -0.018114101636548877, 1.2382563420281822, 0.9301067925430748, 1.0292590179935133, 1.39499694581815, 1.21483597294764, 0.7038944652977531, 0.11889179820538903, 0.9889401644248503, 0.5969094852341214, 1.225527915851835, 0.9979778166813393, 1.2139187729926884, -0.15423910268350827, 1.1585792274309012, -0.0026535900676450015, 0.6016191530699238, 1.3565027623368202, 1.3275696665310122, 1.1316556011744665, 1.37502765291739, 1.163428226941482, 0.5064181521303084, 1.2306962676900344, 0.8279544533251196, 1.3225051653798863, 1.176645076452411, 0.8919845499926267, 0.970006041577408, -0.01261465292186937, 0.7435452052919747},
    {0.2131486745602299, 0.014821527094359329, 0.8917856310731272, 1.270106159803014, 0.8752585476250062, 1.2845558555018144, 0.9243652928938038, 0.6529696304888897, -0.27034890065975015, 1.2347029502935496, 0.4325183355018347, 1.2105090593535108, 0.9822926890566588, 1.0829995430769956, -0.15012472281602818, 1.1655277411184253, -0.24584877704196728, 0.9081470664047785, 0.9656868592000044, 1.0208216815542404, 0.9874036351659641, 1.1103782369090478, 0.9881792779274683, 0.08440623333034573, 1.2280004806702698, 0.9918507786877045, 1.238834559450919, 1.002606313728238, 0.9635920419043612, 0.9328799163199899, -0.17937591221690297, 0.5987037924361768},
    {0.3399476301959028, 0.11849898374986692, 1.2191914211963917, 0.7556802137397486, 0.5554255610098895, 0.9979162552211313, 0.8442775315941218, 0.3155901905196884, -0.1275825839215608, 0.9845543702291054, 0.10464958936738399, 0.8192371569689986, 1.0368798965915307, 1.154419388196371, 0.007997995427912017, 1.008319367436629, 0.1382967197825323, 0.5275997404320326, 0.8661722717606004, 0.7511269373639406, 0.8383378400944784, 1.1034694535799, 0.9552220834619369, 0.3311188742781169, 1.210267830470585, 0.7780503483271937, 0.7856681874336472, 1.0191565517326922, 0.6582561473421994, 0.9281708912340844, -0.27630578715418436, 0.4383736907266697},
    {0.4533852436320382, 0.1008685965517016, 1.090627415310469, 1.17048698395217, 0.482556906499231, 1.1071956825440135, 1.132989456536478, 0.42719297085213653, -0.12853372032498908, 1.2970633404421439, 0.423312639910234, 0.9132077770275099, 0.9763643397763452, 0.9782059024510524, -0.09308332307645491, 0.8960779033844951, -0.053879134120472044, 0.5693733493492555, 0.942968060973142, 1.1747442475918524, 0.9948348237973058, 1.2968035594440606, 1.0152257283494355, 0.42767818167399013, 0.8607881255428999, 0.7594185600609358, 1.1653947831899594, 0.904742264442407, 0.9607468649496179, 0.9381474755159556, -0.2849050148243243, 0.36538853865035686},
    {0.24266886012169764, 0.08163069131908963, 0.9399406510450852, 0.9041825047812276, 0.9362105001590355, 1.1824154480127869, 0.9163660235184395, 0.8689459919190851, -0.20416950809366305, 0.9327720192409034, 0.2635831477843308, 1.2801770849623155, 1.3196763593879781, 1.1628374524244314, -0.1843454956885152, 0.8805589803457955, -0.039910185019971685, 0.8222433830286456, 1.3648151452335708, 0.913451130697891, 1.2431924557412857, 1.3712858768148917, 1.204097388856225, 0.37750648310640883, 1.3271293524687744, 1.1147573197036005, 1.0390078322376202, 1.3335501927418998, 1.1698631617032071, 1.3723460218965102, 0.16665065770014056, 0.7198800009665417},
    {0.17453884559151964, 0.10846368221490801, 0.8068094270061605, 1.0770233528547197, 0.43211120447358664, 0.9925022896593261, 0.8602195984590699, 0.4897241444677254, -0.05774117566038991, 1.1988831908933348, 0.22333245535540122, 0.9916904358183859, 1.195418800061434, 1.0127404907314492, -0.14524095709548354, 1.0240358640794152, -0.11835774009968279, 0.8927012712369243, 0.8135823440413004, 1.0943987004068834, 1.1892965183067217, 0.9930299273949245, 0.8319882764811297, 0.37683667637569634, 0.8749977056487999, 0.7196073634066456, 0.7975335533178031, 0.8965459880687093, 0.7138637591311723, 1.274840656056556, 0.01947657833054942, 0.41239443784455493},
    {0.4498454039715438, -0.2369526070219811, 1.207576684839854, 1.1288843458649713, 0.7435478920750017, 1.1027981604822739, 1.0313181958486823, 0.629657319689985, -0.2783173707825238, 0.9553273595423843, 0.5297921921242222, 1.1163266388177466, 1.1396706269857175, 0.9791409112678439, -0.10441481467855906, 1.0794310854475588, -0.07153338461331843, 0.8377741378196417, 1.22968740829437, 0.92259240955209, 1.020756251084578, 1.0944471006770655, 1.0101598952979773, 0.43880115109097284, 1.0953727791278824, 1.1332724564052477, 0.9655843840016565, 1.2702835149804796, 0.6759572470122505, 1.0636848711688494, 0.16007967728406222, 0.7126389437111489},
    {0.26838049387077123, 0.14626236994206898, 1.1809386145008687, 0.9389518446381816, 0.574252370207402, 0.9143620224181027, 1.314122141861209, 0.5139006032749293, -0.27085651701728625, 0.9294688738504489, 0.3846432161114955, 0.7606966444655682, 1.0057486860483935, 1.0694376942895552, 0.01817795249278647, 0.8007328876465337, -0.27387836512853203, 0.9392047831577331, 1.0406141566362013, 1.2663823189342638, 0.8860081276646559, 1.1184909055253576, 1.0989654549444854, 0.049716538536113956, 1.0054822328119741, 1.0563278288907498, 1.2411088347481598, 1.063859557777836, 0.8310382706693922, 1.2540153545800645, -0.17745432490977997, 0.7711530701855027},
    {0.41570133961536593, -0.07535110507134556, 1.312301974559844, 1.0782113707063097, 0.6852842395850494, 0.959795225952489, 1.3219172377361126, 0.5473406868428955, -0.021660207056900287, 1.0149453097060905, 0.4894867179648405, 1.1189332394966551, 1.3020236857138245, 1.3623313542303446, -0.23253267930305085, 0.8224739519630213, -0.15742161079910713, 0.6015580592904661, 0.989655942199666, 0.9075849613970022, 1.20749989445347, 1.1051815578591349, 0.9648996281938568, 0.3100473850389965, 1.3249020361682418, 0.9712815833286533, 1.0881090968032467, 0.9386568431372896, 0.776706965057395, 1.199071531844401, 0.10683988443512489, 0.702568578305376},
    {0.2729809771424674, -0.1476949902900867, 1.0429242648073196, 0.8665269579237914, 0.7339249591200925, 0.9897453084727589, 1.0121581028648563, 0.4988486067438674, 0.11544622886339012, 1.1569231474857502, 0.3157513602152341, 0.752737052902456, 1.2045414450910628, 1.0783815794244074, -0.185563016471906, 0.8326808368565853, -0.09112895503892969, 0.9098506931652561, 0.8678339151735756, 0.9303163147958035, 1.0983650714276327, 0.9321751566788862, 1.1585885293845837, 0.13904696340651557, 1.1347760699003855, 1.0105482146767761, 1.1707489991594338, 1.1638180447115254, 0.7591257965449678, 0.9331284668517363, 0.06497269842025419, 0.6063598538601626},
    {0.19385500565671365, -0.1546752505223806, 1.3126311534179382, 0.9865753248148124, 0.44534077395451727, 1.3191218234875113, 0.8667511027092814, 0.7641827464601013, -0.13489173888081912, 1.2321070914681347, 0.3244839232799231, 0.9481703202086398, 1.0602523709646479, 1.0497229018297338, -0.15132514402192979, 0.833284907359428, 0.0028218266898586055, 0.7858987987960034, 0.921513586604052, 0.8833877211135226, 1.0893596739960814, 1.089728329207569, 1.2216073444114144, 0.06966128797861358, 1.0344419556913604, 0.9576266356112713, 1.1392636995505399, 0.8971757974083175, 1.1208443766226368, 1.3048221977075927, -0.21430613988726144, 0.6430011666020263},
    {0.1548694047977134, -0.3067684385210142, 0.8643091054631024, 1.2395984624757745, 0.5762818096531109, 1.250192188549224, 0.8933343422224727, 0.48411680471813706, -0.23123946196545533, 1.0451420177711686, 0.5048204422587964, 0.9886015544433849, 1.260063471588863, 1.2009901520848825, 0.11919026573987286, 0.7508712610701084, -0.056783945988680695, 0.4776914100736478, 0.9255538698253136, 1.2003412798744575, 1.261417056440339, 1.2892202445422287, 1.2642343163114298, 0.12389873973014906, 0.8820795381948421, 0.9405677773508448, 1.0299436099699655, 1.1301758218156976, 0.7461410374930256, 0.9350586221007446, 0.03933501023267025, 0.6904191178623615},
    {0.4819930557751191, 0.08224099865239792, 0.862717269952287, 1.0926874818896775, 0.9677768023368954, 1.2733911495054158, 1.2336758046006076, 0.7443039946710264, -0.030882992810778043, 0.9704069547010569, 0.2090628226776122, 1.2103448464829218, 0.9392437512846717, 0.9437659746920466, -0.10278935467556226, 1.1799841786435596, -0.2370173302428352, 0.8548147967628912, 1.1951811799266545, 1.1957972700926445, 1.17003013365172, 1.1565334060951746, 1.0608388301687455, 0.3812638982769423, 1.1187595474850989, 0.8684819176427618, 1.047292197986898, 0.8839758353924637, 0.6890082302684079, 1.092801367925038, -0.20956981782581394, 0.4633399223828788},
    {0.5100806791429573, -0.038029735070782944, 1.056159479269619, 1.2996180046705543, 0.7664712463234776, 1.152711600660767, 1.1000483574979951, 0.7743986211703702, -0.22850518951385854, 1.0005615919659214, 0.5602883849619701, 0.9307501432371135, 1.2759352807011408, 1.2271188646809803, 0.047740828113180235, 1.1211160472296293, -0.13241428245922937, 0.7610904317888701, 0.9457409615863924, 0.8879243042175781, 1.2419356980684209, 1.0253148026116723, 0.866783511275234, 0.2854913780216919, 1.0601166617650422, 1.1615012634995185, 1.0270073553014132, 1.2786679199048492, 0.8372982053180738, 0.8186256257444856, 0.07858891547809264, 0.7404461133671026},
    {0.34419798374770255, -0.27006332465990507, 1.1597561170724047, 1.3296277773556686, 0.9902707503502957, 1.4109125976620405, 1.388742878724044, 0.6212002566317211, -0.17025940829738595, 0.9555529162107618, 0.6762184135190961, 0.9409592029816961, 1.2432712940486685, 1.0742423635864877, -0.0035707140172845705, 1.3311244915863671, -0.23047463223164272, 0.818425362254675, 1.3167616220763014, 1.3138344620830502, 1.101910274460997, 1.0213938994299632, 0.971323722809881, 0.1316957199266341, 1.1466202316640304, 1.2473632681008726, 1.1829794831245093, 1.3262658030672405, 0.7651129412299499, 1.2219934792606322, 0.09181561283045299, 0.7094353786201273},
    {0.44146522097146024, -0.029937138729660945, 1.2472628411269493, 0.9719802433043131, 0.8970358066830459, 0.8607358018535943, 1.0114138286903345, 0.4649905987259485, -0.25312047264545934, 0.9696760411438756, 0.30122000079287886, 1.097652192702906, 0.8692400895257815, 1.1243949441148784, 0.007781135607627963, 0.9089061461715341, -0.22533028749239506, 0.9118016334330731, 1.0290027635229755, 0.9248303891465663, 1.0253446610732289, 0.8511309214014315, 0.9053148945257588, 0.4579931240687478, 1.0765191521894444, 0.96195556808172, 1.119741261899821, 1.1649095361784039, 0.9249551621306491, 0.9556200892053968, 0.03939001182369905, 0.4357198691763901},
    {0.5207618004672018, -0.03977090454689049, 1.074660314983797, 1.0637773148153904, 0.8635266446779141, 1.2640062446700018, 1.112891626874369, 0.5653847257296549, -0.2817209112005696, 1.315059925158749, 0.49854046718543965, 0.9731055975761977, 1.36663489207916, 1.2379850829921275, -0.11151582467669378, 1.2103140787579387, 0.07901731004348231, 0.9317791401800647, 1.1299833670307369, 0.9503903114727839, 1.1024780285176774, 1.3307707089445306, 0.9252028903780019, 0.5068366961544201, 1.0909245553229572, 1.0417075209697193, 1.1413508178660698, 1.3397943388191174, 1.0623006159463237, 1.108118763259675, -0.11939339985085583, 0.558348583077163},
    {0.3868519752542082, -0.08470692286133238, 1.2215449298311725, 0.933735200181832, 0.6321602099734781, 1.1817067467794642, 1.4002806342377208, 0.852719041719279, 0.16212600761739443, 1.2242444833456843, 0.6356484970538957, 1.2178626449981083, 1.3014969395777711, 1.331363779511126, -0.0930918527520552, 1.2190400652780942, -0.02678759263517305, 0.6347774683879189, 1.261116234887603, 1.2433547588692637, 1.0393241686167631, 1.323125173772288, 1.1034159512652555, 0.44777590747116314, 1.3827284842318708, 1.0164454567647467, 1.1281123985339447, 1.226700327820388, 0.7695100074705363, 1.1094122166755642, -0.2999130342616767, 0.4893135898403814},
    {0.3483545070300066, 0.096102294454913, 1.0057515109564723, 0.8434615227665193, 0.6633910306627415, 1.2463106838265885, 1.1038103779454023, 0.4644753623033154, -0.13060546969156805, 1.224331392176179, 0.4514403511062776, 1.230140992903216, 0.9581347464482746, 1.2676415664023697, 0.041066580641605586, 1.0687486371323671, -0.13706289688719403, 0.9769854303692872, 0.9533907386617916, 1.067241472626353, 0.9561389974379473, 0.9436974475384354, 1.2594622139529243, 0.4544053975218722, 0.8878681129522343, 0.7874962924982956, 1.0006077065642018, 1.0228102006928452, 0.9631574750499514, 1.1211504830462808, -0.21702247886067222, 0.3973119347638239},
    {0.33767189723046637, -0.08423801736086879, 1.1431653251883376, 0.943905608963764, 0.9538935757174666, 1.1591753508128788, 1.098954318520794, 0.4021771999508998, -0.060602347623298, 0.9802011867797356, 0.5053226118045593, 0.9595774159466365, 0.9563013114069849, 1.2867384881550332, -0.19692066778681935, 1.1036927384239905, 0.026177262262914204, 0.8687620171683077, 1.13750863759472, 0.8337549507027947, 1.1498275988603979, 0.8487699950362311, 0.9970764303663991, 0.07732963979503311, 1.1784110414471467, 0.8319660639019063, 0.8495879002858864, 0.9479810326087617, 0.7313767758959894, 1.3185860867590427, -0.2345115702013588, 0.6305627455136137},
    {0.5338175955872122, 0.05205133114744459, 1.1535329885448657, 1.195464429997352, 0.700337566508861, 1.1092795137447558, 0.944777962564109, 0.7692953275944714, 0.11244298583217346, 0.912112133581786, 0.24874676567149084, 1.1670132104897843, 0.9448530141381675, 0.9762069859805451, 0.12757155919844698, 1.0003342880219857, 0.13489278172197025, 0.7690934678521942, 0.9305042250819389, 1.2081033201427005, 1.1226476041337232, 1.210558915340245, 0.8501691873051594, 0.321766144590095, 1.106002137048284, 1.0046343387170045, 0.8281238676931575, 0.9511593211486485, 0.660932148179427, 1.0703242394285934, 0.1450644894741486, 0.40935439082053954},
    {0.39926116321669064, -0.20064169346240712, 1.0607483355834715, 1.2096584618730688, 0.7873696620072199, 1.0425453988508175, 1.3173610407813265, 0.6261861680018964, -0.18796134863804165, 1.2197762636507, 0.279727765244854, 0.87248742778329, 0.9900526763883286, 1.1479085095404489, 0.011322571226485651, 0.9346684587529851, 0.08031848315614232, 0.8800962852652794, 1.1906489430662834, 0.7837661630870175, 0.9285502431853441, 0.8132296112437445, 0.8029602264316125, 0.14949325044245965, 0.8174962551141447, 0.9329634995987, 1.2152298629869878, 1.2084440168154287, 0.6338132550630042, 0.8355630190449913, 0.05138167279218214, 0.33945525932294823},
    {0.5675255902330996, -0.16567154530942507, 0.9085471525235733, 1.2470914461066802, 0.8406708382100796, 1.088461587109854, 1.2077813009123888, 0.8582417956139574, -0.1079263098216338, 1.3248938071781544, 0.4924152018300838, 0.956631855611586, 0.8776016736795547, 0.9686081463983257, -0.1124111495095248, 1.191979278573759, -0.21777650669034881, 0.7122986577717809, 1.2492280135379112, 1.0154518056680522, 1.101503983757253, 1.2135219529708012, 0.9095497022740515, 0.15666160886082683, 1.3210974317681659, 0.8497094553850699, 1.0211493229282376, 1.0167206572392997, 1.1021049793939777, 1.00400595511966, 0.005644477017848617, 0.7486329490938737},
    {0.3764318563893027, -0.2523926622783101, 1.1974093781554, 0.9189876188398332, 0.6103242014198327, 1.191498737246961, 1.0711554531194318, 0.7489846168645092, -0.12994908237803404, 1.1492965359634377, 0.5240720375843256, 0.7588009769189118, 1.1196735524496102, 0.7759934900181266, -0.057224032026189454, 0.8568093030103627, 0.0691044391071395, 0.720063443488658, 1.04101122887148, 1.221722975108223, 0.9776291055600319, 0.8411745690384976, 0.8512824379136804, 0.22331669785936986, 0.852891876847379, 1.009609239775597, 0.8129194235549722, 1.1511615377530597, 0.7746495624894543, 0.8748820610551905, 0.06237748805677422, 0.35858826908074726},
    {0.43283048199122115, 0.09557495698737495, 1.0536960786343454, 1.0238389141971402, 0.4772474844597347, 1.0579823003758226, 1.2405905847664587, 0.7395134444929662, -0.15067654488923174, 1.3187812505069572, 0.2261646314603781, 0.8878149782370244, 1.2190128964967821, 1.0637682456610187, -0.2349616765688335, 0.9556023354366681, -0.10101155478012061, 0.9619355327576211, 1.097712649990189, 0.8557583106431502, 1.147760989674116, 1.1905387240756171, 1.1566964896807037, 0.14610054498688577, 0.9860417180637248, 0.7927123420358331, 1.287547856966814, 0.8670550981292032, 1.1279831768482438, 0.9400900378850942, -0.0001651438248936873, 0.5956684999936693},
    {0.27363775439584653, 0.16817379714988623, 1.285121442204179, 1.0063402146472689, 0.7151435855610706, 1.1946095058889616, 1.170712443679005, 0.549326260502211, 0.1823797734476609, 0.9207513241209343, 0.4845062525670482, 0.9909958380923644, 0.8318668255922662, 1.1260365065964053, -0.16368972864114398, 1.1715704690345246, 0.07920831733226315, 0.5678120901982733, 1.0718189079322042, 1.2752688825947824, 1.189783604705289, 0.9462681063116812, 1.0555778783235992, 0.33641235504963796, 0.8312466765796572, 0.7371913184077646, 1.0751885407622748, 0.8990865659129695, 0.7704774120430272, 0.9935713839201318, 0.18114424601811824, 0.4622506166609041},
    {0.4200308236664976, -0.1878925385546762, 1.2095480898117066, 0.7970501399245504, 0.6966860746152138, 1.073913896552303, 1.182440423839316, 0.5289202655280948, -0.15870183978473582, 1.1361337535033793, 0.40240477907291744, 1.0805192594764188, 0.8259953798679158, 1.1994978865701094, 0.15324427773424817, 0.7263850748447438, -0.2972410702301721, 0.9152792628118107, 0.9860895966228732, 0.8731202333808351, 0.8082764676326393, 1.262617201983358, 0.859694763334697, 0.23151156740954473, 0.9090164788882567, 0.9199759083771974, 0.8176707761928586, 1.23064914851069, 1.001067378765538, 0.9208391055870168, -0.1856544932046064, 0.47152151416602217},
    {0.20783630663677458, -0.11990562716334115, 1.1383828950816532, 1.0248060975980315, 0.8816004959716129, 1.293594779685227, 1.209250391115088, 0.8518976867115661, 0.15883267068218246, 0.914069521894652, 0.5032081471047332, 0.8883688326998717, 1.0258475969406446, 1.2432648106710074, -0.10936954601367738, 0.8584158795225001, -0.03462745949250541, 0.5700470276631555, 1.00193207106657, 1.2674851892213892, 1.1673195366217384, 0.8269280778517177, 1.1204545989841967, 0.2684116512005057, 1.158821525727179, 0.8319396215614165, 0.9800745307894265, 0.8327096920841047, 0.9028450955342014, 1.012208571230974, 0.011973175414087224, 0.443579794166682},
    {0.2103051758273395, -0.09233499305866508, 1.2637173870790406, 1.2366955203875294, 0.5966268804038241, 1.0616647980984346, 1.0573962712465148, 0.6302456311965922, 0.12732255156117472, 0.8853948707184042, 0.48811629650280786, 1.143135536928135, 1.082480718635925, 1.2685152990729447, 0.020503089095351326, 1.0248518599768248, 0.08335130554572466, 0.586361780068794, 1.2507949565069865, 0.9075563681202046, 1.220099165792202, 1.02675124389683, 1.225355823394498, 0.3604395722712038, 1.2091733853759048, 0.8159965388585779, 0.9087963502397495, 1.060841716196776, 1.0665160374690974, 0.936721266273098, -0.2649001302328349, 0.3751311865807106},
    {0.5168801645392533, -0.11949310733982443, 0.8243532310321223, 0.8185038796034525, 0.7395381646823104, 0.959185810961144, 1.176199464697925, 0.29152729086521106, -0.2695553014079677, 0.9485816303124844, 0.15182841652708975, 1.1465675013790193, 1.2036328004780523, 1.000009830947758, -0.054281961127805575, 0.8151206170963848, 0.1259739187078116, 0.870845004675559, 1.076646822446846, 0.908172511591895, 1.203722689517299, 1.1568297498302995, 1.24173656231838, 0.5017517141397612, 0.8184608070231391, 0.9762432976149439, 0.9076655024311729, 1.1143916983132105, 0.686103822534929, 1.2049060332625843, -0.2365561928857241, 0.2626060172309545},
    {0.3933950841079182, 0.02427796983441026, 1.2903333605138982, 1.2944837009922414, 0.6837985300136035, 1.2565098263626524, 1.078366732542441, 0.746260069647904, -0.16867499569588315, 1.1700847645440149, 0.08135110388710697, 0.912042887552489, 0.8175131763329763, 1.0953446986905933, 0.06932517203770334, 1.047363841159207, -0.13858274789166714, 0.6742891529773798, 0.9719627485177623, 0.8618915224041567, 1.1337974329879232, 1.2652658583801728, 1.2087764671150354, 0.11622655686867342, 0.9611468003876321, 0.9672618237163714, 1.1202750609369287, 1.2932889394817815, 1.0496236531939895, 0.9557274526075474, -0.0394025574116303, 0.6718472640094842},
    {0.2779856472570653, -0.21531461236805768, 1.1626018004198289, 0.9278677251596075, 0.7365292410567938, 1.2698961394801562, 0.9507021065072571, 0.6951433195520758, 0.14128977365297893, 1.2602802285458454, 0.22162076263770547, 0.8382425864233095, 0.8864307139617112, 0.8746522041521025, -0.23612071214107658, 1.1399660231823474, 0.0027504377119189943, 0.973716698656514, 1.1366294520702682, 0.9313648665040897, 1.1479972285333042, 1.1380668616864458, 1.02865260590101, 0.23197833799402737, 1.0884063062611724, 0.9671728419451967, 0.905434693805698, 1.2367681230235217, 0.8994724286246681, 1.0907379525299565, -0.025220737953850256, 0.7695795080007449},
    {0.5077939115013357, 0.020632022703093025, 1.063754566997885, 1.2143666217948623, 0.9788885749989781, 1.4105808709355514, 0.9723542349685879, 0.7880624415049368, 0.0163933697626783, 1.0603789054316108, 0.3156337931948707, 1.2155073245300982, 1.0867363059682646, 1.0207612944101045, -0.20478116981439798, 1.0255827634987107, 0.14827107413922933, 0.9556365744337912, 1.174337251221909, 1.2618422769947533, 0.9767422718529052, 1.3405625467833815, 1.051519525268221, 0.11721896438926499, 1.1936572215924697, 1.0212207864049072, 1.2550923475163644, 1.4104897997331998, 1.1653394057532667, 1.285711102626547, -0.2631043061528087, 0.47138729522663847},
    {0.41773660655671707, -0.1806455986087508, 1.2009933738296046, 0.9477662186854627, 0.8403014704067078, 1.029117499788293, 0.9512474088354239, 0.3471222119478511, 0.03182298434925584, 1.0813768813160918, 0.37157029925911195, 1.0817899861497304, 1.103623439747739, 1.3124173510224797, 0.16021916779569173, 1.0949742386738248, 0.09190996876693262, 0.9875033170485089, 1.1242147214374214, 1.1412030140094722, 0.891409781902974, 1.0715612012055222, 1.3061808698110908, 0.5344910864411865, 1.3201911960263168, 0.9307471007726517, 0.8893557323278023, 1.2904460934551283, 0.9782497689349083, 1.2117326144946636, 0.0166040295318564, 0.36308668057628035},
    {0.36641720842983966, -0.19305773025188858, 0.9159990856346294, 1.0238656897281009, 0.4441764076635582, 1.0814273810123507, 0.9679402247408543, 0.308020592930107, 0.13084389581358769, 1.1200997514472844, 0.22103341902056972, 1.0635553071468116, 1.0550093406045704, 0.929508000579014, -0.1948770265201423, 0.8026294526958095, 0.06222747073486284, 0.7494725846245162, 1.116878507110426, 0.9148661265893987, 1.1947769001490978, 0.8886975951972752, 1.166141520402702, 0.22779103555365265, 1.1046908955381398, 1.022402191591032, 1.0468932829813666, 0.894231688462386, 0.632513234827548, 0.7902802106103046, -0.023697974018079514, 0.4705466800187503},
    {0.5483022808710756, -0.120163677118308, 1.1125012146400475, 1.3202445121678128, 0.532214445194507, 0.9092193623291442, 1.0303751142305915, 0.7781332439997514, -0.2721614522866688, 1.0701735685253049, 0.26875098263876734, 0.9076809204822355, 0.9147418420469349, 1.021333277518939, -0.0961258887975815, 0.977757181515996, 0.08931167083059506, 0.9348561207698489, 1.2733918611562878, 0.9676225384452686, 1.2729166987751648, 0.9917505312694203, 0.81214969048876, 0.08225290453269342, 0.8339394442969176, 0.8429904696352776, 0.9391438178762549, 1.0559330158300348, 1.1273450714488336, 0.887681028884722, 0.13185732235288247, 0.5157492206963922},
    {0.33225566999288403, 0.10288218620668996, 1.3326906818328785, 0.8428504476020774, 0.7733443785571803, 1.1059047796277897, 1.1516667863673036, 0.7600967169739129, 0.07290122818163182, 0.9374359279018782, 0.4214725878294094, 1.0243859028122253, 0.9670499746392737, 1.2762645530435128, 0.07632396461228597, 0.9242725898061022, -0.10243703791520384, 1.0296739211972896, 1.2284162254440534, 1.0573261524355462, 1.0745524666452286, 1.1045853777730825, 1.1065111736301438, 0.24284769999174977, 1.1217653529059068, 1.1221350319258658, 1.065749459119894, 0.8672002826257342, 0.9711694132858449, 1.060832110632003, 0.12929893761635977, 0.8035422328775527},
    {0.11217591037486765, 0.0815418666965657, 1.1029119224124662, 1.0445927043123024, 0.6532965268811637, 1.174889138017098, 1.1915133884703195, 0.3097419224997486, -0.20598081768184914, 1.1493961697695199, 0.09081117734135988, 0.8696844742616339, 1.1864323496610905, 0.8693561393588003, -0.2785878378902939, 0.7435768042156117, 0.18624472283586122, 0.9226669848315453, 0.9327371040101792, 0.807853666817368, 0.92739820273082, 1.002450815390523, 1.0813352917529655, 0.377146129763749, 0.8609939749938017, 0.8712560517236625, 1.2252557083693612, 1.2792287057121072, 0.9644978036461607, 1.2539293970759513, -0.21810795289410856, 0.5258662828402499},
    {0.44641630128594045, -0.28464182285010997, 0.944973515583508, 0.9491720282113754, 0.6116977562544786, 1.3184692507037374, 1.2011498245419063, 0.46567800074684434, 0.023851161836562305, 1.0898930276966852, 0.5184542323267547, 1.1281323671539678, 0.9166005438135537, 0.8853103900153353, 0.07689327268386992, 0.8909584069576155, -0.23198115982292247, 0.5748332006026065, 1.2242327248605736, 1.1865193705646027, 1.3148672190419926, 1.2868649425199818, 1.1993434488637553, 0.3026983041898553, 1.21326425776525, 0.7483010377998048, 1.1093559664493151, 0.9748605507655999, 0.8458962565590367, 1.0818243527392437, -0.1612804553132083, 0.4353817555114639}
};

static const float b2[32] = {0.4941559585491463, -0.08792968629010117, 1.0299816478646175, 1.0076208623645706, 0.7964571340303175, 1.0764058512356833, 1.0988408046948133, 0.6428110908151554, -0.07013433037625343, 1.0429452766518388, 0.39295792037591565, 1.0328436913538772, 1.016136019865623, 1.047646624833105, -0.09988999488282876, 1.0468086130509344, -0.056892735561106154, 0.7629063248958728, 1.0490176589541107, 0.9990448461635187, 1.0328328152568498, 1.046472688843352, 1.0182326656224545, 0.29739205577382, 1.0485937859428465, 0.9573748788243251, 1.0248719760370837, 1.0811580949082475, 0.9222322898382387, 1.0868730306346148, -0.04693850029198283, 0.6339761755276356};

static const float w3[32][16] = {
    {0.020010087231558542, 0.8724298536392359, 0.08974797546152308, 0.28606241542335925, 0.3328314414459529, 0.24086861114206695, 0.054221268731882356, 0.07575758797360801, 0.2078525822175771, -0.15577888762275782, 0.37905935992453277, 0.3959967367310458, -0.20024484854845603, 0.5487844483485561, -0.010725380067706139, 0.7128382097258494},
    {-0.29004337849697526, 0.030752434336451744, -0.33166491032078477, 0.05438924272915698, 0.30203753100814207, -0.23462443455073426, 0.09876979502816516, 0.25359657471820196, -0.011983049829129214, -0.07821729940043569, 0.17667183982948473, -0.10998860646974802, -0.28563740862649684, -0.25664861166754144, 0.2975359156469588, -0.2965600736148273},
    {0.012553739778170616, 0.8818990320984139, -0.36211562159823807, -0.306031932065022, -0.20605745850740118, 0.2931101310789256, 0.08719131798219072, -0.3487021847491078, 0.1182398584503283, 0.23262486086052364, 1.0004030110367679, 0.9939482967893524, 0.14316370261793407, 1.4484724702586342, 0.16124639316648548, 1.1383240331587423},
    {0.10420318035656957, 1.41021807664857, 0.0989119173210564, 0.22417102726718194, -0.2228889470685655, 0.13483007227899263, -0.05367401060779189, -0.23864979136190953, -0.016487939038129087, -0.3863868725972299, 1.4111304487383232, 0.9033084456775986, -0.025642276428569737, 1.4806991188717311, -0.26103717487830497, 1.2571589153045266},
    {-0.2631066411336974, 1.1086755325178552, 0.07477318034776877, -0.04575443427042391, -0.3098234866768453, -0.3536769870595654, -0.14916774723617243, 0.11757696157037718, -0.2833964561482186, 0.1311332284845771, 1.0874107911105781, 1.1647327429581968, 0.07412042754755843, 0.6564092282054856, -0.002844863074687985, 0.6822979228736792},
    {-0.04435922372456175, 1.4476362821746134, 0.10746644751003145, 0.10060786145912588, -0.22839657254698892, -0.2370892280112409, 0.13754753262346928, -0.2381983092775007, 0.21951991975658924, -0.13203284746748978, 1.0657762601906728, 0.7378744474810304, -0.19716377848619204, 1.1958084135815643, -0.31699397719641775, 0.9571749184540163},
    {0.08579142443449941, 1.3456813648629788, 0.17433627277851774, -0.22042828295441996, -0.10528568931024676, 0.011975162421314706, 0.0184793571884881, 0.13018357983194936, 0.06454286816948468, -0.15747976010253284, 0.8591614608151665, 0.9186690496818242, -0.27371243193986994, 1.1965040509139555, -0.3535622442553652, 1.1119126355452056},
    {0.23026647483903123, 1.0568770603396644, 0.006519338710471339, -0.09697017036995975, -0.05568107811825473, -0.05742564701296685, 0.05645672338326571, -0.006359238371694981, -0.07437397506830287, -0.32179566564630285, 1.1723250257697744, 0.9683423121183697, 0.29034012617638005, 0.5084682686492632, -0.2542025938142468, 0.550107068326855},
    {-0.05267609133325172, -0.035718539453383095, -0.19588096587985823, 0.268165636856594, 0.1450740254609119, 0.17521738884287708, -0.12075835051495735, 0.027073301469890104, -0.08896143302867698, 0.058434293867538095, -0.13099005638873426, -0.22445061742630287, -0.2930502095941205, -0.2187046767266307, -0.23678080751088929, 0.035362770861380774},
    {-0.06222942129420096, 1.4156526911522522, -0.28505542371728365, -0.3291343825442554, -0.34063381644258744, 0.2873394422427127, -0.22350462810218724, 0.05405373271293142, -0.1736462960689317, 0.2555301349688427, 1.3594929350503469, 0.4841815894741519, -0.006240653667778949, 1.493958645590449, 0.09486363877951688, 0.9714504840584026},
    {-0.28847054285657087, 0.38673556285325356, -0.3320304999291513, -0.010935216683479503, -0.29462324677953394, -0.2922329224013632, 0.16957968467431864, 0.1594114823155803, 0.18608515556459326, 0.2813278765141838, 0.6788373664983661, 0.8042887368911664, 0.28933488892488485, 0.3379494330537955, -0.34154916195289475, 0.652461514088887},
    {-0.14590830574744998, 1.324003817849985, 0.23009815454205762, -0.2938165737281577, -0.13675698355798072, -0.2666565854143535, 0.0681680889706008, 0.21929652927635218, 0.26629288071612733, 0.3033182040677309, 1.391220661440169, 0.6963223435296744, 0.11347330692716329, 1.0950671420413256, 0.31462786628863193, 1.1254646774399804},
    {-0.370573101596926, 1.4167706246510616, -0.155712292610607, -0.33226320956851896, -0.2109591511313658, -0.31944352076214005, -0.318634427117727, -0.2833667074814184, -0.23713149891106, -0.37566088695694366, 0.8720003920958257, 0.5777645787921408, -0.03779153047461857, 1.374459687453839, -0.08771507148212258, 1.2710481180901845},
    {0.178232041934979, 1.4316558783040407, 0.17306038524122638, 0.31549699698026307, -0.12486628440404308, -0.05591365113115971, 0.1160046092493541, -0.18094485543841002, 0.005597718545733803, -0.27635791019663136, 1.0211362109531879, 1.064983686765585, 0.3098846725106832, 1.1303993770489005, 0.1116723582139459, 1.2595752107467493},
    {-0.3656677835164426, -0.12489452083859166, 0.2098061796371654, -0.05276760520887618, -0.320116376598616, 0.03507493024690399, -0.17429378953233748, 0.25703230645883957, 0.04654037081589825, 0.02239580673724228, 0.01808621750066253, -0.11268399108562076, -0.36054021742359366, -0.14184388774027687, -0.03570125458358496, -0.16066517384131457},
    {0.025201646643988614, 1.3308708483513478, 0.22191714401576496, 0.16059415699353288, -0.15609590743010118, -0.056186674839551455, -0.23386784436417782, -0.15481537768851375, 0.3255585950804809, -0.11763250304499531, 1.2150258768445252, 1.0325789120788722, 0.01878545152983883, 1.0490867648370024, -0.31515135087837426, 1.456417381370452},
    {0.25387166386643134, 0.2950196302478853, -0.12969205405053028, -0.1641668317424087, 0.2450570266119114, -0.21313393660606822, -0.1361582999371531, 0.2680543660890819, 0.19250244941481215, 0.20285687079474113, 0.03492058995153482, 0.16610917253758833, 0.035817430125216945, -0.20933738408062835, 0.33044752357218155, -0.06104912119342169},
    {-0.3141744067608647, 0.7322934362439214, -0.347897354353568, 0.32698861685072234, 0.2303151175516472, -0.11661069830773524, -0.04790238500665051, -0.2814862625055002, -0.17631956592202722, -0.026517314469664505, 1.128659296479586, 0.8248389059534932, -0.011263287760172465, 0.9703308968054867, 0.17951940065177044, 0.6627485470100678},
    {-0.04133973235692093, 1.3543605419971947, 0.23696699143963473, -0.19847938719104957, -0.26655715398273844, -0.3404660165610627, 0.11834265037861191, -0.2444111408824777, -0.2151319625407993, 0.2609245569800111, 1.4122375524879758, 0.6559410472497604, -0.13082217740134006, 1.282266501320027, -0.36378266670622805, 1.3446048410412204},
    {0.23641641772070487, 1.1897881817749385, -0.26747724771912273, 0.1896681290901048, -0.060371658594703136, -0.13443336808533762, 0.19052810936599682, 0.22618010614525508, -0.11988934326884185, -0.07830162285058799, 1.4251099894308539, 1.1076797559074572, -0.039360683084412255, 1.4529968321645366, 0.12206746560318572, 1.3606930719553751},
    {-0.2600764811461875, 1.245613961025853, -0.29311588039361924, 0.030588859336693194, 0.2973513211122823, 0.13772740829840918, -0.3068372438181205, 0.038433320945421866, -0.3479922650884295, 0.2448107912776275, 1.0960562804011365, 0.8324148905419716, 0.1331600799579966, 1.4497769808157301, -0.22574596682220413, 0.8211290542281586},
    {-0.3017914339941387, 1.352998585444191, -0.21202727712569533, 0.13530836500945978, 0.203576541845847, -0.3557392848629347, 0.05969901800199108, -0.2742740385425192, 0.22669477666515658, -0.3336698016679738, 1.3699135980185437, 0.8371998264332675, -0.2349459205794874, 1.2021441243997646, 0.25988378612014873, 1.3885026742663367},
    {-0.11118179545980922, 0.8267359315448342, -0.04773983880577974, -0.3027391784861286, -0.022709802153752828, -0.18755542909465125, 0.008157575219073215, 0.3083313539837812, -0.013395498645251901, 0.2828591972706292, 0.9128028743169958, 0.7506706622058716, 0.3042896812477085, 1.4113291762543898, 0.0968651628086967, 1.4010073299400387},
    {-0.05102102338837799, 0.7081244948931881, -0.30741424308464677, -0.3507421518679632, 0.0684688065087764, -0.2667712832260385, 0.22345854530764858, -0.07093465192779498, 0.2039577626605728, -0.2130080592018725, 0.14406763837367484, 0.3136582446102033, -0.3278203705756538, 0.18204495197435563, -0.23535389790331707, 0.6470753763385726},
    {-0.10574146624162557, 0.8363816834137129, -0.08503437243557405, 0.08385640408935448, -0.12051106843220234, -0.24453027279698353, 0.1094614808151029, 0.11784386010499892, -0.33860210569969657, -0.12275890555108292, 1.3799922024927584, 1.0537869259471522, -0.31022820918206073, 1.326269984782728, -0.271168751543801, 1.1197127885900051},
    {-0.11045742305165983, 1.3875976270660317, 0.3315907097611854, 0.2657417188559383, 0.057193702205842925, -0.0487321936197857, 0.1635127092451194, 0.2306086864715985, 0.25157839270661897, -0.0024254469871779647, 1.2384054551180488, 1.0899377463252005, 0.13920380649918382, 1.0314268070107913, 0.24502308839645012, 1.16847360854019},
    {-0.14575607942614338, 1.2511173454663151, 0.05228116017011737, 0.3117829902917139, -0.23696707807395598, 0.18991369679253559, -0.18467953896983255, 0.021135987054825875, -0.0884192639607995, -0.09099497326438098, 0.9845833441686662, 0.5816508210318181, -0.30247218235088363, 1.339408944955104, -0.352270341860669, 0.942469442288408},
    {-0.09725724404368512, 1.1531785581933724, -0.3575609712671896, -0.24324245831703956, 0.10560758668340918, -0.2854716628368493, 0.06462480830026503, -0.12434509653335027, -0.2516805905305724, 0.057361427437154514, 1.3940480550666003, 0.5792764551046911, -0.293654678000621, 1.1455428742355407, -0.24675572085180628, 1.2995835146607633},
    {0.0875005655977866, 0.9290638334582018, -0.07936254252901366, -0.3757152518876706, -0.011969336940920557, -0.30657271942569575, 0.09194462520664248, 0.2435137606444734, 0.21153226388187477, -0.16365867878412377, 1.0182991773339318, 1.2241827192312926, -0.003952343614274328, 0.978511138469869, -0.033403227046190885, 1.1289762936461252},
    {-0.19161684939478174, 1.291540284203013, 0.2664516991560408, 0.21261112203236557, -0.18594694819627797, 0.28097219575280646, -0.24074640053324287, 0.28436081441310124, -0.35641788981997485, -0.3188826863721743, 1.0020646001116384, 1.0554200346360885, -0.2890427324462794, 1.1992087611973374, -0.11569244712557258, 0.9181183137347669},
    {-0.045917601848263136, 0.1331277688167484, -0.1371855543704274, -0.1924662920640069, -0.05414576482596263, 0.1889656682678324, -0.2621593811863067, 0.07113047846277225, -0.18323552396228632, -0.15658815288972572, -0.1406743675691338, -0.07140981381620637, -0.1932499816047874, -0.21270003403443904, -0.18804169627075956, 0.28063477491818206},
    {0.16603524901809547, 0.7568676603067942, 0.27250348628849047, 0.3206337550238607, 0.23866698134022338, -0.11607948213826468, 0.02032564633791573, 0.30707715669209107, -0.06455427193352548, -0.03436610064126642, 1.1092473016329256, 1.0791318564637873, -0.12120830589153883, 0.5550522560321673, -0.3456522622277736, 0.5276959541202522}
};

static const float b3[16] = {-0.08203941142696326, 0.8320125357498808, -0.02044894124556398, -0.023622966796378434, -0.015880701160088006, -0.016949633323283964, 0.04681238648195013, -0.008523780042789789, -0.02502542359845722, -0.03130054375951705, 0.8270691401317257, 0.6868957806617861, -0.019050249143586263, 0.6917498685770472, -0.027242268874111724, 0.7895282948107082};

static const float w4[16][12] = {
    {0.31669115716320717, -0.06038812036883255, -0.337220647679253, 0.008429469990571483, 0.042619728783607945, 0.08082031899370422, -0.21495455817608475, 0.3268605191734985, 0.39521961066060896, 0.2729481626963827, -0.17838388136391, 0.13468091815404365},
    {-0.7118277069568699, -1.0857685130177859, -1.0511763781040557, -0.8132875082812768, -0.9669468415217222, -0.9103292326868133, -1.1874123326307424, -1.1515832496309162, -1.0173766420326478, -1.3907526521248201, -0.41452697906850783, -0.732893165692731},
    {0.4006283730878009, -0.19815760458043846, 0.3919941082751252, 0.3041803404742688, -0.1188330501907658, 0.29658622437905413, -0.03291416869836837, -0.0946960653448509, 0.23847540550622887, -0.37459993334616143, 0.4116624541061746, 0.051912346254824354},
    {0.24349788819005352, 0.2314374112109528, 0.06849117126564752, 0.29087052456595214, -0.4117291807604301, -0.12432876718675472, -0.21049543239979976, 0.042030876924043226, -0.11131304534795765, 0.31938318652542136, 0.4163577390309752, 0.4366883486846136},
    {0.17967824272218055, -0.29401253534676297, 0.015025258079529697, 0.36970208072555044, 0.08234271903076647, 0.1780055572169274, 0.38866824883021384, 0.42618005200154774, -0.17656355835997856, 0.4074229350644484, -0.2951698109447027, -0.2974685213601341},
    {-0.21141768719636936, -0.4599688210862203, 0.28719284275985635, 0.07848190163105553, -0.4164997814256455, 0.28272657195771816, -0.3340154726507249, 0.2643876646984506, 0.3337512081812542, 0.4198671390044772, 0.1050101141079754, -0.15545590757285768},
    {0.20300041549730474, -0.5504597376548114, -0.10682222520169195, -0.3601782879202521, -0.44062340356857577, -0.5492352391603401, -0.3199837549658947, -0.5782673705200752, -0.12196531567367709, 0.26629215129438405, -0.29166606037821746, -0.4887678970561016},
    {0.014136135652251367, -0.1539421281815984, 0.13146421526804997, 0.4151702655458924, -0.3561933486631431, 0.2962579917678719, -0.3743759425758282, -0.05789979846742772, -0.2373391336551483, 0.40769423884204525, -0.241212279988199, -0.06956886555197354},
    {-0.23852613801556227, 0.04170085097142228, 0.21351749946889348, 0.07431398164863057, -0.16633888535666527, -0.1092036876388359, 0.4007075625391814, -0.3059632962124784, -0.47667745870608286, 0.40908709513841157, 0.08266131330779566, -0.16945906061070437},
    {0.32559933133034846, 0.3698213244465902, 0.4107328485142821, -0.28393802526475326, 0.04555650692708367, -0.21026992852971033, -0.2469799696841876, -0.2818915961111878, -0.4818098329689108, -0.20896769888867064, -0.22986482440679043, 0.2826170027424846},
    {-0.72628047763143, -0.5375424563225839, -0.8060611538084902, -0.7115816227327532, -0.9437756422589036, -1.1202427930828929, -1.0685843176691125, -1.2217320616402625, -1.298734299758117, -0.8570801049563221, -1.217746323899027, -1.1278579036265617},
    {-0.6898209600082723, -0.9683263964862092, -1.2075142755909414, -1.1634835822855898, -0.9238981846921165, -0.974911129945485, -0.39833523413743144, -0.9893272441054325, -1.0455650048887737, -0.5817573903960086, -1.1372134994336713, -0.8954630407619122},
    {0.3399478385669336, 0.10091880334300557, 0.3580966092443345, -0.4786389215515672, -0.46075826150992305, 0.11573412751685139, -0.06575537901553197, 0.18924347986932116, -0.026450520165992326, -0.37365919839285455, -0.22030898668696447, -0.23916228701263462},
    {-1.431917367064532, -0.8457534911696207, -0.6584102205491337, -1.0986355933000507, -0.7724829434508899, -0.4944067106522959, -1.2546352442120552, -0.5841006912934074, -0.7550006456608088, -0.8565532171260603, -0.7300857351715868, -1.2866452039239293},
    {-0.1444995947151914, 0.43062506405956485, 0.4167764248558711, -0.19890394646239873, -0.06200917834560505, 0.26797038554024577, 0.4234453292735119, -0.34347869811815845, -0.35283286404597736, 0.014289459228836714, -0.3598734555597452, 0.31647544430616215},
    {-1.0197744490885545, -1.2105072871976683, -0.9748476216597861, -0.8606181445698067, -1.0141625526138016, -1.1603948882418949, -0.601567597122983, -0.6683537616562748, -0.5008053104265094, -0.8112055897777625, -1.2064098698184538, -0.5585526310431024}
};

static const float b4[12] = {-0.3796250744707942, -0.1995870775465431, -0.3538034451102915, -0.27983484097358563, -0.271889503139559, -0.18285540317323257, -0.3404853147933939, -0.3276014070475581, -0.3195726132030456, -0.3510747722673436, -0.23949885737892793, -0.223306924304102};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
