#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-1.2669131110465188, -1.3457511838214362, -1.2263102803674326, 2.8896441766056693, 2.886928090263188, -0.15816007507362026, -1.114247314348056, -1.6799884006503576, 2.3562166354641976, 0.08253131892616108, -0.4905183806545223, -0.5438563388928783, 1.6199227695061038, -0.1306657510385321, -0.6894288636175134, -1.6159139144303882, 1.9000032944540775, 2.9849883155276156, 1.465680526909408, -0.13462003314766058, 2.7043154534862817, -1.9383058905437185, -0.5423507723334492, -1.8881385869535048, 1.5504035235285154, 3.328307862975519, 1.1611435007042819, 2.9151585340021087, -0.9861076082755573, -0.09008960370996702, -1.1446774358409282, -1.2111152393513016},
    {-1.4813013133230046, -1.9792929841995315, -2.591384570876549, 2.8779715245757944, 2.498506655329258, 0.5081627188800524, -1.8521708467969418, -3.385001351444318, 2.770275852796019, 1.1909338546071455, 0.4950744654992262, -1.3099989085463277, 2.527157704307337, 0.34012949248463764, -0.09176772367899441, -3.486370889060479, 1.8901036913208427, 2.735757488381594, 1.9144030707645066, 0.6203110842523116, 3.073904163993161, -3.001121908132552, -1.2487084399950723, -3.462885249750501, 2.35641649657644, 2.6383248134672677, 2.5791650717805417, 2.670483302099889, -1.5473072230709946, -3.2694685176201266, -3.118484292469757, -2.0753342795871648},
    {-1.9361247872544458, -2.3951303554867227, -2.177104692705335, 3.6568124199217578, 3.7347220360816364, -0.16830748990567362, -2.3576225644736586, -2.7092320883512175, 3.7168235440248614, 1.0170669847982834, -0.22474947792912905, -1.8049712421150825, 3.323615010220526, 0.21448567718536618, -0.44954801504869324, -2.8926445967532097, 2.9074091582088637, 3.791895225521423, 2.8313606017961277, 0.25167864231969733, 3.5991593666588253, -2.760829416983204, -1.3108893470132073, -2.9696662007943018, 3.0640862649659755, 4.036298832053598, 3.0559922737456944, 3.9128608283964903, -1.8758100362607362, -2.2141950559173975, -2.7763353687408583, -2.4244547277677864},
    {-3.3176244551963396, -3.4119896937029615, -3.442722487247075, 3.417488532424698, 3.6184408018162824, -1.2926897750976392, -3.4569139575809253, -3.373572337476431, 3.2105825375200934, -0.19160923412369552, -1.0191962676830932, -3.3135860140021136, 2.4550729559194058, -0.43109047868120887, -0.9839800801430928, -3.4731762363418954, 2.616705845608044, 3.501331156986543, 1.9912541956734895, -0.36527712845081145, 3.455204905921182, -3.5935274797950196, -2.858853463916651, -3.419045837320548, 2.1015763062633566, 3.7301311467893, 2.2861890615276277, 3.542422348263401, -3.14391084536151, -3.0734760944985857, -3.271318535746212, -3.1455683600706754},
    {-3.5908553195780115, -3.744141337170439, -3.14636950498281, 2.8849118988849805, 3.0801964828353974, -2.006878649162249, -3.7874647817820963, -3.3200528166597225, 2.460972098079701, -0.7442828521691894, -1.4632281216832148, -3.7306566144844977, 2.094702937875417, -0.914049779342405, -1.4460705397794706, -2.861637288315461, 2.2767348385191832, 3.132860503294824, 1.7539100036220636, -1.2032370443959308, 2.804828892496089, -3.60406024510178, -3.2647063449721827, -3.351496559139759, 1.8264957656179814, 3.0368915214547925, 1.9050316939044802, 3.516879164706827, -3.4035418611346797, -2.75365080052044, -3.26209597816975, -3.308547148529809},
    {-3.4860270042738697, -3.787132827935045, -3.24558043585208, 1.894845474424076, 2.852685205928732, -2.060293118564102, -3.501440852480712, -3.244248679758234, 1.8411011313457994, -0.8657689338497964, -1.5941413073248998, -3.5678592438887997, 1.5086730849811338, -1.1276620669278317, -1.8049386155539784, -2.4017714946352435, 1.6770472526029245, 2.7239558043650636, 1.1392439493477007, -1.3308025158496004, 2.4535319580830777, -3.285157923092783, -3.403960003509244, -3.3797220067081764, 1.2059725858546406, 2.6737689875414494, 1.1741955091108247, 2.9544528541976267, -3.444376597454665, -2.142235701027706, -3.3440789872629253, -3.5082912037670475},
    {-3.2418974226771557, -3.730229122924599, -3.37847545996007, 1.6082265424569406, 2.2216569910360007, -2.1892078713194367, -3.5127322669979546, -3.5981766735637417, 1.3079632361747748, -1.2652276440725967, -1.649598661747575, -3.6681438298605014, 0.9777011938739413, -1.4625804979643888, -1.9621329400326197, -3.0222710349203314, 1.2192358854074132, 2.2782545597153514, 0.9557258337010441, -1.397079213450678, 2.1541726741885046, -3.6645455999753715, -3.369146758935057, -3.6353410920871436, 0.8965844441352498, 2.175495673382577, 0.8291490981404557, 2.553981811704679, -3.3418337071395077, -2.7619751346577073, -3.4533696335965183, -3.49697186754963},
    {-3.68777227970033, -3.7972381816498237, -3.6800270102497277, 1.6504611594984895, 2.5808719284782997, -2.418670776927844, -3.750462938759383, -3.6628246613573903, 1.3172329756195056, -0.9944366684172536, -1.4924133751689834, -3.668486048450547, 1.318557860636095, -1.045673931116414, -1.6547446112181192, -3.2301589447505, 1.2171020256990237, 2.2971768853180787, 0.6172175524672844, -1.6226953553686707, 1.8386009078690302, -3.8336500091971764, -3.331227297570921, -3.5193244249496503, 0.5884887315872646, 2.390571006361618, 0.7407014451750538, 2.75277544050543, -3.5019869904507517, -2.961446881169627, -3.750661356116858, -3.4779979469905675},
    {-3.6343175160106163, -3.4487830868426514, -3.552234679887359, 2.013636299256115, 2.5665577540610016, -2.2610438256202823, -3.7824077664479465, -3.748878630826123, 1.6111019379217146, -0.6303630481290827, -1.426857640499522, -3.438240792526158, 1.6907411437380337, -0.7616722261643782, -1.3590749786719056, -3.2165303904407887, 1.530503762260801, 2.3400455773495508, 0.9850025019526277, -1.215577833133037, 2.4448432153986484, -3.853837934644614, -3.4517351855354823, -3.5607817049498647, 1.3685346270483403, 2.6743028365196695, 0.9929008415257938, 2.510238949054618, -3.7266967123801757, -3.166177468682339, -3.688001830231427, -3.7979923826208886},
    {-3.419399589790301, -3.5347124443009994, -3.7345245994318206, 2.439387096532032, 2.9165247888639447, -1.684580149059732, -3.4487918577406633, -4.038571285341982, 2.3451349088162545, -0.2914209329138845, -1.1012709114804506, -3.6019342547623645, 1.8090224846811709, -1.0654949045728594, -1.6081721832176907, -3.49501078589465, 1.5117976856125273, 2.6563769533494823, 1.111998040442356, -0.8975990334536451, 2.6777751902152924, -3.824375861353223, -3.3118905937066776, -3.9602483521427283, 1.5447051450386404, 2.861483090530231, 1.5823570164849268, 2.983097205239441, -3.279471800218433, -3.4980752190640723, -3.945876063961054, -3.6975574174717822},
    {-3.3251839817688933, -3.3473805049718837, -3.768410886278839, 2.0318330918827825, 1.8822908961119769, -1.91175634596984, -3.399886630908305, -3.959157722871867, 2.3376064426451535, -0.7782491155794001, -1.5633534312146662, -3.1228091052177533, 1.3382979628199145, -1.4218282890279965, -2.0096388931101647, -3.9814803745916936, 0.5194218314932102, 1.6557652271863765, 0.6075577381053727, -1.2381051866085981, 2.217631225632009, -3.64262056267903, -3.259244989069637, -3.8749207740858975, 0.9514399387855249, 1.835609221244363, 1.2312078046079664, 1.5890298323728627, -3.402778287927149, -3.950923351272821, -3.902519209906006, -3.498855916790141},
    {-3.4692890212547134, -3.31799966695405, -3.570568335974231, 1.7408768814528723, 1.4024233275954028, -1.795529849113158, -3.6840340624357797, -3.7794731398849337, 1.8236408638508246, -1.239679478395294, -1.6012961440637443, -3.3572022398071564, 0.8929858470243835, -1.7369332217938678, -1.8251365010852196, -3.741806240267045, -0.056219346780076195, 1.1474687976073519, 0.021130309715018118, -1.620243779584033, 1.9553980977614496, -3.662147195888531, -3.2304440739171754, -4.054238540668324, 0.2049563381898051, 1.1851671608743635, 0.6764464553426056, 1.6818722614678947, -3.544431929280914, -3.7214797758363023, -3.901223842262694, -3.6212912880456942},
    {-3.241963947359101, -3.244099364306146, -3.437154274396755, 2.021769704835888, 1.4854340630682843, -1.2526511242603526, -3.5102018980541203, -3.901799083659795, 2.3342187241295558, -0.916503302899997, -1.143307139597506, -3.2504258332337876, 1.4562971195109016, -1.0970331471770527, -1.4766344159118054, -3.5482725284219243, 0.4435182208989788, 1.5507781405288057, 0.4573743265426861, -1.3878869829213565, 2.2796905672984438, -3.482478907514334, -3.327332501813954, -3.9938442860188768, 0.984547216777672, 1.6855998942646977, 1.4046568059068891, 2.196436633914281, -3.123297220393938, -3.7565243983155394, -3.75508863904675, -3.4863656860842407},
    {-3.220883362692415, -3.244881061429265, -3.5068146047363684, 2.39877051937787, 1.8542219447063077, -1.4763206444575672, -3.6382280960308524, -4.003375725647639, 2.4054778504161525, -1.0336676417521333, -1.0556509296776926, -3.1370050796103537, 1.5419585693008653, -0.9776548740574635, -1.4650763413846708, -3.7096528343819295, 0.8701447867310569, 1.4271621165709059, 0.8188636591693899, -1.3060426126506113, 2.4317492607101845, -3.551507155465105, -3.2664386465680177, -3.887052972771144, 1.194561897046522, 1.6252731075693114, 1.6112374750619125, 1.9848889367947689, -3.323018296877158, -3.819897273201164, -3.712046359118628, -3.288458310871915},
    {-3.251102391098362, -3.3231385114412615, -3.5716390021263025, 2.50134044793137, 2.5391787295982735, -1.2665952316804867, -3.2247130999610074, -3.7111729325154093, 2.786865150011284, -0.37013138662460005, -0.7260155261839318, -3.2170602061048674, 2.176541050476022, -0.5711427491684298, -1.1628575961907834, -3.7889137861215594, 1.7022760396280445, 2.514376785768954, 1.2881748984525998, -0.7059293813665601, 2.790160597462916, -3.61492854703335, -2.9082531792891375, -3.9556295926355127, 1.8136802730078636, 2.5064134615963183, 1.907199795900896, 2.5500593671779423, -3.315428747974213, -3.6811427751057066, -3.6753994247093917, -3.3574971467658146},
    {-3.1575703673758917, -3.5201301795487767, -3.7838963168196993, 2.9180352371955434, 3.1970432966310143, -1.022975445547256, -3.5940654929278657, -3.5838046347925117, 2.9286173462162606, -0.11027568665759208, -0.49961984148964034, -3.4512185143086143, 2.31279464014234, -0.05140821386965141, -0.7981466400709465, -3.5833492782435665, 1.9159122701274116, 2.8092402019815137, 1.919586865485718, -0.18951599545601922, 3.096591810163411, -3.6021736721934867, -3.236955581747172, -3.7754620030787596, 1.9447318941087288, 2.912138046743866, 2.5238657889476133, 3.156022689911119, -3.467000979575267, -3.3817569327310686, -3.557561713034993, -3.532696790374165},
    {-3.159239495602928, -3.268433917961605, -3.362825672172026, 3.4505528280949145, 3.468390881836226, -0.5549169153320788, -3.6043850098076002, -3.4221700275313163, 3.006782701938444, 0.33711682154198447, 0.0651854676171018, -3.1754805588213464, 2.638210317319901, 0.41663831829487286, -0.2272773053919751, -3.250813181668643, 2.625969477040138, 3.3558007022623237, 2.1516221772220168, 0.19517648921890562, 3.4366070504520034, -3.6200657402592973, -3.0231186638806875, -3.4647255510639665, 2.611651853354594, 3.639195458686866, 2.8080917317547294, 3.5943757705085844, -3.11039690699183, -3.019719917002704, -3.494543321342172, -3.107207012717963},
    {-2.827630103532266, -2.6958829849802566, -2.823304709993163, 3.827546148594893, 3.836712807941752, -0.5819164347819519, -2.9258088008164576, -3.2318523102825876, 3.517291727731013, 0.41643781719404455, -0.008572986890171937, -2.74211296346118, 2.94512103594477, 0.32994547326752666, -0.28091274128997995, -3.09170307431727, 2.7283326621868365, 3.7207181942555447, 2.6126739765324216, 0.10011577536195601, 3.5470075437994386, -3.1341082870237824, -2.3744893511146703, -3.1872259869401454, 2.7832916273141612, 3.9985085065146344, 3.0649665156818333, 4.015382743888597, -2.4532853896543823, -2.4636495878330815, -3.1042753466539708, -2.63875079164367},
    {-2.5495486187846423, -3.0957840793156413, -2.738474616960951, 3.5759870838562007, 3.5523333303973486, -1.1792210163262578, -3.0269621022696978, -2.7401788580865833, 3.1753367755851936, -0.14598618084519938, -0.681476737660165, -2.7121198051755897, 2.8305615615475364, -0.17207007605183258, -0.8717633384476973, -2.973851538233845, 2.589903754704527, 3.330645941803281, 2.25730322688394, -0.6671749902805009, 3.639063356542772, -3.1368489703267057, -2.2364549403473117, -3.021805106646617, 2.5154991731977123, 3.607053441156899, 2.571505548716725, 3.8238953168797387, -2.3862330650120156, -2.2811243614588497, -3.0247944473121104, -2.629360442002151},
    {-3.1484510401898484, -3.180519262183711, -3.2536342936854035, 3.412687817681731, 3.3588856218876124, -1.3995835721240468, -3.343136633046201, -3.505435552075665, 3.28663748472444, -0.5978983994851227, -1.183149218954498, -3.312010100117428, 2.807802336958365, -0.9453203607732795, -1.378705627381345, -3.4977873830923065, 2.4373700896396984, 3.203942041380932, 1.7177777178850826, -0.9558316759886342, 3.369431422866378, -3.3568005863030557, -3.083625700183346, -3.641511599739312, 2.3390003440689053, 3.7946923727301662, 2.4419352592129515, 3.7316407126425353, -2.8508017701992383, -2.8623518312403893, -3.6108734446154087, -3.0954933856175564},
    {-3.0403093680688, -3.507618994364792, -3.436250714854011, 3.5029696766109244, 3.4610702626860363, -0.427066129676766, -3.5511449454980264, -3.780707838707866, 3.3034620512606163, 0.3201431876590835, -0.38947109942449226, -2.979649512073925, 2.54281370019636, -0.4825853474059157, -0.8072551887775204, -3.5726553998464703, 2.3019032801662176, 3.0966270795474897, 1.8634852175584207, -0.17303974056692248, 3.400649694152606, -3.550090688626256, -3.134521574036198, -3.9524735913819726, 2.377865977120716, 3.4958714641600377, 2.7720783831600695, 3.4134554234069716, -2.8531213972907046, -3.2215098577519505, -3.766306464675553, -3.0356482635521163},
    {-2.7090991147501255, -2.8817975379803884, -2.942936906623585, 3.9384978843487137, 3.625560200597453, -0.28629891095163157, -2.9398867563528723, -3.6626890960408978, 3.8342255565834127, 0.6488189518859181, -0.11077102526278118, -2.6833706241728135, 3.039055479555149, 0.10430136551571549, -0.4973778226605292, -3.5288568744286812, 2.7698736057079527, 3.8527029874762895, 2.4769561308943535, 0.2321212970726005, 3.7869796014650237, -3.5144335934736706, -2.349080286572132, -3.6518910106641127, 2.683149459802174, 4.047604770595912, 2.76596854056172, 4.098312237334729, -2.4479819344591855, -2.8317616940237844, -3.395424639288153, -2.6228744748717263},
    {-2.0164836092867624, -2.0868668274722935, -2.7845521329815996, 4.022309422821709, 3.766511444143443, 0.17825316802073018, -2.6165859639889946, -3.1168777064001087, 3.61758303371065, 0.8987386364896698, 0.091019149225596, -1.8884472878888987, 3.0405034812347767, 0.42950810874065104, -0.31131568057523423, -3.216562881231477, 2.743321652699898, 3.9380940697652314, 2.6318527012916975, 0.4086728774127486, 4.152621463877565, -2.8215503018634305, -1.8942390235898505, -3.363022813673483, 2.8809745419714865, 3.8883964170173506, 2.9249980283440014, 4.011387285825478, -2.0076140214945113, -2.511285063133034, -2.717753029875541, -2.502462098744208},
    {-2.773115022806363, -2.9491514164986583, -3.3574254490520206, 3.8052863643033463, 3.4222949293268377, -0.1505245631743164, -2.930597718056152, -3.5416684887150964, 3.6750589181034856, 0.8046678393379766, 0.03933664046796226, -2.366867161475253, 3.0918435738133336, -0.06330149629423754, -0.21768222280244157, -3.430516417222568, 2.8097749402078604, 3.7444511784386902, 2.3002703185880993, -0.035127217235867, 3.8296119424144157, -3.309791924434683, -2.349631010123318, -3.551888486191425, 2.907488750558939, 3.834141365097021, 3.1352587463900727, 3.7088674783640307, -2.8159323116353727, -2.8147969704602462, -3.2460048291919286, -2.6784628641970403},
    {-2.7070770168918363, -2.9511118592777383, -3.6921667526315805, 3.3590748445484464, 3.0873435794294926, -0.5914075151290143, -3.3264767968508737, -3.567110647715877, 3.3323245586015267, 0.49229792034660985, -0.37485591158304016, -2.7415188619308046, 2.6748565910591173, -0.20968551380807077, -0.5385931043007, -3.8351612427733133, 2.3799420343948983, 3.156321885636335, 2.307450231679331, -0.05205695897837291, 3.4576589215064053, -3.600107721399662, -2.9273260800958485, -3.860378792287779, 2.3916014402789854, 3.3529728322473202, 2.927204932150938, 3.4027887335664846, -2.913202502171366, -3.1714029680259537, -3.627823554488702, -3.19098607495951},
    {-2.7557768694480296, -3.196277039378647, -3.2667511514427137, 3.5801854776325532, 3.2821030434594283, -0.529437531598587, -2.9813011062403176, -3.2601420867747573, 3.5152645970181053, 0.014421884435563083, -0.6225328252027126, -2.78671584688176, 2.5700368705988037, -0.5696238854954636, -0.802460052966393, -3.378516822893845, 2.2898655886612937, 3.0445328414712396, 1.9572953283056027, -0.26368996937706435, 3.531780787676767, -3.1655420658975344, -2.7453126955911067, -3.6770083105960443, 2.342313271456413, 3.395158001148605, 2.3669052645234436, 3.6391295030911293, -2.923119138066203, -3.3048668087017634, -3.306370230812054, -2.804711837481635},
    {-2.6424702190529628, -2.814928287458979, -3.021407410811107, 3.589709345664826, 3.4266167898995485, -0.5723976319877763, -2.925629518851807, -3.5896853791145773, 3.628687327337365, 0.22667272542425204, -0.21365627626275652, -2.8136046640199326, 3.0166290557585986, -0.11808048078213546, -0.7273378658535117, -3.5620088551490565, 2.52560919576759, 3.6240188494974652, 2.2307405260584585, -0.2669473986390829, 3.8182482136287352, -3.29328495629827, -2.492100338588529, -3.7102949987703635, 2.6134106714353518, 3.8635094555796177, 2.820381037134732, 3.9293709321820836, -2.5694026677895216, -3.13223790054834, -3.542857986540656, -2.825980679688351},
    {-2.9608682460319353, -3.005869105983781, -3.3395547282605715, 3.7844599790238327, 3.4515969518886744, -0.6025198119489007, -3.0620069416438294, -3.4583132231265825, 3.533680595358184, 0.3876914958888821, -0.4090025867578817, -2.7842668243894635, 3.0921895768387038, -0.2544321750739338, -0.8587203196212231, -3.5245375976720132, 2.818254341489212, 3.619650322897804, 2.1213183165083507, -0.2581999927826958, 3.69912493288339, -3.4268275471034637, -2.5186144595432456, -3.5442815358711894, 2.8911646570626326, 3.5918864731234765, 2.976221856670372, 3.8772481156769643, -2.6439201369004057, -3.191930152995163, -3.49528573296269, -2.973096125997001},
    {-2.5146539862469948, -3.079428271354192, -3.0534650047390337, 3.7531352941770213, 3.2735908020693874, -0.3670839849127006, -2.9624190027717208, -3.7354969973035814, 3.7037351680436013, 0.404220581525647, -0.3060748314518314, -2.477269820049286, 3.0819106609702867, -0.250021196357918, -0.4922313948935802, -3.7135626475816776, 2.7062245892569448, 3.6450637655373455, 2.614088549075251, 0.09901113149984916, 3.9505441534145573, -3.4312502313339266, -2.577370866238668, -3.7052341184821462, 3.0127588165085992, 3.582581607939927, 3.384452164196167, 3.535320717729815, -2.8313234817957142, -3.3560712422561276, -3.492062732131624, -2.853373021763895},
    {-2.6658359746739664, -2.966602666083554, -3.483623829455384, 3.4785765765492647, 3.4836813643729445, 0.05239118698447864, -2.884984976780009, -3.7637440908567026, 3.6905465852044403, 0.8077692189472468, -0.20664397263933518, -2.369598082026686, 2.9945545202937427, 0.19132813456564082, -0.4258658476318949, -3.9434787446778543, 2.5329815461439154, 3.576060159317539, 2.339992051761295, 0.3416809804287649, 3.680128097921621, -3.390502909263074, -2.753924996999693, -3.7390110602037003, 2.8792686561062393, 3.6936288856014334, 3.0185661706476616, 3.53169893104645, -2.7372974309474394, -3.3242545488109676, -3.5259177038340215, -3.0053534809347378},
    {0.3007610800217493, 0.0037638700924319565, 0.3679781743715511, -2.5245152083684284, -1.8364642033021397, -1.4292953409881286, 0.45315253248171616, 0.6422503546580041, -1.8540594255295142, -1.8226552964357603, -2.07031170363624, 0.337350999283671, -2.3034660682150983, -2.153756173729797, -1.7656460683864308, 0.16566259654496152, -2.336243447278632, -2.7744363961031455, -2.486940043382168, -1.9397096485694056, -2.4629422421007283, 0.43332988312120246, 0.328087973916765, 0.7131220070497869, -1.918156255261797, -2.3672700305750856, -2.2205673005381876, -1.862414787133509, 0.39985141779604155, -0.27689363386082655, 0.11001743083420179, 0.24668032647415783},
    {-1.7963450503337124, -1.565827981478562, -1.4929966229710923, 0.8194772105360432, 0.1628202889104827, -1.447026575054536, -1.4745803273227436, -2.7614523963962374, 0.4146383680483327, -0.9025313405197186, -1.3463454829723125, -1.0842173493859293, -0.1509363057992228, -0.9610641070570085, -1.3157871885170416, -2.7028133209738314, 0.14440400920554264, 0.7630780132554902, -0.3103054307706, -1.1556756703866673, 1.170966843972617, -2.70584743520837, -1.3827154047815335, -2.709511638516816, -0.31679042138119756, 0.2081429776392642, 0.04020537770162511, 0.785043065121263, -1.2055162206820378, -1.5157297144788817, -2.253455620054276, -1.5692192316318208},
    {-1.9309437870379011, -2.3396348614339386, -0.7066636841874966, -1.6499212691119052, -1.0275687907648094, -2.555002166266786, -1.7822669063442917, -0.5026227246958914, -2.4655324336299715, -2.5125961089869264, -2.625738888740265, -2.367008814012235, -2.414615083295229, -2.624925422681388, -2.4326428035402627, 1.0461793235599486, -2.183863255451906, -1.9703941650211063, -2.345857301338018, -2.388199177249568, -1.5651865135105107, -1.07975847277179, -1.8088656681930555, -0.5700807553413851, -2.378508654416048, -1.599393985605272, -2.3300289112186334, -0.6727003365274054, -2.0520028129430687, 0.33486799695557606, -1.120657534287822, -1.7675106085692085},
    {-1.9410009282108887, -2.0935162733138846, -1.434271942834931, -2.0790762236402895, -1.7542696394264028, -2.4872506359248634, -1.8529384821649804, -2.176590177112565, -2.3398369889645116, -2.614664564006339, -2.379738802465038, -2.2485172039876806, -2.366182381480179, -2.4804851630244653, -2.310721193331456, -1.1992768179028213, -2.807131585443544, -2.369678450283237, -2.722017345206118, -2.5783803397305367, -1.9466591629057683, -1.933849428150615, -2.0161606236909724, -2.069986355128685, -2.454167533046787, -2.5551745455181254, -2.4756087126155966, -1.4971103262760128, -2.141002040625112, -1.4302935776562922, -1.6921465778298093, -1.8226226457937391},
    {-2.296932603018518, -2.7882869150612613, -1.790781857922117, -0.6896016618892366, -0.6109101284302314, -2.7183243313194154, -2.4678644949744983, -2.313424135001579, -0.9977597373601321, -2.0212167970373858, -2.5748713840009625, -2.5227447823788336, -1.5500491768323512, -2.5003335961126663, -2.385015324178255, -1.2788905138968512, -1.8359840276905257, -1.1838205986967192, -1.6416339084651843, -2.476372073405315, -0.03908725094172824, -2.703562061549881, -2.1588367785523617, -2.361269089453543, -1.5760681920588067, -0.8438849833390796, -1.5883311418816077, -0.24401480358738403, -2.7142537409212726, -1.583367327445945, -2.235373535269739, -2.331399126768417},
    {-2.8321372850720175, -2.7375021751154804, -1.6287567054195613, -1.0931842830259921, -0.34531066504467456, -2.8810540626828356, -2.466858544215816, -1.7980879701650463, -2.0021692018579254, -2.1875091633867245, -2.324386220556986, -2.2686947587521114, -1.7269808132503335, -2.2607474520123017, -2.6428145044796394, -0.2544325453900452, -2.1026041402891464, -1.4647418272760233, -1.8200228698122465, -2.290990020432595, -0.7687460588258064, -2.263171203964638, -2.5216873774430812, -2.097289651562049, -1.7877778438437708, -1.409304310086738, -2.1490739250915905, -0.33394238165475704, -2.6694007342040766, -0.5385720929507682, -1.803407703198894, -2.5950825295602535},
    {-2.760544724095831, -2.6064414455979805, -1.8735475041009306, -1.6294986901813453, -0.9607789650190715, -2.9948721195786567, -2.497586396109909, -2.467169796476812, -1.6151991594233057, -2.4426739011829457, -2.883560511374886, -2.4643840574207836, -1.958423102649169, -2.466997185323031, -2.84362970512253, -1.5105597938881283, -1.8832355038881932, -1.3586657698110132, -2.139054607799695, -2.8097497979984176, -0.8543052112085909, -2.9094593374125957, -2.392470049427066, -2.550291581919959, -2.137646391322842, -1.482672605626269, -2.001279865862497, -0.6154622247548978, -2.8235574512912818, -1.4944379250925406, -2.753972501872384, -2.5300230049946566},
    {-2.020123443741484, -2.298629854827003, -1.4904142484259622, -1.187274093515076, -1.1160403345465029, -2.402990201226635, -2.293428639825494, -2.4173798733738403, -1.3484647364571336, -2.3321356550009873, -2.381317635006318, -2.201844290926397, -1.8561017555937425, -2.160220273904814, -2.45674337671418, -0.8434262827702939, -1.662297650699432, -1.693962453814794, -1.9501232270647573, -2.4662992191090165, -0.5269767292727022, -2.5968280405090347, -1.8327514128574083, -2.4064534551906522, -1.6395944194477874, -1.4797594460029762, -1.9140454365576924, -0.16778743520021297, -2.273460021921211, -1.2705500131634393, -2.5642168798735976, -2.395677854051923},
    {-2.2518629949827242, -2.6551753718478914, -1.5788264809646584, -1.392411262209429, -0.4212664825847797, -2.565684956801589, -2.230588288094517, -2.4297026902190426, -1.3641401354851443, -2.6200670511686748, -2.5297481266668016, -2.545749255965421, -1.6474917783848577, -2.4675328675835093, -2.5347595604738626, -0.5905357433056703, -1.8941572037216707, -1.3367070131686176, -1.917433922181269, -2.4718941120730102, -0.6491363484834436, -2.730149302921309, -2.3038124942487643, -2.244832137933867, -1.8159499480680452, -1.6813064789905396, -1.6910425824834645, -0.02337169531905572, -2.4114969458624196, -1.4461989823387986, -2.4614274115958703, -2.5669092150309587},
    {-2.5315106092883157, -3.140601294276139, -1.4669096558625456, -1.0828817974813747, -0.37424780989920087, -2.6580636539334623, -2.729692093768758, -2.5301266737194545, -1.315928293330294, -2.6485420770185666, -2.836369446702957, -2.7004914050279973, -1.6820757132236217, -2.4318653145093534, -2.7452119179087386, -1.0230587217600522, -2.0677137845895404, -1.2835031878677636, -2.1632087002520675, -2.843345420920869, -0.6492085971369008, -2.722377129909891, -2.407448573537955, -2.2393435640219272, -2.1849295237402186, -0.6165958521350798, -2.0182514865512626, 0.43892882858034654, -2.6711161874166627, -1.5072941946894876, -2.6798946054504484, -2.4966079721978525},
    {-1.9932960446145538, -2.5894029828060683, -1.596267145313642, -1.8563033189999156, -1.28948359944087, -2.5755163287592335, -2.1448917604764484, -2.162304786440915, -1.8761150283630827, -2.3004778960834322, -2.73958180641861, -2.345311693302888, -2.0971435691380296, -2.800723533211797, -2.736108097787428, -0.8833345908267981, -2.4113848195942063, -1.9513282366045313, -2.475422389215369, -2.8133323516540023, -1.0654036035124752, -2.267147496784023, -1.844166078361236, -2.0963978640163305, -2.2823113924087073, -1.620326676249861, -1.9632356046270003, -0.5813717848312449, -2.0964603235137558, -1.1786676895592418, -2.103458217729334, -2.326718470002938},
    {-2.5957440884086465, -3.053323235385507, -2.2439505689885824, -1.7797231514233973, -0.9754033954113283, -2.825507608757012, -2.58655728059532, -2.4214076564234763, -2.1264337805965625, -2.7637522666625154, -2.9011576274964344, -2.7680849236992406, -2.173361112058049, -2.720697408931877, -2.956784165257494, -0.5770540626079488, -2.276798519544348, -2.003293128041711, -2.5127292993501387, -2.8248081658622395, -1.249490156787816, -2.694184261991962, -2.261996461444853, -2.354659461804913, -2.3846705757626157, -1.3923404912361206, -2.392638893665612, -0.7878227667816962, -2.4559012897277843, -1.486824790590078, -2.4946489471832285, -2.394903961608248},
    {-2.627944455257151, -3.2409754477025303, -2.087362655360245, -1.54782891040852, -1.0275637923071652, -2.810977082635921, -2.7829889719029, -2.572128823218397, -1.9220741558555987, -3.0955576832938827, -3.2083134694219937, -2.7907841605699435, -2.234356594900332, -2.898348324950313, -3.17193037291933, -1.0743876332256859, -2.50396597560916, -2.059786832839212, -2.423888022982299, -3.182065179395829, -1.0817476405456246, -3.0500691749903512, -2.7978947765224325, -3.0239898905342137, -2.3350336910034817, -1.589723551745524, -2.3817134557199013, -0.1461046408052472, -2.9926604758351973, -1.8278279134877544, -2.778434168494621, -2.607506796801053},
    {-2.8742840378603054, -2.9229699882145, -1.857043093688596, -1.6659118657854475, -1.4276383967087707, -2.9235237842646282, -2.911415171852753, -2.28495499554238, -1.9894216962225606, -2.986332612740379, -3.0531644603492922, -2.716724005070233, -2.6595870691119283, -3.0193425273172863, -3.1114840281620877, -1.0206198068904364, -2.6701232133144948, -2.3392816636938516, -2.5931399224461544, -3.150023075954461, -1.3630903748624827, -2.733448536990082, -2.574558553167966, -2.3938291383582126, -2.5581086509727426, -1.7296465657089597, -2.5881767001013145, -0.6940752186588699, -2.914498069189471, -1.3559298848025427, -2.688220760979577, -2.983275140174169},
    {-2.5853798756234654, -3.073737753765745, -1.4502448913234698, -1.3741472708438571, -0.6197611772188446, -2.8573777780407394, -2.7142373980713335, -1.8396939660321467, -1.9615883885782146, -3.0419989478835103, -3.175078816677455, -2.629865917148888, -2.1220884326316716, -2.6319761687671335, -2.885332555287538, -0.46750636165322834, -2.1312889500640106, -1.3242017036514497, -2.4067223122948036, -3.081995521319797, -1.3147210192483616, -2.705875910260673, -2.581425803491339, -2.180185992754496, -2.307502649264095, -1.122613114227606, -2.7490911498683825, 0.02402850001210512, -2.721269704035516, -0.9010666561365865, -2.4692342284473727, -2.5382468416202806},
    {-2.525651103621092, -2.552996959196585, -1.574835360563592, -2.107017500596138, -0.5602501472565693, -3.1742715586662835, -2.6916076470016015, -1.6076525251148348, -2.6987532693939675, -2.972244572900497, -2.8392063059307096, -2.86671252923183, -2.5263991293974835, -2.6831160347130902, -2.9407945798602735, -0.37587457388622814, -2.3843714776412535, -2.217118750130539, -2.306153599511103, -3.13363590022372, -1.4388506406862573, -2.3080659442154663, -2.561392222314484, -1.6027304127950155, -2.5039142296703134, -1.6874690538857524, -2.8587971967485117, -0.6509282434797161, -2.8389309745070896, -0.31436353441249715, -2.119815034968804, -2.8244559484727647},
    {-2.255517931566858, -2.5731510177805736, -1.5529343290288766, -1.0941061900691076, -0.5885158048497873, -2.6639171471950682, -2.1665426157955534, -2.0690635459087816, -1.8030033428955072, -2.698437755553151, -2.8266623001240276, -2.3758406619345753, -2.2205529795661136, -2.854633404786494, -2.805069220455465, -0.8118712335886547, -2.491688637019944, -1.347190208865506, -2.0511871762494263, -2.738915987458979, -0.9590520134411653, -2.210429461783388, -2.0575507597352902, -2.2527425108536003, -2.2459213370149818, -1.2464312139255351, -2.2914477844300163, 0.23739135983555507, -2.2459259800548868, -0.37510419779105775, -2.4466064081943966, -2.2225888070916584},
    {-2.1311915248868454, -2.1520835872594186, -1.3444983707769818, -0.10213080766674211, 0.23765529346253184, -2.536139544358163, -2.3422014174729635, -1.478979790655428, -1.3881657752507373, -2.0829490837244062, -2.280489341540756, -2.0238616276528045, -1.0475926955031827, -2.234482371904116, -2.0861533004372115, -0.4992011245784888, -1.4579081723024663, -0.3756905238496156, -1.3746069014283673, -2.1038232528048124, 0.3367498813588245, -1.9282950175625402, -1.7839416472746998, -1.6488837329206978, -1.452611324789543, -0.25201625585973614, -1.581160217912555, 0.8767358212902399, -2.144332672767299, -0.2088847282500504, -1.9066900788835193, -1.942921460188466},
    {-2.627095218370393, -2.521693272584385, -1.312642132230386, -2.1810637742413563, -0.9446918420541955, -3.1691329504760044, -2.5727019223557357, -1.403949810450536, -2.7375649317682544, -3.0801536439023054, -2.953984257686339, -2.6962178470836347, -2.6830872757452306, -2.8911952998418955, -3.0235589518548123, -0.23796796497155154, -2.8675842701555174, -2.0895272170506005, -2.5718499114053066, -2.8312180620119607, -1.3398822272977593, -1.9251143413822103, -2.242317569849014, -1.8972488380825716, -2.7005568003388856, -2.1235239805740522, -2.7556049898185444, -0.6825380206026929, -2.732608865419539, -0.2729650919276331, -2.052271680924962, -2.5335121324826027},
    {-2.9976849502137406, -3.455709971984112, -1.6908178574091954, -2.4964979002079604, -1.090317570703287, -3.194646500018209, -2.9318466553703764, -2.1224087549898214, -2.5633919271921455, -3.4190400145900663, -3.4947960295305815, -2.9556472680179473, -3.0502650088686143, -3.3684473602307867, -3.328717452254815, -0.8395632522117991, -2.87728815398794, -2.6190981170926695, -3.0709995099228813, -3.3642862373719375, -1.5946216382360094, -2.94475478609816, -2.9011566656205185, -2.41338214437369, -3.0722606818447, -2.1663833590703643, -3.187898544674883, -0.6638005411309119, -2.6604105855584974, -0.9856672534294252, -2.661234460241657, -2.82755192257312},
    {-2.9313258884837152, -3.4976812052611246, -2.1376067428044006, -1.5389620854078505, -0.9190510033950305, -3.1812481457536768, -3.1770146445376346, -2.5765754050963605, -1.9917180617207833, -3.1562438648822497, -3.2783424516632866, -3.174924547676234, -2.346618493437639, -2.9973670622452357, -3.2520935437415464, -1.8072644960360937, -2.5902160773533507, -2.17556785019556, -2.9025644775653423, -3.287152921138787, -1.1934855434408234, -3.1562594689932224, -3.1381694602767856, -2.825353454596528, -2.775331324714673, -1.4355463921413907, -2.5445690069233695, 0.056241911487702266, -3.1703822023499826, -1.618744890741112, -2.670261395006599, -3.2155443760336646},
    {-2.68601105454708, -2.95342304343669, -1.7136391413004137, -0.3022137165599722, 0.6494075267452758, -3.2359669149200045, -2.680405849309695, -1.3945473442612681, -1.0466778402608639, -2.647325214517812, -3.128551226318283, -2.8721548354486557, -1.5650356769595, -2.8647836407042595, -3.153769059759757, -0.8018908485291282, -1.2332454969639215, 0.3065623392098534, -1.6527845192040738, -2.774141090738851, 0.3107657296535852, -2.342728222020403, -2.432497259990608, -1.6220632836189053, -1.8411195314146558, 1.1371770304061062, -2.090302075816278, 1.572255188030117, -2.8820249027952602, 0.010209639306008385, -1.6403828755198229, -2.868064779125624},
    {-2.1638270941631337, -2.092125164341639, 0.2865610721294593, -0.7933789319417694, 0.5491871061919187, -2.8731324050060256, -1.6221095636835434, 1.1106940691693372, -2.246703329640289, -2.7719327082070806, -2.9948224957310496, -2.361936207193133, -2.0058603506218025, -2.50963641355772, -2.7849278150748176, 1.4493229204934244, -1.5160165924285018, -0.3682383633039759, -1.818874023777462, -2.9564268263307336, -0.27999545181455326, -0.5739916855739184, -1.2341441146717271, 0.8822933522388685, -2.3091224035719864, 0.9274800967906167, -2.8207774387690945, 1.6532791429289482, -2.0179866233523334, 1.6609023771904912, 0.19922145655805606, -1.7793963973206033},
    {-2.833609870254854, -3.0340152747893856, -0.9339756094370356, -1.9865826290301045, -0.4594319142313073, -3.3351064946647018, -2.405869097557033, -0.356020442389425, -2.8225458529116296, -3.086248462941902, -3.221956040765132, -3.03506252359916, -2.7091941462206277, -3.0738602830489357, -3.06498724097342, 1.0143615077811947, -2.5354511417372163, -1.6926356084793626, -2.7343695433600903, -3.3276580133341813, -1.2777026709092256, -1.8085989921988361, -2.2553981863920884, -0.3819516217710483, -3.031752808986121, -1.1582148029783315, -3.0661322362703953, 0.727411421950838, -2.6576132267214922, 0.26768218137450217, -1.010386669831091, -2.741458038035722},
    {-2.8880830814533596, -3.4026466353554, -2.108787855098726, -2.0752983634134194, -0.7952612247805505, -3.402754356127441, -3.1127302332249824, -1.986639481769208, -2.8139220980126707, -3.274975262352985, -3.26776856279515, -3.2578130892657153, -2.5483531858882458, -3.1710519822352152, -3.0994619790028093, -1.238178857223561, -2.885292640211848, -2.2552561285781283, -2.595764646908901, -3.394699967370347, -1.4496415661446225, -2.873815641876914, -2.6516170905567136, -2.2473679200235455, -2.8927930882020965, -1.49654405281253, -3.0165394182757255, -0.11530290809545618, -2.8417828196683836, -1.1185783467481525, -2.318766348528298, -3.095580686147265},
    {-2.4917099286612387, -2.454332975424791, -0.4580318164344005, -2.539082103698211, -1.0568690349622238, -3.3921972184898457, -2.0598375591492535, 0.14697484176686346, -3.056539048233558, -3.456404470179345, -3.192803268376354, -2.7066787494607394, -3.2489244570202445, -3.185370319279426, -3.2409000362320293, 0.7496937753230897, -3.051421940500346, -2.7358207928002574, -2.801027821636404, -3.3843645947657484, -1.9613849779547952, -1.2948730896069447, -2.24369950204302, -0.17535192333487, -3.122272118690015, -1.6532768354350746, -3.630390400168649, -0.0024949315674238355, -2.5140101220455007, 0.48655698367652556, -0.24999386227147474, -2.1906241590822115},
    {-2.4424542768259956, -2.9362047403684226, -1.1069846892491544, -2.1822694614641986, -0.579359266401674, -3.339494312576477, -2.3397780993228854, -0.5052109813994047, -2.6480847516976698, -3.471035083908535, -3.56478633099156, -2.8139665404842917, -2.590933822329068, -3.3740023921325575, -3.1796204977845512, -0.22498883979003778, -2.7924668823348795, -2.0941724156146875, -2.5299110757937124, -3.2321632659030324, -1.3027663166537158, -2.062990254485241, -1.895143824808085, -0.7708988704172516, -2.7421522244607126, -1.0307173667999825, -3.2530875595595785, 0.7454783962132604, -2.4042443476672584, -0.4293030794080058, -1.319833665167741, -2.4976148472575113},
    {-3.0064460321242623, -3.1605573418507715, -1.5497764124950049, -2.27054678055564, -0.691752837954281, -3.5323392140241303, -2.505691248282881, -0.9424404929378487, -2.98822281878837, -3.3213559301864057, -3.4973544184115197, -2.992229472589359, -2.805821224969175, -3.111796105634281, -3.5257214572143285, -0.16002990804451253, -2.8523116494940113, -2.410020956425456, -2.696230023323724, -3.3022065901697815, -1.2974985908069199, -2.182744039259133, -2.5706275358194706, -1.5867276685249885, -2.982819601898005, -1.4135485845546594, -3.261827131154821, 0.3944396712540113, -2.801677863793379, -0.5782882644320833, -1.5154546755639215, -2.6145930740355934},
    {-2.5601441234348736, -2.6020694247225817, -1.1615898063567107, -1.9218886653938643, -0.2996098030427135, -3.294708062658234, -2.5939842000652487, -0.013190157059941135, -3.0583613887989327, -3.0495967306424836, -3.354229674923994, -2.8315564392480876, -2.7943236602730988, -3.017021952956542, -3.3167237108109937, 0.6739657718811713, -2.7641981890977165, -1.9730172253683094, -2.729548554528648, -3.405412005998539, -1.1095215453163598, -1.7909628283924737, -2.4836556043886837, -0.390778814209002, -2.7915803937352353, -0.6544588595826429, -3.223278212963256, 0.5143359179203381, -2.6904782189977015, 0.5743987972378508, -1.0032910731463387, -2.7372102103487554},
    {-2.2537736540124023, -2.476512649701673, -0.8719358891949041, -1.7656606602766973, -0.06716427662258719, -3.2087930087947925, -2.4289996539697176, 0.08589657593700989, -2.5615417447468163, -3.0778604482016014, -3.3440403478101377, -2.4495083686716126, -2.7267744057365673, -2.9947262062800113, -3.197292657778386, 0.4016409034190381, -2.6561649147405944, -1.6144966497067483, -2.5132135532257616, -3.0860172997512674, -1.103881001105794, -1.2473602198798694, -1.943287904510407, -0.23416603059097704, -2.8345416221548985, -0.2652002757853794, -3.2765132531627508, 0.8895459656384779, -2.1813251908420597, 0.6825366655744348, -0.5107769215333372, -2.1557065016152372},
    {-1.8982838452880328, 0.8120066567041623, -2.0835497191306414, -1.3300914793513547, 0.9339372794284773, -1.5153258027970884, -1.7752771202426556, 0.12777517173993538, -1.1553264816196613, 1.36422594250721, 1.096772547526506, -1.3654020220565009, 0.8976353812946266, 1.5868420298758388, 1.1472135970093156, -0.30198258203041345, 1.217340247072492, 0.8377886297723454, 1.0454212570001002, 1.2090152782912935, -0.9350958261734574, 0.28676878950492984, -1.9618653713860856, 0.17351319791877465, 0.5153893799137726, 0.220182834501479, -0.3173992105331536, -1.6947059245751763, -1.6793958372081468, 0.4952322139475946, -0.15924835236114523, -1.5310822966034365},
    {-1.8065893938623772, 1.2414461574822664, -1.6545755588355842, -0.46755961132074647, 0.9189140171852667, -0.9175778619914026, -1.1207128433531628, 0.23571074717424512, -0.5487873052563954, 1.6336010933714251, 1.57809605958352, -1.124698666552159, 1.247973400677314, 1.6703848129033465, 1.9214017050013856, -0.7772698213638844, 1.4400842132683287, 0.735710578065336, 1.2121670283064596, 1.508873792265419, -0.005918882029694627, 0.16311822961967284, -1.7796076344144505, 0.1058215061613697, 0.851888702119051, 0.11109188314859167, 0.3540860511253666, -0.6094446900548238, -1.6862340428342164, 1.209808954677016, -0.37262233276857515, -1.5227573328744963},
    {-1.8839952066985146, 1.5606431939443761, -1.9504517033055353, -1.1860219056716919, 1.478027045757184, -1.5443639757658787, -1.2204851123287022, 0.5761625137058151, -1.1157785312933024, 1.5110095770214134, 1.9596206415368103, -1.6014958974952818, 0.8257552202242779, 2.042206722666798, 1.9373066047529321, -0.43935889554243157, 1.4494502660421513, 0.6322358394787102, 1.526684785468723, 1.8469287489991826, -0.42778261836904896, 1.100416090654566, -1.9841241781403673, 0.6874181750819967, 1.308137758090748, -0.24478398615248528, 0.07021604553810688, -0.6473815604426577, -1.590910791653801, 1.5199361290032674, 0.23011324574118172, -1.632542198211293},
    {-1.8956641116929995, 0.9086834589060117, -2.2743444900341543, -0.7436447930611744, 1.3465122406328005, -1.454757019425703, -1.566140226128437, 0.3296042430942516, -0.9126588312817407, 1.874427190830302, 1.6590820124573835, -1.4035831585422822, 0.8216345393318621, 1.8661762321500763, 1.7872577223013206, -0.4555417113457869, 1.17975937916469, 0.7181209614874322, 1.6017602351710916, 1.5557367518720082, -0.6168610034628863, 0.9525429299875641, -1.9205395175342528, 0.5201380035071448, 1.2812652232165507, -0.13879694031857898, -0.04596119323525093, -0.7996135538349786, -1.7875990102563428, 1.6699347363781878, 0.6822552287471537, -1.7804447497185327},
    {-1.934869333096238, 1.0700562439645753, -2.0083951472952197, -0.5738327289685508, 1.3362740654091787, -1.224317573286347, -1.1255764001817372, -0.09460443926526445, -0.3582725082855291, 1.6701571959025743, 1.5431901629755966, -1.7046144779585097, 1.1370045237584478, 1.929037053876668, 1.5091275913939386, -0.793123478133839, 1.232430843348612, 0.5367273613092908, 1.3061122543546693, 1.7966173077033794, -0.12614602260607488, 0.8532499079036518, -2.2718958586152547, -0.16288599169603024, 1.1030244198036219, -0.2058711227897475, 0.24374938116806638, -0.41186836829273715, -1.6195176193465268, 1.4703723590814701, 0.022857109923971997, -1.7466530550576664},
    {-1.8233333693051463, 0.7373750194821168, -2.4476117867552225, -0.73211556753083, 1.5724147605933163, -1.380523662267909, -1.1117609150764287, -0.006669058657866628, -0.44304356274910744, 1.5351265574485191, 1.2468543128376917, -1.717348002352112, 0.8970409663833895, 1.9344165645301623, 1.42034732906866, -0.6977738184574463, 1.0179518685389213, 0.5208076740666355, 1.49544204799602, 1.5838652563869544, -0.20980392141078288, 0.9484412213312194, -2.445264541940075, 0.458364832742524, 0.6524282432172862, -0.4677230796567826, 0.21939532939839862, -0.6931931779617061, -1.7160677979910757, 1.7790011869959022, 0.22596471986614014, -1.6265347636910363},
    {-2.4694547189122518, 1.078680116086945, -2.2461732391979043, -1.6061115713077758, 1.0732955187244786, -1.6916416838342687, -1.6267169003782658, 0.5271640883654476, -1.0597887487463589, 1.3759594603550316, 1.2841641757590425, -1.7212292094677983, 0.8944068897947586, 1.7140684566819238, 1.4439838591748935, -0.7589960920428936, 0.8215027644462377, 0.5835217798234982, 1.0487786754854065, 1.1353771529063723, -1.0778642989074216, 0.8494449446084411, -2.6253828292499413, 0.7722452726808567, 0.6706547653821333, -0.28830064347406903, -0.5639030316347786, -1.490342643875061, -2.1917840181328727, 1.60996221165581, 0.8230084579018261, -2.11078078798285},
    {-1.9007961919204703, 1.150923871746665, -2.3889675432482274, -1.120057375216178, 1.4424934073808267, -1.3689661270887274, -1.7221776899148764, 0.3581480891999662, -0.5291312763970616, 1.8576355933782938, 1.4731739429419586, -1.2058308839391298, 1.1714632015389674, 1.710556446327854, 1.7905220212972868, -0.798834801990023, 1.2254292138061207, 0.8056642676774913, 1.5381557621143735, 1.6214859998362272, -1.0550611261802383, 0.9437050531679585, -2.31619086812143, 0.7684109268052461, 1.023012140409305, -0.18085648688913156, -0.3025644260115144, -1.6247904949310341, -2.065723711261414, 1.831520668157936, 0.903687009300985, -1.7071580319728559},
    {-1.9050287579975953, 1.0178220969899183, -2.342031939865473, -1.135541154374918, 1.697180341829797, -1.118730241357131, -1.5343225402277751, 0.4449984898315886, -0.7035559730161197, 1.9736231727807483, 1.3432578810291227, -1.8530229409978562, 0.8569602805367443, 2.107202693666716, 1.8461887183530783, -0.41025922093987455, 1.6331008526987383, 0.9286934976820871, 1.4792567480915726, 1.4395367357619457, -1.1927518332246512, 1.440107275649451, -2.6171216361177105, 0.732572519230974, 0.7684122055814498, 0.46847773192178205, -0.3385424912356179, -1.6659454498311834, -2.1643519516010006, 1.9323836456347279, 1.0864429007452039, -2.184968619705163},
    {-2.030219631938847, 1.099581673151548, -2.5160498987420112, -1.1355994314617268, 2.0429743528943147, -1.4940835322706734, -1.4241628567685494, 0.907507149248002, -0.81085893508929, 1.7541698485486228, 1.50425388798991, -1.4912084564421029, 0.9887293551889169, 2.0911191938245803, 1.6266137688144977, -0.08011953802644764, 1.36832325736881, 0.9828003915997533, 1.3992046578009727, 1.695733084174495, -0.8687209900378202, 1.5538730922227644, -2.5516611805402967, 1.0139592356083271, 0.8224966964805714, 0.7133582966336535, -0.49849565254451944, -1.5652592650878507, -2.0289301206122454, 2.197779427845667, 1.1899696413528837, -1.9434029729404187},
    {-2.1831907379265107, 1.4125927496673074, -2.2865429806708897, -0.6918399659835178, 1.6729024014473648, -1.313418877565597, -1.2481935560293889, 0.3716589564122353, -0.4462982031209337, 1.624512533395904, 1.3540069419353866, -1.4255996848664878, 0.760337808518211, 2.033251126699837, 1.6497783017398924, -0.46256936331633747, 1.1863791984549918, 1.1747975359715659, 1.4523724863636018, 1.2446307279451014, -0.86015927799025, 0.9778125058551395, -2.4583562400937953, 0.708853522085166, 1.2431085240503406, 0.3581025681410375, -0.5734840900981034, -1.4116946096574776, -1.8270789364196063, 1.6895084156883684, 0.9741944215715556, -1.9120897710532783},
    {-2.377807096675202, 1.1098464223560778, -2.474275703939547, -1.1561215562072205, 1.7175857741829723, -1.5798702595986536, -1.725178093305521, 0.926392691214269, -0.9645193703118202, 1.8265181227715572, 1.585701555200734, -1.6172925755744223, 0.6732668054861837, 2.055498798053273, 1.6515516979793263, -0.5137157682006536, 1.5603784387120443, 1.0821362826429612, 1.5845556451849017, 1.6371838810101893, -1.283070930110114, 1.1951674096050726, -2.4198969936174586, 0.8628041214362414, 0.8512184283596079, 0.4194704054590608, -0.51706138881023, -1.8946994556828098, -2.0101097563870542, 2.2460168022775138, 1.1179965993762266, -2.300655261068258},
    {-2.356066503491452, 1.621248757747922, -2.552385857083347, -1.5495776635233254, 1.4749031412597948, -1.8555990448286999, -2.163264715379444, 0.5073701254717868, -1.0735310413429586, 1.888941277286431, 1.5615975104631121, -2.0790611138610737, 0.8148315550767088, 2.035264830857689, 1.7348101176488797, -0.1666894977671321, 1.06287733883628, 0.4657646771178323, 1.1962552966866, 1.508141159601116, -1.6242124853561826, 1.3271448178870353, -2.619363125928996, 0.5301482042151728, 0.7520994304424531, 0.09993104063373914, -0.8343985164304557, -1.8563502585152598, -2.233253606218669, 2.036763650626904, 0.9995798283971401, -2.3019331657660267},
    {-1.8931618921282554, 1.2621801956656935, -2.3750763120571228, -1.4105799123565002, 1.840772760174312, -1.9168292632072637, -2.0405593489435496, 0.23433784685291664, -0.9180618911149013, 1.4292811699039933, 1.573003040343795, -1.825910780611108, 0.36134766594795076, 1.666696832408507, 1.4885074973686392, -0.18044468324169324, 1.1878487632399721, 0.5338189875221002, 1.4630242084410037, 1.5036665255403139, -1.4754134044653675, 1.1256683648544288, -2.6222381254077747, 0.9230534707039494, 0.5681616701130012, -0.017819827006380882, -0.715714193039348, -1.71828698313296, -2.3320067975375878, 1.8800999570726007, 0.8428240311829839, -1.928022906902614},
    {-2.046629783400176, 1.3752401613474596, -2.0685316132694096, -1.8204045437883452, 1.6951887595105606, -2.0211883607402785, -2.019566207172571, 0.4883147998922653, -1.1062449630260311, 1.5946716276963644, 1.2207776588694257, -2.0735252581132664, 0.38594675087277625, 1.7999172088383204, 1.8184812831362576, -0.05237438180448926, 1.442217438383539, 0.7987483284618583, 1.532701245069317, 1.6048824757653875, -1.2928503552774335, 1.0774488900317687, -2.36449781128124, 0.7725172681634981, 0.5524782071598979, 0.004087841496473227, -0.8588977687624524, -1.6481099131052581, -2.4791924407361363, 1.78694284339156, 1.0491058538045386, -1.7637862327833518},
    {-2.2168087734636366, 1.688215024180539, -2.408975036208033, -1.5319877649921343, 1.7668020756700926, -2.27490808804583, -2.2470030492115445, 0.4657523730380328, -1.1667597448868263, 1.922257953460959, 1.8033325108903897, -2.2156003104314363, 0.9820113439391845, 2.0032391124125426, 2.04345192230474, -0.2312274080852486, 1.6705430859753938, 0.9717858655425956, 1.9189316087392057, 1.663681292073558, -1.0403770201413962, 1.2034375105248172, -2.729445387739015, 0.2874365430719565, 0.9800096100612218, 0.35667200785221653, -0.42202150948309786, -1.6442059165080984, -2.5425669815134206, 1.8366735335228566, 1.2598365755254237, -2.180940316440071},
    {-2.3487509408697917, 1.4367974541611481, -2.494949299873922, -0.7610304909804232, 2.2024270033427777, -1.9592446237017511, -1.8639651582532921, 0.05154832455209946, -0.6680313473853731, 1.9250404677203563, 1.6903921060586875, -2.2973950468061397, 1.2573567203739395, 1.8838326118723288, 2.1209324292389384, -0.5048274427569396, 2.1272164955959965, 1.553382546940039, 2.0879878300209396, 1.9520025369923144, -0.48850512049125316, 1.488123606081976, -2.6611135896914515, 0.20112315152279953, 1.569326020128177, 1.2075816233703176, 0.25430735746499045, -0.9007504353192963, -2.2554174606498965, 1.6547898200645001, 1.2103454714740305, -2.3525299737016185},
    {-2.360784308828301, 1.6978888703955137, -2.5626814512505747, -1.432293322536977, 2.0200806536264464, -1.6423539035355912, -2.200484456811052, 0.26795457853963695, -0.8426501725465394, 1.9096333977704811, 1.6804256295569462, -2.2704934020732956, 0.9155179612885078, 2.0617331826053005, 2.020078799000245, -0.34622843966035527, 1.8986891200416403, 1.5301362195478518, 1.9626938696546612, 2.0305168706857954, -0.8927683832973395, 1.513994138225322, -2.4571551061387824, 0.2376160870141749, 1.1407238431568079, 0.7647314967270432, 0.07776871110458342, -1.5747301716675215, -2.4134999083321254, 1.949943091295458, 1.3609820974733735, -2.531571214736672},
    {-2.5895054907800295, 1.6239945863005005, -2.152359929829416, -1.3993352881469392, 2.0640161136166486, -1.8089024269985832, -1.7865234690539666, 0.45086605446704076, -0.8881351872145427, 1.9981898604880546, 1.8499720013440402, -1.8325244775724032, 0.6479428374532976, 2.1657648119993107, 2.019041358495157, -0.2580352412766151, 1.418337928465985, 1.288618502725751, 1.7852943383919613, 1.9413018849374217, -0.943881448979007, 1.159176644115417, -2.523287305120223, 0.7699164379248072, 0.9062214046117787, 0.7779662668684254, -0.2568764339424764, -1.5859254782974013, -2.524779357713413, 1.8902734567724755, 1.0251163324942212, -2.44298103456191},
    {-2.424662743761996, 1.699397687901287, -2.1208833612591924, -1.1897967318434526, 2.3232669997144835, -1.7629514114145581, -2.035082997605058, 0.6146860394602486, -1.1798382696193441, 2.073828752873532, 2.0886764325265843, -2.03070029163594, 1.216956964432153, 1.9655872880821794, 2.271405073281734, 0.051784633438124214, 1.5568545100519864, 1.1931481963041797, 1.7492477379539935, 1.9959377540035927, -1.4159186975356286, 1.2883542777456898, -2.3792149547913115, 0.9607249026423534, 1.3489032998093975, 0.30044398842660375, -0.32792996429454735, -1.787940651577328, -2.3336958408861284, 2.0238301125206783, 1.3607549772011203, -2.3164887577359585},
    {-2.3638349547879467, 1.4241903762186372, -2.239943811543703, -1.1898856257138803, 1.9662129591726825, -1.9600187298004539, -1.71430209857529, 0.5617210841683176, -0.7392927069359967, 1.9535954648599227, 1.861434828736081, -1.844021055732966, 1.3641051460444151, 2.3002625442640103, 2.2197242140830524, -0.597821925841091, 1.9622809990601546, 0.9233873738311758, 1.8465849865404411, 1.8431571690884772, -1.6666363363190506, 1.3940164181488903, -2.5051517730903736, 0.5571259774761792, 1.5171130795507495, 0.5588787490786669, 0.047131925401270584, -1.9811349485731022, -2.5583185455733743, 1.89513568301523, 1.2448819417123074, -2.1131184987232743},
    {-2.0680318373414193, 1.8016505566410874, -2.3597902556243464, -1.1766043394941235, 2.518135007688084, -2.0319706819329197, -2.077527104677719, 0.6426619828288994, -0.8358362144157765, 2.1277669159615993, 2.071042311790879, -1.7108754113401614, 1.777091513515042, 2.418847645826123, 2.523671925760541, 0.07978154951309427, 2.482735912210266, 2.114610589630892, 2.3747457750166654, 2.2511498913919445, -0.9834912523866308, 1.283905922602021, -2.4003958148072964, 1.2195729616115696, 1.694165626295221, 1.6656514685514143, 0.013565155916225773, -1.5830199077289848, -2.384474847361617, 2.3615418734062312, 1.2231029051573519, -2.42919640392177},
    {-2.383742841237285, 1.8551419506586384, -2.2171338212469496, -1.6136617224926735, 2.495281766623894, -2.4669453349839245, -2.0005442730755876, 0.5469073917861748, -1.3603480693175949, 2.3040100025883237, 1.9825611776031233, -2.0589166205721035, 1.4305361517909605, 2.422928260117117, 2.2856367093034704, 0.20227045564746207, 2.395390447862245, 2.019061864063299, 2.3431360482690002, 2.134633503640445, -1.6638538342097016, 1.6625777473982009, -2.7428007984918557, 0.8618053595084085, 1.7901568133165742, 0.9989456962920584, -0.278819133971133, -2.0660843819711534, -2.7743911458944845, 2.0474936968304656, 1.28418794986322, -2.4638946245921263},
    {-2.422500002912348, 1.7488636738836187, -2.4584072029987265, -2.017951730568301, 2.2070904915943848, -2.5070346391100116, -2.452103009204415, 0.44849874374058657, -1.1801763334590747, 1.985103401509737, 2.2157480817742585, -2.1861475192497983, 0.9465343373947444, 2.3956656483280767, 2.4644902416657066, -0.26158548985142205, 2.0801876960371937, 1.3232158966711165, 2.0332989970697795, 2.317828877335735, -1.6982920894517974, 1.4499035704275325, -2.6368004698872993, 0.551985965357857, 1.4969197662761566, 0.8706332721035561, -0.5336865141381312, -2.079003955839664, -2.9566059912588285, 1.9830517061283428, 1.442863577560657, -2.6871189113613543},
    {-2.2856290606092187, 1.801367368568408, -2.643035937635632, -1.3357440105487344, 2.5510555782406716, -2.178314646597458, -2.1915800209560725, 0.281785615505888, -0.8387213490423209, 2.3423502768069175, 2.0650264672781495, -2.312320271293364, 1.4954795671564503, 2.4010018322460636, 2.225134393844639, -0.46925080439390243, 2.4966999220962673, 1.444298613821961, 2.3895708843624752, 2.196925157080724, -1.473953286265946, 1.3225840390865489, -2.8398496601540435, 0.4251380625370356, 1.9330842150789975, 0.7108309404955512, -0.04690123973259824, -1.9320111245738412, -2.714403163357475, 1.9910864166223938, 1.200351220070825, -2.2420060233196883},
    {-2.759006417461185, 1.888599473090454, -2.7974497259780144, -2.0991919400422123, 2.338714764819218, -2.6340949601048718, -2.5234941963484063, 0.17821018608590294, -1.5572039288316222, 1.9683246381843598, 2.1602807013735017, -2.232503068502785, 1.4963663983404545, 2.6950959739676676, 2.4905936455399527, -0.16164207361034091, 2.4362859621512167, 1.7509962614720271, 2.338417653078426, 2.141117158170287, -1.96729029190916, 1.133165285138211, -3.1230993854750064, 0.6733613242530727, 1.865311360176447, 0.9557908552975387, -0.3432037363010871, -2.042508364008253, -2.8019383412134893, 1.8887228982134379, 1.39817888895637, -2.665687689116925},
    {-2.328531866914051, 1.971368530017098, -2.6714209833255187, -2.1003532557377174, 2.5996741585938974, -2.526592986578043, -2.258192349850533, 0.5745311636678794, -1.3375075895553536, 1.9708726538603234, 2.0684384140024474, -2.1559259010154297, 1.5724210839890287, 2.7386474255204196, 2.235690672584168, 0.12914909537055524, 2.2915029111756327, 1.8796094451062388, 2.142454749086078, 2.267474567092803, -1.8631114139189995, 1.2863288302551752, -2.9592086288126267, 0.6206198129162159, 1.9754196246188398, 1.0036806296282283, -0.3179355658626094, -2.429103823131059, -2.5438966418424425, 2.544385010747576, 1.383293181271725, -2.241107035680472},
    {-2.5193519130049356, 1.693659315934026, -2.252407096817653, -1.9771878937958178, 2.3480940817525324, -2.4422019013958614, -2.0278916534903115, 0.6420534723924408, -1.4838763279033023, 2.088365929014418, 2.05368668720154, -2.2960627493012233, 1.016636542656076, 2.2287112617316684, 1.9511834862305633, 0.25732521426628374, 2.240671547222655, 1.642941840151348, 2.107436297921592, 1.9660867762475074, -2.0103098720736776, 1.6078617966162347, -2.8168111813868744, 1.0593753043552159, 1.554927353858072, 1.0048658080891948, -0.7626367900306635, -2.1962371724951564, -2.7808770221941135, 2.3593621694998483, 1.4251916502043813, -2.2750696347219277},
    {-2.7768511131760683, 1.4945656635302216, -2.507065211273031, -2.0277974156878145, 2.1571980239015747, -2.4350561779617084, -2.4362497259115345, 0.6267067002494886, -1.746239485843135, 2.2512470346188342, 2.088301948260927, -2.6786133048800767, 1.2329054136424709, 2.3048252344733022, 2.1606506369204994, -0.006749077180446008, 2.265523126768646, 1.3751151697827386, 2.1164814782706767, 2.214485486824343, -1.7287896450884352, 1.2359391130853408, -2.7831184759989913, 0.7468602073081289, 1.562944279357321, 0.8110730481496126, -1.152258952242104, -2.221526094021318, -2.6017475043170566, 1.9534427949944355, 1.443488034313754, -2.7613104784959925},
    {-2.85967561046227, 1.6717392337938646, -2.7945485700905057, -2.007694318686849, 2.1895061854056377, -2.551065484748822, -2.5009208802170466, 0.33024469197872647, -1.466242385541269, 1.8797472227996335, 2.0794108430817797, -2.6357003610487677, 1.192642873392371, 2.4710248097646774, 2.274183923515712, 0.23562160752938904, 2.375877441367338, 1.6825780953345684, 2.397977974020724, 1.97205661599631, -1.8214403365273386, 1.3267388717882511, -3.0978449015487204, 0.7375853355103733, 1.7580120063100142, 1.2650939410897843, -1.050168003902255, -2.3294321943947565, -2.5447285976936627, 1.9464410223545558, 1.3865286675744435, -2.392923023365378},
    {0.456644776508856, -0.14556586572261002, 0.8208208586855623, -2.4849694915205505, -1.7694257298096236, -1.5773353546517161, 0.6727523296981458, 1.8841398829761136, -2.4247794722307083, -2.1364283335554215, -1.7594717480346125, 0.2167558072556291, -2.435518290747855, -2.0245367861325514, -1.8619158937763782, 1.7351807770906054, -2.7594160696863246, -2.838352838701153, -2.436716957612709, -2.104731399948548, -2.4813988327192957, 1.4100913011610348, 0.7780342484373317, 1.8710417360435379, -2.225650682767831, -2.214105733977904, -2.743352351799326, -1.713584002431669, 0.3830498514271079, 1.317506048417822, 0.9796990239129868, 0.8798293511970823},
    {-0.48571063687774446, 0.09274755243254035, 0.8510701576011961, 0.14518854945407778, -0.2663879490572815, -1.2264181947059642, 0.46962981525920816, 0.26210316619189566, -0.41483360138324293, -1.0991953161693533, -0.5625966466272272, -0.10120664287611764, -0.682303246356427, -0.7236990047374542, -0.4680546162832645, 1.1365725705676757, -0.26021937349552865, 0.13547733114552352, -0.51829047818786, -0.5793683139607797, -0.15677831854062715, 0.5906120554591886, -0.01964359708157338, 0.31931930707536216, -0.6911770408515532, 0.011276546382103191, -0.21477393425371932, -0.0018697349251258922, -0.29084530392877067, 1.1221429393393263, 0.2117506622512561, 0.1470287323958257},
    {-1.852561062052369, -1.992445762054007, -0.4295191734123976, -1.7872686200006591, -0.9474982593033755, -2.3807250127140254, -1.6775243608482786, -0.09781533095299824, -2.5426873344425296, -2.513360575774687, -2.4712124459380833, -1.7873685984451784, -2.344564946921932, -2.34939899931333, -2.5966844985410336, 0.9390877151915163, -2.2846090919923565, -2.0323755992077603, -2.4817520547699337, -2.489991627712105, -1.8896859612444705, -0.8656806829639004, -1.4561748996037518, -0.7179978917517635, -2.5977458514592167, -1.6304771664548703, -2.2943217332606047, -0.8001973208655948, -1.8292965902998017, 0.09205472213442416, -0.7636114307895415, -1.7231609206669367},
    {-1.1436272888028345, -2.045198126881546, -0.6911179454841715, -2.0914132815197184, -1.58165354373219, -2.1860890280360534, -1.2567867769642291, -0.420530515131827, -2.5193209149163187, -2.2562791003937757, -1.89861177761937, -1.754043797795097, -2.256074522578492, -1.7753333865721848, -1.9080755774270717, 0.13091422342680017, -2.2764670255125385, -2.1568787748626796, -2.5310662085561724, -2.120492485030022, -1.9698566799387076, -1.1968372322463978, -1.4514561201143052, -0.7509560463866155, -2.2490371234375464, -2.4428008849549254, -2.8259021081178366, -1.3928296117630423, -1.5480584105466217, -0.4565234512698478, -0.4416427833201609, -1.0164995417313203},
    {-2.198303151750067, -2.2614532381910024, -0.6920364217727034, -0.8715918848910449, -0.16968842598697195, -2.3860905252410776, -2.0211656565164717, -0.5894193712117871, -1.3800804540402234, -1.7494451279603163, -2.0715107434491093, -2.403548389090104, -1.4754457520696431, -1.8212092839644947, -2.253821084904627, 0.058786634471601526, -1.1759404621990268, -0.6438281008671859, -1.251366671871794, -2.1819679225789925, -0.07435243661195697, -2.089805462458029, -1.5968018361876528, -0.9304758498609791, -1.2889110872777512, -0.601105567817869, -1.8522202448590286, 0.4432601039754537, -2.3212008018795247, 0.25252541431850506, -1.0528412957897302, -1.8942542418840584},
    {-2.1764535085844146, -1.8916763501782978, -1.1525893132916918, -0.6465872129108073, -0.21522070026765497, -2.0888244341703586, -2.1002905722086487, -1.2365408799303723, -1.2227975876567623, -1.8725181559474908, -1.843539520773769, -1.730302473467787, -1.646298371060718, -1.7405895851642537, -2.174915149020353, -0.06191123598689972, -1.3806569394039365, -0.8927104506593941, -1.3018671621825508, -1.7613670769767928, -0.7969512009660655, -1.6629076134121297, -1.9982195820404343, -1.5595414266570986, -1.2768927328434263, -0.9071496314096418, -1.623490372154284, -0.2681124283049339, -2.1072866925017335, -0.3191037068482096, -1.3953302788626096, -1.6996830372631222},
    {-2.177028954586543, -1.9881884883053027, -1.3309767499952716, -1.4306032303428056, -1.2520698396883638, -2.3902155250064996, -1.927139376773862, -1.7847142447969722, -1.496793102216442, -2.0204758920301997, -2.218806631224403, -2.2018370822446407, -2.0646179008668417, -2.3542291747759236, -2.351968874257911, -0.8517816529428748, -1.6868252309269767, -1.803161208674766, -2.070745492022489, -2.058305148012232, -0.7939537369882579, -1.9174129477973199, -2.006068162317479, -1.9253231012789414, -2.0485317448672085, -1.364609445613334, -1.867230076052413, -0.4579217503224278, -2.4075163812116185, -1.4382114711886695, -1.7722604676723082, -1.9841287664491467},
    {-1.3169159038851954, -1.8974122080977747, -1.1003908663834416, -0.8622278808042971, -0.9076226189656715, -1.8685068900890913, -1.4096675908044987, -1.2518694647513045, -1.3249527457434849, -2.007043770337488, -1.8279181737135097, -1.4873749022215295, -1.6235493080534755, -1.9575696923443517, -1.933126445829501, -0.1482360824536648, -1.5640773264487435, -1.619489681895249, -1.908519032411274, -1.8427497077942716, -0.8805711186572787, -1.4185690272919824, -1.2587659363305848, -1.2518201784101095, -1.7633271948371072, -1.1593743050124123, -1.7211223301225356, -0.3978280913146788, -1.8964061379418509, -0.9086082738905203, -1.448531395057927, -1.5898451370480988},
    {-1.811079496393308, -1.99700187696628, -0.7625602125586655, -1.052672699773141, -0.39545584584773413, -1.972351195206859, -1.2911706977685158, -1.3240521491958757, -1.3580613005517777, -2.0943335725579213, -2.1930735203803127, -1.4719286706331975, -1.708302165808112, -1.8870637025735089, -2.0056051397917383, 0.41040768853510395, -1.429519544303293, -1.2330834793248013, -1.576990346569107, -1.810817709220768, -0.5788567759009036, -1.972072624094232, -1.473853805020635, -1.3086768669550364, -1.5732953533948302, -1.4684553418650816, -1.6028165306495243, 0.18966702247245057, -1.8234441276408255, -0.45285557621609074, -1.6471519163626418, -1.5333027693974792},
    {-1.3966267665458518, -2.3973412979730226, -0.3157402133224145, -1.0908189815136593, 0.1663551174722008, -2.140107836179513, -1.6710994081571542, -1.003080721373447, -1.2989655771859723, -2.0639578098141347, -2.428079614208427, -1.5829010272110478, -1.2334616271864631, -2.0509657258970004, -2.1492379474873458, 0.011417220705825197, -1.497629557405365, -0.925443049825232, -1.685245872843163, -2.271771836826998, -0.7364536982772747, -1.6705009728754754, -1.6357620011960383, -0.9884196972629559, -1.91164788938707, -0.5878261454579796, -1.3861140253912865, 0.5601485016881416, -1.7156712327312065, -0.23010276343451852, -1.792882944420428, -1.6020694383434515},
    {-1.3028000695237114, -1.7865450813902097, -0.65797793403895, -1.799414324159458, -1.312087336334539, -1.9774405725750421, -1.280472033558801, -1.0969199407751788, -1.7575171674273977, -1.9588904950377255, -2.427022733003337, -1.3684363395419763, -1.8308101905680125, -2.3072763222398325, -2.0832785113162586, 0.328246997829363, -2.0744025780630686, -1.4222957853822176, -1.896093976252298, -2.25585438034454, -1.2804503143661803, -1.2526675298789263, -0.6935121668265853, -0.7991368324574154, -2.1430614907884267, -1.254234953003455, -1.7658119938714707, -0.7667693376300386, -1.3878774309541877, -0.47456151652908285, -0.747523702033381, -0.9505072833504197},
    {-1.9589598081020838, -2.042542615149605, -1.2419284715225223, -1.650042579252142, -0.755936996663624, -2.50479973061074, -1.6145093884317836, -0.919908914789421, -1.9912075475125364, -2.41990584085435, -2.7497629771852825, -2.1016054116170455, -2.0119952754842396, -2.3973704985211968, -2.7364035690472615, 0.08497794629480131, -2.2766704969771983, -1.7257821365408272, -2.3237011192524135, -2.70100531796665, -1.6454565314861787, -1.7625575076755426, -1.382014688737499, -1.2845967356854002, -2.1732332481844003, -1.1523222666921218, -2.1391571131956066, -0.6085839782606799, -1.5657751662171453, -0.4962766733782069, -1.2689049494674864, -1.5732766573709431},
    {-1.7275611275941005, -2.36238558325383, -1.1375596803949861, -1.591696601005051, -1.191996854707913, -2.4607298898913004, -1.812663848277335, -1.1067938279166618, -2.0616162408218606, -2.6467731879806475, -2.539314732774524, -2.1787133647086803, -1.970160791345655, -2.4732105175328605, -2.6443630689695015, -0.17023841919541552, -2.397445849448843, -2.1612879751783765, -2.2091720620387147, -2.695650950951032, -1.920472193788754, -1.6569400579020348, -1.8475183513029636, -1.2459368689831805, -1.9819480329815502, -1.3351362655934018, -2.2267647418497054, -0.13407916946873832, -1.8719152259881073, -1.0731923882425407, -1.2678663519741329, -1.8440989375684333},
    {-1.932587881921776, -2.0845233761247908, -0.4322466469878, -1.393532319962671, -1.2885093489551616, -2.2353875824847713, -1.6701272894712844, -0.5876634148521931, -2.0745003875929933, -2.5584307118150864, -2.6022376681578936, -2.0552802988989143, -2.0985675776695225, -2.4027973273798064, -2.589041780414446, 0.3045185218144072, -2.5798655644667137, -1.977356922656059, -2.19994110402746, -2.859445541441988, -1.6087360273150175, -1.4619186347944295, -1.8086803799723088, -0.8301687669926683, -2.445104372219367, -1.387834616123046, -2.34190987410722, -0.38621473294266256, -1.8654754671878069, -0.2194243814296827, -1.591695570820938, -1.6120175386486837},
    {-1.8459452266762053, -1.975249209294993, -0.20220209526460578, -1.0994968230529851, -0.1804263220740631, -2.6316067388581574, -1.6534982364126314, 0.21577831997832644, -1.8324788193688084, -2.415158233788174, -2.700950594040903, -2.0825888801329837, -2.058451139846583, -2.083916896485414, -2.6795079460670577, 1.123593383127727, -1.6696259986119846, -1.0532776859257778, -1.8164341429738442, -2.5372325687211847, -1.0853981857763981, -1.0192285548953912, -1.4758819107406513, -0.11534459600057775, -2.1749272904254213, -0.752217926953884, -2.0970202889334417, 0.5045290740953796, -1.6905102488162507, 0.6299448782218332, -0.6756599395371018, -1.6688870156217237},
    {-1.7853761400778954, -1.7599666338236306, -0.6480819865105587, -1.9237796672082361, -0.1867774319861849, -2.606144360709207, -1.8157372678762989, 0.24996810055182017, -2.54090446992475, -2.5174478389023425, -2.5312310766663484, -1.7268936149577465, -1.9637912887172986, -2.342020487004237, -2.3659517084389243, 0.9762070571136109, -2.0365565046108367, -1.2282154340354732, -2.1071315513268285, -2.5310084399959423, -1.3119020026077988, -0.5779765612897048, -1.3976793394153866, -0.09993537633290314, -2.199673089293623, -0.8883061393732196, -2.4910693659229075, -0.20780741112681606, -1.963045706518408, 0.9996777499481265, -0.5365715373648169, -1.7975441245090984},
    {-1.6083473928325884, -1.5783822028405823, -0.3766941758668991, -1.449309473287696, -0.25008596488963614, -2.4159472613812194, -1.3234955834337012, 0.14147374517898845, -2.1674648197042212, -2.2356910883710053, -2.574158036892208, -1.2318615959172505, -2.0410657660332694, -2.4806752394524603, -2.1748857218333835, 1.0141200609543362, -2.247534217661908, -1.702994564262057, -1.8972566070816, -2.186693195303158, -1.5170129180926553, -0.6898898835664488, -1.0667855115596867, -0.3381785490159496, -2.1516314594235415, -0.7428198820222385, -2.143099335790438, 0.15494415958529548, -1.41743659454486, 0.8355634494018664, -0.9810974714014022, -1.4556998230067695},
    {-1.907124825550653, -1.9713289487220624, -0.03224309238873856, -1.2582021254350686, -0.06886322716806116, -2.8278656508199957, -1.5913353474513527, 0.6028185950100332, -2.4583511838830514, -2.2227154742870567, -2.540454841794864, -1.9598643151814326, -2.178940778593348, -2.0746867607840187, -2.207552577567942, 1.6188459083177802, -2.2156819801839376, -1.243687023498529, -2.014476489166287, -2.474289555928614, -1.4134647051467266, -0.4600708867880533, -1.1823747962106588, 0.5226980755348533, -2.2946576895347794, -0.3914482973954302, -2.6902614308502275, 0.6029182721522355, -1.3933069919475614, 1.2524560257141333, -0.23667541676811057, -1.4041716664580715},
    {-1.4491429383749466, -1.8216131239704842, 0.07513570501311752, -2.173436645964824, -0.4706060898745143, -2.7237244210623137, -1.2535642223060897, 0.972700549966188, -2.450603855014834, -2.2787031846956713, -2.5602631432127607, -2.101199536871211, -2.5266888094519424, -2.139428549567021, -2.5805043887653096, 1.5187661463004953, -2.5122595329161372, -1.8813259307848296, -1.9543781273778842, -2.3578641277908745, -1.3791526738660107, -0.17004434339087532, -1.1339535049840144, 0.5766623956391034, -2.166221601700052, -1.2264341422007465, -2.9353074387080724, -0.12301037825804198, -1.4848108915135616, 0.7834752410527599, -0.32920004047001117, -1.4503991616200171},
    {-2.0834578825753556, -2.2494500085071674, -0.37029710067615423, -2.5582075316455932, -1.3071699636955072, -2.945206531859355, -1.93038508075871, 0.1201780130117297, -2.9693316633807294, -3.0190709620727336, -3.0981132652409267, -2.441291223991479, -2.9350489577226875, -2.7161717018237983, -2.7163968251607264, 0.5761899744370491, -2.5759199578893455, -2.454585131776387, -2.9899361565288376, -3.1416053041710743, -1.8793863405969613, -1.5906118361420618, -1.7605559115539404, -0.5361056906153012, -3.0771787371292163, -2.0779742743514436, -3.262622674642091, -0.9410209641558911, -1.9149373768549725, 0.30187996404225975, -0.8855691399535621, -1.897730938483839},
    {-2.144873866123799, -2.6572350014983357, -0.021452327273325165, -1.8701461202153609, -0.807139366409728, -2.976774300744723, -1.742917214375159, 0.5120941334896663, -2.6390140183100277, -2.7984153615594556, -2.8998806167934825, -2.261919259625906, -2.6066589668658753, -2.7589297843400726, -2.9638013308970974, 1.3329388127214477, -2.324881034238279, -1.7694833398713152, -2.7773631908125522, -2.9566657207743225, -1.8723070872342846, -0.9849470370234628, -1.900565699152287, -0.03560072136454302, -2.416164419983662, -1.1010024350073344, -2.7133339533514715, -0.09420412231819929, -2.2098959301858736, 0.9167144036721367, -0.415264230456991, -1.99957000889233},
    {-1.722005819269116, -2.19295293558065, 0.833940824627793, -2.177673145801588, 0.07420332135822583, -3.3041442741646114, -1.408127004034027, 2.102757997708567, -2.861882403136067, -3.084691017035476, -3.019854788550072, -2.202980476723971, -2.5636624352963095, -2.629166248432975, -2.9681622864499295, 2.5727959055348437, -2.2706545189401774, -1.3067361311721772, -2.5983875346450462, -2.9480885318190473, -2.0605210583100715, 0.30755745668143036, -0.8312676912179786, 2.0454641474028095, -2.62937426659059, -0.015085103530584546, -3.4094862013189515, 0.7214428085018231, -1.6851805100129533, 2.5212191881414876, 1.4591311502906956, -1.4808985147301517},
    {-0.8523768694295011, -0.934482343452605, 1.5171084965309858, -2.4682552758394403, -0.10115920674242468, -3.0828248985887283, 0.08187623736960604, 2.9355348598146738, -3.4849003562296197, -2.7910898887391578, -3.0917694024577687, -1.3031978196423066, -2.909026096627387, -2.72425462192461, -2.7419624651414547, 3.0111801655921533, -2.31552189931554, -1.823100637070802, -2.62283396204443, -2.9303422187788146, -2.393550075828827, 1.5858520910797547, 0.2866484273908326, 2.8380265294861005, -2.7646209514392783, -0.5030888694160709, -3.3846547255980086, 0.40788402932361995, -0.5176405608198883, 2.8345038080080265, 2.417467311523462, -0.3618729187593666},
    {-1.6880267731083571, -2.179566737766588, 0.7117513968396217, -2.287341643252766, -0.6350181737330799, -3.281326025698837, -1.0079392742790012, 1.95349950305563, -3.4052717916198296, -3.2442307826717163, -3.0294940372540538, -2.302394794760069, -3.105641440787427, -3.038375247498124, -3.119583213552748, 2.6397155966626245, -2.8734622406788697, -2.1242159937072134, -2.909451728609286, -2.9757793771408942, -2.533611666767086, 0.6695252135743431, -0.6678006010472192, 2.179602958035157, -3.2430691905138147, -1.2784148222915188, -3.336929997586737, 0.33069764937321644, -1.5332682083689164, 2.340946813261863, 1.1943498613017824, -1.0438198037810227},
    {-2.515168191328231, -2.838087717179972, -0.2991800356308362, -2.7176979471523013, -0.9165142693167432, -3.2824362825590097, -2.049845946891331, 0.48855953904849514, -3.2620354214695335, -2.937146698321617, -3.1695942771187546, -2.751074073350342, -2.851360526529964, -2.852169212998241, -3.054058779935494, 1.0813774755295438, -3.0108914787661445, -2.3436183723094324, -2.7369090889120375, -3.1526057351958983, -2.1663469434622367, -1.4302718716142746, -1.9661617850958715, 0.16190206514128716, -2.914557284424077, -1.6645874052981078, -3.2199409889906367, -0.48464450482018023, -2.257115132696839, 0.8133028498499684, -0.6372176567318891, -1.8840059666061284},
    {-1.407636443892048, -1.6586414355313772, 0.511781081795324, -2.984551378312215, -1.0484363245664607, -3.1845392825406056, -1.0574941061772754, 1.9731081458959745, -3.6844713416413826, -3.227106075720287, -2.97260320170667, -2.1389878906403292, -3.072625874388182, -2.789946376398445, -2.820297519736426, 2.3818690566642973, -2.633753081950745, -2.6618249028330623, -2.813566563919707, -3.146063047768249, -2.8167485602258946, 0.5699309632786447, -1.1433204075372034, 1.8014026118172812, -3.3504692782443146, -1.5288177587314804, -3.538377972525653, -0.1881054593209062, -1.6622223554220106, 1.9563403322846749, 1.5466157875386404, -1.4481731162052562},
    {-1.4023802264575556, -1.7991974280701593, 0.7996957292546117, -3.130914441281596, -0.9908969905519728, -3.008611960742839, -0.7888071976273089, 2.1313956221709334, -3.3529000125790227, -3.1174842349218492, -3.3944970195915936, -2.004963780659489, -3.2337786171875567, -3.2609816592671734, -3.2239898436271033, 2.332833106117423, -3.212189290778778, -2.6698528343957015, -2.902414481386724, -3.3490793682462736, -2.8565757745600413, 0.1519827827323752, -0.5452643083825536, 2.0565329377535844, -3.0526574572889564, -1.6806586757413375, -3.5553269176275415, -0.003415649167483389, -1.1444633384784892, 1.4875832115699268, 1.2724108615977814, -1.291913996866317},
    {-1.6067807196275536, -2.055515453361642, 0.5973580988420119, -2.940493089629038, -0.6927282396324687, -3.2445139552075415, -0.9891826061295403, 1.7821750400145464, -3.4743763051454923, -3.056008364824054, -3.2844558765160023, -2.4770336910215143, -2.9862891532447025, -3.2107641108924136, -3.2264992189966226, 2.2829882003067032, -2.846423800320031, -2.5018728251509645, -2.824599124280956, -3.0316433455535163, -2.6523955109931068, 0.24128987433003107, -0.9976141028123918, 1.8459221530257726, -3.0855323551927025, -1.662510646901858, -3.5945550419482304, 0.04349836525946045, -1.60735421503945, 1.7164795688851737, 0.863620615879878, -1.6804461013452372},
    {-1.559090582712884, -1.7584751580909137, 0.7667342349216169, -2.709870588127845, -0.7847392773477494, -3.06766947559239, -0.7428778120518997, 2.215242111717599, -3.468220800475354, -3.117086888628168, -3.05730480209085, -1.9188169587501442, -3.340495067880563, -2.9165082631176382, -3.1342014168265093, 2.8931791006043404, -2.838728756703202, -2.468788757565652, -3.009201968183037, -3.2241049790473193, -2.822606849407994, 0.49945530093833024, -0.6825567038446583, 2.2773187989971944, -3.283954578130839, -1.5903679131379398, -3.892531930441036, -0.01840538442513817, -1.6830254377411755, 2.555013758553548, 1.4277245309254036, -1.244734573282666},
    {-1.024527356203671, -1.4258994058567318, 1.2599438882523744, -2.978396958511503, -1.0558439842624845, -2.9737895536647576, -0.6212814285264796, 2.597810163918039, -3.3345201904707933, -3.129587730030669, -3.336536955561044, -1.8058693710134905, -3.0242599293334624, -3.00126883486652, -3.05090171524341, 2.863067856425503, -2.9998859366931265, -2.2931848801680066, -3.0120597992480342, -3.1847032406412437, -2.6120731690121337, 0.9909749834059256, -0.4975285232643065, 2.443327873170971, -3.195547723977929, -1.052308031945422, -3.742186637001516, -0.23813184377748117, -0.8851094608119247, 2.663027857277067, 1.9085935825852693, -0.623689861912491}
};

static const float b1[32] = {4.267933459111044, 4.247276351088052, 4.27491188171817, 4.338133048862591, 4.324422440322642, 4.329839597357402, 4.234369830527555, 4.359928394211136, 4.3309049227181085, 4.315886242285799, 4.280454413622402, 4.2827287229970885, 4.1159072978142754, 4.319351250906642, 4.29253550362695, 4.171227116866021, 4.362358424212166, 4.382568101958499, 4.225920343204971, 4.287039010621277, 4.3488161186867265, 4.309012670553217, 4.370133648661937, 4.408164156704901, 4.216803957161242, 4.341189030342363, 4.200173301727152, 4.510366607309461, 4.293504375442108, 4.322524755584976, 4.28309138701698, 4.248012322617949};

static const float w2[32][16] = {
    {4.165023427316024, 3.5189919056365477, 3.6918695219315065, 3.6222309231780994, -0.0928934257480695, 4.205270538849342, 3.7193213201656574, 4.008621309541083, 3.3442253225621, 4.148561393076184, 4.202691907240399, 4.034667563100209, 4.089971954052712, 3.5070514151651104, 4.196868663302576, 3.5686140675759828},
    {3.893405816888695, 3.2591883600745994, 3.951538710241192, 4.037037520358971, -0.36516943188791273, 3.7985972109630985, 3.436318477359194, 3.626723838283507, 3.1388714077962026, 3.4473278082684535, 3.7934006631362758, 3.870156306500744, 3.7490520421246685, 3.6156481100131748, 3.7528795234281147, 3.9359990264128224},
    {4.381317330309439, 3.608040074414776, 3.985627042311078, 4.149130737738431, 0.1019696380038592, 3.9071362759083517, 3.749929823186156, 3.7551019834903108, 3.282931174415764, 3.988840469899213, 4.02414726433835, 4.176524896536902, 3.7719053723699205, 3.7024174978889346, 3.6587430642505, 3.834689759790939},
    {4.216198011564667, 4.028095493025533, 4.254768185740717, 4.094595814999373, -0.046781647650505354, 3.6903905080806267, 3.891911588073032, 3.7929745991897574, 3.488050456160223, 4.158480869973416, 4.250631299668524, 3.8113834908469264, 4.219257312492304, 4.073303824917382, 3.7801352818085845, 3.8484082469715144},
    {3.7024834390763526, 3.8793612621749616, 4.212716036767115, 3.9500991061260335, -0.28610593249638516, 3.923530400021916, 4.1250118629371695, 4.2102007933153756, 3.67521668896879, 4.118455559014438, 3.9454117816816217, 4.144742116028531, 3.686543688643808, 3.6641804157150415, 3.908762204787902, 4.060891491756797},
    {3.9558276429138637, 3.877433467042243, 3.973074805696024, 3.6301363977407988, -0.12962284739757887, 4.015146539050712, 3.403061971777234, 4.135342878409013, 3.561495042129908, 4.298448830574739, 4.06278223707686, 4.103174952915575, 3.94743868045631, 4.062935635333652, 4.216022212101092, 3.977125025599329},
    {4.245272406837276, 3.9860517823871238, 4.125662731919398, 4.0989436167696045, 0.035412474428193924, 3.84131848001706, 3.4626976477524845, 3.750456534566075, 3.842077209251058, 3.8151798122526768, 3.700547580991497, 4.035818985642304, 3.953697300685221, 3.675461673827477, 3.764243768480291, 3.9969944079737627},
    {4.114950334665937, 3.83876130785531, 4.157981170703948, 4.0724191528866776, -0.14631471098620183, 4.240197330709912, 3.566427368842196, 4.061555984639908, 3.6338847317143985, 3.7855955194911814, 4.166285646976065, 4.331095068122786, 4.2914897987162695, 4.036355149564513, 3.874876341381865, 3.9082811757270886},
    {3.862381314044333, 4.160367153512561, 4.149595989467719, 3.834303589850913, -0.15833533227336577, 3.8166546919983992, 3.5404296794118624, 3.6520887319733215, 3.728183186761097, 3.7924523943172335, 3.666132676532733, 4.254358821768074, 3.701843683909973, 3.379760029116137, 4.105321292187209, 3.6199388908783474},
    {4.229126332975506, 4.141315209281075, 3.735358594622398, 3.7027612697201455, -0.002201828928987472, 3.8588712570022206, 3.6993680125255928, 4.003417008007184, 3.2779065047984166, 3.8357337178320687, 3.6268324088723616, 3.9903531591569084, 3.746523197261774, 3.887549873378641, 4.139723793097913, 3.7557275435126574},
    {3.7061361298774704, 3.994616427583001, 3.8216320934247263, 3.9445502719302534, -0.21799992407217092, 4.085657163483105, 3.680303118386305, 3.737420172985165, 3.576613385777257, 3.8059976618066975, 3.93461063844772, 4.209773659803988, 3.9997203514709523, 3.6396445349608326, 3.7173273144404826, 3.4734010669171274},
    {3.8058681824511162, 4.068059213030683, 4.264265294084849, 3.8826287595121824, -0.3580131100915053, 4.112564283688923, 3.5882814800606897, 4.094568005059781, 3.2490331377693744, 3.5955546259629556, 3.9988706584778773, 3.80645460655103, 4.028531740751789, 3.78054640232735, 4.064049882518649, 3.6501004826000183},
    {3.7371826140545314, 3.8314416027173226, 4.136303870638373, 4.048605454589032, 0.2885857223821977, 3.8345953239586446, 3.4861604786314606, 4.027415497893297, 3.430119264644906, 3.5193009701994638, 3.6799171171971237, 3.8798155856507357, 3.964150044783841, 3.3787044419705703, 3.554066804261438, 3.983973402414955},
    {3.6867048868717007, 3.45685127192474, 3.5620505292335527, 3.97965801539158, -0.1976532750635905, 4.212090863277308, 4.0220379340239765, 3.8976143737593674, 3.773049962267824, 3.911542102212272, 4.023645887037107, 3.687333661191124, 3.776799251653209, 3.4314031155033895, 4.1158489208455205, 3.9088696205904583},
    {3.723795344813571, 3.4926130247251015, 4.115253497030592, 3.553930630085545, 0.08176396944766089, 3.8448418446615706, 3.644138685937663, 4.131965945938521, 3.752997817798531, 4.024807756457495, 3.6942510320883146, 3.681694600169252, 4.151342665964786, 3.654546402903447, 4.049401173649637, 3.5259992322129854},
    {4.248902794171222, 4.177823812363697, 4.204553116904917, 3.9539706531793706, -0.38027705082709257, 3.8667519178345655, 4.0587160049166515, 3.864218734094793, 3.477646823077259, 4.19757265448042, 4.283960941211947, 3.9349278698685337, 4.067509866252921, 4.0644771482905115, 3.775584933262562, 4.197956261061743},
    {3.730224716594883, 3.9985347732642227, 3.5495965900673423, 3.8821751620494376, -0.3835114451006626, 3.6665435163890288, 3.8078241192829356, 3.6830993265802436, 3.1503495346056276, 3.5113186076512894, 3.9289564747052426, 3.6759221840040333, 3.5980447764577743, 3.292424760042872, 3.982997639824755, 3.7081054416069166},
    {4.007869068973783, 3.5499094045080897, 3.93670852565441, 3.59910982096284, -0.16780336197044168, 3.888329822026838, 3.3964493658581456, 3.6783335770431815, 3.472119473309529, 3.823074484089354, 3.733916424921042, 4.159573642085338, 3.5223959514015104, 3.950555527614292, 3.6867864716361836, 3.5334316807219817},
    {4.055974739071003, 3.5614226909144717, 3.7973207594021408, 3.5724758022868284, -0.22575155671816616, 4.003586095352099, 3.745207466274644, 3.8255098155855602, 3.329507869851377, 3.489705993462517, 3.8938801819944464, 3.927650790525043, 3.8994483173296435, 3.5906632273663477, 3.5215432882942292, 4.049163958459358},
    {4.145148556639423, 3.516014130220725, 3.7344150227326627, 3.9578771680498503, 0.15583764623463214, 3.839779518781439, 3.822891871969961, 3.7713010281667465, 3.808378294724888, 3.8660373574346782, 3.7166519684834434, 4.235644486342511, 3.7785148800078345, 3.6711239439142522, 4.145476237466568, 3.6370709758654924},
    {4.1027799337133475, 3.815171734959486, 3.985422238365817, 4.06681672565895, 0.2880084038141987, 3.8817526282788775, 3.493164684064189, 3.852351083203429, 3.658390205860664, 4.0063732805185985, 4.239641437677573, 4.224400308145465, 4.000372770878918, 3.6202209242043577, 3.8871170181777996, 3.8526186282115322},
    {3.510611327218709, 3.4757510405069465, 4.119486900239739, 4.211488813497778, 0.20134274873740501, 3.8598042986182097, 3.3255024245682225, 3.662765358018633, 3.3497930820072743, 3.6055995739994957, 3.743129193799484, 4.064310488753434, 4.2404620869797025, 3.8734007516630045, 3.93645441017237, 3.808679465805964},
    {3.8616123488478142, 3.9630334944761, 3.7543659307040103, 3.753133833511319, -0.07498624724449042, 4.223065445192143, 3.7408778066368393, 4.212392329462281, 3.649496373973811, 3.7956839288448228, 3.999621535682061, 3.878289395049371, 4.350186332352199, 3.8243519523612703, 4.2518721766165894, 4.001275524833043},
    {3.761066537251445, 4.010403876604537, 4.034013236781153, 3.922592808622705, 0.16790016186158752, 3.7640171574167263, 3.9090567013731863, 3.911939458811058, 3.7444194809441615, 3.9155474103882075, 3.9286135539434683, 3.656486838971749, 4.103631540707173, 3.8517912668884517, 4.065945082558503, 3.929652228572741},
    {4.127271485714128, 3.9356191550723856, 3.701140398386307, 3.831080250026589, 0.2616011889294742, 3.5621023350200822, 3.4868470966922414, 4.115034187993837, 3.4618416850481135, 3.7809336565046014, 3.9345518175523764, 3.5529233949978303, 3.944871075478344, 3.444727696566196, 3.8009250310551037, 3.501967910973221},
    {4.3417071107282865, 3.6271530608751075, 3.925695475985397, 4.142698636773619, -0.26317382999399874, 3.8205614546367284, 3.66332292615698, 4.261335526232249, 3.8400841642970533, 3.974005331015531, 4.2643136275683355, 4.127881442202828, 3.7702751113036164, 3.611173057258317, 3.790414535108501, 4.096590947915658},
    {4.060892347212393, 3.654348787025564, 4.005189484562219, 3.8238977441554924, 0.11227568184421137, 4.228109545310147, 3.919277979140281, 3.841281856560834, 3.7637822528252283, 3.5898205559845695, 3.9249635144438284, 3.7864102342195993, 3.775911427664458, 3.639699920175184, 3.671906486698822, 3.561408103385835},
    {4.007471525871358, 4.1027565840704945, 4.318057610202606, 3.814579016154737, -0.34596859089572346, 3.774706092154291, 3.6583737314406894, 4.176119405511852, 3.382778796129481, 4.428013498943992, 3.843776408904165, 3.9958206203954627, 4.0545051294650865, 3.723340927355306, 4.370096807415919, 4.015649943603882},
    {4.2003853619405955, 3.9644713271209433, 4.088109281304883, 3.9683024287186095, 0.18929841291313454, 4.106433495536015, 3.3331262363499135, 3.829702793576003, 3.549687996354656, 3.7873512777142535, 4.095161166715825, 4.0169706797404405, 4.18728876031358, 3.5023176677962247, 3.8419110076853267, 3.857808298572344},
    {4.04058251763185, 3.836414259186546, 4.175927150779426, 4.250272324231512, -0.2466026789076404, 3.80804013257923, 3.955624113515779, 4.356951977448483, 3.9055998211883756, 4.306696790422128, 3.941745989134819, 4.113382661120284, 4.379608681698202, 3.8921118736628904, 3.9344134449797723, 3.8472749951131293},
    {4.078613585172288, 3.659500292217946, 3.7241690834707346, 3.9457308570080425, 0.09056132464395053, 4.2384751476206874, 3.7381293987432693, 4.16414023447427, 3.985770973777466, 4.1213212699599735, 3.9002923409974977, 4.106924889731602, 3.9146306099018333, 3.820590719758004, 3.7785805868439506, 3.8541887914043986},
    {3.9263438952354597, 3.973525958962779, 4.263571404972045, 4.107873872040328, -0.3432473333654978, 4.21675613792387, 3.422199203148597, 4.10571434660331, 3.2988243909126145, 4.105240972077544, 3.5817722375840466, 4.027746837121093, 3.8124576466538023, 3.648182663694831, 4.1568942411379, 4.1315068220281805}
};

static const float b2[16] = {3.60120529116161, 3.6045501985229405, 3.615300360145353, 3.4703225260160555, -0.044262984826854285, 3.4891051117481084, 3.7171387027386844, 3.4702618786937798, 3.6562946529514075, 3.57941951167263, 3.4125233816283904, 3.5546053208400874, 3.5599821838377927, 3.6902867219204487, 3.303177969507576, 3.54715434735209};

static const float w3[16][12] = {
    {-3.4034510017758737, -3.3137790044718427, -3.2097097743568597, -2.7071153370003462, -3.1814048267058284, -2.675767119776265, -2.690119475770161, -3.342154318905392, -3.2415044699248345, -2.619100014266511, -3.292133306665233, -2.73204641734102},
    {-3.0309916261637837, -2.996189769813022, -3.13241056595517, -2.7742944048486406, -2.6754489977294043, -3.293287157566351, -2.8898497886515067, -2.529499844492623, -3.1989457625313613, -2.807654918407449, -2.727041492754336, -3.0988182349139874},
    {-2.8483402147325814, -2.6830547841794607, -3.1748057133361605, -2.6501605873733283, -2.7281745457338147, -2.784611148992304, -3.124343122395741, -3.2575193331840557, -2.889975468230239, -3.438036465018139, -3.3768564796628153, -3.441021350030056},
    {-3.413464642108641, -2.835217379885149, -3.2943216707878276, -3.1109229801954004, -3.1797034759645615, -2.7182582173887355, -2.9022017754931704, -2.6447438251255706, -3.2861368430640874, -3.246662230836409, -2.7061649131016625, -2.7096168130533353},
    {0.276125345256192, 0.2836674111339441, 0.1877902318442209, -0.14818394055569353, 0.40383525666677406, 0.2206697697586566, 0.22610674432707503, 0.3091312383814847, -0.1641096027389888, -0.06062362027152013, -0.1401397010509461, 0.33682516563993403},
    {-2.521260507651549, -3.223951359267323, -2.9275684268232878, -2.677618009710258, -2.695146279172339, -3.4226421484006355, -3.052386338234539, -2.7999485947367253, -3.1199246907833604, -3.3074757784287843, -3.4141778433269607, -2.7809943900977494},
    {-3.198471271810366, -2.8166440562577457, -2.4447228984264737, -2.8798732225682344, -3.073889597724578, -2.705554253630873, -2.8479877736967256, -2.916937800703941, -3.1742584821288045, -2.5187004744247825, -3.3012473429849227, -2.4166261687750974},
    {-2.9062604293109984, -3.3942798903450973, -2.5405769762565638, -3.1558290231412656, -3.395487480067773, -2.735953156355685, -2.6064165060874807, -2.879943584679102, -2.585943563789085, -2.7396872349512074, -2.636558447407991, -3.1979785113909482},
    {-2.477747650394994, -2.503341316904987, -2.8781456740687914, -2.837311614401983, -2.2331380266212943, -2.4636081212458274, -2.857312828133485, -2.641707466712812, -2.666034853481991, -3.1713838147421365, -2.906309540415607, -2.4400861256277566},
    {-2.597617131926548, -2.7629890154743184, -3.211018221953338, -3.2726870732710784, -3.2978277947708916, -3.1275430491141334, -3.396437008517962, -2.958675455707971, -3.2027805216964715, -2.6526837520101543, -2.6363985384523843, -3.1326250371686197},
    {-3.133274795875348, -2.523560121098853, -2.602693225922814, -2.962713980456951, -3.3808054785266193, -3.2402085020786857, -3.130539647433699, -3.1871505380022973, -2.742417431309985, -3.465266964151113, -3.453670382081061, -3.0129580993098997},
    {-2.782249807187036, -2.7688727766384833, -3.173445192670945, -3.0688279108350223, -2.807159626445423, -3.4711493511205735, -3.2265542190268937, -3.10056725920962, -2.7225148559728582, -2.941689096754052, -2.730774723419157, -2.925676608110194},
    {-3.0826660360803997, -3.065114084713416, -2.9112391668282855, -2.7950518113715375, -2.8800275063087106, -3.3545696142938275, -3.3041631063601278, -3.3738809139554644, -2.4469663347189705, -2.949428567693235, -2.740405169433958, -3.4459263468952535},
    {-3.323531464765438, -3.4805199586878826, -3.00000150525906, -2.9865201245517636, -2.8188959914857357, -2.956321267397457, -2.511337176895659, -2.5334055843447727, -3.096136482699923, -2.6079979379091753, -2.520810903462339, -3.469374848589416},
    {-3.350841481041705, -3.285999780319766, -3.162636115077753, -3.3549479589553566, -2.9127982238281334, -2.881501901268807, -3.0824961645920532, -2.904441880542346, -3.0661938876260746, -2.779793040387261, -3.1242112246851295, -3.0639469524293457},
    {-2.5588313786997325, -2.874718403875918, -2.835787989378043, -3.3042409765868923, -3.2487191150448274, -2.651760335416737, -2.811264407884136, -3.3740492684129575, -3.0597419822936027, -3.0897773723205355, -2.9262503759561804, -2.5658586373348156}
};

static const float b3[12] = {-1.5536185352078782, -1.263824841486557, -1.7361105328751392, -1.1799313021383329, -1.5020903716959586, -1.4033129732730891, -1.699922450916711, -1.5437051045879109, -1.2528567815917233, -1.609012296603387, -1.7034125347928024, -1.275586980115059};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
