#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-2.2890952305047163, 0.5018485121545798, -2.0504091731655665, -4.277649155592713, -1.4221144787761246, -1.7241187129592852, -1.3724471222995265, -2.878180004996873, -3.5861008761854962, 2.124735595092746, -3.517423195983533, 2.327708111050238, -2.206278100899001, 0.7178039094965853, -3.944820648767025, -1.4194122990524418, -4.651777809728957, -1.9764709689975684, -3.307217207966962, -4.123049840986168, 1.8220353398486226, 3.8073415797357324, 0.8111252727552143, 2.8681990056782913, 2.6189815847178783, -1.0410139951572983, -1.8898102426254137, 0.13693554944249237, -4.786321006837882, -1.927453458940323, -3.5891354612924404, -0.7600936500926728},
    {0.36584898773483593, 2.2140628434896144, 3.3819135303011265, 0.052117443151512295, 0.5879904441078052, 2.8009510835892613, 2.319022212034637, 1.6539047830680071, 1.5255970337686067, -2.657074388702651, 1.4185031630107856, -2.1231830387708603, 4.455902627990293, -1.2768813055050792, -0.22201006123170022, 0.6821427381267111, 2.455255329587401, 2.8875341678709443, 1.2352225744222467, 1.7201932228263255, -1.2392339558534462, 0.3538538818491733, -0.11653301114789713, -1.6978275125489968, -1.6484160809878037, 3.3224467187962103, 3.110767122519613, 2.7576883397392837, 1.7981110632762263, 0.7864701070887842, 0.8995714345942898, -0.5163558786943018},
    {5.177363305021318, 1.6660837354280722, -0.8543032947946955, 3.772308939730444, 4.392339006254473, 0.9953765533413619, 0.7876418756682788, 4.429834454479952, 4.811272506643556, 4.379528002566004, 4.2041668335969185, 2.6696337831829675, -0.5767060203421892, 1.310279983877563, 4.7534637924847445, 3.13012320602449, 2.653468719734316, -1.932266639702386, 4.560148807474856, 4.55792480269568, 3.7835660401898905, 1.1720061308811178, 3.295873933750928, 3.552923050663033, 3.0792439938634786, 1.8129736075793423, -0.7819228971668148, -1.507960742666216, 4.132835082487208, -0.06330271230774644, 3.648013837985633, 4.638107236900489},
    {2.7835321658921455, 2.4085096671785213, -4.418034987524428, 3.604233709316692, 1.8329127221482704, -2.842559517364981, -2.3898384585011163, 1.926339148895536, 3.007168316751953, 5.750465891192805, 1.4878134041772777, 4.296358022166687, -4.454305034932789, 4.4280901264275645, 4.718090601410594, -0.26527458061923354, -0.05873592569834689, -4.420017122720637, 2.5243608543831724, 1.6872957854170558, 2.2938097610758774, 2.0861319383587364, 0.6057794810074475, 4.697444436045679, 5.431515869145265, -1.3290026498087057, -3.8389600571853304, -4.6328540085298275, 1.0938621053873872, -1.3912628549472945, 5.143310826331311, 5.984715296197666},
    {4.753182299403482, -2.5345070459228745, -2.2247341995636805, 4.391669275036496, 4.0011655530348715, -1.9266524736044555, -0.15840229338068285, 4.502102903343458, 4.061654375107444, 0.3966149398677382, 4.552632159425626, -1.0694866238144112, -2.927935332088869, -2.3232873601154, 4.985098729775438, 1.9653091016063284, 2.729072477961027, -2.1910494387352375, 4.87467309378643, 4.208231088431465, 1.1993022314342663, -2.4567221004897495, 1.47436472487377, -0.14861734271658691, -1.2593932910292367, -3.062294735714471, -0.9787629091137362, -3.434024811414504, 3.9048170408397005, 0.41119727567094533, 1.2659296540441096, 0.8138618056782042},
    {5.229627859244776, -2.900217998226285, -1.3871286803236227, 6.344074853637479, 3.5991222397820906, -1.164780200502782, -0.7744406810257525, 5.002996266346113, 6.3923548576974225, 0.5525579398294334, 4.756971381307924, -2.1422779774440692, -2.3360271145380556, -2.4487914190360374, 6.108192978104917, 0.9610268962997168, 4.776821694730481, -1.3847710722643838, 5.558065878389259, 5.801376060477995, 0.0029658039402709717, -5.340032513913502, 0.23242698174599707, -2.2961034683834334, -1.6837530022165588, -3.4819907621720168, -1.0580971976197997, -2.3363976357913305, 6.029184667367373, 0.8122870700529154, 1.32430635942761, 1.1410457822744566},
    {4.593902219489149, -0.9944070274242918, -1.9169503542197828, 6.2673117445408035, 2.728265265677686, -1.940861251752725, -1.0595519453244262, 4.475685070028568, 5.709499365963201, 3.369717519997566, 4.591745349314764, -0.05194251238433994, -3.1727754345661654, -0.9339255688563027, 6.032006209185788, 0.9825807926981005, 4.746703844393703, -2.280886160269964, 4.956258180754206, 5.401731893204492, 0.1310339840321978, -4.6305504093194125, 0.25004362629159993, 0.5654473394042736, 0.4735419710801479, -2.185276618390277, -1.6101942527086326, -3.3981130907142214, 5.809171000992154, 0.6657832354344887, 3.7606675848449798, 4.260452939131665},
    {3.3355054786928817, 1.4030371137255384, -0.19802933542603493, 3.133240773802277, 2.6377651110108395, -0.598323206419098, 0.007458387708638506, 3.78238765745877, 3.0270537002143154, 1.7457208468286372, 3.310229752117479, -0.5464730461044706, -0.6478180346609493, -2.296377757027413, 3.0478499641845875, 0.9203159503812792, 3.2348102786104365, -0.9255561074182446, 3.530379998650584, 3.098410360673362, 0.4740053005608367, -0.5076644052839091, 0.5602608437964394, 0.851504430845803, -0.4901054430328813, 1.6906384802977632, 0.26693059608644726, -1.1219800586241842, 2.989097462501311, -0.08114511987475291, 2.092852672522859, 2.181526465058512},
    {3.5281680956055803, 2.456830359826485, 2.181038923445208, 4.001987924688102, 3.057849576780046, 2.968085474140608, 1.7844530273950208, 3.536841952740866, 4.53320968502589, 1.2193083099126918, 3.8652403392180705, 2.3239460004454005, 1.7101094692902195, 0.4634566161748866, 3.5969871777733333, 3.4532412414120444, 3.330083955525056, 1.5689858879883918, 3.459264466644606, 3.9235461154113302, 3.8639680779585452, -0.9304870710644939, 3.6599720531430395, 0.4236383506517275, 0.8341750421290619, 1.789006743686935, 2.4218797662399183, 1.163349963816789, 3.719622703094806, 2.9984977857197226, 2.3594084095052903, 2.9603410358726325},
    {-2.6546308155393796, -0.0021832695524803664, 2.924277930670116, -2.3630930234773984, -3.0920625704485984, 1.3785036693755663, -0.03389977363807389, -0.15045533606422867, -0.817782669291112, -5.058437278305456, 0.2569048945640871, -4.938655326892924, 2.832053841854751, -3.2497636771433354, -3.8038195700856146, -1.6413491969323577, 1.1849958449893108, 2.8259845813998954, -1.4680681921756933, 0.3181191171324532, -4.052515720591238, -2.4948368097016522, -2.3248087423435257, -3.260782276829291, -3.919786901804944, 1.6419966385914377, 1.5179625549097406, 2.146384425832409, -0.24434792291162896, -0.42548718583984196, -2.1406243584958013, -3.393650308863188},
    {-1.4313092871734312, -0.536455149842277, -0.8642236548144411, -0.5219169540137544, -1.917238139169555, -0.7246243444264141, -2.5688745578662906, -0.5810552027717215, -0.1034058658030218, -1.1201263217561503, -0.9253683414304205, -3.3165278351670553, -1.712268042003005, -0.5589638974370903, -1.4620518515046004, -2.4614550274581646, 1.720001857255266, 0.17839303306881338, -0.7758138042878341, 1.0699380137725594, -3.529292736808496, -3.0120566942455396, -3.0388746873209764, -2.042792672076309, -1.2344960956021933, -1.9116019039375756, -1.456493582911056, -0.7453992488859955, 0.8210288720319474, -2.369415539484888, 0.23643322622871651, -0.8377821055506642},
    {-1.1498433280136293, 2.852949400856819, 1.9866657147347184, -1.1823453522386456, -0.6047697872639921, 1.946349289479052, 1.0772844997419053, -1.6436622254939988, 0.6537727828302804, 2.6568937230662533, -0.7500692783656054, 2.8917505947132334, 2.282502944934787, 3.0853797033586274, -0.7907618234309081, 1.1298994671942837, -0.9205971420014665, 1.2521528512479803, -0.894302764767568, -0.3793824000110262, 1.956673855660417, 3.0625723747070683, 1.818690193113042, 2.6935092323284864, 3.3702496701232563, 2.859892249483888, 0.300488205492873, 1.563868152930566, -1.624559936713594, 1.1879278661032688, 2.26565706932522, 2.7639687795632493},
    {1.7168790423486842, 0.13319895196121265, 4.15283961484937, 1.1029335791108317, 2.193459639408801, 3.4002517007117867, 2.525299596843639, 1.5471598032009515, 2.119423522042198, -2.2672954039516786, 1.985419340838466, -2.033483264277268, 3.9326315844759696, -2.9009679723736572, -0.06525633671172425, 2.402469145055299, 3.3950392184471774, 3.2212264119480825, 2.034768501751887, 2.6544573661739244, 0.4644913722652929, -1.4776674503733997, 1.3322626451425363, -4.264960993393299, -3.501704217884798, 2.772997682792635, 3.537531017014716, 4.1916255590147475, 2.5550735060432963, 3.5047595673334984, -0.7605308486419203, -2.679276366815313},
    {-3.216456436534379, 3.760074141336602, -1.828246261478582, 2.1765164730229, -1.945927329966724, -0.9904708607373464, -2.3351295497343116, -2.8898727430279614, 1.356127427357425, 5.201082930522698, -2.1192986705475225, 2.77152417682902, -3.140556777008125, 5.555744846472764, 1.290143044782434, -2.0880383451703866, -0.5845226881208805, -1.7773694987008357, -2.471288218027665, 0.1957065365246695, -1.8342296461567011, -1.6314039603783341, -2.7654398113754515, 2.642956801335488, 5.207523269036339, -1.0129917118500937, -2.3820751822706057, -1.9858474632319778, -0.384885971894722, -1.1980490787731048, 4.34390079257333, 5.282751295619146},
    {-2.740803757220853, 2.9803774596532904, -3.3861821934558565, 3.5090177935067977, -1.2707935332022817, -2.8162382863947895, -3.043437844607694, -3.735407540374819, 0.24019018829368563, 5.674231819640627, -2.8335185622712844, 5.111953497950741, -4.180423961835466, 5.3314797590602065, 2.014809356931876, -1.6180479340530654, -2.2178721603362193, -2.9690701822339016, -2.5174984050741354, -1.2855898814744586, 1.2072715203791022, -2.187248242866814, -1.7529752493337873, 2.759585274686142, 4.365340578460753, -1.9037416933931546, -3.3496462402461145, -3.124466522143196, -1.3270126745472683, 0.43908170985866485, 2.820555146666771, 4.54058765598506},
    {-1.6566394629559955, 2.9814883710177016, 2.3286883830030036, 2.8012197566316943, 0.9959271540408575, 2.659163102354743, 1.6397951676189277, -2.5790452192793896, 0.6689263365518332, 0.5784163940839336, -0.680604789211346, 2.750673558367691, 1.711978927580972, 1.9357492706979658, 0.3951796548789264, 1.7359091418547397, 0.07358005455485722, 2.274612383842252, -1.632928829357943, 0.7790815359830385, 2.350611279236535, -1.800990220866669, 1.5804915881233332, -2.136952368557227, -0.8876933020858212, 0.8445131661164064, 2.2937643426208933, 2.751402786861, 0.8323566906578395, 3.398453441582008, -0.24158066697277608, 0.08916920607286757},
    {-2.3356070609346675, 3.118154822950649, -2.576120468294658, 4.2857809550107575, -1.3840602265012896, -2.890388213620665, -2.6027059170697386, -2.22863722313344, 2.5791534567510204, 5.74185377094019, -1.06106509482905, 3.2179061629536294, -2.8210766551953923, 4.92297234057489, 3.492826407903949, -2.365695434186625, 0.050474428249731244, -3.096107601521595, -0.907190903442505, 0.37602023912242216, -1.9873861011310732, -3.3598680505173313, -3.542764912011147, 3.0075803128708554, 4.393068674748214, -1.064080215963326, -3.0126821990973145, -3.3922714825818883, 1.1214413202204938, -0.46863822422934537, 5.450989053545623, 5.220722778543994},
    {-1.3321724574342309, 0.17217922347475456, 0.7038762992207589, 2.895775898396944, -0.5542753382076682, 0.4870717020763248, -0.5360992716254792, -1.01295536312361, 2.608320156185823, 3.079561556763663, -0.2392171870144519, 2.0489957934987486, -1.0504184951238167, 3.437282927237732, 2.8270133335928405, -0.3403611874397779, 0.37598605151226683, 1.016736450474049, -0.500271601338318, 1.2081617996056997, -0.4296459376345151, -3.3066874020043437, -1.9467225973573479, -0.26423647658695365, 2.249373613862307, -1.7193045261907067, -0.9700720284391018, -0.5763314954685606, 2.017823378294133, 1.8810797554861618, 3.027515715704467, 2.9735845334341593},
    {0.07751635654986334, 2.0637541737395733, -1.3140159450698172, 2.6781793466819144, 1.2453837478442393, -0.6887598126144198, 0.14303288412087503, -0.7768495676011384, 1.9059786721590555, 4.491438299358059, -0.11837985858547932, 4.855762202227924, -0.23855401305880397, 3.958324018352375, 3.577499915833395, 1.9099161805937899, -0.5258545626821648, -1.9786208965111747, 0.3230287248883526, 0.360894036969132, 2.299095514339228, 1.1401487764723977, 1.059772446662462, 2.54726028251263, 4.042202492474468, 1.765736000401026, -0.7103323849952808, -1.022934111610491, 0.49213067958164214, 2.348671635614413, 4.551377316100949, 4.199218663164208},
    {-1.9056750539968124, 3.5112851883292686, -2.618032225940144, -1.160647050584651, -1.9669844927296432, -2.9507465931587458, -2.7850161325961342, -1.3595852883525699, -1.0878299429916243, 4.56069122906832, -1.8178850634093866, 2.6067294138401, -3.0020880561911127, 4.013180417027055, -0.5986040205805262, -3.1678735996851395, 0.4247159095631948, -2.5796701424777497, -1.8923712822994811, -0.9131317935450393, -3.202382702805767, 1.462336342173964, -3.566293903000835, 3.6827939188860426, 4.068018283468721, 1.8241550094567036, -2.5389385257635624, -3.036352335951108, -0.9132985965286394, -2.870429421611578, 3.965606032526079, 4.687011763550222},
    {-2.879275460785042, 2.4120768545615205, -2.318096601234591, -0.1591840867764329, -0.9842330325423712, -2.1080606758794405, -1.7083891304579581, -3.3192286220510963, -2.307148138788439, 4.828625580810872, -3.0405954700844684, 4.931480598882309, -3.301287405315339, 5.33994430229979, 0.37799868366867345, -1.7304599267516527, -1.764497648654376, -2.642598979270527, -2.6562901896211937, -2.493550623358558, 0.010735767758059999, 2.4125460577398607, -2.683223339200834, 4.766739428617987, 5.259827447007823, -0.6905298679283465, -2.6229845884732246, -2.4579200085428257, -1.817368269726778, -1.0768433059270015, 4.052362615075075, 4.523412657304556},
    {-4.715962440085607, 2.0589919902842073, -3.814333149447025, -2.1679992652886906, -4.274126593325072, -4.70662158212417, -3.8820455598928247, -4.247612959708946, -3.4119379757379793, 3.9743895992776834, -4.206361580760802, 1.4803053976357092, -4.518912037694675, 4.872680422123035, -2.122369836193073, -4.3999890589433, -3.109076476841006, -3.9839577454127095, -4.491116616013135, -3.34738273407285, -4.80201372480042, 0.7479260690837691, -5.117215794521322, 2.966391086958627, 3.7235072240864966, -2.1006994731005015, -3.910539606202359, -4.232912505255919, -2.8238534709417022, -3.682378226880304, 2.834613257314034, 3.026704117552558},
    {-3.8718885684049544, 1.7096770818260514, -3.478992816538515, -1.6205061125899667, -2.81567946420368, -3.4173322828836694, -2.1357293580095775, -3.9912224170264796, -3.5435456370982314, 4.978378044548126, -3.965466593822634, 4.506783329586545, -3.1572651328025065, 5.862184895954969, -1.357909581031564, -3.0670609066512187, -3.385724639667014, -3.055601357513921, -3.2352625412115024, -3.441432193833623, -2.0293960901330754, 3.524069448015818, -3.408350732052322, 4.252932962948664, 5.056984788152436, 0.8548410782216561, -3.099739231082984, -3.0189066923568566, -2.769164800636593, -2.0799452446713986, 4.188023687134601, 4.1552053092056465},
    {-3.5006315083907436, -1.2469823048260709, -2.993528568409119, -3.6217299533344405, -3.9860050622877266, -4.4876464285009865, -2.241493247870067, -3.3847922598909306, -4.46677898618565, 1.0733270169221147, -3.1201684755243977, -0.19068121508393052, -2.887610630790956, 3.653666252217253, -2.772332641385352, -4.281227934557899, -2.6459194414083598, -3.2056832829939093, -3.6098079702542254, -4.163883769100249, -5.026407353513823, 3.8360852646307517, -4.8640454762487595, 2.854869276811048, 2.741972120769802, -0.29770910311075355, -3.075512541110185, -3.6508890106569893, -2.6759681566579503, -3.9294865643334145, 2.67938903921047, 0.6735334650888442},
    {-2.1980595673347305, 1.54794884397632, -3.2770345777820022, -2.1994695880378656, -2.8410135388166595, -3.715975364879666, -3.146344140584555, -2.0068072047783447, -1.9257381673821818, 5.799230347175978, -2.2181659587526403, 2.0354027156522916, -3.318358210406452, 5.540047373139295, -0.80100689608596, -3.375899347471483, -2.186770493121702, -3.35519688456332, -2.0960639125494516, -2.20942765048341, -3.3214491924481697, 3.79072863145097, -3.638329370355789, 5.704066333127662, 6.16146807502698, -0.32341378435148366, -3.6008388350677167, -3.9318534555210927, -1.8946872086290536, -3.838749153877944, 4.469845005751832, 4.507064265824862},
    {-1.8993888011808586, 1.0850347644474452, -3.8423808739379957, -3.9868868218475066, -2.6243753007632344, -3.1937057427914564, -2.771152911939381, -1.8726792580109732, -4.018318496337578, 3.7844443746083654, -2.659991204817135, 2.2683141527288284, -2.3363893024127207, 4.882865010946293, -2.8779717048804594, -3.463801194806393, -3.0942548829611285, -3.8131398059610935, -2.284486953503588, -3.8211086808826944, -2.328537611928168, 5.821683180111645, -3.1008954006607734, 5.531738184930222, 5.138083984260396, 1.565296263379886, -3.542453246218376, -2.723609448142503, -3.4829862034289416, -3.928953144668153, 3.4378120449920844, 3.2890941095211303},
    {-5.751102694178916, 0.027383760760948943, -3.849255492258362, -5.557686737741459, -5.573140592146349, -4.579489252200704, -4.46693036819084, -5.3533785593412295, -6.33705728773073, 1.6491363353928559, -5.67196369402898, 1.4727747263757367, -3.6540409356149652, 4.597829475624872, -4.566803995990735, -5.256928232309432, -4.9606200132262215, -3.5339110505007763, -5.4255544218804745, -5.848018234319799, -4.729017265567747, 4.0373372867506685, -4.77644519982244, 4.308997627624473, 3.7329316021359156, -0.9569350249749783, -4.4024306056569475, -3.7178561746388676, -5.839976467257624, -4.154151622086494, 2.2877341007814955, 0.7208865178840973},
    {1.3356930729889545, -1.217357401546535, -2.416444976636145, -1.7059665026080275, -0.3067471129672652, -2.9307989426442425, -1.450114037123857, -0.40976669918140984, -1.1775562705881297, 3.2755614004585873, -0.4807269769633009, 0.28176286954230934, -2.329860960484417, 2.088253957493065, -0.6060286928041738, -2.0084502498618053, -0.201730504608007, -3.1943179085764855, 0.8251425172357147, -1.3610228113078726, -1.4389853746282646, 3.8100350604419546, -2.0594230969611083, 3.9797533302315764, 3.2354405236327164, 0.652359933832441, -2.632557662100059, -3.39592054765066, -0.0409035749984834, -2.140122106828964, 2.6697024480430382, 2.152243226838886},
    {-3.552129344125178, -0.24364431675310405, -5.009738641367975, -2.3149964413409285, -4.275536884329623, -5.213814519015997, -4.90024153785772, -3.8612789339862528, -3.164888390119001, 4.668420151749945, -3.6208598620185324, 0.7239141860092745, -4.9827437442311, 5.125180843696308, -1.3725281789952672, -5.225683597568834, -3.1754867510214457, -5.142489434147215, -3.4644923915762855, -3.665543982390251, -4.658031406457754, 0.7156022026819194, -5.016806115841632, 5.168435612950158, 5.353297850591959, -2.6270160789303474, -5.6001154486658296, -5.219499621651707, -3.3736179973885645, -4.243416670027316, 4.069673301205349, 4.16100983953372},
    {-1.9205661449549087, -1.0706800647652328, -3.0870622341312766, -0.6122836674045289, -2.755173309767704, -3.3068054771274475, -3.2363063087492128, -2.558801726682088, -1.199488931194163, 3.2377197464311904, -2.1063194450943, 1.614845678526234, -3.4067210088938182, 3.6669364429562084, 0.12283396421116205, -2.751634276639255, -2.2260430927865213, -3.2475344587088224, -1.796272594510074, -2.615337231157678, -1.4774664138822127, -0.29777147816868954, -3.2383522160644, 3.7080230525900117, 4.01143700727532, -1.603208873865158, -3.7381465699233543, -3.896880052317104, -1.6915142096149183, -1.7586717317069676, 2.389230616945096, 1.9899356249919848},
    {-5.542061212192968, -2.76679665560942, -6.701663884024715, -5.550789973959149, -5.553222942827437, -6.761541836631815, -6.193206100296406, -5.477580990061757, -5.706189211952541, 1.4098143391438835, -6.310883752097855, -3.495029869844768, -6.244757744204891, -1.0646539365208842, -5.251181281564022, -6.552174517816191, -6.120249179616739, -6.361435528320386, -5.902659213608496, -6.207306681580638, -6.310398657523077, 0.24662612647752596, -6.056664975026072, 2.1204074227255014, 1.706906090921735, -5.611974182400246, -6.5073333412849355, -3.362419999436081, -6.142110531175585, -6.035715821140287, -4.464534056735412, -2.387068063175272},
    {-3.7649504590385705, 2.5943397097631866, -4.483347456065256, -4.292913913773414, -4.33685715148995, -4.746990592649819, -4.930956429342748, -3.5300829374470797, -3.1896383148706167, 4.7545510290071675, -4.210352928753146, 2.8797393996329195, -3.7649974192573965, 2.99247654820338, -4.164089890392145, -4.655707059833552, -4.8296974098279755, -5.274158502681974, -4.501202561723423, -4.107845964068645, -1.890039604679209, 3.213966193618302, -3.2453417801495004, 4.55126490281299, 4.39289291713972, 0.68186912026433, -4.89551176006317, -2.702387964464957, -5.1900819750045795, -5.193076582122059, 0.578490479846895, 3.6674556326213628},
    {-2.0004601474188792, -0.9306274921066839, -2.5982228366671327, -3.639167257519246, -2.832936915023752, -2.3865830619068436, -2.614531080273088, -2.1931047210134826, -1.6271960306502886, 0.9261762766157501, -2.926049588959371, -2.2616789379861952, -0.7685173625072135, -2.8157592434486034, -3.534701686026548, -2.8605326304061958, -3.357251511227262, -3.0886296541774994, -2.8919020372607984, -3.0541085188636514, -1.4640223937886379, 0.5608078647806518, -1.0641040457051922, 1.6370238392229017, 1.0571814334031249, 0.4304138612002171, -2.9751846040014005, 1.3833703287224925, -3.8917616547891716, -3.7386554033156463, -3.91494764678804, -1.0253734562693524},
    {-1.7256326260161345, -1.0935378043800128, -1.0589673705385492, -3.3645490612338067, -2.1380283532816193, -0.3196649202675536, -1.3195498266908408, -1.6524486683089084, -1.7869969492411135, 0.6872863226283111, -2.5904445298753105, -1.8682755721908408, -1.3411710102468335, -1.0286850781354544, -3.36362146024712, -0.8763541338436862, -3.2112650346840543, -1.0156702231957484, -2.550970901689443, -3.0871983917188497, 0.7757768795084437, 1.7184475389589293, 0.29918951214325795, 1.6138199158957491, 1.1977150645516499, -0.2018737129349654, -1.183306358453119, 1.912556132642021, -3.6886904370855556, -2.9994988181639983, -3.4282549065082373, -1.761205186494216},
    {-0.01332235755721315, -1.3531573035406195, -2.1341264282695076, -2.1398978899807504, -1.6683456023448615, -1.3922242431840026, -0.15576682445014423, -0.5053718959255611, -2.257025962509518, 1.8192742533613107, -2.2379979388861693, -0.4811803719493508, -1.5480340171260796, -0.5987220468827781, -1.6221846708245242, -0.7573918392161533, -1.445464702221112, -1.9550173009271903, -1.178967571100645, -2.3676956036691954, -0.28526363987974934, 2.9007808334403773, 0.2308634258200345, 3.310409775564475, 1.4396071213953727, -0.18381593699013773, -0.1395153837247173, 0.23131927387462742, -1.6777003056258772, -1.5811961282592133, 0.37049952039520767, -0.3219130809889053},
    {-1.2394767934312827, -0.9327459178440903, -1.6087410095094763, -2.0995032817654415, -2.060263186753247, -1.7270705413711607, -1.251958849905708, -1.266774045117495, -1.4626840517186934, 0.18627354698160517, -1.2409194861800228, -2.2845119404611607, -0.8578626163023709, -0.4504009603598397, -1.9975669760504016, -1.9364996147875029, -1.4092292457263182, -1.2309931335713147, -1.0255451121053993, -1.6842082431634173, -1.0905771486227398, -0.15747136661559977, -1.5332365023202592, 2.0858305707004074, 1.3997436352426453, -1.0287078903542237, -1.0789168884387241, 1.0055485312209567, -1.5525993918119605, -3.196626001325892, -1.6323316686624012, -0.9588717333283492},
    {-0.5830820602800877, -3.234414359589392, -2.383767713801587, -0.9142172511951976, -2.214732510197413, -0.22383096209694472, -2.3523892837777054, -1.58330587985554, -0.012132431628232864, 0.634983532271158, -1.9087310191484863, -0.6926206276550427, -0.2372513016240709, 0.19659132282254788, -1.9042391001887946, -0.5794766805213206, -2.7008394302963037, -1.6162568932840256, -1.735104654623389, -1.1217841768130028, 0.17456812412590889, 0.10125169159197545, 0.28149471709958124, 1.3329416525471054, 0.3720368890581793, 2.5889536554452746, -2.1429763482508775, 0.6169581226464159, -1.6852781494516478, -1.9634667468917537, -3.0856345415887394, 1.0658987711097525},
    {-1.1222018122830595, -2.970537145142885, -2.6628614640153225, -1.3429942385391456, -1.6621596599619821, -2.632449125806301, -2.3108797152093894, -1.8470230719756333, -1.7259778931886927, 0.4108590942988945, -2.090966921705075, -1.0685237329430135, -1.1224819109621658, -0.026414542662648796, -1.3438923424371756, -1.672100235635795, -3.0637204739580337, -2.5818445158746237, -1.3372638098286804, -2.496674044596725, -0.6032306378884273, -0.34897521911056245, -0.1552194365625357, 1.6032931083214024, 1.307957077059012, -3.5480439896159903, -2.963298074650244, -1.2908280173606062, -2.305329430538406, -1.2878378677054851, -2.5106378401822735, -1.9113687803554147},
    {-0.19568631109485632, -1.933475836992834, -3.45512528414624, -0.6246603583925182, -1.7704107018600463, -2.842357588766291, -3.137591913810116, -1.7156529896909571, -0.13066821073654525, 2.513441399082355, -1.453539548491865, 0.663752524016139, -2.1360150410151433, 1.2607582609352403, -0.6457476034834034, -3.127019571276023, -2.7319967442769837, -3.131264202271302, -1.479532883647215, -1.8058148655801447, -0.6852303707619158, 0.35459777804556564, -0.9405115100961986, 2.685662249189155, 2.851393782524668, -1.057772713998474, -2.637647827544732, -2.4637464713437467, -1.6014519678275914, -3.256153512574234, -0.10561593477732983, 1.4225037729544776},
    {0.5989690212232123, 0.7275447498842528, -0.3085012936031944, -0.1683078867571574, -1.4635259030890877, -0.2756166022005088, -1.217720396937505, -0.5544454850620186, -0.19195077808514482, 0.4394622094200895, -0.8435751500027556, -1.1982788766789412, -0.7969445456243616, -1.2968176217341891, -1.3444387463719258, -1.3357168938346193, -0.7024684317243517, -1.5960011358139952, -0.9660635910762514, 0.03428205888378564, 1.5409287977103823, -1.5653076802601293, -0.48942292543480015, 1.2928366988284035, 1.2972933170665268, 1.0324496313692964, -0.20636128779996366, -0.7263132086331691, -0.4943608295555724, -0.3164420031494295, -1.3580155257429676, -0.18083752889665586},
    {-0.044359175796857823, -0.3950564153822078, 1.2139479532603334, -1.3087205953862486, -0.5741643444705347, 1.2164168426398787, 1.153214055084465, -1.0049988429444978, -0.3931540677536765, -0.3196357654410423, -0.9293133598105949, -1.0707935575858456, 1.5850577216937798, -0.8753970901488178, -1.9042789980450971, -0.2973728850265789, -1.3180961933510869, 1.693844369212966, -0.6489891341658798, -0.673515498108482, 1.2723140666403152, 1.900970190238213, 1.9044122259352136, 0.5927298908575651, 0.056516044202206434, 2.2345308619704074, 0.22525217338193138, 1.7757620933944218, -2.383861384565313, 0.701277804902019, -1.2425728058508685, -1.0891911227355615},
    {-0.45257085827318333, 0.1075840797001163, 1.3290350839779557, -0.9243539600920777, 0.34360610873930664, 1.4249782753150844, 0.17510644517620846, -0.12822916443694965, -0.40741501427972115, -0.972993007176285, -0.8434680997115818, -0.8063169114278804, -0.08787378233838794, -0.7909904262965847, -0.8930030845272315, -0.22893760938331983, 0.15106555038434638, 1.6228636984478222, -0.5483282936932765, -0.9184233069435112, 0.12102622476496287, 1.5857296557503011, -0.3038230182414281, 0.3875543573583405, 1.288419302215429, 1.232950747865249, -0.9770390901153294, 0.01419032292774402, -0.2465300159798839, 0.1378209498515859, -0.2093088621650201, -1.3697808392394457},
    {-0.49068706394736045, 0.650521951962163, -0.9633346423570772, -0.22380179638298522, -1.5618839995270961, 0.24727891088018655, -1.806793107526215, -1.0458729593602, 0.5180480827473705, 0.5810536147714803, -0.3143073080747811, 1.4966294692956263, -0.22845636598137767, 1.8516988193611559, -0.003978525746459126, -1.0775614453692017, -1.5090237454125681, -1.0547590694624802, -0.9314851911264669, -0.4876789191552208, -0.37397004208452644, -1.6391353145838417, -0.38219447694668574, 1.255583461224431, 1.6936648982173912, -0.8096442083725667, -2.969012897193092, -0.7478044556650728, -1.1694538554555922, -1.0124304749265776, 0.7709091029050954, 0.5134224491673364},
    {-1.028104909451459, 0.04968616447173314, -0.9474104466121698, -0.5585661283451645, -0.5355290461787998, -0.01062409686331267, -1.0022545687181799, -1.1220883771333778, -1.6401431873009267, 1.0384400855233336, -1.6275562163032544, 0.5676745357863784, -1.7193249392933052, 0.6915176397541097, -0.3898139570818419, -0.29488608145346823, -2.580506918176389, -1.0158752175768133, -1.695985981322117, -0.8992532976902049, 0.7831770819756987, 1.6129709299826132, -0.05166557044154563, 1.3671225685405937, -0.1588740092125632, 0.881162773901421, 1.1378071060398973, 1.1740271803484852, -1.1186740799793897, 0.8558951340355299, -1.3966018765254518, 0.3802429295021527},
    {1.8815767643089507, 1.012299390227875, 1.1051665010761698, 1.2164153173754626, 1.0177936994641006, 0.7870359285540942, 0.2585462441472409, 0.4143575197219658, 0.6174381097618501, 1.113448504234249, 1.8757252248242153, 1.6108025817376925, 0.3156353840648777, -0.14209769813666803, 0.6360719165285164, 1.469328120741319, -0.023816291413768825, -0.28080463628989716, 0.6306950871333855, 0.6976012679099615, 1.903093103758521, 0.7699108570827073, 1.2472155712413853, 1.8291367980721813, 1.2694206382577728, 0.5644921549491067, 0.5108780821314315, 0.44848772695892886, 0.8965584202308295, -1.091009900320967, 0.7924606921025755, 0.3984298093797278},
    {-0.4700689376453942, 0.4157145381813759, -1.3268874811981977, -1.1664544093112346, -1.0094690731412557, -2.232454962005012, -0.22380169184488272, -0.4535705231297598, -0.4358863324862537, 1.2780201012338048, -1.1417845695047053, 1.2981304548369146, -1.919239241087462, 1.0554968311746311, -0.3547672922358966, -2.19228195998359, -2.539763611768727, -2.4127609468231377, -1.5307588375522807, -1.499799593023523, -0.06957014051336513, 2.274310980654305, -1.2930222680264416, 1.9393853527237506, 2.8032674300784315, 2.621789041715549, -1.938373529994606, -3.0568102624058833, -0.9265840569694025, -1.8307942975748734, 0.996954739349203, 0.6510911793589599},
    {-0.8044038995806332, 1.1135597440147915, -1.134630002359957, -0.9409460111321714, 0.08420359040172601, -0.046279444623172225, 0.4981770039930321, -0.086634751943273, 0.2244372719070527, 1.8558640783584919, -1.6325531317935227, 1.231886347224304, -1.6690044854552724, 1.9333524497765475, -0.7784362822145386, -0.259583016351334, -1.2445931824550702, -1.0084218660746072, 0.3040120129687882, 0.16225366058089635, 1.358645971929322, 2.316885375822147, 0.8897594543221617, 0.3056473135156499, 1.724130889895375, 2.242725341316882, 0.31068638056745723, -0.17051581037008973, -1.4610495836525137, -1.398155690246318, -0.36517444122132897, 2.4103466470554213},
    {0.308476077934057, 0.13343408753960936, 0.3364544497740837, -0.12429358327825328, 0.3923619147483777, 1.833759601914269, -0.21881299358648132, -1.3578778713841224, 0.5832531282369301, 0.7756172339093064, 0.15753845626221052, -1.7137759020595948, 1.2447099741645138, -1.9102681565664839, -0.17333682220868532, 0.14637695843785847, 0.9068995459342559, -0.9897288827784759, -0.5761013334814279, -0.279958631820036, 1.7968352914623598, 0.4455752607282753, 0.7450218721015491, 0.36437658880623, -0.07550475782753095, 0.8943526385244863, 1.4578238565346004, -0.24513540463401828, -1.263750166869086, -0.698243495974703, 0.12455738223905556, 1.289474349188067},
    {1.3232266730211615, 2.049107146023662, 1.8581951761194226, -0.5463637034471929, 1.0421314616966213, 1.7648235860383292, 2.0081410412162093, 2.871210541497672, 0.8053344725640187, -0.8605697134363344, 0.653390946318898, -1.355214182797592, 2.986937235740105, -1.6727069449485246, -0.9355772553802203, 1.4243455608559965, 0.26878399061865177, 1.4524268577064567, 1.2593540990733298, 0.7751249564742287, 2.1586394780918052, 0.08413663653422762, 1.8725215173240335, -1.1850192572088978, -0.49530204367679903, 0.8640451354749541, 1.006897601742408, 1.7804844665038058, 0.35874481378895823, 0.45669850826318026, -1.912194897086459, -1.6978143785134974},
    {1.2737455587971809, -0.29715683271223214, 0.8180598998496434, -0.7731119421504437, 1.1507002779888307, 1.567014325593542, 1.235436752574419, -0.12148597125809298, 0.6477413040253621, -0.24335104736150764, 0.8596916949941426, -0.7679834927498728, 1.3142834633686251, -0.8540661503272927, 0.47331881136299475, 0.5467638690830939, 1.101092732489569, 0.4067349932003228, 0.17130904327694302, 1.1325121182408326, 1.925960262533454, 0.6178473432308343, 1.0973848229944596, 0.0631759040476555, 0.14529501578369783, 2.627908862799653, 0.7320181588797137, 1.1427428259694405, 0.23375333721314287, -0.7223988236510394, -0.8020671421898593, 0.3282012142920452},
    {1.255702856082195, 2.7911481931804802, -0.03377417716267594, 0.527170155693248, 1.5978732372823266, 2.156389939297612, 1.208829461883071, 0.34401936730762867, 1.589838083385699, 0.9988131044497854, 1.7312197782780603, 0.7599151742779792, 1.322703187522937, 0.18843212620195052, 0.9593524490086823, 1.7907915336840208, 1.2210529102937961, -0.15003202506293373, 1.503118282860315, 0.8408552052994046, 0.8323613767483127, 2.1028491748310243, 0.5557450843431087, 0.9412790122726207, 0.8397414210753636, 1.2255921865698225, 1.630616702062359, 0.3249995254443408, 0.7784313120688069, 1.0507778318998855, 1.4113877072868977, 1.384393251877332},
    {0.14223102107182384, 2.938807094479233, 1.1769159785388539, -0.19818902469528005, 0.5354735821534851, 0.9252815633440027, 0.9648413958695716, 0.6464988921204454, 1.3127639630334977, 1.0355366486640036, 0.3157606216866108, -1.6822572008674408, 1.645768290439333, -1.4172006945039761, 0.4715197502943219, 1.144317648346944, 0.7883533894205378, -0.0529065811534057, 0.5018307822538594, 0.9372051959109344, 0.6223003112685211, -0.5114317435254317, -0.01086563219767593, 1.8702089627967529, 1.383971151047326, 1.912811710604427, 0.4748773628639882, 0.8425134263218953, 0.1773825050587252, -0.9443647845005283, 1.7403659233392563, 0.8472618512980409},
    {0.21904083179580722, 1.4966536095428298, 0.07376305359265718, 0.7388059455784679, -0.9610595517970119, 1.372185923566304, -0.6234159654151252, 0.25931204158416055, -0.19390128286293237, 1.0742909743062004, -0.6848800948169975, -1.211333223380407, -1.0615288616945449, -0.16684035668230687, -0.4657823279599622, 0.35493282800273945, -1.0186389621429492, 0.5202258013629036, -0.0820722949351134, 0.9429568689998123, 2.170129396995925, -0.15652483611609364, 1.3413621622146346, 2.0413216453859544, 0.42178132045408495, 1.7673558286185442, 0.8242839191341549, 0.2931314193112133, -0.719769817446887, -0.8743883915015189, -1.8803964594092726, 1.5248798559155898},
    {-0.9572651771303055, 1.050547675503249, -0.28255522593271737, 0.0642228346409267, -0.4097987248885388, -0.8875711296376984, -0.02672691502138135, -1.9300011449596848, -0.03567757200546061, 0.12298142255914778, -0.947329061968973, -0.05237958206146087, 0.13607187195650572, 0.43710204738053576, -1.2288145591790511, -1.6868821011304957, -1.2405999618165293, -0.7340879695201249, -0.6084230828327488, -0.20360478864248593, 0.5412922053126483, 0.33197799415286544, -0.3257714950524809, 1.0297786515185132, 0.16768621134688397, 2.6073088593150873, -0.4855610111531062, -1.0332133043995768, -1.2527320957723802, -1.4450797251126253, 0.3651065053422104, 0.5010275580000235},
    {-0.35711542307862104, 3.6216084259756336, -1.659198211736199, 0.8679309559355735, 0.47333676019523313, -0.1446480330032179, -0.5344960060928777, -0.17916151496804852, -0.4446873495397304, 0.9425026856027147, -0.5475717338213968, 1.9067312334501274, -1.0184591601310895, 1.327633846376701, 0.33239170854217925, -0.2472799860975496, -1.4490864680973428, -1.4232417176866439, -1.0149163381359092, -0.12315383679886817, 0.7802129062420581, -0.8047327611854649, -1.0970122675007568, 0.6655509499271631, 1.9719433411933813, 1.3235167769536462, -1.5969896114336655, -2.0943986777745547, -1.1374842026850875, 0.5575909984915821, 1.234272915544743, 1.2725676876607805},
    {0.9138212109592837, -0.13903084295477305, -0.565558443919944, 0.018644146786893637, 0.25648548168451235, -0.2107800483334195, -0.7061899636835216, 1.2858467392475568, 0.5262717207860843, 0.6115705335194731, -0.438503916002503, -0.9965831861684167, -0.22269884346475158, -1.4420136934274077, 0.288479550599499, -0.2547888445502976, 0.8957344780856165, -0.35104603074135765, -0.05032004840634214, 0.17736551032320358, -0.6934648914329877, -0.47354393004036494, 0.11932606893579487, 0.7323692710369659, 1.3031714653611548, 1.4452220276718144, 0.28018957600633676, -1.141991646831643, 0.707122404777793, -1.3684717942466895, 0.21369232040167174, 1.6012172373860334},
    {-1.0357218517790727, 1.7741595441357851, -0.47881690168176605, -0.5399571929342041, -2.141440977891112, 0.7961081303013476, -1.5660350504862903, -1.650835214864715, -0.5123620395304345, 1.1663903892209628, -1.2338574897257253, 1.5774905109111976, 0.04469563296411015, 1.9894723082404966, -1.163380189248804, -0.10870955832805351, -1.5106717399021303, -0.028303943195987086, -2.158601995455413, -1.9333860189338803, -0.18864740070704417, -0.29315199462708363, -0.7045429699150546, 0.27869886559336304, 0.9817852799353773, 1.8837912039925664, -1.1031625213210947, 0.8447306238993554, -1.1006166493633434, -0.09790649622937332, 0.9219679984293561, 2.1779553234790265},
    {-1.402416855646499, 1.12282449545204, -0.6212068119958369, -0.6062359055868415, -1.3011012137370146, -1.470090759073415, -2.087177663594525, -1.537917155589519, -1.6792847506268058, 1.8083800817785607, -0.3818346046707437, 0.5469090658151268, -1.125920578207376, 2.471853071969874, -1.4417085833452625, -1.7984260971499235, 0.06826138124733426, 0.13384922885165143, -0.6606063088441151, -1.3126258620349118, 1.328103939199404, 1.7551182390751878, -1.2937728703637434, 0.257130354529363, 1.703491778926779, -0.13664829519268284, -1.104839739708077, -1.3549909596227043, -0.5217749686834997, -0.9861581206701581, 1.015490745284707, 1.7621564183747427},
    {-0.2878381603237532, 0.2131616434164866, -0.8652713965876075, 1.1653534006880832, 0.5192593029905379, 0.14463947076444872, -0.07228657911188872, 0.16893315436967804, 1.1162955056029085, 2.405525543241655, -0.8666728473869865, 0.2559263694201083, -0.260706310121014, 1.9353805359867011, 0.5597121976729733, -0.810944910969689, -0.19420200860286574, -1.0307829110512838, -1.3661111228137834, -0.7513923023751422, 0.020907082593916774, -0.13633034473887568, -1.7447011577945855, 2.836920154995888, 3.8720490169782042, 0.2999950980546038, -0.7826833571786681, -0.08671152076741748, 0.2569733913636829, -1.463264308437663, 0.7393757275953391, 1.9829293413940845},
    {-1.3765784551703693, -0.4412462007262149, -0.9042689369400665, 0.3821375252665609, -2.7677339820633193, 0.6306988935861142, -1.1529196494773095, -0.5667404503281512, 0.6386479170746265, 1.6978826295120462, -0.38580570345111465, 0.8212293318897981, -0.1345114066400611, 1.4741285243919646, -0.07217963900110842, 0.15716652054776722, -0.620443742439018, -0.8639740501749396, 0.21028675028667707, -0.10857869788917474, 1.3538079323326369, -1.1556190729981335, -0.4504450906520654, 2.100147400840905, 2.728885732361498, 0.49559420119673236, 0.3192999890398687, -0.009165290141071928, -0.2878052808034454, 0.4365855799995571, 1.370779952448653, 2.0691328937545586},
    {0.8249387698794785, 0.07574682259010371, 0.01243908796663885, 0.7665541125622127, 1.0728789106226764, 0.36437032027506205, 0.38136589580502456, 1.436920936248531, -0.005280469773962101, -0.5097066663567341, 0.6000094811370141, 0.7592053687620607, 1.3338374272054223, 0.24149661543423268, 0.9831817595700658, 1.5669420262344662, 0.5637899831688641, 0.1414876011043449, 0.9051685276910969, 1.3265295146267464, -0.17720813872418292, -1.2302737170174567, 1.1183225042840104, 0.13577524149695347, -0.8446460083578378, 0.06248428483460462, -0.5472496559411643, -0.2505850807254454, 0.7172818897244762, 0.4741701456046692, 0.4664486414305927, -0.4322574300336461},
    {1.2337415142390253, 0.7586713175723648, -1.1878041801753976, 0.42799460218391705, 0.4145575984582928, -1.110409144490237, 0.188593024958775, 0.2625344435417859, 0.11283910512922364, -0.260593077195157, -0.40998640663141606, -0.4527618030317364, -1.05769605715422, -0.4274091644508589, 0.4748510349413806, 1.2322469874633324, -0.8257871056728457, -0.26770873259401995, 0.6857053620304876, 0.7778539368861505, 2.151058176627741, 0.22353580842079032, 2.614217050342127, 0.22161162105582327, -0.8427311833488068, 0.3332084601004285, 0.4217340390237758, 0.7237834620821998, 0.6945321649280894, 0.5300472536057025, -0.3023264403180687, 0.9638901282314901},
    {0.06564379071615427, 0.4050420210231882, -0.014535164331268731, 0.5369446246089653, -0.2377640430593467, -0.0476197977559482, 0.5850910473181101, -0.24206929590661774, 0.2563642521132663, -0.23362006168020294, -0.3475480704737562, 0.26491712360927666, -0.26366155614219583, -0.2256188527679702, 0.02944944305649436, -0.37975191309087475, 0.658355017165138, 1.4117328099303903, -0.29859369543513936, -0.15833806807604178, 0.04208741156051613, 0.5151866931772758, 0.3703281059433813, 0.21835461697022837, 0.5090057366275469, -0.5910585399481444, 0.4864024943111892, 0.658584248317028, 0.49884784376555874, 1.0490204046544014, 0.17198987713063577, 0.8912603899458132},
    {-0.22087499662125437, -1.020786518803242, -0.3868113770715444, 0.6027071000922195, 0.18178174113064202, 0.3340733256952584, 0.07358234191046607, -0.25452890858717886, 0.7115153239679888, 0.5283880603401012, -0.02777632228053543, 0.8843146471059168, -0.3679533212465983, -0.2056502062918756, 0.1381623544528264, -0.696147769601509, 1.5298620057637866, 0.3204630567358507, -0.06749928365458512, -0.6077329454283702, -0.2007958976239274, 0.6658411735350964, -0.9853256548276298, 0.06012947159817371, 1.2304132276782092, 0.23130851875778055, -0.42060419433596924, -0.06934071862162275, 0.7919235664655595, 0.5495637103327253, 0.8761139660484271, 0.4374460707608671},
    {-0.7827728842464803, -1.2453217612757508, 0.04427916470269171, 0.33631511937954395, -0.603704475708902, 1.0204307633926994, -0.26390866363395166, -0.6900970164859775, 1.0250287416649657, -0.2338695530843733, 0.05885695145233009, 0.756672221020802, 0.021007409695794777, 0.3029702329293008, 0.1614495823888769, -0.4350881145007992, 0.9619787364268834, 0.21862087086459145, -0.32716749553457364, 0.21759256876452657, -1.0440678011524869, -0.35988487831487553, -1.2952038357313642, -0.6719788750789867, -0.007628769640558537, 0.37666319312115587, 0.5884723861341362, -1.0666645224455222, -0.7930010701275672, -0.006583748997133985, -0.14612345308901423, -0.6338647451738522},
    {-1.178883447466453, -0.4194546030775306, 0.24303586190354587, -0.040979783178110026, 0.53522973315329, -0.3236516658924506, -0.8139014750274622, -0.5753291309063143, -0.3835398756935333, 1.2040186136903668, 0.7876328583259213, 0.4121310043996227, -0.4280156453739395, 0.6354864161948904, -0.2239830717548945, -0.8695774782632809, 0.8610787993949532, -0.7827396980874988, -0.03373329729535427, 0.045128202480834836, -1.4863510815114502, -0.8643133424501253, -2.289270925905845, 0.036973193580915824, 0.6244692177712452, -1.335427260244403, -0.2650523134568465, -1.403002629780302, -0.4967396493690097, -1.972015281589721, -0.055643653365637244, -0.5895936032616608},
    {-0.4621463273457146, 0.6347566263163437, 1.1199179569023707, -1.2472207647870868, -0.1594454459266804, -0.24813234477497517, -0.6044523776085422, 0.7321311656841808, -0.5360766742445475, 0.5630773377169305, -0.04982866906846898, -0.12306176585253521, 0.697184547582341, 0.6092855360898357, -0.4089070881966395, -0.7091079779579165, -0.3961671715804996, -0.30895453950547647, 0.0017324928841396727, -0.2968847737040755, -0.4917180154565164, 0.3400065940494808, -0.006907929736512343, 0.7952431584481561, 0.052665273026750066, 0.38921185107511386, -0.24033510283680648, -0.7874522338830193, -0.3553844802940868, -1.7076748200670058, 0.45977180254722927, 0.45701866884844045},
    {-0.7207680836460496, -0.951002842699061, -0.3554663490030077, -1.7371797934919724, -0.877968155319466, 0.2599614624422983, -0.9939839339101403, -0.5411851543062302, -0.6628714366369131, -0.3487500717653735, -0.7109024770314502, -0.1426651818327406, -0.24256899332949294, 1.5621097183568828, -0.17869636727797486, 0.14092051797704877, -1.6783574276038606, -1.0280849783887347, -1.3979099514058821, -0.19963966819565213, -0.878935918030363, 0.347998952748512, 0.24390031011846122, -0.44956359684025643, -0.8383257561780897, 0.2849911416827591, -0.015643952353576972, -0.057942591496046504, -1.1061820540840022, -0.8528185168511575, 0.16530896933689584, -0.8270728172860256},
    {0.18400117091865167, -1.725359174375634, -0.3981983739173506, 0.3654955127213379, -0.20980689995504137, 0.5418987902613005, -0.04927770646546139, -0.9995122345868702, 0.15987685072535374, -0.01369517271323381, 0.1749335598801779, -0.7384740008045578, 0.07036496450561057, 0.6040659512134897, 0.4691253501583719, 0.4361816642021491, 0.22986069814157653, -1.1519239891779798, -0.6471176683347202, 0.293254108499097, -0.625462575517655, -0.3927786883479946, -0.860686363524243, -0.5990553530527375, 0.0018837036732976564, 0.10370371772050808, 0.1940449608297918, 0.5162511495324463, -0.3299664014923809, -0.7651581419412531, -0.06335453918660507, -0.540097950631736},
    {0.4410111791087944, -0.08375429460169485, -0.0326465509996767, 0.809846259866518, -0.020316338212383787, 0.06109570608340705, 0.7327500807768413, -0.6318130767147301, -0.38903913587033156, -0.48509117392203366, 0.7379280308950547, -2.0643906935153424, 0.06989821743414358, -1.362934194209466, -1.047609318530643, 0.2882239890072606, -0.16892723335389676, -0.39764464062740257, -0.09305215671064752, -0.02704109031409672, -0.4511037448938837, 0.05742571450092802, -1.1650563526198205, -0.6804943088678987, -0.799222628314459, -0.5368332931510998, 0.7068379232429701, 2.1365547417894692, 0.8527473907778194, -0.6660776319613343, -1.6218304506370411, -0.8565835173313773},
    {0.7477351293107583, 2.0223629000705947, 0.35172814835958455, -0.17963825737403816, -0.24789502029342256, -0.1034820284559968, 1.4649944404436102, 0.49576301336175377, -0.1706401362138257, -0.9594673047064332, 0.3543247087815402, -2.1505667357260836, -0.32821480666797226, -1.8607194228201565, -0.9329551441700358, 0.7204262482788926, -0.2436210509259619, 0.668044083369019, 0.2836920262105282, 0.22185286085073172, -0.9295772845975925, 0.9405609180201054, -0.49693150831976357, -0.35063245567784707, -1.402310860789614, 0.5110442840193302, 0.4834658429045922, 1.0960546467975785, 0.27716257313171966, -0.4790871701143122, 0.1572104767728717, -0.8162211340629646},
    {0.9823514406852667, 0.9332963222578908, 0.2574199391251444, 0.0666793891681324, 1.1359242256476747, 0.5307410295172246, 0.8351296427931626, 0.6370483405986461, -0.11648795616837093, 0.8027085923144632, 0.18599755372386761, -1.809363853628699, 0.10118209279894463, -1.515974818079969, 0.2541632504889411, 0.2726981580787857, 2.0774724347096867, 0.6097319248862602, 0.5198895643616425, 0.4201420260575445, -1.4051382503791743, 0.9801709825940877, 0.8243950221770392, 0.21925667998227513, -0.35240683163190595, 1.1818725226903932, 0.6262238676707594, -0.6355359449087343, 0.8498712122234511, 0.10466937459391933, 0.9032854445046014, 0.2904916751633432},
    {0.03558205004953238, -1.6117453409572038, -0.8603388388835468, 0.6231787847904338, 0.7265739927366643, -0.46645277733025703, -0.6136047186182683, -0.24448188351784045, -0.051863505334415354, 1.0924046618405723, -0.07797227349504286, 0.0019625190689349682, -0.9529650229292151, -0.38389441103374666, 0.8363753748815294, 0.1723121446155782, 0.27160974578324254, -0.5130755846479278, 1.0023833012817513, -0.12799833752288936, 1.4227910034947655, 0.02176942276774998, 0.7118710764252969, 0.8842418068926006, 0.42058991324339884, -0.5699265218927042, -0.020171316683668356, -0.6036326347697727, 0.22673951959324393, 0.3658070922738315, -0.15279289143412725, 0.9172107500775651},
    {-1.567455403990408, -1.7254119227485143, -0.39338262149868536, -1.4874661072045947, 0.3225860625768796, -0.08156403076686024, 0.17629023874188227, -0.3877895109883382, -0.6437985955103711, -0.8916380824367466, -0.5654515469814354, 0.9821968174849534, 1.6188631188330167, -0.6925700638755727, -0.2347575746383844, -0.20041531321750908, -0.4796801465683022, 0.3121794643720084, -0.2851012779719493, -0.9489050031156433, 0.9329727027669185, -0.19672778882804404, -0.4958030917275166, -1.3488459595019708, -0.4161800148294747, -0.46208197214586694, -0.08686313675842884, 0.5850552289035083, -0.6367763482296437, 0.8045147503548803, -0.9823510151637822, -0.379168413670017},
    {0.42190300415096965, 1.1999264182440612, 0.6874087146854816, 0.45882653322071637, 1.0770755888936174, 1.527203529968483, 0.27606329992728057, 1.0936762863955194, 0.4689599786336404, -0.46432672241217077, 0.40041735963735636, 1.8396353865129895, 1.3825305163158477, 0.8135685110823979, 0.56819626126485, 1.5077185096171326, -0.2595791214447181, 1.1753676433405453, 0.053349817972679375, 0.9131289787231006, 0.8651034587850702, 0.07792553857177413, 1.813040053669225, -0.41764180609139595, -0.08174216628221558, 0.9052403185427066, 0.4039994623562555, 2.0223688443475787, 0.24408463949796996, 0.8952161362275841, -0.360020239375471, 0.7627154473202942},
    {0.8191838205464845, 0.9598853494854717, 1.3738937604281156, 0.5493378080062142, 0.9563446963395387, 0.6922614385413927, -0.01699806723831724, 0.6691085592418744, 0.8267536155365697, 0.063505898012827, 0.6064432990113281, 1.0794408043686252, -0.4300889705837049, 0.9054229340355492, 0.07301685997299427, 0.6189842040113014, 0.6260573069791626, 1.723663455351384, 0.06461021875965482, 1.0967400923284665, 0.5018005788287445, -0.09421334945436681, 0.7463011130701854, 0.0014702081760156868, 0.4050810143264635, 1.4120300785172355, 0.6196341836446082, 0.9255871451115997, 0.3306511279537474, 1.1676201409696938, -0.2649426966972646, 0.23100549571395146},
    {-0.3266853465899994, -1.2058660331239521, 1.021739170278916, -0.021902583345088898, 0.9702255330166654, 0.33008599819401613, -0.30477976744659946, -0.049240455833419676, 0.1472516628921584, 0.3327398742431209, 0.22575375476866585, 0.4769789506778011, 0.09809371575953527, 0.12488079889116349, 0.398921659910356, -0.9229081495129949, 0.6309852231264008, 0.1980842242149933, -0.35658834042334747, 0.041912283452280465, -1.2480533812997268, -0.397368752216638, -1.3067170150986134, 0.17394679630978233, 0.19235610834377423, 0.20894954129104573, -0.8113784090428076, -1.263641394146118, 0.1094753826129028, 0.7101424768552292, -0.9004113349539022, -0.45164041243193626},
    {-0.6993295607173218, 0.877683227908931, 0.6625431581290777, 0.517102811229504, 0.5831154200678106, 0.6922406055608603, -0.740277726867821, 0.08396668189787553, 0.42779043268180605, 0.8626791541625494, -0.2199877897314192, -0.16404725999283057, -0.1755681289612611, 0.32223562621842994, 0.19259908553190244, -0.13972265808069737, -0.39821159732926975, 0.2086350992272714, -0.25159491492269115, -0.05993376827959475, -0.06621732225191661, 0.8911947453021267, 0.5540660765125008, -0.14746191148688298, 0.8820280961128572, -0.6352111056292684, 0.10618058510319892, -0.6615132412368898, 0.42884049357728365, 0.2610314644778362, 0.2936950686139787, 0.875629082131558},
    {0.8235529716619606, 1.4762763506233132, 0.08492626684126516, 0.5082481343035983, 0.6930983065621091, 0.17409273819707802, -0.03031866157481787, 0.4928051259124195, 0.27133731480192286, 0.5861253821060135, 0.09033946649447694, 0.4734127868152155, -0.0623815922320285, -0.4408739671751222, 0.7006177632908724, 0.38481061583608234, 0.13773904055837244, 0.6243233425849255, 0.1353126722954763, 0.6669148823322735, -0.09302196163393865, -0.3938845749208839, 0.8086755381021521, 0.2694946747682544, 0.5466021034078332, -1.1495205617294884, 0.6771721241054802, -0.979866134456588, 0.6809586243793553, 0.7698060169541677, 0.8186893967248078, -0.2263506328644871},
    {-0.0683879205806231, 0.6662874477221932, 0.21910487178572274, -0.5338989833067144, -0.09169780049454865, 0.380205342617522, 0.06457806251464931, -0.39954028311630746, -0.9145492775676626, 0.06071279420321819, -0.47581670228773076, 1.9642542749436918, 0.23666463894392614, 0.49338890053394724, -0.2277136743537159, -0.16813187832586374, 0.06994507170011532, 0.6650347545756, -0.28856920257657565, -1.2984358381377157, -0.33909961786352355, 0.09367810905537431, -0.5091173026954597, 1.278556240178334, 1.662580484215246, -1.1162339973775595, 0.0773214225735161, 0.3451812847957001, -0.136983867876192, 0.6376861700870835, 0.8890717733141602, -0.46590145784260484},
    {-0.28832675797096097, -0.9698659533481078, -0.5991480811574502, -0.25331761611340997, 0.1391950659023132, -0.16281598421393945, 0.8033399370093077, -0.7295127565286283, -0.528851527074879, -0.5797748813401216, 0.21910941470683612, -0.18328467634241982, -0.7533122717890569, 0.3868874763918538, -0.5532031170924574, -0.5084783012122241, 0.14431977938277044, 0.1922809661109818, 0.10795921206334617, -0.5236258260260955, -0.004174676170905169, -1.4648834507462063, 0.15264859071572406, 0.3008585479731554, -0.9065850239488332, -0.794915174253194, 0.2533716131666112, 0.31210677001227277, -0.19821793143455485, -0.605099735254442, -0.16170862466367705, 0.2517570816174864},
    {0.3932398478121554, -1.0261425158057849, 0.21632129768728023, 0.03410920952409318, 0.5159129536022526, -0.26487834553523415, 1.1931797232955783, 0.6587699149703158, 0.30180590825397946, -0.4222905306560239, 0.44123185223791883, -0.9971705615385381, 0.7906739563469576, 0.26285943382757276, 0.22557809863015618, -0.7925993393841426, -0.30634236323902975, -0.6744390530561778, -0.2715310202979955, 0.7999614927933043, -0.3601419900964048, -1.4687040332485963, 0.22790647714638693, 0.384849610967954, -0.8314265557559635, 0.2817752067452063, -0.6678712736419807, -0.179920437390114, 0.14569718781554838, -1.0990323314298713, -0.9169394763847196, -0.43068050714346867},
    {-0.03813555861243687, 0.8833184066070201, 0.9119645158313319, 0.4261399334312608, 0.2895915850462406, -0.47015196295025985, 1.1177972423873532, -0.2766374022259187, -0.4147163828354668, 0.8061152473430772, 0.34981791208497176, -0.7238678366193071, 0.9395657230673505, -0.13858917484560798, 0.9633649837537873, -0.6588452247599808, -0.0005808773024809131, 0.03583618783249633, -0.3971464994579998, -0.017768808354287704, -0.3001300542388157, 0.21571483661400467, -0.5238054772038974, -0.5283410373072607, 0.7191800040814964, -0.09150960198160077, 0.6373506594667732, 0.510555704779695, 0.03520085982118314, -1.2682196768004323, 0.8229608660112788, -0.2062604341537073},
    {-0.5888500629205279, -0.693442733018738, 0.06480687292739808, -0.10368535585681458, -0.7552557575332598, 0.2738056928054834, -0.8929663287734256, -0.9143537639642053, -0.8567523730084047, 0.0819304062386217, 0.10768593721035635, -0.5607649304698301, 0.2187191060102467, -0.6173972731767968, -0.49483492424309944, 0.2189078136429499, 0.046090160324299426, -0.28578705587217434, -0.14343056893690065, -1.2110564876819454, -0.25996486130366586, -0.45038668241715424, -0.6511724707599353, -0.7705895392953197, 0.11101039830882958, -0.16073474020484496, -0.5600941802248465, -0.8573866580537068, -0.08050493081994768, -0.16699399485773986, -0.10321661199648463, -0.6972813604316005},
    {0.01464596855811104, 0.5462995178049654, -1.3856802289531722, 0.3803470535707407, -0.5435777722310453, -0.11152514977281096, -1.9075402601097635, 0.0361896147297313, -0.3854006452263824, -0.2751573773235756, 0.5145885813490577, 0.07789418195764625, 0.5985488109308276, -0.6929991967072259, -0.8071250097607829, -0.3222631565845327, -0.4697030379902055, -1.41350077093204, 0.5141389353396849, -0.3087015207857557, 0.454402399294385, -1.8885215240594475, -1.6515802920855187, -1.3564148216220002, -0.08217352157426666, -0.2939943926070816, -0.9356942709724693, -0.7206651448548026, -0.9170409322411941, -1.3122867826130378, -0.622745838561215, -0.9085425119236791},
    {-0.11656964453403738, -0.5118375811273521, 0.82107705010365, -0.6193607014395215, -1.1092048528716079, -1.070757175833301, -0.3229548657763703, 0.3332917578694699, -0.46578780866150826, -1.194599721099366, 0.09177893125638577, -0.28387893503341527, -0.056256755335907065, -0.7107490334493745, -0.4878071816130627, -0.616955099900617, -0.6797179343473827, -0.07338268384263372, -0.4410507573530228, 0.2873296951742422, 0.3699594418660018, -1.2714406029078253, -0.10104333186326689, 0.5232451721116351, -0.5419503724823151, 0.1806275146412422, -0.1702000962225555, -0.31739935194656316, -0.37098738227181727, -1.6414608851064905, 0.26506644478611413, -0.5182062447306265},
    {-0.1527351645375872, 0.6244697100675621, -0.19618747338067832, -1.188350124143015, -0.8404383070201203, -1.0360438830496153, -1.6400073802460151, -0.5925082247469623, -0.7784569729241146, 0.813266551067015, -0.6641727880134592, 0.07885186090491111, 0.12301108268700883, 0.2115818864508629, -1.9935865079560597, -1.342183834899058, -1.6421364656727024, -0.6169228010936304, -0.7824600367942572, -1.2732985392128684, 0.4505505149839382, 1.5184380255133618, -0.6861922664522587, 0.7163710573147494, 1.5498954887900873, -1.2437861919720992, 0.011705349867154989, -0.8456283622202775, -1.5821257027067392, -1.1843804267969278, -0.7135908545995475, -0.5682277340019639},
    {-0.06604690210146244, 1.5682361533021585, 0.3277166740370308, 0.1520977991844549, 0.9863723432575499, -0.3494541436001343, 0.5959722714743347, 0.780825586478049, 0.07813338442856138, 1.055700919024017, 0.6434887220290676, -0.7592551929585686, -0.8046636803134198, 0.9712078780655954, 0.1351029323161639, 0.11754081066148662, -0.24467404938700596, 0.09083523064805914, 1.0461392872969821, -0.1884379310019351, 1.006459045382898, 0.7782306173178128, -0.05016614219996751, 0.12968532540968153, 0.575574675751107, -0.39019737883386185, 0.16977474400619805, 0.8675927960261359, 0.7019328095698018, 0.7126520716660942, -0.6131284403070543, 0.3644826995818421},
    {-0.24524129460807628, -1.2891848537463284, 0.29635311832603656, -1.2972039591746793, -0.3668513203902422, -0.013188522151675899, 0.6022013605789048, 0.20246668143386443, -0.36899799770527714, -0.8952972386540368, 0.5799211948434579, -1.5321122421690987, -0.37032901546989083, -0.0697465910046008, -1.1974034707498542, 0.9192694079580584, -0.33602062811604355, 0.38694354826411836, -0.5511301669591897, 0.4274462138322437, -1.7667479534409662, -0.535859726203583, -0.05590340734001786, -1.1914912791450918, -1.252557860770834, 0.6215752159305427, 0.3251273028561264, 0.7186904972413053, 0.029111385971933978, -0.37815814918641383, -0.6016390934832756, -0.3815698067859972},
    {-0.4265202822043818, -1.0106101691449736, 0.35470525068780867, -1.1636803410109438, -0.8670626712053381, 0.14347888433485614, 0.0036210170741612126, -0.35345134200569, 0.5596939531130898, -0.5226779787284916, -0.37126828495771935, -0.7806211725048052, 0.26373568487951204, -0.28405664344217757, 0.6331342774457672, -0.7991442994662175, -0.1354102514564752, 0.6382355238512404, -0.5145028328675366, -0.618952257400975, -1.0554359950368044, -0.09697852335864124, -0.6323359167205532, 0.01506285222344922, -0.5875025905288884, 0.189646433439022, -0.7332904971669665, -2.021798367409624, 0.01683132531443839, -0.060617478122363344, -0.6794013540286449, -0.4330861154731399},
    {-5.0702404937309185, -0.5168647981343099, -5.7997194119690105, -5.094805898060386, -5.77288854783083, -6.171097024368413, -6.097466255523341, -4.627923498200445, -4.80305854090954, 2.0731802018853, -5.267628244326025, -2.5680222981901704, -5.269609971920612, 0.30808303631214284, -4.713293850791144, -6.053682346311621, -5.159732527387578, -5.707764324505601, -5.260647661139056, -5.069109123153904, -5.86610847403025, 0.8038051283394103, -5.869848012310442, 2.8361073351595834, 2.3123881612848765, -3.51290266263026, -5.618145309657194, -3.068834847050704, -5.268520211444508, -5.7424982010787895, -2.375348779814581, -0.30778180278863204},
    {-4.423821068853396, 2.8834637418686504, -5.443103810613646, -4.351801836410945, -5.413649238968373, -5.7079302116151265, -5.686624360950465, -4.401227398252369, -3.777055336831643, 4.186606420785729, -4.55640799519335, 2.144006353840756, -4.068626914090168, 3.2070598419666987, -4.4790536688698905, -5.55814120557571, -4.366344736761364, -5.569576824178934, -5.020350893581929, -4.59312491975265, -3.7531792626308613, 2.975672459213608, -4.857261627162909, 4.153905408695388, 3.9596673298692284, 1.3851463125548351, -5.187899616087653, -3.7248457101805355, -5.186924325617168, -5.763476430459733, 1.4918885045555346, 3.558984004062349},
    {-1.7374044275906422, -0.25941055782776523, -1.9690319828137341, -3.7516891571327684, -2.418620371140518, -1.5367339359895515, -2.545445232658717, -1.9761833751852491, -1.3394850047645037, 0.40991944689429005, -3.279024742864419, -2.17956945432455, -0.6719036195642433, -1.6081333670063018, -3.4235644146375157, -2.4023629563418885, -2.988934677343763, -2.0882114564932817, -2.9076702253516635, -2.667180538111722, -2.1649284022252204, 1.094059867723829, -1.0654331680487084, 1.0035612621850951, 1.028777310504459, 1.3985529307207836, -2.973383575687183, 1.3799639037575746, -3.437460463949244, -3.3275063436125296, -2.6154943159583888, -0.3577861443550634},
    {-0.870118070933412, -0.7240134213237553, -0.5085825008946848, -2.604865550999835, -1.4603435206079978, 0.01144768328912043, -0.5818760996959106, -0.9990305879581312, -1.2758146176414884, 0.3642291462202907, -1.8412619300779187, -1.738837957628277, -1.1344981234998572, -0.9684628659775821, -2.691262416619206, -0.15097922757859128, -2.8005212176049703, -0.6435277513656734, -1.8413655107917137, -2.8951866113288722, 0.8025828782801983, 2.093174439442776, 0.07834271506722831, 0.5579684410665849, 0.45680091249433696, -0.7770492124516852, -0.42209219603307524, 1.754888674684332, -3.109560125621245, -2.164859434345471, -3.3279833380644894, -1.9524083411306365},
    {-0.7587034324497153, -0.9030262620510751, -2.337834821879285, -2.257904253037381, -1.5612425726000128, -1.574520237785867, -0.743962404853299, -1.4540084964465427, -2.3925413502137167, 1.0571398996240304, -2.8130952306208923, -0.9449568781334703, -1.8843681194495516, -0.10152316166958322, -1.873175152765619, -1.812732730126231, -1.4475508795192773, -1.5980125636947353, -1.6944809598564146, -2.868060816332949, -0.38419421616776306, 2.4984903631869506, 0.14104074406624995, 2.0375553997866254, 0.45995892646050923, -0.40968348803567944, -0.3802469445867193, 0.6375491377204878, -2.4838204989911916, -1.6765597002046757, -0.7339998525276396, -0.43932118950269516},
    {-1.744741159017778, -1.6288828285432824, -1.7162680390443377, -2.2089974508459487, -2.2985192076783525, -2.498482968642744, -1.9723096366113035, -1.9939207371237118, -1.3337356254891533, 0.03468614594311152, -2.515114030844687, -2.8196254913681638, -0.9380538401037931, -0.15439874697385847, -2.7193900361887606, -2.410583625382057, -1.3977414172172675, -1.238219841779032, -1.7869958158475006, -2.331631830910078, -1.353994708880747, -0.9273363899357647, -1.7765166547991689, 1.3775219601084834, 0.7578953514492617, -1.7043625549500891, -1.3365804193871527, 1.186581662448215, -1.913147929004437, -3.3216857412523124, -2.959534983303396, -1.4719469932334341},
    {-1.1904984969376338, -2.637263597113943, -2.7327954433633805, -0.193025289289917, -2.5521101904612413, -0.7609505285103831, -2.145211172339832, -1.8921276986818458, 0.5115532459591576, 0.9094660924929203, -2.126879245210656, 0.6129022813694021, -1.1594029104824368, 0.8581169064754594, -0.8683217120078165, -0.26315050821367675, -2.10297916020764, -2.299553553098527, -1.850255354237525, -0.5340416580498051, -0.3877527150042386, 0.17962324091486084, 0.7010012887175955, 1.3741109150364756, 0.8187880084768705, 2.3913575631180755, -2.1017349438653166, 0.5251597617353682, -2.047025238084261, -0.9525386451372503, -1.9687626389785526, 1.4766771697649204},
    {-0.36741446698001956, -2.2258462579455536, -1.8351486705675082, -1.331050256107687, -0.9831457757663069, -1.7510032008804213, -2.3617023797839134, -1.0787072383846907, -0.8794089430967066, 1.5675776259616536, -2.1006395304504757, -0.7591371539085756, -1.425325188162655, 0.9328384027209513, -1.1420284376556924, -1.9167061435570223, -2.649943154044855, -2.5668280972828788, -1.0336956961691168, -1.73596530005396, -0.2543764973826676, 0.7414977149051212, -0.3535353847302036, 1.8379260298371356, 1.9676050980941633, -2.8856125682504294, -3.246024022209125, -0.24763300531308055, -2.2528131618399323, -1.4058324222030343, -2.252573050075013, -0.8006491061730445},
    {-0.613642796130246, -0.7475304231904796, -3.350110812471406, -0.5344762235113573, -2.3324971746118246, -2.7470394229818678, -3.7829494187003485, -2.850624895429212, 0.5425382053613803, 2.6064032908201917, -1.3572552687409798, 1.240701160217581, -1.6279840124664762, 1.5541027749480134, -0.6068688843025716, -3.5081555924939423, -2.3711593061495115, -3.5340922259006278, -1.6789538788369496, -1.7767130348095885, -0.9635181233911015, 0.4233561764485737, -1.713211954797807, 3.038529011572612, 3.008024023071853, -0.6156213589519824, -2.886722650653986, -2.6565696932671967, -2.2960676701405407, -3.509518221530915, 0.9815216992730497, 2.136263853126978},
    {-0.10954137610582479, 0.5899719636356637, 0.3981437563736963, 0.07162431628461396, -1.2593449328451465, -0.37978412939935047, -1.1560918141804786, -0.7849739925988117, 0.464686858385063, 0.21053177645268922, -0.5584718149145607, -0.6929153236946927, -0.2981089474759198, -1.2907247999407927, -0.9082528055112995, -0.9169281869800261, -0.1648961462892329, -1.0758575650043862, -1.0640838617264101, 0.14247317407629473, 1.5656486712979092, -2.4140256082367775, -0.3886617772155971, 1.0700617198224411, 1.1398369177292615, 0.8261121193589154, -0.09315897533158084, 0.09055951350065364, -0.4094845560157942, -0.07129535607938432, -1.3898072364693739, -0.3270624463258853},
    {-0.4453842196651775, -0.7990822592479627, 0.2336448046492799, -1.3722322416131842, -1.4206480858255446, -0.2235334817702889, -0.2925729591347471, -1.2991091307770162, -0.5776568862858239, -0.38521558603483763, -0.5253458135611144, -1.2937697289617904, 0.12884297272761877, -1.1363391577337307, -2.034746964510242, -1.4127602519997984, -1.3057219331726198, 0.7073048510162513, -1.2594583048525936, -0.6862146519777961, 0.5270759213916251, 1.062180481704053, 0.20327771566837977, 0.6565509657734592, -0.4112638775148199, 1.9538322930265546, -0.9328151971271671, -0.35486651436392763, -2.4159029968052974, -0.25351060041565754, -1.312216601835834, -0.4321552318069088},
    {-0.5973793828167434, -0.8176648648272845, 0.9507387801017231, -0.6642932257840358, 0.18768899035743683, 0.9416213904273016, -0.19136712813875073, -0.011228847322133056, -0.7577037899912057, -1.2570352238365514, -0.5909056481762593, -1.1997375712833316, -0.7009024792733088, -0.5473721713569961, -0.9658752751838988, -0.8932917355235112, 0.3723166122517078, 1.6595733780965327, -0.02165331407561254, -0.8551631493900207, -0.4080718122087561, 0.710223942336622, -0.727626272308704, 0.5990395012348642, 0.9390506624761765, 0.5645835890716646, -0.8632893073146557, -0.5968474757655519, -0.15890159687744052, 0.4878794622087438, -0.30314037369199986, -1.691990734493711},
    {-1.348754480523159, -0.5351485716232015, -0.24583394577444376, -1.3605362059083888, -2.224099690477101, 0.1242558834525979, -2.3830732733130007, -1.65005931295682, -0.09423201262359159, 0.023101550158803226, -0.26404417029435373, 1.0019784714462403, 0.7899744226074488, 0.19410763741999804, -0.5984904859178022, -0.9059130260238405, -1.3268716699063146, -0.30395978867195916, -1.596339860007706, -0.679517176342132, -1.0192310369026185, -1.4736519808706914, -0.4682741808376799, 0.0928526259256368, 1.1354117808655468, -0.20156702644332858, -2.962530753226054, -0.34001515060647, -1.7195519598410502, -0.7510874943510094, -0.6048089335613523, -0.6425200142829682},
    {-0.3867400471444849, -0.046646092828631774, -1.3153596860955683, -0.34768018169778653, -0.5788980054367726, -0.25692198928529403, -1.449791947065256, -0.9989437992804896, -1.3361213865055308, 1.155742043900562, -1.0238982165039534, 0.3650543935742073, -1.7672108508360502, 0.9334120627028664, -1.0310194754888335, -0.7263875409873585, -1.900183446797942, -1.592330636845006, -1.9749441695616172, -1.0392486678324295, -0.0721966826792779, 1.397888451266352, -0.6440254126702902, 1.2503205084056557, -0.3204970328508109, 1.1163435741565002, 0.0821121375696742, 0.4559360924616076, -1.3251043929994342, 0.48516420982720243, -1.728611709843469, 0.7615181448930297},
    {0.1733028181960893, 0.5104985257809734, 0.39936555176954486, -0.1597326191515423, -1.0849583727779077, -0.4582223482246666, -1.5675075296456797, -1.154467243881128, -0.8366509587604024, -0.043025177268075226, 0.7683040565814654, 0.8574574787894783, -0.105121207360498, -0.544503677001987, -0.8749249027103213, -0.5169823242345079, -1.2290898494929772, -0.7682674538052714, -1.0706242244100845, -0.8266605658103372, 1.066135382742496, -0.7718490099803734, -0.01942145648344987, 0.21707114878138997, 0.41159851806486847, -0.8968167598971399, -1.2714631243516656, 0.13987716417893598, -0.7636027412254268, -1.4188230228516343, -0.9139726490480747, -0.6202333779521172},
    {-0.9925658783091978, 1.0720604964898865, -1.6525891788341462, -0.8732309360302334, -1.893815209161176, -1.8046136604398715, -0.40671825821874824, -1.032421513759077, -0.36371554062350575, 0.5620288871446077, -1.611890010386914, 0.79160416526943, -1.5901072706006545, 0.9147648713192641, -0.9249799303749534, -2.3793736305617266, -2.0795875101624786, -2.1358270754355906, -2.1910946723972113, -1.622642448521258, -0.594654418560364, 1.6659924296412463, -2.1024932675917314, 0.7581304891806472, 1.497972706189702, 1.7875702296240017, -1.6277907983321762, -3.212092600768681, -1.3910275172289268, -0.7505997602820369, 0.1276344384863642, -0.42895085410426415},
    {-2.110942561510869, 0.9788298890034467, -2.1646247756705055, -1.8131860867705354, -0.8373531681599105, -0.9566757681540691, -0.23077989274490476, -0.11920873509544908, -1.0195656308792702, 1.1615066117357529, -2.3936814441992373, -0.21631466272306812, -1.8816167182941832, 1.4964807997936698, -1.8268257003932509, -1.6131984950426161, -1.7812814495607054, -1.2384345625336945, -0.5578422252047801, -0.9963933616369572, -0.19712247991620874, 2.4667980206536204, -0.32932398882165914, 1.234496829197657, 1.3050548654874425, 1.3456021123974413, -0.3345187889605168, -0.8273627233756121, -2.6527741922828443, -3.0655284501757394, 0.03122213921778466, 1.2140090963971775},
    {-1.0424279906568463, 0.19454584777597222, 0.20285628686711032, -1.024799260116544, -1.5020856829848521, 0.6865388519598512, -1.1840180448407582, -2.4172956235072824, -0.9136683340952629, 0.2816564718270472, -1.0722091040770192, -1.1573970941202092, 0.9661446128731477, -1.0570737368856276, -1.11002543020804, -0.5412144390497909, -0.14207210300471088, -1.288427597281213, -1.8735273268505015, -1.1043692640930907, 0.5425750783521486, 0.9780218998086423, 0.05121956797441257, 0.10836280171502227, -0.027161455192347358, 1.0681953982558225, 0.9603650031376589, -0.6463163334595223, -2.1174664648927157, -0.9710807078378595, 0.13545467439568343, 0.957127368953323},
    {-0.5472694044370187, 1.183294664872679, 0.4220841377076052, -1.4673786338894976, -0.24625380510400866, 0.7951734347856289, 0.6687172563626447, 1.3503242472221644, -0.6341383119338674, -1.1575321548137778, -0.941549161998696, -1.8642264513079732, 1.6378054234883013, -1.0484000892912293, -1.8578081119657408, -0.16887801917591974, -0.35708662705232386, 0.1328118185710342, 0.00077678303939682, -0.4615517673395784, 1.330985173695332, -0.9424803386127885, 0.1405259489932866, -0.8031483636242875, -0.566314691835938, -0.7459674244095786, -0.2994311518242973, 0.1403058205754998, -1.1971921267779313, -0.46956500078842217, -2.886350606848566, -2.404615902248695},
    {0.13699574808502793, -0.5938467240079498, 0.3598550766969248, -1.8205618450320538, -0.25590033719043764, 0.47093380612433705, 0.4969333304271359, -0.1818044541477173, -0.9825212539605447, -0.7459821092985903, -0.09299625852432301, -1.724504881955021, 1.31833730793992, -0.9221849163135435, -1.2280678757652184, -1.1811086774770225, 0.43956487167246455, 0.041118310912207794, -0.8450562071471289, 0.13503565547012453, 0.4845343616140057, -0.2581495803821596, -0.025521907286404685, -0.12495684271176821, -0.32692891633021026, 2.564097251023062, -0.11994337693350812, 1.0984251248644055, -1.3924672051469371, -1.806167202684229, -1.421632570720596, -0.6070764919868429},
    {0.0869741729390118, 2.235315832785557, -0.5981595876975213, -1.0580882664367242, 0.7406661900476368, 1.3870262004218643, 0.2095964974334735, -0.2079689769774868, 0.2938587509679184, -0.5483033005896935, 0.5054289457395633, -0.6969731009678453, 1.4927050587582755, -0.7586961898351186, -0.5279371797200881, 0.6323933244280385, -0.1671958503971164, -0.824325113984414, 0.33857006808595635, -0.43333923057287643, -0.6061178402471817, 2.2725687657102145, -0.2599749659941853, -0.04639869193074776, 0.15671457754147322, 1.129751309669243, 0.9716962200885743, -0.08787955758123478, -0.2874132879003498, 0.3471993402952471, 0.5783773358324285, 0.04209303489660598},
    {-0.34421303512106194, 2.9051378705941193, 1.5272315524479159, -0.4746242927635324, -0.2602532709747905, 1.3888972585207848, -0.006590128268682198, 0.5683401322311983, 0.7456958509580368, 0.6974013533757688, -0.3166388972935684, -1.8853264429163892, 1.0892721458715635, -1.4792520687078152, -0.06129370572181926, 1.3096391764953041, 0.008472303920389578, 0.006318283275827327, -0.26330481873910755, 0.9653532419367657, -0.1763725336909409, -0.1812607610545642, -0.14484328665175736, 2.546804787413292, 1.4762533293999234, 2.0261527064082094, 0.964189659453243, 0.15946633740561753, -1.0583738140650698, -0.8570471284721669, 0.7396805413625183, 0.4069697203783975},
    {-0.8981131767648882, 1.555137808289747, -0.23006068410518538, 0.17137391787656867, -1.1485665182422267, 0.8342023232109711, 0.12299627630142769, -0.12521253324814455, -0.6107094046167926, 0.3196881944870402, -1.5831477626261103, -1.4118476008789036, -0.2702464281329767, 0.2057959210129873, -0.9465197144024624, 0.19291824441229397, -1.1959558610824514, 0.371255654103293, -0.7429818537080722, 0.5859379558463704, 1.895827915328263, 0.35169589980302124, 1.0797310256962172, 1.9661867350596658, -0.3569078947654321, 2.2893536969239228, 0.9019984084969946, 0.5816119168404574, -0.25206960892558733, -1.0759943883165408, -1.5502605000584782, 0.19024833109447403},
    {-0.2430371705748083, 0.38140643761235105, -0.025228378692720686, -0.6062356560101455, 0.11452041878916447, -0.6850339557940371, 1.1482720501167318, -1.235814254315236, 0.43170112119525217, 0.0001696956436341676, -0.5426389656149646, 0.4176132237367642, 0.9997833473686191, 0.08793339137370992, -0.9580195091911018, -1.2680638109762683, -0.6268810461562262, -0.5322346320569262, -0.7192392144138476, 0.25303556012400785, 0.5588507423952895, 0.3512849032971442, 0.004382514283018269, 0.8223340939127911, -0.5519095066254963, 2.4632104709038787, -0.25554209105609, -0.933607505734094, -0.8591846043130011, -0.8573871797896352, 0.7217177032766295, -0.28621005034842173},
    {-0.22994833828614628, 2.8544706179564407, -1.661817381017998, -0.007971921046861622, 0.3127879011425311, -0.10473298388938289, -0.10927562990981171, 0.17811529271090826, -0.9204929582949488, -0.0037307414544210313, -1.5768664592791548, 0.23390865693476767, -0.4892723272178247, -0.11490438486605743, -0.7747145815661003, -0.2619765109209107, -1.879832539036851, -0.3106555382729798, -1.6059392502149081, -0.570947264181482, -0.497949521802046, -0.7876967688094094, -1.2766097457476395, 0.4212465570865734, 1.2476330994171174, 0.5783945883186478, -2.121693890691495, -1.9423435473731265, -1.6149530804338592, 0.4353421847985242, 0.008439748805897566, -0.13619470010546175},
    {0.41080849263725094, -0.13228902481511062, -0.05496737526181337, -0.8330129612799406, -0.33012353029917885, -0.5728058939702121, -1.2044142530414184, 1.0217590876186267, -0.11434667414346436, -0.08933732411276187, -0.5342234462947125, -1.4474944043441123, -0.8874319060115848, -1.5821962268864715, -0.812320716765625, -0.6100083411815367, 0.20843678582883868, 0.29487310797138505, -0.3612178041451081, -0.28253077723254855, -1.417162946698578, -0.5738687588097349, 0.07842271328667665, 0.2678071835522669, 0.7141371918656775, 0.670221894708074, 0.529953863992234, -1.1106625862295845, -0.12338601230155895, -1.5045683374927483, -1.0430891992305467, 1.0546522983930717},
    {-1.9364472938089257, 1.7833852862003665, -0.579100962259456, -1.0311592693465073, -2.533451301031662, 0.4651546671936259, -2.1045872311276317, -2.329406492740686, -1.4369448242304306, 0.2657533436213429, -1.5644171591084453, 1.1944374005290261, -0.0737858865071279, 1.4351691823402994, -2.397773201431494, -0.6308592036475963, -1.8305158061634508, -0.056547275221065826, -2.8038108554402164, -2.3301934613925517, -0.9020514834143285, -0.08316197789020333, -1.0812057835236368, -0.15924471730101586, 0.28390559003697974, 1.6656831298661232, -0.9644781636731945, 1.1387116254523648, -0.9539811276816134, -0.7899938135639906, -0.014379260286965763, 0.9776522760532129},
    {-0.9504677912152512, 1.0658207062892973, 0.24799187688656105, -1.5462582665622295, -1.3404964226726221, -1.3211481923293629, -1.9575316260272047, -1.074101359557096, -1.1273984209830368, 0.39597797255136435, -0.42567931928293573, -0.3384985118925944, -0.4797411716986126, 1.4801939965162845, -2.2935248465504694, -1.7777453944119421, 0.413207206692973, 0.009586258132289107, -0.29580519720425685, -1.064710183170814, 0.5430968389415235, 2.339789291892696, -1.5417797827373365, -0.3196654756454757, 0.9861405084078644, 0.20174516430864473, -1.0544267594014873, -1.4463991805166543, -1.10130623632781, -0.5967564953040896, -0.0835632145440613, 0.3924406473662848},
    {-0.5200317431671327, -0.34276319182972986, -0.7887281222168223, 1.221655491991294, 0.5267178635826262, 0.13307614176215055, -0.2702095262138259, -0.4052860347259802, 0.7934379169180671, 1.101457305783455, -0.9144257184076162, 0.34786080401880376, 0.40493004926653886, 0.7062899603869544, -0.4237826970437469, -1.0856523508059113, -0.661686802429515, -0.5547204455365999, -1.7086486042252091, -0.7393630143359177, -0.6713993923692712, -0.7835586431175176, -1.8680902285182772, 1.8672377632261477, 2.192608922955464, -0.03162461440994488, -1.2405080135559472, 0.36837443659421065, -0.10710906515162108, -0.6025829994956238, -0.2809863223405881, 0.49097279430524843},
    {-0.8253851798584243, -1.08507869948415, -1.220637022287916, 0.16015381870772452, -2.693469595670629, 0.2788861402798589, -1.4952099815772997, -0.6520570838972277, 0.30952987168938323, 0.897857731611891, -0.9396875798571385, 0.4409067641305997, -0.036945628744514056, 0.5832762617681189, -0.9207378043500564, 0.27923605240947497, -1.4176459861777113, -0.3264272276093577, 0.11649722867784873, -0.7191949037234485, 1.659250396952991, -1.0759558527202675, 0.024085957422530915, 0.43728457074965227, 1.8987096353842823, 0.7700108206275743, 0.08491184249376926, 0.3389996818227449, -0.5179103332587598, 0.0720340377799084, 0.3063555755375857, 1.211214368002984}
};

static const float b1[32] = {7.688106447303528, 8.083708497708674, 7.745056570264048, 7.847211151258891, 7.670934995191597, 7.857946846558146, 7.741938221829042, 7.862529087101652, 7.945067331115475, 8.053728922127128, 7.811154957407579, 7.972379779629538, 7.70859503930389, 7.993661219797665, 7.725714554957585, 7.80833723318914, 7.861614484908459, 7.778644066534873, 7.756864318764135, 7.887160447611277, 7.83728937921767, 8.037255799234305, 7.82985247913279, 7.968453755995897, 8.08598483024045, 8.123057547641615, 7.849637637220139, 7.797042462065042, 7.902327798986792, 7.6842506218537725, 8.12518002961706, 7.9903189319647305};

static const float w2[32][16] = {
    {6.2232251969229715, 7.193936222527422, 6.815828472190886, 7.052530175859667, 6.901100443145723, 6.750853703193344, 5.37352219857327, 6.407833790435413, 7.428523024133161, 6.692929389268992, 6.558795083727308, 6.778771801680925, 7.0458964353633, 6.926128791135662, 7.206332840886151, 6.89761049988342},
    {6.467420301651888, 7.08634448901194, 7.026645620528445, 7.034018204314981, 7.262419830771128, 7.242525647326709, 5.41708073635191, 6.611778380578107, 7.215577818423269, 7.398210964563032, 7.220367764198669, 6.429267087095144, 6.750723873788514, 7.462238386420264, 7.051817727762951, 6.93687315521286},
    {5.954322801360423, 6.783391515849353, 6.507115570472338, 6.9504866385319675, 6.862254899593971, 7.1436458236735465, 4.992436441725297, 6.608888098528139, 6.747712574142355, 6.467005367315275, 6.423967037544464, 6.277369275588806, 7.186713556687095, 6.707618923298345, 6.242747372199719, 6.886384684958103},
    {6.706829094983004, 7.434681304624211, 6.889386152330529, 7.090240713134016, 7.298407470849967, 6.840498852710388, 5.418007650020361, 6.828497404001282, 6.78907273086337, 6.997971541712317, 6.982920621928846, 6.058960936277406, 7.118182567649039, 7.103962453297635, 6.822961917990961, 7.095238266535183},
    {5.879944912420539, 6.394460537721511, 6.493551746445075, 7.320719960202728, 6.603915297448472, 6.861260299269166, 5.280940183954142, 6.3086003508034905, 6.8446536062906596, 6.274425052068526, 6.61138942414951, 5.878192949967904, 6.980814733929715, 6.73611743090862, 7.043166146485559, 6.9788014924697},
    {6.160019934259927, 6.713781101467204, 6.760217198258244, 6.466762602119975, 6.920351027340086, 6.8296375028313685, 5.133117843789298, 6.748595009968111, 6.664108199528413, 6.636806978508315, 6.183103571602969, 6.435695626645781, 6.796218567572365, 6.642482890738069, 6.030453521891108, 6.558996171220652},
    {6.32131242068328, 6.893655434824676, 6.485305579493834, 6.767310454014826, 6.760495315095362, 6.904689414037987, 5.328517489748181, 6.419510187184582, 6.836852891679106, 6.996694389902915, 6.9322596967502745, 6.444870385101765, 6.741816273846975, 7.0547466928474565, 6.637803108128269, 6.6217383353127754},
    {6.437609937782738, 6.770885689485349, 7.296100825692014, 6.9951634361602695, 6.829353735250429, 7.107327968434789, 5.02461904758039, 6.25344293617087, 6.739532087503498, 6.964205968543382, 6.694839370567225, 6.03727772067262, 6.921308263632227, 6.64878350297353, 6.733984351495317, 6.854936881691151},
    {6.553251933619885, 6.7733151642170775, 6.785564146140854, 7.403103714299985, 7.401408547911673, 6.533997631348436, 4.8323920863135355, 6.737567545266416, 7.3954387287415235, 7.145425632563746, 7.33554896942568, 5.863166287930576, 6.691613067857045, 7.169368795177707, 6.957575881182561, 6.5279987373352695},
    {6.565475327886979, 6.85255669440146, 7.289975958460282, 7.053601365228906, 6.633446253868164, 7.193916874465157, 5.651195586260323, 6.707028554400297, 7.319956443896907, 7.688804180021024, 6.8904405630521435, 6.789271010415506, 6.964162626930286, 6.946581514841776, 7.319015093573591, 7.2190361679167205},
    {5.946477069926722, 7.152827764393278, 7.057966367091933, 7.040790910534133, 7.397508702887622, 6.43884733846755, 5.063337255574132, 6.538704342049673, 6.950486234901807, 6.9286387808793615, 6.728391900331254, 5.9695544136705525, 6.46275086941348, 6.797458155154396, 6.564792601600318, 6.720253105914409},
    {6.183622308435497, 7.492709174937078, 7.31848059951429, 7.039879009518319, 7.435900988699019, 7.078846691568111, 5.743216418953368, 6.8613864257328405, 7.538792254043853, 7.3459685360501314, 7.338510772719602, 6.810565969962214, 7.078749757887619, 7.098751632896203, 7.086665832230702, 7.739216521166755},
    {5.825292664091642, 6.861166506348858, 6.904779452869319, 6.478683003532624, 6.450475422390512, 6.702780030189467, 5.1711237418735045, 6.592413960539267, 6.843543674200123, 6.80820222173468, 6.263702302269436, 5.99413032509936, 7.1265549685336484, 7.259092797433715, 6.6416458799889115, 6.463236294920374},
    {6.463060015988703, 7.30643046695055, 6.742884806872699, 7.411036156892573, 6.915625937851783, 6.898548249094394, 5.455614087453829, 6.8566200930032535, 7.044479276986358, 6.9239081130647415, 6.812034995682752, 6.0718618408195715, 6.937254711762322, 7.263535827111246, 6.769982429164262, 6.849059866384287},
    {6.406524162120999, 7.162323595440029, 6.793179294517308, 7.19189294997619, 7.008033787333496, 7.443689993619158, 5.729198066051828, 6.8326246006899725, 7.63397470888454, 7.402182860141814, 7.010727445166112, 6.74302338946144, 6.765610168803999, 7.431323066903539, 7.310279921627991, 6.999678804126486},
    {5.814050585284357, 6.727976893559237, 6.494893117335264, 6.5232858575710395, 6.850518774780763, 6.282164525448805, 4.6462691254783275, 6.198771623100854, 7.102309224772454, 6.346287268042467, 6.758955155121671, 5.8201028848447525, 7.0556019279149575, 6.9391675685524605, 6.537677140932905, 6.5546066264571365},
    {6.349695471721594, 6.466303110761633, 7.089621927458295, 6.90060870200285, 7.011188967110829, 6.8416443064037065, 5.2756530636337375, 6.491800420544451, 6.930838538759797, 6.822714943053137, 6.649313457508441, 6.218945943882335, 7.235174564779879, 6.790096583134462, 6.817400235447929, 6.812013957517651},
    {6.011236221850595, 6.916771244022406, 6.837610847133278, 6.817841176428612, 6.6279318553341, 6.7199729390807, 5.2485340246494845, 6.031351913083698, 6.871779511488117, 6.847582010288693, 6.254948365138836, 6.012926446891549, 6.90034528560103, 6.922045821912192, 7.162405623462476, 6.844227631730011},
    {6.16178525124589, 6.938308680507687, 6.677229837152184, 6.883941490746989, 7.018247549932634, 7.003835712004582, 5.289307721917496, 7.199462302633153, 6.868859113714937, 6.74387992380121, 6.562179033987273, 6.5514460283986535, 6.940739431253409, 7.1202278887001285, 6.630757790570173, 7.148073003727707},
    {6.092624551028769, 6.645280869973624, 7.019237445376854, 6.736381366198696, 6.431366879144861, 7.150608447523306, 4.829261631533535, 6.564594483503638, 6.917766497046962, 6.7757557404424285, 6.610520462128624, 6.298633653158933, 7.071651971043589, 6.45150373601775, 6.906498539750196, 6.892464006539034},
    {6.268293451517029, 6.569700077764915, 6.810070620951134, 7.144664932438129, 6.773563537676842, 6.852741641289385, 5.2135085243866515, 6.2536079666642586, 7.072825091452636, 6.746697140381778, 6.298072418628277, 6.315331971782457, 6.765773627886306, 7.492739826005957, 7.392198220479292, 6.949496482228996},
    {6.246956072095624, 7.090227928225235, 7.1581275814265455, 7.095583799928168, 7.103010593582655, 7.139307300169074, 5.7728016929143235, 6.37283789856052, 7.189270117134845, 6.806846640496415, 6.699548634296125, 6.235475639823671, 6.90646089480306, 7.234052189228689, 7.116780794353233, 6.565113795424942},
    {6.251215951495159, 6.709458687104847, 6.746168514437573, 7.002820936876864, 7.21863871048947, 6.809727948405543, 5.572456514130533, 6.861867264410228, 6.554214207036792, 7.01713160677355, 6.492195585428619, 5.935549516197413, 6.784784904538653, 6.732215734022999, 6.43308653587662, 7.298485483545156},
    {6.330626199746345, 7.186697163099428, 7.180742812150046, 7.221721956019078, 7.24897983859285, 6.549063569579955, 5.797029844857053, 6.590782639158718, 7.142204023589071, 6.670330905584313, 7.082622848081467, 6.5060973651030904, 6.729697864752835, 7.436052836596242, 7.1888346045246, 7.0188925196385545},
    {6.242309888696994, 7.1764400389186145, 6.702012305749578, 7.31960892964081, 7.241222225944123, 6.904696869024306, 5.491840569445069, 6.529811057036621, 7.067672389412647, 7.258981072330938, 6.699082125733457, 6.254905683169836, 6.83319883536352, 7.130173510481923, 6.892839264828927, 6.623156904363194},
    {6.406692029679948, 6.658291242312822, 6.792886631548842, 7.16183124435733, 7.413155352255511, 7.213836957664725, 5.609336139110385, 6.760751824875683, 6.963767638269793, 6.780156570471856, 6.524674096601365, 6.2656513723840535, 7.211020283475564, 7.333933733972505, 6.821543972533869, 7.054277547275634},
    {5.440598998763854, 6.337368335544294, 6.610311553508522, 6.668350804566798, 6.62052250786865, 6.530450485118936, 5.003692683723261, 6.495908069092466, 6.922968512816878, 6.65342708768473, 6.485806657062823, 6.111753739953016, 6.84019890113605, 6.446372762029143, 6.61945135297968, 6.330078985327011},
    {6.5800534688578765, 6.612925547695671, 6.6456271320556475, 7.139002440722641, 6.56993639511033, 7.368115891439847, 4.7783300337121615, 6.537610719497817, 6.768788863824152, 6.992602275905972, 5.89487318529243, 6.0335033164082965, 6.488568783691533, 6.711223360809504, 6.822911313759415, 6.298373977410328},
    {6.079425357214829, 6.771875299211945, 6.921225512225147, 6.67610609617236, 6.7572834982952275, 7.102665852476542, 5.4103508225920045, 7.131141730921934, 6.660899560038919, 6.892210514445445, 6.392962627093444, 5.7431341331659596, 6.668929284768665, 7.095297196811457, 6.719114771508411, 6.770279777366641},
    {6.392903354403566, 7.106234776315537, 7.069584968885347, 6.854338386690338, 6.590645191773088, 6.911939802555022, 5.114429891821815, 6.838696808487587, 7.2995213550922475, 6.857004419748524, 6.7653291495462975, 6.199318048484006, 6.526946033289748, 6.589090150515331, 6.865466925671982, 6.837790787280491},
    {7.197220311241804, 6.9540122410618945, 7.321340442287887, 7.815260375977333, 6.927837786783009, 7.349686151601146, 5.82410119501484, 7.105811882688066, 7.315627473643218, 7.307879123874294, 6.9299893810507305, 6.56481419900723, 7.431630400843326, 7.262623535581501, 7.041176530577051, 7.131679870823853},
    {6.723183017134872, 7.45681368267231, 6.839198640188698, 7.530828165188369, 7.059143387153888, 7.398226912432782, 5.9491655714428315, 6.645493568754951, 6.883752455322394, 7.174521028145772, 6.93003308359229, 6.658520418977724, 7.331822499387889, 7.894833888699215, 7.5111764455969485, 7.113933780811859}
};

static const float b2[16] = {6.630712116125194, 6.486069566472673, 6.310434147774034, 6.569538377201173, 6.567752891068101, 6.623570889806036, 6.300987854927988, 6.6821216305652635, 6.638837319224487, 6.469470874069849, 6.620530177466908, 6.408955638728456, 6.364628214796513, 6.570959577987683, 6.656052356111446, 6.657437690699851};

static const float w3[16][12] = {
    {-4.585242165963009, -4.172216335487153, -4.266859617579702, -5.001959699737247, -5.522656774050957, -4.738645785843082, -5.681699104314694, -4.559690695452338, -4.544230074624875, -4.596429399122684, -4.819085046788894, -4.5427994499672595},
    {-4.450458538411549, -5.722306065705811, -4.324530336742563, -5.024062313935183, -5.055621537360284, -5.126821910118021, -4.703314902856928, -4.820605454195477, -4.873260411604534, -5.472162963568962, -4.984069689081165, -4.994282964475475},
    {-4.982595714594023, -4.921674354710413, -5.878287424491765, -5.02585273127961, -5.444925982458216, -4.71910175569552, -4.880678194049128, -4.633161494808989, -5.223812125771986, -4.60105989668456, -4.230400554851308, -5.300737285050397},
    {-5.046488172884392, -5.111388947715881, -4.838841877432869, -4.746473308852558, -5.12436211000495, -4.75471874922467, -5.325821076677988, -4.531652930108311, -5.375544764345324, -5.217852035856682, -4.5125366851181035, -5.337105333791081},
    {-5.722689156500133, -4.467630793921548, -5.084358344756739, -5.20118888921286, -4.853284991542224, -5.44502535980925, -5.000992203130804, -5.488168020477217, -5.079196080156341, -5.641042814674034, -4.530235694193123, -4.563260761699617},
    {-5.127777487625599, -5.13224107274161, -5.280110648324388, -4.962607935502206, -4.3083122418855995, -4.712063166638562, -4.827820298347086, -5.175754953862591, -5.8370955935827045, -4.907611221639556, -5.485674474397643, -4.441706586336877},
    {-3.9928179804085877, -3.411798390862847, -3.4651319782968604, -3.782922757894454, -3.4384173891742456, -3.9394321243718324, -3.8760736410587, -3.7149819865007387, -3.745507833261672, -3.615338221079263, -3.5835354654327958, -3.3682627010258726},
    {-4.555401300759819, -4.873368106819624, -5.114899656500267, -4.664462473821207, -4.430012251788524, -5.272741189581532, -5.183210515078004, -5.405363475921825, -4.918077313755254, -4.614252274880084, -4.9114528262124955, -5.237724850076601},
    {-5.336256796747414, -5.228791778580873, -4.4843844646616065, -5.257953055152667, -4.540259245498166, -4.848614835047834, -5.428191099222224, -4.5748975395540805, -4.904505298765913, -4.637973441339272, -5.060287797224486, -5.511251072443315},
    {-5.291641440515985, -4.2879599053171225, -5.154113196703859, -5.650218010321666, -5.24122259341354, -5.560419222277267, -4.80276049921742, -4.887148837923776, -4.855704024357129, -5.435704944967105, -5.5184561278920805, -4.724191090767935},
    {-4.683038911671054, -4.671171610506211, -5.222396889894371, -4.36103819761565, -5.081895424905991, -4.658233588390198, -4.164643112051931, -4.501048759457852, -4.4971488390769805, -5.312880242141132, -5.300239609389769, -4.8006569370188075},
    {-3.993884366962085, -4.608118416701637, -4.057339319273612, -4.552152201525069, -4.91164462836982, -3.6744777287513606, -3.8541623741366204, -4.556256713069339, -3.9844178762154283, -4.700977433067211, -4.587159221397573, -5.190444578667759},
    {-4.781925339870396, -5.713481057852631, -4.748079891461692, -4.445727837726215, -5.072248339701612, -5.247265180013892, -5.044936942973518, -4.529755742542399, -4.702854151710647, -5.296173732601807, -5.000059441267608, -5.00727864577473},
    {-5.283411791909312, -5.188921486340483, -4.770368977898438, -4.773245423904619, -4.835497661368418, -5.025580670396394, -4.988111160649133, -6.098652977013803, -5.369969231349156, -4.7366007711871, -4.8658049343548, -5.055195346567598},
    {-4.952349386975144, -5.107358031443249, -5.498521414221019, -5.227375423733386, -4.729750391025757, -4.9641799233372215, -4.874089104151689, -5.085216895054295, -4.6522485991088205, -4.541793971428879, -4.599083666384663, -4.995566665947897},
    {-4.699239696612431, -4.79763741886098, -5.265180723239561, -4.903031177761131, -5.07930670015483, -4.860668769025251, -4.944741895005203, -4.9557805722520865, -4.8891792710823205, -4.28436985253908, -5.742551737679254, -4.381580945872728}
};

static const float b3[12] = {-2.602145014969628, -2.015881178282262, -2.1786235280288815, -3.338404358116556, -2.7623074326883668, -3.0209474694755167, -3.050569746638955, -3.543607364515975, -3.1828185122504027, -3.089611340165334, -1.1418365862816795, -3.5789214670779796};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
