#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.5873799452001122, 0.4243102352356436, 0.1646881352457561, -0.427415619361899, -0.7878165067136872, -1.0180510684409212, 0.46947773490025446, -0.9223439201873186, 0.17330383391332818, -0.510417209690812, 0.2062069774525358, -0.27235527475742216, 0.024061259705233158, -0.9679869985645584, -0.8924208240474498, -0.3794983351766081, -0.0023205806786844706, -0.8166204815711458, 0.3380334179415137, 0.021808398555193873, -1.077624302875882, 0.396547476145573, 0.23912826325208036, -0.949206943650074, -0.5312484970512159, -0.40428911461735995, -0.38542986476412977, -0.17266814705100683, -0.5306934909606887, 0.15662110392783082, -0.8850110224951954, -0.7424679729785808, -0.07003636010899866, -0.027535203913752637, 0.6090759736528674, -0.7098447744850696, -0.9596035576621988, -0.1558523460953294, 0.6494086519658827, -0.6355428094847323, -0.21910078758321494, -0.6206117191335012, 0.31179931083828855, -0.8141051145544996, 0.706154981157433, -0.5488290488740116, -0.35938903326314026, -0.01565771461165513, -0.1467203254792633, -1.2090303047040245, -0.5476394140165565, -0.38061027606402226, -0.6402779275300899, -0.2701351130163222, -0.737400550731114, -0.06789940234341954, 0.15103221376214396, 0.07426169847713479, -0.6633336766489187, 0.25652510765022407, -0.7036934278421514, 0.06107781199576687, -0.01601888312252222, 0.07899394712059092},
    {-0.5165449586685292, -0.14947828838227878, -0.4766852558945344, -0.6749977579317766, 0.45851701316300725, 0.05115314111127251, -0.8842753863218704, 0.2236020489247937, 0.16233294830877407, 0.30849870832119286, -0.8130408045253045, -0.487153472426275, -0.4718516194413638, 0.8866527580518524, 0.12445857061326038, -0.540894854581915, -0.3754381966822394, -0.08794714615189726, 0.03688512716655219, -0.6964111538375239, 0.40939247770756737, -0.7006647654122249, -0.28091189391628263, 0.12421859594618985, -0.0752452972458899, -0.9046087758401619, 0.043186389328336426, -0.873794107644051, -0.18649867648607296, -0.6917642422540985, -0.2562238917110441, -0.27480627673402497, -0.38465797539264834, -0.7578908211661128, -0.6526858864496239, -0.19402428571203423, 0.42460338264738867, -0.6792693254998057, -0.795220701689737, 0.05869076406515181, -0.6935731348722814, -0.7941199390368491, -0.9915103074704007, 0.4295751472326876, -1.0682446217576782, -0.5448971457024504, -0.7845013630116591, -0.7829665199994856, -0.5977683094756749, 0.046574347893156114, 0.5343468964232786, 0.0397579280082588, 0.4634318404231787, -0.5393150318819753, -0.037123185566803295, -0.6277194621907444, -0.48648151081671687, -0.14708375650744898, -0.33746651678709483, -0.5033191113342672, 0.20680450150833898, -0.4930985052099381, -0.09208293544628059, -0.617020680548904},
    {-0.6746294892133093, -0.7283327447752203, -0.5751649300944007, 0.43560296415106076, 0.6029612634069274, 0.17592565425845377, 0.057188142791349886, 0.3880139914624749, -0.5407965748033549, 0.6309751830001986, -0.3819901117159616, -0.5481834272926084, -0.6775154365000858, -0.7527944820154004, -0.299993361456041, 0.35737204826403457, -0.7606516554354716, 0.04967264143812761, -0.042861910135567206, -0.2091351646057876, -0.48684575062386265, -0.840615327071327, -0.3931153511800669, -0.4063839698449677, 0.5541946513754497, -0.07342542578128036, -0.3306326817766217, 0.22105640952238728, 0.06151243006671534, 0.2373949325970994, -0.32893670140595527, 0.1529661817528408, 0.04140549252038857, -0.5685532516079855, -0.4855289079313034, 0.6073774972179303, 0.43307864914768646, -0.04309290411997645, -0.47511212439422146, -0.007553978765637314, -0.36647434563714953, 0.22828868105884578, 0.142799588843991, -0.04561853659601597, -0.4066537698069159, 0.4493612665344993, -0.2825582661848196, 0.2650100456119437, -0.0005285451354925392, 0.1498073089883244, 0.38434721988545534, 0.627444862120283, -0.8059333324193055, -0.2563547906944645, 0.36133933634514126, -0.49177252089702916, -0.3535943087470557, -0.515910390488088, 0.5168302380732245, -0.650624108078296, -0.19632351348446214, -0.2847141721077285, -0.24923158624918082, -0.1292560456522932},
    {-0.6254263651110293, -0.7021550025999663, -0.5145145292503385, 0.06648089982483703, -0.38743008190952244, -0.33761560760832765, 0.5041706265756403, 0.357005417800304, -1.1372275078728278, 0.15960675398196272, 0.8391030776562102, -0.43408624014257446, -0.8148317721402117, -0.7422756109965333, -0.4615002483765856, 0.9468240960078076, -0.5360717197503269, 0.24538301846136243, -0.36000320854960044, 0.46885069470035495, -0.5218442808650618, -0.0034844598863258097, -0.27558527672945377, -0.856939335353675, -0.033037982086106595, 0.6728861451416234, -0.6207474468830106, 0.7567027868349262, 0.26828526695097304, 0.6373206247259867, 0.4947596627228795, 0.4017267202588431, -0.306274657965799, 0.31626088926999135, 0.5820087572772317, 0.8692437153681224, -0.15821026774760372, 0.45784225604691176, 0.2748052132786332, 0.06092534100095975, -0.13026016653148317, 0.6914244902698817, 0.8434275238638171, -0.14111068351310455, 0.14158931236739053, 0.804893582140772, 0.7865979996951095, 0.7199429303786411, 0.7883830208522175, 0.006596237316142065, -0.505787400701368, -0.21691726874668188, -0.9840175734346484, -0.11866753216547507, 0.6504005334999, -0.26297372446202844, -0.7336544069163556, -0.34571253831212, 0.7319031033899652, -0.6809285061436534, -0.15459434442479644, 0.42552508172637693, -0.7780873094691231, -0.31611209716900307},
    {0.12518455264678932, -0.10710879209366467, 0.25508571537863556, 0.8089531777090752, 1.0232155299033758, 0.8958906392842578, 0.6455909434245052, 0.994769483621742, -0.4971866495891078, 0.9176996301687455, 0.4614718780676905, 0.4735259413410273, 0.027780580531666352, 0.4562413489021523, 0.28073759318501695, 0.6598867751400275, 0.4709811634629067, 0.8187331412487835, 0.08073565371882648, 0.6735519174960809, 0.830223586131954, -0.22737365445050553, 0.3055539766862888, 0.27923037619150026, 0.7682076180634948, 1.246516184362535, 0.7238623107297524, 0.5979871218196953, 0.7735388551664139, 0.7958116789411129, 0.9040266495024665, 0.9207615282464418, 0.0013413708964812162, 0.4674710746537356, -0.09070414456342346, 1.0906162087589915, 0.6594978657300179, 0.8853199315051354, 0.24532555642647272, 0.6786968294025979, 0.6440896525925196, 0.8898374304365606, 0.21451748784983168, 0.6931501490548887, 0.4109951241168571, 1.0275754861372068, 0.30472606063334906, 0.5157290049842663, 0.33002215382343186, 0.8893195824323362, 0.3688862798700725, 0.9109641950938971, 0.07692778777045611, 0.4389922237583162, 0.8806783350440888, 0.05367347428689527, -0.24687003463048057, 0.5290843911362336, 0.8002518760183656, -0.1033385639926577, 0.8669877161243956, 0.4421782591746285, 0.20090773419375393, 0.2574956967438176},
    {-0.05512210934340968, -0.14596362224280365, 0.07955376656422301, 0.19491458482910345, 0.711622570020818, 0.734436924157633, 0.6832167801246282, 0.9383355461984106, -0.16951784484853827, 0.8633898626479606, 0.6522700627227556, 0.30535663923462397, -0.4175975087713093, 0.24655284333979602, 0.4486564634840584, 0.7578118030151382, 0.08122059729773076, 0.8723928047730166, -0.3916711787965098, 0.5607435358230298, 0.37191287378510535, -0.758372543448586, 0.31282492528063854, 0.33586797050181766, 0.41657120517884294, 0.9172357192558079, -0.41685370183256415, 0.6643556897329668, 1.0817476877001837, 0.5184165664502967, 0.9441775689898242, 0.49595675586456706, -0.2807894011857572, 0.6373550946658201, -0.24805612139993427, 1.0455234255111319, 0.8533143772871453, 0.5070645886118524, 0.13268643155780582, 0.20195830262334527, -0.09887819852722013, 1.109807054118243, 0.28599554081718626, 0.45563983636327665, -0.3196319407138386, 0.961185517416599, 0.7681952991661312, 0.6121487515546874, 0.21077793708674775, 0.8263130099440424, -0.041017276645952255, 0.7167219785529334, 0.1307918503175421, 0.7114655885095064, 1.049322168496294, -0.35719185018215377, -0.577784320592991, 0.470400273655212, 1.1787197912028373, 0.3484041946589014, 0.6369028921268465, 0.7711319914320287, -0.24665607419110203, -0.3240230782059822},
    {-0.696531201521085, -0.27809739781251436, -0.031075413899404655, -0.16801581844151642, 0.7462271972998726, 0.3889424091768613, 0.6446603520349679, 0.5128151593584532, -0.29434884242199116, 0.645643641239248, 0.46910390448267403, 0.062494413961096944, -0.6244724531542724, 0.3342151259622978, 0.19335593231298512, 0.8206691014705664, -0.30525812017643034, 1.0059709856703098, -0.6039329220932117, 0.7983016168154288, 0.3324972119747864, -0.47508155458869544, 0.17323283702392228, -0.2565368664548647, 0.2151021371360368, 0.43747973579339017, -0.11547362193567448, 0.9370662792481264, 1.0024587156666651, 0.4382718979637215, 0.9968500498470756, 0.6884729163227685, -0.1726666395070952, 0.2844212065193564, -0.5028590147917349, 1.034019067406034, 0.7547501176774069, 0.38083213732942156, -0.4335604094583308, -0.30139675308446323, -0.1730229852167795, 0.6146472396228537, 0.051239521370354486, 0.12424879169842884, -0.5569467155601283, 1.0205281896901899, 0.6364208939084693, 0.4365280866148769, 0.4423589705204356, 0.30259239031871266, -0.021955333185301247, 0.5834323468989797, -0.2828158482343398, 0.7329077535227658, 0.7900163875794568, -0.27352986896371195, -0.9889738962157338, 0.27738087101864417, 0.6217364096786924, 0.23815586189898416, 0.2843594107918741, 0.545871681620181, -0.3264934916344691, -0.029842792611068012},
    {-0.41795859528310525, 0.38674772380703865, 0.14222765209858235, -0.3518223028870216, 0.462048199604577, 0.48268050322450307, -0.01278785731757907, 0.8012449210768323, 0.40124497372808776, 0.8885288130121671, -0.17389375909454086, -0.6570493596916818, -0.2808980860590519, 0.5062639750178772, 0.2533249596289916, 0.6634284692604824, -0.28387803619220026, 0.7877248530973295, -0.6461749225153167, 0.583168192998283, 0.1977625872527101, -0.06850449366768777, -0.0800585439982658, -0.1832839813196485, 0.5875007654702676, 0.042713269533117874, 0.1826416765117847, 0.10427054545627758, 0.411223110307786, -0.14903193301916554, 0.5717836542039955, 0.6150404725644857, -0.16787739888029135, -0.11151929320602033, -0.4711493379890846, 0.612425101475782, 0.8666662450207936, -0.10894105313571853, -0.4795371013881064, 0.16566807070576284, -0.502631495264188, 0.3238589301381728, -0.5457493448301406, 0.5883871907045641, -0.6323343333687029, 0.5899109070085735, -0.104453110146021, 0.11850135194739109, -0.2018180704813785, 0.2577594658593743, 0.6291335345584108, 0.4338457300682494, 0.11513105308443479, 0.0733618359824241, 0.2980125063438895, -0.1817012426214264, -0.8245036876655574, 0.3400799294544053, 0.40923129198167696, -0.2125153806719506, 0.3914540724444534, -0.1410580701041455, -0.21371630668604052, -0.8072188784300162},
    {-0.0031799441444588035, 0.29838366883685363, 0.4441900683637769, 0.15763787959880785, 0.5369369523012019, 0.41095913746339047, -0.38873366010247035, 0.7143160380334591, 0.6726974423754393, 0.7729407135569198, -0.40437605890993994, -0.18555704403855408, -0.5254279308882772, 0.9172405026538986, 0.31738532127646635, 0.9743226815206821, -0.17770346769145728, 0.11815645200590241, 0.02239946444366336, 0.39699818241720014, -0.07703110288489347, -0.4412095293556969, -0.43125419979288615, -0.1167566805183985, 0.2895108071803849, 0.3083856088417852, 0.10935328468002875, -0.23442860996583484, 0.3182751384511085, -0.33519317972013035, 0.4113359774878271, 0.8018563700848975, 0.1295118574362868, -0.6954050121297275, -0.08291774097265267, 0.7272954897692693, 1.027651299258201, -0.009193788184274713, -0.4831688881594303, -0.22516367074443455, -0.1299122162908264, 0.14597771578603982, -0.03323253844598077, 0.7592355104777504, -0.6045669010635808, 0.25611422922044774, -0.5670287961239067, 0.11717457629066132, -0.27934150372469907, 0.22932753403051306, 0.6741332085859391, 0.12556923893252328, 0.06154098628703997, 0.08098118464653693, 0.9512364961984504, -0.37310074163928464, -0.7305411480599323, 0.09904631646021275, 0.8641116511411528, -0.07813257710605553, 0.7000591633929217, -0.28299236763402585, -0.23043482646842817, -0.8898049484565553},
    {0.43736917427030236, -0.005029005337669182, -0.18830903433399832, -0.4286378764059695, -0.026678474374976405, -0.17412584047425622, -0.46337982143318207, 0.23266524140726322, 0.5127779953872676, -0.11410318875291983, 0.1272086969429996, -0.23046244269688929, -0.1375316718863557, 0.7641462275277943, 0.07799667811292295, -0.5736255563515344, -0.32095208203431763, -0.3953534283493871, 0.40154896385558636, -0.08904945623801955, 0.43715098432839705, -0.8091644204953087, -0.360666840250284, 0.25478166745761655, -0.20982935786817536, -0.8644013720864866, 0.37873063446897426, -0.22134535408187017, -0.49746080388755387, -0.5733698834171624, 0.37973391609993085, 0.10824266764382254, 0.1513764873098117, -0.585848331751224, -0.8895969773285599, -0.3473257331843607, 0.15902156204161694, -0.27144554771697127, -0.40559962873332644, -0.2322986952156496, -0.6876660521271175, -0.6174516952549801, -0.594315592187659, -0.12182223213399335, -0.8372399210090105, -0.42422110469078744, -0.6112060672600724, -1.030006070978888, -0.2213961023139615, 0.006922587456702041, -0.17623539567065208, -0.29332510762460345, 0.46237722984843443, -0.045307955710735155, -0.6258748458508956, -0.31937434801244224, -0.4977675822256464, 0.22906884767996305, -0.5027855359545794, 0.0031483184040667182, -0.31377573395117664, 0.08921628784271615, -0.1826789902266444, -0.4535105589711092},
    {0.22833874226767262, -0.34439301416286894, -0.14898566709697864, -0.011028758891672853, -0.17419514309729234, -0.2144604176246175, -0.3657956211987106, 0.44166678242081636, -0.04874206358959522, 0.19293535705089387, 0.537340871617338, 0.1874086407911947, -0.33868675930283915, 0.6299728913600711, -0.055898278429606964, 0.1575441824972898, -0.3843783445562275, -0.0316417307432647, -0.1967242927431431, 0.35511645541823006, 0.5912894292294527, -0.6583081575227832, -0.5707237613029914, 0.11086102306120676, 0.31472583143252614, -0.47053824233916175, -0.48430995150320594, 0.23392736167897982, -0.11890016834669932, -0.620716420013465, 0.708678510373192, 0.279069715519017, 0.44353021318905494, -0.08808306099968848, -0.31756835343934037, -0.013796223514330361, 0.14918646766016874, -0.10354729915397963, -0.01810331186118007, -0.019543747486731905, -0.364342915672155, -0.18993790586586753, -0.27890426136840535, -0.28899064336814273, -0.708856981454034, -0.014947159103760202, 0.4919912881239013, -0.5488375370165062, 0.38270987778911253, 0.4437085480013671, -0.14315439139448485, -0.39191826261387724, 0.15958286071427505, -0.34573582803075675, -0.04506727912209145, 0.16530244193520044, -0.507567863129333, 0.2157561049363714, -0.06161086868813369, -0.06066837510392753, -0.4498424839908868, 0.4018366338789342, -0.38518313648986097, -0.19620959347347022},
    {-0.24907336278409997, -0.25824390730071606, 0.19820839530566758, -0.005828855050027093, -0.4454455762036433, -0.060124935059140995, -0.5333495608584393, -0.7057286372642279, 0.34706846859147744, -0.4838975397971844, -0.08388800839411682, -0.4308563036659927, -0.46494451373259554, -0.4077213840667584, 0.08367562816788872, -0.3067308687943384, -0.5718364222733046, -0.017316298688986726, 0.35946673625075354, -0.24574910790370585, -0.5839260086743346, -0.03921237827127375, -0.5498066328998817, 0.12123599233257874, -0.13041370578898462, -0.49187192521145073, -0.21122419317954336, 0.07795654352082378, -0.4862149031830035, -0.3059047715636758, -0.6308978486346383, -0.524808987714654, -0.4268450249573343, -0.5488865271914466, 0.546964720159718, -0.3944839486676289, -0.6074712853322348, -0.546978293694922, -0.28703378850849287, -0.7348200729323413, -0.039216834730563976, 0.06810104919567554, 0.6653066842005426, -0.016086428957709478, -0.7048281666111333, 0.21202045248195545, -0.15212747308086802, -0.41669642692184494, -0.0710082472625812, -0.5682623561962699, -0.02202462488990312, -0.4481783627402675, -0.271484748625946, -0.5017472840219482, 0.10564838190315679, -0.2697968766356127, 0.023302590320181112, -0.4312135100395404, -0.4677605850343795, -0.05897753580391483, -0.4798189705124548, -0.045509224787717295, -0.14100955083181943, -0.04303750550971688},
    {-0.028096866444761042, 0.45002955547620505, 0.14048145609143795, -0.4276095866573111, 0.9470155931168792, 0.4721820417899751, -0.4841285512809044, -0.02681565145326944, 0.7819636244546198, 0.30818364829886796, -0.826713179494648, 0.36541279892243517, 0.3733046835125431, 0.7063036864738118, 0.7772014130174457, -0.6771815789656842, 0.014602810149966823, -0.013266275427925541, 0.2241749702104411, -0.7282321842170395, 0.4540092948096062, -0.21046398108696107, 0.37961178867816064, 0.683222148818528, 0.2769321183840248, -0.5307321143793403, -0.23284326182226517, -0.8593941299108557, -0.05864713014551997, -0.6026196563065437, -0.46972249920553344, -0.24428965624050863, 0.4120855226992097, -0.3073099199250423, -0.5334840141822256, -0.27536915574624526, 0.5074430608197024, -0.5241113224422883, -0.7653808989626218, -0.3081862058282283, -0.13672305248595593, -0.820916909253225, -0.6763959732581702, 0.24920588277423897, -0.9054175976173781, -0.6509896888857533, -0.4906775076142539, -0.30390068755735045, -0.5526121479677163, 0.5403146930843499, 0.6456672285945776, 0.2040918515703987, 0.5754910779004145, -0.14185306394004377, 0.31200885464320904, -0.6288754589874027, 0.12921746134867843, 0.7265340796047249, -0.33137607951019055, 0.5753770149365366, 0.4825528728585897, -0.6093711682461426, 0.10392270674538737, -0.5754970260522204},
    {-0.4952173238963264, -0.5874558932468847, -0.26339430043382217, -0.046786041206903474, -0.6253703600168375, -0.7010628421450461, -0.011634361962355214, -0.6194882738189444, -0.3366564916284155, -0.3009939259041828, 0.6283135019601352, 0.19239991593257533, -0.4993221192085806, 0.0960663119475645, -0.45133118583070864, 1.1256531139402934, -0.8972272183418739, 0.06026408037682103, -0.7339460270480392, 0.4689941380828565, -0.6794976030464551, -0.2773741274735911, -1.020365210825176, -0.7131384180774554, -0.6801811872403833, -0.28719575145236653, -0.8621322054601992, 0.001214150148721145, -0.15271866283692775, -0.4963437369222332, 0.20494250032593445, -0.1400365825902394, -0.6030322089110216, -0.45497587882942936, 0.5081647736051702, -0.1352362316881156, -0.42406435525030534, -0.32657457215852054, 0.058449528734594816, -0.557439962078808, -0.2096178138406662, 0.7966282820062839, 0.5275307542469574, -0.36887744462358296, -0.5770939649599381, 0.624709288185273, 0.2947065500672223, 0.11331898606960857, -0.0036917347910160932, 0.166233294451801, -0.7915101546884361, -0.6336434551210957, -0.723144080908035, -0.09879185206055346, 0.27043442558434483, 0.027540796722448514, -0.2853220365948303, -0.8688371998569302, -0.16184225935883292, -0.10378609494347193, -0.5892027028783728, 0.5512964901111299, -0.5619738764142004, 0.2596221007051569},
    {-0.320210297854813, -0.1973983840291408, 0.3511930635570151, 0.640596064231758, -0.2414291345689007, -0.5494251549783193, -0.21546634662673353, -0.5767932815718592, -0.0736186387229005, -0.24534996891800162, 0.28097160908687197, 0.49445508441899766, -0.48203531891532536, -0.5981545913458067, -0.2286122167057228, 0.8401425456700107, -0.6119156398279204, -0.0001943842637460589, -0.5565956998593089, 0.18644966855302542, -0.7216027883563736, -0.06378221598024238, -0.47580065533496724, -0.5511305275006633, -0.7696227420724792, 0.8015700607759075, -0.9087824896764263, 0.15681388601680807, 0.8515295781393817, -0.4299899053927018, 0.09133698430028273, -0.4876544140983253, -0.4311795843362352, -0.4799942379425354, 0.6118743957936658, -0.20231834326480147, -0.41655952437436955, -0.40771465335459195, -0.06792830573379989, -0.8878931019588989, -0.11956840096214512, 0.8872587461287134, 0.8880326670874953, -0.4846948176859017, 0.06820590852083656, 0.3792244996903643, 0.8229390127010109, 1.1453601941841818, 0.27004483927367884, 0.33987137421528374, -0.9541783021407165, -0.9197731924490908, -0.7028871238275838, 0.09075207632632204, 0.7084797943479519, 0.15239280156868099, -0.23241855107329748, -0.4000627908240578, 0.8114087240604239, 0.5745200711622623, -0.30466222021787526, 0.5152339434268397, -0.46802254449478625, -0.32977445269191447},
    {0.3162566163590282, 0.6720408094610665, 0.7043899524802747, -0.09452576093596825, -0.1610040496071558, 0.01972158484734299, -0.7401419068792032, -0.6778272740889186, 0.6050785542802607, 0.35479133038467126, -0.6075085151891996, 0.5309592732135759, 0.3862030641181779, 0.46375268530561997, 0.17176457161555472, 0.25426492742596113, -0.5737677263336307, -0.10393833959863308, -0.17601288592974984, -0.9094926097486555, -0.06009104117701762, -0.20682873669646976, -0.4673145508618049, -0.2356985424109526, -0.49323219849343697, 0.502779127674087, -0.53664441469497, -0.9655283467635755, 0.26107007512284, -0.9357263184226545, -0.4514143887454326, -0.4013210254092381, -0.09999111599976199, -0.7886792905232449, -0.027975561714923314, -0.24054865226366404, 0.2986849460291946, -0.9408693222937179, -1.0227646392777066, -0.33596555920039084, 0.06350411963128826, -0.09116678990243042, -0.3997176083304023, 0.2275323893693297, 0.03196762635312765, -0.46801649921829946, -0.32668388017916267, 0.18666239186934183, -0.5795479108762474, 0.3743406577888321, -0.03839515251515103, -0.3100735034883969, -0.14787328275740647, -0.0191635602960789, 0.4538052662823744, -0.3413074555184016, 0.04528418354702232, -0.23787828160161006, -0.19565767645167156, 0.8103161846941671, 0.30849867868426145, -0.5584036196552432, -0.15819944720915735, -0.6008653549300135},
    {-0.11952659002940721, -0.6948285266262112, -0.20777500450296196, -0.29065070728184805, -0.5695190851945158, -0.21107260497443467, 0.5472402785759062, -0.2827168624068568, -0.16220681715859514, -0.44959380046390274, 0.5998414066293434, 0.2083216567176342, -0.485564073407699, 0.1714142152065215, -0.20391690634382556, 1.0300861399289885, -0.5672828894790658, 0.16474250582166763, -0.6964871842090353, 0.702243632193514, -0.31735870964500007, -0.047148453682071045, -0.6324442522676053, -0.8222085133622343, -0.8087456958667166, 0.26414292867048167, -0.8120799114832103, 0.7990703759485692, 0.27933230705917067, -0.41521344804986166, 0.46589184625276076, 0.17461643445176445, -0.8335971548926605, 0.07953983668860246, 0.3813940514728805, 0.14400344871866666, 0.013911098766805626, -0.019811889848171935, -0.6323807767250749, -0.4482233079619297, -0.361820281130751, 0.6439079131697133, 0.6555726152319304, -0.5102896149522705, -0.5450691013436307, 0.6933980250745603, 1.087508026129015, 0.3598354641865842, 0.7777634638012714, -0.059729846975664636, -0.4452447233301451, -0.7608529266799535, -0.46228258085420565, 0.4653515471305915, 0.5228962034742431, -0.1754597965493475, -0.5478814830896932, -0.3141276217564638, 0.5380352104489878, 0.43462807009808624, -0.014413136060887564, 1.1987811092213603, -0.6664025499144632, -0.15630829683088468},
    {-0.004677615894657574, -0.5592662126113324, -0.02982064125205753, 0.08912451444121772, -0.1261106691558848, -0.17916357004087888, 0.17073622849615028, -0.9527527531942774, -0.005046703623601087, -0.4182618174071039, 0.7461250417115651, 0.27152126481866046, -0.5044833368285415, 0.10252500050112728, -0.17319757747905332, 0.8609839426150891, -0.5146460319230628, -0.0756623978816424, -0.6997735310082298, 0.22348609921832951, -0.3270418258977322, -0.0054567962484361205, -0.5197283126093256, -0.46900135559492084, -0.5189646905546552, 0.15651159777224807, -0.6645314821898366, 0.42802772395531924, 0.0829204119486737, -0.110295708872149, 0.46412565075417245, -0.07618679757246712, -0.46828006164109964, -0.30680146283458065, 0.46454939572344944, -0.24574698183468577, -0.17079488769575382, -0.172529378471191, 0.06035779614429857, -0.44061680984335144, 0.03057051215302101, 0.7499945699182069, 0.45477057943074356, -0.27590433434665196, -0.8039446320106234, 0.5304906137613473, 0.6331469248561061, 0.07445240072208577, 0.29624059695343535, 0.31140865674120444, -0.7169215113983093, -0.5547612581245127, -0.30754782819019066, 0.08369268925133869, 0.38211410141165303, 0.11574729309143461, -0.470700153961845, -0.06573346298012722, 0.5834350769881549, 0.2375651339444431, -0.3331374957347474, 0.5413265067159588, -0.7033313984396717, 0.09898679424154891},
    {-0.4783437546507543, -0.2569187716105145, 0.49859732636365084, -0.6255798175098032, 0.37539770248962867, -0.012169484855517686, 0.4499468648333983, -0.4980879946999343, -0.0759487524774789, 0.24503126070974823, 0.29362970989598774, 0.0807121010216126, 0.19708796053145647, -0.13491242790311622, 0.3638479643395384, 0.7631943071691696, -0.21584888556635645, 0.1794515670167372, -0.09587746820322614, 0.21748091949345577, -0.06125267479129727, 0.8200279455630348, -0.1277454713641794, -0.6036287062602446, -0.3247867036690711, 0.585174753467196, -0.03304318993767842, 0.4087851197442478, 0.4729117624690457, 0.43871821886153173, 0.19646240218631653, 0.06450443344645604, -0.36343016629181046, -0.3574118235635879, 0.5489733276695945, 0.1610713923341393, -0.08356580518500877, -0.14943193991483503, -0.4605575578460581, -0.330502351214409, 0.061824568698985144, 0.423745798086896, 0.29199451692550876, 0.534285593941997, -0.09417207739121805, 1.0058156958103752, 0.8360535804334019, 0.3775710100509279, 0.3586074726015803, -0.13879443628581234, 0.38038533798673074, -0.25121842124745536, -0.7469451748685882, 0.12804991586668002, 0.4359210510413484, -0.08905305231685408, 0.3527484360404548, 0.33120597377138694, 0.5721472517016586, 0.18745154031055325, 0.30701087138912553, 0.40117646006814606, -0.11589624627241785, 0.11964575922156889},
    {-0.7347090971207277, -0.07254367520548535, -0.33306912829672886, -0.8213976793188964, -0.6775528298539037, -0.7074688436374731, 0.5737962073380202, -0.3443250491725928, -0.6151477390639934, -0.08693951396156997, 0.9614680041762588, -0.4583818348617487, -0.26913511977327814, -0.46476904454346296, -0.5509400752150715, 0.7150881808267017, -0.23839005908902056, 0.24335701779426042, 0.14157701790869268, 0.6138182127510853, -0.3595348628438337, 0.07538584380115942, -0.07976793671090686, -0.34780659682061627, -0.0876757993188545, -0.5349743750128823, -0.13320214678971973, 0.6521357712938928, -0.5860869836530895, 0.13397275213604326, -0.3710705538204998, -0.27452531453612466, -0.4760674846423206, 0.17287518453800005, 0.08504954273428994, -0.163894217609295, -0.42499361713298345, -0.2822918893035928, -0.17957208064193836, -0.3509347522493499, -0.4989093930759315, 0.2610012060145397, 0.05069808675163761, -0.5884602592055148, -0.15569635741420293, 0.2451095712992507, 0.7149151169051503, -0.050679055982279, 0.8158723884945303, -0.4039318542610788, -0.04260806195197078, -0.4954750256523605, -0.590705713249324, -0.14352373832421123, -0.27885471618094104, 0.05507930659005319, -0.07434314981600233, -0.18692545012239695, -0.44618385921170384, -0.13728437320553882, -0.2639117278586087, 0.35072545653019455, -0.364576962048564, 0.16766987043005227},
    {-0.563399065484818, -0.5762872219553626, -0.5463459179152105, 0.011770236459961593, -0.5590748471509112, -0.3866306553853213, 0.5341184429986383, -0.6416519650823459, -0.5743246931376276, -0.466037947911892, 0.24821986071048677, -0.13516507652685517, -0.37136428308039476, -0.7290301143900704, -0.32808677432028327, 0.8837005896034337, 0.27505034982408777, 0.0443398031453218, -0.16424422164847638, 0.19490002165546444, -0.7777429081504538, 0.8041300438949237, -0.3565078772258848, -0.5731301162558118, -0.5646320291957504, 0.3839443447532198, -0.05393671955947146, 0.5872139453644565, -0.47745149214312316, 0.506148613078773, -0.4238841372498755, -0.6672811168074817, -0.7083091960010601, 0.23810329906745903, 0.6602912220144692, -0.07118330947797022, -0.6133988587885062, -0.02862791543948183, 0.1622961096850583, -0.11410069178609243, -0.04587406035322896, 0.740107468001954, 0.8994907689381331, 0.07537309847484865, 0.7930522070243431, -0.04165670422829294, 0.9341444799606128, 0.11471793114775791, 0.8436402595191957, -0.6132081902058177, -0.5270349603354074, -0.6040373411975283, -0.429726571110318, -0.42406391896480233, 0.05880036482897545, 0.5631181248254691, 0.13537303054531405, -0.23697252623937293, -0.11975478818107856, 0.17443194161953252, -0.21094632085211495, 0.3559005488312742, -0.3702160183783415, 0.3698227771969127},
    {-0.3463357576882595, -0.2764366647475805, -0.40731328521686394, -0.44705333307798417, -0.8114339926545223, -0.3533026484776629, 0.4772227497796224, -0.43462666581800846, -0.7635306683381164, -0.5526372439277394, 0.8152057558356597, 0.44939299457174514, -0.21824685565409452, -0.31537595672861646, -0.680814892050223, 0.696455666417568, -0.18373192800559143, 0.15271766264764905, -0.7353148173460529, 0.551226906922665, -0.2280141334063356, 0.31657898313117117, -0.9344451600639497, -0.5870536480909528, -0.7454590053760641, -0.16200396037709855, -0.31123057611068566, 0.5884764862895007, -0.3664764937411757, 0.29854351416262903, 0.10329715597856337, -0.14573544658961401, -0.6609491710011085, 0.5311750399079039, 0.6808358325868753, -0.25868986446707837, -0.6946721491284144, -0.5332813946141124, 0.13008052232600273, -0.33105555880463866, -0.18403155948301783, 1.0862912758672039, 0.43737773646113104, -0.24615817695544073, 0.4549894013599019, 0.5845786675500204, 0.798352990494081, -0.12551710695413446, 0.8093576236318606, -0.17933741575651552, -0.7348739937940195, -0.6311445206283046, -0.6669823358942486, -0.12609229952909135, -0.5013658420221297, 0.8759990113226752, -0.3643343637823354, -0.9225125735886476, -0.29313972545392725, -0.2786597305215488, -0.48803405790405524, 0.5192802774586859, -0.792684008543153, 0.5535748348297618},
    {-0.7756141322184548, -0.734483375224174, -0.4064555908351046, -0.701321416389789, -0.7579933218773698, -0.6568067760608025, 0.5005118335274107, -0.7008924420686713, -0.8691793844861985, -0.7105697935796487, -0.48641223291320623, -0.23370387663899433, 0.21810106424920872, -0.7817717450845861, -0.8557227647301553, 0.0914452315095146, -0.1751716082608647, -0.5323226972434529, -0.6548046205023758, -0.27698212015960544, -0.46578746814343147, 0.6996403239464133, -0.4991762879249921, -0.5206526755442977, -0.6098456973474519, -0.3717738173802882, -0.1787234451634563, 0.009278256975846668, -0.4772801340882292, -0.02284356897165838, -0.3772398998927007, -0.45857218779647696, -0.8372878636226951, 0.048737041034949705, 0.5974059943773969, -0.7847918224285537, -0.7001330164536813, -0.38351268976037267, -0.22186765423882443, -0.3715307584194917, -0.34798092636691147, 0.4894837433511741, 0.512634299587739, -0.1838174726093925, 0.5440701167074496, -0.2987262504678295, 0.0765880672860005, -0.24459180847533943, 0.13197019703730975, -0.487504464435937, -0.8574486094992044, -0.9644162805742619, -0.6719489699651018, -0.587285834060461, -0.5709426414214708, 0.5493146393446593, 0.07048507781308255, -0.9423860009671768, -0.7232863303241626, -0.6939340457567859, -0.6467332358087353, -0.04915031482132651, 0.03825665498479651, 0.6028768355586352},
    {-0.02164955890516607, -0.4434228400308568, -0.8751032638065906, -0.46382470254410263, -0.4989710957411879, -0.4604855242134893, 0.5565095716611254, 0.07334867675699977, -0.6495272035561755, -0.6183969065166488, 0.6351082188313135, -0.48029450321038447, 0.14724577479880127, -0.6008380946766637, -0.41373171249929724, 0.02048418012728046, 0.8636273147607327, 0.223955734644413, -0.09408537962960566, 0.3501242814672036, 0.0896587544215642, 0.9603712807687379, 0.4543571030239669, -0.1471578908673671, -0.3112232240381787, -0.181143123699913, 0.5600818655666168, 0.7801810370828371, -0.5568085778389267, 0.26187999949148255, 0.05464813212401039, -0.010362047161121976, -0.6786379214094261, 0.8357802958992171, 0.2592299137461997, -0.5365713981663364, -0.7431036666328752, 0.0105445938719917, 0.4318064755555452, 0.12155349004402727, -0.010117436685131993, 0.6246779327795193, -0.10747781535281534, -0.028822936174551922, 0.5326801053909058, 0.17308570524223918, 0.48023934910044846, -0.7831582078701242, 0.8821128152890468, -0.4853915460200681, -0.1249112614462753, -0.3441773829346765, 0.06738300574434385, -0.07035992710594, -1.0655750794733636, 0.7119130816113294, 0.24138808056584743, -0.45776462155064646, -0.7328171587075709, -0.4349833998364622, -0.11760199465501973, 0.4800851405562264, 0.11999559935862343, 0.886030241232522},
    {-0.29208626261575776, -0.5817994502415523, -0.5412923545948761, -0.15844626236141732, -0.6997777368130479, -0.11385639702751245, 0.9020382865549701, -0.08484359612289467, -0.6058984486700827, -0.8349913095067774, 1.1084630191281961, -0.2790686306038073, 0.1974187198427336, -0.7339788719579408, -0.6241396824898036, 0.4266500045239845, -0.3073954107573376, -0.35520425693248936, -0.185644389114297, 0.9687540306200193, -0.4135582464984946, 0.6185724830338137, -0.44523522840287255, -0.7750821083744883, -0.3945491212179863, -0.5795659876836019, 0.29893361870597357, 0.76952686971892, -0.6759249310559686, 0.6328705823631736, -0.17431218192586345, -0.12804567096192307, -0.8614198689391406, 0.7145123690975571, 0.3949729496151418, -0.21673716012708646, -0.6609461709956638, 0.28380104371214504, 0.6859714815915526, -0.11976809756219033, -0.051459052650347614, 0.7155048084249689, 0.8450730945921124, -0.6642424578578513, -0.3409345639281747, 0.9125757149980077, 0.9600066784374165, -0.16799520224620423, 0.7389257257871604, -0.11329683643019264, -0.6443351595793414, -0.548430919769918, -0.423352643427563, -0.19593173015113327, -0.5977776482538918, 0.7577672247527032, -0.3176596338160889, -0.34686824915437653, -0.34259770743767437, -0.7636119303590099, -0.5209390760727433, 1.1354196863794135, -0.3458851873302234, 0.9002175520468443},
    {-0.2795253614806858, -0.43274458658747145, -0.7243304208616497, -0.5603524644872858, -0.523256290310042, -0.6880839085356406, 0.826096254603246, -0.3574714673968967, -0.5080409019543943, -0.6897904670543245, 0.8650901653423488, -0.7283303161617555, 0.1332463185297808, -0.790000436042954, -0.7046447758159682, -0.09963223676428486, 0.37464235516486444, -0.4036410084979235, 0.28985133222929366, 0.6439225721205789, -0.7408296465909346, 0.6583665463497937, -0.14973088921705016, -0.5527016580887492, -0.027502608776726924, -0.25350399783578953, 0.47953329975552894, 0.48410189935301373, -0.7410168572769088, 0.5451672416345963, -0.0358964856493377, 0.17277235614147576, -0.7174551181367467, 0.5517821000306412, 0.6737798069552653, -0.6134443737085611, -0.69093301581363, 0.2478892993881718, 0.786646551771112, -0.2845511696398087, -0.3014386161953234, 0.16278588112273665, 0.19361479959088176, -0.7783216944729853, 0.48976229409995503, 0.45560734886310744, 0.15437332812912913, -0.21408334455547193, 0.5257032761369771, -0.43065005281185575, -0.20996677371510358, -0.034840136855437485, -0.6267077955987279, -0.5341795477821393, -0.6524221104960328, 0.7617685622410296, 0.06901326549057156, -0.23927438890262062, -0.7536922967403398, -0.7303942027493455, -0.4819562372797358, 0.7502047473320964, 0.03329624558637118, 0.5166766934235177},
    {0.2437752845352996, -0.5431260120324437, -0.8434454059865404, -0.4709790591901364, -0.8417578864346518, -0.8026373729251458, 0.6949563847814944, -0.45824746486485224, -0.5004815016987398, -1.2369443954541368, 0.38246959483137566, -0.3398125789298063, 0.24761388786941219, -0.6002435213836363, -0.4998881845619124, -0.3701515968471396, 0.6869687336605966, -0.4980456527926901, -0.2622932394511321, 0.37387801460690606, -0.744443459337408, 0.8095383177870692, -0.7646085812974417, -0.27175738249321196, -0.7006096295628741, 0.0005076908570744744, 0.46021621144736125, 0.8442172350004756, -1.0452109721953118, 0.3997046883992607, 0.10007338932922664, -0.38011304993725725, -0.6644053978278456, 0.6190864205558362, 0.7542778458165719, -0.7370921111567177, -1.0332499126165091, 0.29883774477464814, 0.906290332779794, -0.44963303545451944, 0.08217917450380771, 0.41680829692970905, 0.6892712699358405, -0.28821956137678034, 0.1732646110530161, 0.08153052763408228, 0.43005159968836776, -0.05112534285607644, 0.7552270192049408, -0.12623787829893213, -0.7810734313661758, -0.8340996506905884, -0.18720460373244688, -0.1502950199730368, -1.0489414735063123, 0.6947158901223832, 0.2755020137583187, -0.5872958177781902, -1.0482655040150772, -0.4180296987409388, -0.7574864824510157, 0.8972016006941613, -0.158905565696201, 0.9032917643969891},
    {-0.47952980793578015, -0.05012025790189643, -0.6408066518814429, -0.18379579160664425, -0.3057862120995788, 0.6378931703193301, 0.8025768366647681, -0.0339669368805013, -0.6241570629136315, 0.09833758102554963, 0.4097224251220561, -0.3403304925505366, 0.2911134312817852, -0.38189191908314074, 0.19405448126921376, -0.10351662873442981, 0.5068247531583577, -0.09131855395833265, 0.6579715801157815, 0.3851927115940197, 0.2420662531275471, 0.7738174972196195, 0.43289285118275445, -0.038141346006290835, 0.44090472858792745, -0.008776431180548452, 0.8155256452011471, 0.6611574032508054, -0.06963890312043323, 0.7954992548213103, 0.17711404510678008, -0.30041802157490655, -0.15533337146762663, 0.6829738834485952, -0.021810575730014495, -0.1619168484657383, 0.20539769166001867, 0.3860206387840002, 0.2956008754714427, 0.18377599579569576, 0.15049987212902705, 0.1572568431476858, -0.7400578894190194, 0.22350786484350246, 0.1258228144517569, 0.06786310559044509, 0.3757879395983897, -0.027232698258255923, 0.354431921657064, -0.06854517852921493, 0.2104396723473729, -0.38642463497209145, -0.20314728158765546, -0.1522606928628215, -0.5418171444162583, 0.4590647638257729, 0.5038069873396634, 0.29344081328555216, -0.3902815069042838, -0.49094015509153244, 0.4639408709424341, 0.8681912477381099, 0.28420326772358195, 0.7452415687673084},
    {0.0710529143878767, -0.752616152806274, -0.6280294602736177, -0.59671697132575, -1.0151552616463089, -0.5326547836023983, 0.5610132377753162, -0.18155904946244, -0.9120141066860603, -0.837174360118431, 1.0347522486874137, -0.3979070404759908, -0.7188081569719663, -1.003123502535241, -0.8814552166893699, 0.9815465023267894, -0.1762295568256584, -0.04024773636479948, -0.15567247750490157, 0.7589382469872566, -0.28936619253557233, 0.5824893931810029, -0.36639251054526367, -0.46858764959989696, -0.4131102997755516, 0.34292675575576353, -0.05142836619221331, 0.9998739801293811, -0.46862192088196575, 0.6853686156031731, 0.20944417221467668, -0.40415205122098014, -1.0630709401099845, 0.7550529749500948, 0.8035697928784398, -0.32076111961571774, -0.7101004506661934, 0.46425368801437367, 0.5340868470722256, -0.4415034006774459, -0.21469603373577179, 0.7566430769336364, 0.7550083972370294, -0.5175102735349405, 0.17345868679238693, 0.836545580673118, 0.7836868254746473, -0.31520902349441476, 0.8407385736023796, -0.19733177733203097, -0.5464223180447091, -0.7186702049688347, -0.73090091358425, -0.23576251742669793, -0.6129533792231172, 0.330955819350133, -0.4304413490819842, -0.5851287267677365, -0.08604451653128461, -0.645859059847219, -0.7180274269510222, 1.2790381958928956, -0.5823839934627129, 0.33990756687120416},
    {0.35000086853747453, -0.8128452913856669, 0.022111916063758123, 0.09041054864210173, -0.24134619502568358, 0.37471892242319466, 0.2993289713380199, 0.2543453620755998, -0.6775871827819585, -0.47276935644913887, 0.44173019754604087, 0.312561107344516, 0.023663989353125577, -0.13529610974400458, -0.267776698297501, 0.27951646122774165, 0.28613760092886625, 0.5685623281200959, -0.4116631768687025, 0.4872430855211098, -0.017611949653181795, 0.3522332892930875, -0.5804969334470317, -0.04501399719164147, -0.309541513705668, 0.3366745305351486, 0.2902477341504364, 0.7827362760993787, 0.20805572086570745, 0.47404401266006785, 0.8214288358504228, 0.0947711928976493, -0.7294272829347392, 0.14526999960543222, 0.39767241663907726, -0.06759096129305701, -0.4276371177908716, 0.4607762591904069, 0.21886488760717315, -0.567558491432656, 0.9021029886895022, 0.7747087516069529, 0.21713599117334767, 0.16591135748873898, 0.22900727610943644, 0.6604317392052156, 0.5866787481822118, 0.029726549763863772, 0.7824313010775938, -0.07159345341373881, -0.5675542110241708, -0.3005655256994098, -0.568291246510253, -0.3714335729275232, -0.09251913619825901, 0.6301793593056465, 0.5937885007693695, -0.5339014789801129, 0.3642640149328379, -0.2313753187644602, -0.26562769692359917, 0.8537092865238562, -0.43225638942771144, 0.6077001889898189},
    {-0.03351625489349544, -0.47424612724187787, -0.027759988889406638, -0.9062239135540467, -0.9783540594223364, -0.93828023735119, 0.36845731042925745, -0.9471019154411182, 0.02543195361870639, -1.051893064144144, 0.7329468549947297, -0.6813935471854136, -0.593569067826951, -1.1803072988732766, -0.9905880946362913, 0.055197403704228806, -0.26949548181858407, -0.8386954051364873, 0.4043273154770382, 0.5185404745683007, -0.8991905172777583, 0.2351897120794264, 0.30880720008146806, -1.0403220500686448, -0.6561597475625355, -0.7590017672148549, -0.09439176730947041, 0.590024709649664, -0.7460671260285, 0.6404345964636703, -0.664975106276091, -0.7661476945093327, -0.23438963230334392, 0.15312213546655207, 0.3496731316401082, -0.6740493011466995, -0.9996100066309133, 0.1926434378838467, 0.5156345115683597, -1.088213470682502, -0.8997224303324515, -0.7008435908425585, 0.44460132835289223, -1.2107732293047977, -0.2647870557883183, -0.12081075457891252, 0.2711889604799654, -0.7451618967687308, 0.5707709948802019, -1.2105136119697384, -0.9258043216389271, -0.5311976398222686, -0.656528453795562, 0.39916850679918336, -0.827977859026243, 0.11778324055553521, -0.023787495873287788, 0.0915880486170716, -0.762961180235115, 0.11551019556934591, -0.7975691198846682, 0.36750132209280284, -0.9887089629194787, 0.15011824562308754},
    {0.1984726007190253, -0.08374690490665562, 0.2215124796849255, -0.7077821479554391, -0.9033229356911981, -1.1169751730086066, 0.4211358619906751, -0.5928243331636789, 0.26453970919860154, -0.761197664279458, 0.8306148031541093, -1.094829375834775, 0.12900240115650957, -0.7324007685305287, -0.8466904917534092, 0.6940985232513933, -0.40354696127831147, -0.9138691314965695, 0.44843098900983175, 0.7129242504185289, -0.9694043008796539, -0.09848383489677824, -0.43429899098578595, -0.833864269405056, -0.5757082967921595, -1.0793166160777143, -0.09187243100228787, 0.4808851166452812, -1.048557344286441, 0.41206603939194586, -0.847957912054287, -0.5417327492373313, -0.35027848031434117, 0.18156992027908495, 0.37768568903483135, -0.5382868172636399, -0.3597138006928758, -0.06759138757657018, 0.47705632083016725, -0.9568474621984936, -1.026239440249891, -0.9376646802852324, 0.6218357694715432, -0.9192002715298018, -0.5022112522981397, -0.4212258003785527, -0.10811412906130632, -0.13203166503156988, 0.652776024642847, -0.7051546033242367, -0.5797479343998891, -0.5305868407833338, -0.9963710821402858, -0.008611725745421057, -0.8453164797595257, 0.07810013874275612, -0.45385021531607006, -0.09534921798671232, -0.39558007346405394, -0.032607005435775195, -1.1920423299074985, 0.7349461162154759, -0.9624301211996779, 0.39848956968604377},
    {0.17982118991300827, 0.13951164144520242, 0.3293399761960562, -0.6177099633628674, -0.6681682028414025, -0.9289901405312914, 0.5258659666924729, -0.4465729176129481, 0.31434099067522536, -0.564497921180774, 0.4399627810361076, -0.753380274233269, 0.2665432932450659, -0.745012982174153, -0.7096671798166859, 0.41413315446010096, -0.5488519825750664, -1.037676578974857, 0.9153405278124144, 0.3014324453676556, -0.4938233028386925, -0.36003340391471195, 0.17970088711444512, -0.6891528172397171, -0.7840841389460206, -1.0016982950816704, 0.055610633554850214, 0.2095786817210798, -0.758020773878724, 0.37250836550980815, -0.6014130512829445, -0.48016683828049733, -0.20145433419509873, -0.448823080395904, -0.2421984511068961, -0.6632226701699305, -0.7103682792859497, 0.16078264623830033, 0.8861756385821157, -0.869863132538317, -0.7213153992677307, -0.6762128399284082, -0.05610034151590604, -0.7196126111321939, 0.06881239616794303, -0.05928223562927137, 0.09842288644243091, -0.17796314353137505, 0.21719734691380366, -0.7794870102308382, -0.6639209458469272, -0.9535058978297671, -0.7060531639690029, 0.4637131826590868, -0.3160370614654554, 0.07256861124754627, -0.11714304885095628, -0.1312699618216181, -0.3740564903007846, 0.5901350127577959, -0.7686377357004675, 0.272113322371201, -0.13960855369668965, 0.25510406019165444},
    {0.38199257988220364, 0.21625760346646816, 0.542039759508595, 0.35514941965855, -0.5385642253350961, -0.7827683977726625, 0.40808158349175566, -0.500697187339736, 0.27220660984844686, -0.535903209700235, 0.09532607634167721, -0.6130171230339521, 0.5586960238884711, -0.9861432101912141, -0.481442022625626, -0.14807462465544075, -0.6148323123888766, -0.7444897427648881, 0.5745301957615921, 0.4299030475666075, -0.6065783629461907, 0.14705078467674623, 0.48699699032025917, -0.7253385918125677, -0.4615225635744867, -0.5984910664628724, -0.22189611186411554, 0.2661192290597494, -0.43896742047303833, 0.34122926581873314, -0.832811307506388, -0.15674456366794082, 0.2679276467643266, 0.013909869260363044, 0.5160134602258362, -0.37077361251922697, -0.5637126741571075, 0.0703319370922938, 0.8712928812090985, -0.8066003129202426, -0.22266466311428876, -0.9780177992083869, 0.08351804678994725, -0.4692183415826506, -0.040847977487472965, -0.6088138394545245, 0.46422940830845455, -0.39522739569493726, 0.25725346082903033, -0.9143281619507221, -0.32147158682978205, -0.3857112010506508, -0.2043633978259578, -0.1154091672624128, -0.6232407792502916, 0.04385984962245338, 0.11652501443876302, 0.09443435394792019, -0.1357311900451732, 0.432013655391531, -0.892840909256656, 0.3148960049771708, -0.3315172180530603, 0.20321875064182657},
    {0.5619220038880253, -0.1083529869308581, 0.38242427990925476, 0.5873282756985365, -0.15448962701234806, -0.14817317061956678, 0.6862221167134693, -0.5623837123094467, -0.47434406631422216, -0.21667762685861477, 0.324776301450366, -0.8668081046978227, -0.2784160056280594, -0.5446848398528352, -0.3106592750931796, 0.1745398075682009, -0.15401288479060118, -0.1840795437670735, 0.7436829843015349, 0.34822127511985834, 0.42252355408250025, 0.028475586370132373, 0.5888253078455443, -0.058852694072841966, -0.6000672691960202, -0.3789363101384323, 0.24223690006948448, 0.7733860184866267, -0.5523247896695695, 0.08128973306881346, -0.17764615078296267, -0.9604160600038265, -0.06441005976844767, 0.5933078455734252, 0.15024067237476535, 0.026937320288259386, -0.052707472505664515, -0.282386485161605, 0.6555556665489706, 0.009907403545564717, -0.13146165489815104, -0.5807472507696464, 0.22362467974070654, -0.5197065749412777, 0.07264075255688908, -0.18508036144577686, 0.17781689197817244, -0.5965143409128839, 0.8131289149322256, -0.2502727027890018, -0.1971968585164562, -0.7227151695033924, -0.503220876046348, 0.2884556501361412, -0.29618526482902013, -0.4287345291151074, 0.22509632213084008, 0.17483635102826808, -0.17153319951665585, 0.1189293605212596, -0.7432314046018987, 0.23405417912406506, -0.10272624910810661, 0.34226698562283614},
    {0.8464101880377792, -0.6096153398055246, -0.21617092955782222, 0.4683348537536421, -0.288455553960217, -0.013952616227224013, 0.3236548157217124, -0.24689962743792798, -0.29785203319714465, -0.41633308562402366, 0.2003842676791575, -0.2632848393280637, 0.47844564334153317, -0.5420205663707292, -0.14431711135012082, 0.026069131674379666, -0.25043719617537635, -0.07499499674683167, 0.6201928840281461, 0.2745283212854641, 0.006558289479205172, 0.12307868561810273, 0.5862141934849061, -0.24182093736842697, -0.1802258267806976, -0.019444846056199058, 0.051090911374832085, 0.5051692825002498, -0.6165680484153249, -0.09487940205746485, -0.17395715123095495, 0.4350195528266037, 0.42325718151732133, 0.5860045870220975, 0.0484502892128555, -0.3113679803748379, 0.04042175833069327, 0.3333821640574994, 1.0827941329419262, -0.08928361269199914, -0.5652854524423413, -0.14730588880761566, 0.4984205747167796, -0.5935542475515998, -0.5053502211756837, -0.32367412853542227, 0.218516718527173, -0.3845210298703922, 0.4742906064367518, -0.16267175606209544, -0.36329486747304296, -0.31271965153986836, -0.219462447770794, 0.12863174684070988, -0.44139696293101666, 0.2096047223888925, 0.33835969343512134, 0.21223976300699623, -0.22544758541315196, -0.010304165569461992, -0.79709607999137, 0.7527508239029838, -0.39905675291520876, 0.08062090587546765},
    {0.8303947929443837, -0.6607291943354585, 0.8951146603932477, 0.5785860897862399, -0.4842236190636188, -0.1471650127616786, 0.313185563197627, -0.7133998315555774, 0.10796093442578315, -0.0025565193737720816, -0.05369472371671742, -0.8025693253110382, -0.18557861439112408, -0.39712800915816093, -0.006296872365974698, 0.17631459469432467, -0.5087480067773057, -0.44253436023946985, 0.08286747833613385, 0.10839943756759945, 0.1592654676651785, 0.026440692499635942, -0.1320439146326554, -0.38806866339612744, 0.06370661945246649, -0.9134826117305879, -0.5371827068665653, -0.02249253336897774, 0.002754163170132661, 0.09256333991678795, -0.4939654741537665, 0.07984711904494043, -0.36801014840151053, 0.5955524756781131, 0.6790610560940904, 0.24390152045413901, -0.04090875645689805, 0.303540107102013, 0.40329450257075955, -0.8275038372997977, 0.08433825965382603, -0.3353362911102624, 0.09919862951602144, -0.024612881671394953, 0.0405995416232339, -0.09342659198077741, -0.25658944556093605, -0.1554445023500646, 0.2090195192880328, -0.4993149856916892, -0.38359055344085724, 0.01884554179608707, -0.054733469661495476, -0.6265379463534729, -0.2910807044174606, 0.3748715731020867, -0.31537262254253456, -0.18879799257564775, 0.04934919006888273, 0.4125841241703964, -0.4894006316684601, 0.10384830749936659, -0.2732734178300235, -0.23498289261735503},
    {0.21644288997299507, -0.4037386893759323, -0.2912125216187901, 0.2687030771238047, -0.015283815309609714, -0.20259468660018495, -0.026322530382712383, 0.18813329139563284, -0.3068269523229501, -0.432305378257815, 0.008362714091145728, 0.1570323384037167, 0.4119636809489383, -0.6991761431977278, -0.49523262812355057, -0.13056548146669453, -0.27133120232565744, 0.16527254156271706, 0.21964018546972106, -0.15158004791717608, -0.2565611008519402, 0.15392374993011113, -0.8571665971321303, -0.7630947039385662, -0.21952431721991894, 0.26101208502120427, -0.5088827662409899, 0.33075996111985395, 0.2885661838506755, 0.3000963919046274, 0.23629552206095547, -0.32428735783572626, -0.7372760314453911, 0.18586489887138263, 0.4287330862624459, 0.16736261619240772, -0.5520387905770694, 0.4049968608869403, 0.059791884212748704, -0.46590098606511593, -0.24968768076837425, -0.1169539385892266, 0.5315453981630194, 0.11164435446895636, 0.11962416476198126, -0.1099318396716405, -0.19322870440722864, 0.09582824068638066, 0.3207928616433017, -0.4385313535029214, -0.7765497619424964, -0.12672610576286703, -0.2464019339381476, 0.20735743741690527, -0.29406570059894405, 0.3889951338939636, -0.4934646940887796, -0.9155118081288365, -0.053347026224730455, 0.019727380354568416, -0.27909597968722366, 0.6728841682229444, -0.30923733418036226, -0.04811495313534351},
    {-0.49448237982454035, -0.5423394184442182, -0.6016571705753017, 0.20007621367177558, -0.17944211628590095, -0.40197489370959777, 0.4307417103573595, -0.389788838938035, 0.20766779972450922, -0.08308995130971569, 0.3874313129240685, -0.1107932961568825, 0.6851862470988812, -0.1263401926585481, -0.6344461054927871, 0.43513747437286077, -0.2583856084807289, -0.3604595732980049, 0.5655229901516362, 0.4992552447536187, -0.3628211920839558, -0.515503939647578, 0.25559863268261046, -0.6155181147282401, -0.6138291725808057, -0.33992689905911844, 0.1307663024131314, 0.2772939419565515, -0.0758668462917106, 0.19080160196748616, 0.3508526156997815, 0.0582818107494111, -0.47940829165903576, -0.15710403123291436, -0.0902467891089017, -0.19224433819599246, 0.4625579465567352, 0.785165974088495, 0.4085869464816557, -0.6809780389168115, -1.0008670761454372, -0.16051015688779138, 0.5820080060320851, -0.15745141730573445, -0.5114114578158583, 0.06644695532757378, -0.1377101008098557, 0.23081586542465177, 0.6714705522062431, -0.3208708589400098, -0.29206304195060523, -0.49235022601028683, -0.5108600610894334, -0.6388856260175811, -0.29293623727898555, 0.06450990006892417, -0.4929550611304481, -0.641925427627171, 0.23577865132960765, 0.1716568142360052, 0.30563566000141723, 0.22784048915826208, -0.7898989606352192, -0.1243700255558545},
    {-0.011265768971738244, -0.25888230852807803, -0.05140173795869498, -0.10815977119861973, -0.1930432051008777, 0.10451391669312328, -0.549748368966135, -0.05013475290077566, 0.04712915072511773, 0.04802158743337079, -0.33005752189630594, -0.15596175387487274, -0.01699097231977394, -0.016443066705568242, -0.060796688748175544, -0.2664993786418501, -0.44933319767743823, 0.043889227011223726, 0.08998174957653528, 0.30395251374655335, -0.7333600902219016, -0.08422699117929905, -0.08902414193180995, -0.15317482267065988, -0.3930990031113143, -0.2336015725767844, -0.03927131440092226, 0.25978310071190847, -0.08899342780250884, 0.21754724754903634, -0.1705209474450651, -0.10959544441034633, 0.16759094420327514, -0.12131058199581017, -0.3670955013794015, -0.07647128135477602, 0.29868363917299284, 0.8993609122065427, -0.4435055248222072, -0.16509656645292137, -0.29024171100021895, -0.15705933516628967, 0.2993188904385371, -0.13376833918695638, -0.19891140951220965, -0.14928221285631807, -0.06588617196088808, -0.2977232149870896, 0.4381322596773599, 0.12773827507413113, -0.14937632520792318, 0.1797947107248228, -0.5821641477051661, -0.6749470771391197, -0.5517699314180714, -0.3260037865457983, 0.5876581054589546, 0.03734519916619272, -0.053162479751570034, -0.16378036754008904, -0.5170025883517245, 0.22315655292798317, -0.6319794711050447, -0.3561218602782047},
    {0.42543116037997747, -0.43167756903072635, -0.3915178406403366, 0.3539846342319983, -0.239918090441133, -0.2505647795001848, 0.2483699959663859, -0.5963141882491879, 0.25946517778802847, -0.45914093416385005, -0.08654285721025713, -0.23598606066574443, -0.35544274253306624, 0.0895785387927509, 0.3689404437613394, -0.17565495308248946, 0.15825698471710048, -0.030463399354812522, 0.27075969484933854, -0.2902928581871134, -0.2855881739333005, -0.16318894584917806, 0.10365821050363766, 0.29393357405071285, -0.939309559285487, -0.15531556073320893, -0.16515127148242711, 0.21941187027539302, -0.054369251069128696, 0.3722442658682861, -0.052613594137945745, -0.14225623414990757, -0.14609583063904266, -0.7535468997896808, 0.3467178846904352, -0.2684128796919482, 0.024839274221090883, 0.47862890666232166, -0.07733611703530631, -0.46616960650925404, 0.21165805981671312, -0.15644105194598967, 0.5340288235800764, -0.6929218650155151, 0.23735049131649605, 0.2768028531905471, -0.9409621926169562, -0.048659831764284574, -0.08504412316401555, 0.3968266926379496, 0.06499189190807787, -0.47367228417841434, 0.19204406735567373, -0.09650303440758867, -0.267692230955867, -0.6948168037837541, 0.6226193420893376, -0.572895582986163, -0.11510852286349767, -0.2905010971035646, -0.006888360272171646, 0.2055556242262851, -0.08480022275176043, 0.11786269496045294},
    {-0.0749304429948233, -0.5148682877789568, -0.2742561426831768, 0.19794258791369734, 0.2749363407431538, -0.49411614818583316, 0.4276109364145285, 0.18534173844340018, 0.32040791427110576, -0.4448220907128612, -0.13105910054501757, 0.015201324145626489, 0.2349650041342354, -0.38368428698551654, 0.32560833340813305, -0.13682009447359092, 0.1672104206110242, -0.585092457466379, 0.19803721434292995, 0.39105581920662913, 0.14326973716674948, 0.08493004779623768, -0.12114351633030328, 0.18537593431675398, 0.24566824273199805, -0.242548182850172, 0.6019901312205461, 0.7116527862305375, -0.6799140407350871, 0.6241292399811914, -0.27058479339421776, -0.3823999824778888, 0.5701614906063949, 0.26902199280986144, -0.6640738762566549, -0.3331478122311493, 0.07185917336485315, -0.36909100628116653, -0.06066860595986034, 0.23293931607708565, 0.0016558427082267457, -0.22467171111093284, 0.16841721493768688, -0.10729395420779093, 0.11859759295176325, -0.12525904883978473, 0.29072455417666726, -0.5946378247243861, -0.11118695602612312, -0.05081463797089989, 0.5466143633606229, 0.3728232234214589, 0.27900187029270274, -0.4575126117243686, 0.07141995081894191, -0.023055660406077556, 0.22456751001094935, -0.12346341959570328, -0.6683359769236787, 0.25366321092925836, 0.23524327914954724, 0.05582512058982317, 0.057211063135233116, -0.15448076355892024},
    {0.18313775045703481, -0.35190808113425914, -0.44201662489502624, 0.38303959896853734, 0.11873588044820178, -0.5018605210037971, 0.3085302156797756, -0.10137617184702562, -0.23267097732307185, -0.7401037908486332, 0.0931098157683367, 0.2619660885639776, 0.1805294035927459, 0.2604084797127807, -0.35976809648145, 0.8276379756192068, 0.3729262638422403, 0.5580208567416564, -0.5912689784094703, 0.47806936337018946, 0.023012535087775374, 0.4415160672490734, -0.19641581359634536, -0.24470243809205122, -0.12803032597477979, 0.390764163769814, -0.5370816352042116, 0.09466349234423785, 0.18120111445053763, -0.04583682576346595, 0.2793245538023467, 0.17005157140671928, -0.5414041424920042, 0.2435815976194564, 0.25767258278428024, -0.05929918262618116, 0.10458894571118038, 0.6819712675115974, -0.053526715655812365, -0.13553947936875252, -0.07501692459129804, 0.0400690698334024, 0.6572053634245865, 0.18627958512593654, 0.07447601511853855, 1.1180281132381271, 0.16471034238468546, 0.45009287771789425, -0.08958142418362512, 0.06625158234468675, -0.13799579014179922, -0.34742030659340245, -0.67554227313658, -0.25868059731737697, 0.09040128411106213, -0.6538106861336915, 0.2893497512484591, -0.25428920009406053, 0.3241548139236677, -0.14175742011309964, -0.38259832007039185, 0.07440641127025979, -0.7022330056533924, -0.23802411723475692},
    {-0.08397462699392164, -0.05647885254701536, -0.1614995780512494, -0.04082727554936337, 0.28308676748064887, -0.17677004919383174, -0.08759937702410217, 0.0009006293191481243, 0.16443288587184554, -0.45102109660227047, 0.10389158989846609, -0.1512576700518831, 0.5976453931761572, -0.14646870159315006, -0.6093103256023139, -0.035556233132296854, -0.30980847952535, -0.45257830326185877, -0.48863610980236044, -0.05993419247990509, -0.13031984773673627, 0.2001779964314252, -0.09866817905592935, -0.06170264227548963, -0.3474982982355583, -0.07879350738719344, 0.6345238829400561, -0.0603553925621186, -0.06978369108329044, -0.07038354266292049, -0.15927268485346696, -0.3406773299842616, -0.08098812060687055, -0.24174486808076687, 0.011415765494121238, 0.03682629152655914, 0.04418586436729555, -0.4084280852617045, -0.3112983066684556, -0.4458444531424688, 0.7645957448530838, 0.01750306390025327, 0.522713024859897, 0.27913034053159475, 0.47922986298416764, 0.33903403428825474, -0.36230599694808097, 0.6763035567873704, 0.023791683942303764, -0.02639189003340038, -0.2741850264441062, 0.25076126604265675, 0.10552616742216432, -0.05234760396112506, -0.5969802337378469, 0.39568009384429503, -0.056813816789508365, 0.010242226316960984, -0.08221792352526534, -0.661944291673736, -0.08485664198420806, -0.197242899811516, -0.04475314485948552, 0.2275638278752897},
    {-0.4023226317503287, -0.054682237618411025, -0.28807927190635524, -0.44772434432572616, 0.33420835883683475, -0.14302195800653927, -0.23936166053345703, 0.4785977678528072, 0.17586664417381886, -0.14190431927114697, 0.16137442046430467, -0.05164736292428098, 0.47006493331691507, 0.35582161296937764, -0.7525004875720603, 0.13647218323064064, -0.5699198745704074, 0.43833494641134657, -0.2912906953302903, 0.4743703275029239, -0.036163938096714365, 0.5388400704043523, 0.20800688318705726, -0.41498057916438685, -0.46077495491543785, -0.3733413591898794, 0.2622325171945712, 0.20043395095120595, 0.5676616240693428, 0.13566129997122597, 0.21584331513157673, 0.3092417257714815, 0.6097390509785935, 0.304566493031896, -0.25529969598023194, -0.022622173189373335, 0.05574309811071708, 0.1648756268259948, -0.06712367446155469, 0.5970799451593183, -0.5482449019078753, -0.002153835252755566, 0.3899663479503658, 0.08188559744435871, -0.1865691819543299, -0.1781193839017092, 0.30095935942869056, 0.17892482793840064, -0.09550970578720833, -0.4264512996821416, 0.2049552633015532, 0.09421280524565927, -0.30078923410440095, -0.5296052284756124, 0.23013555964191063, 0.7286555987817248, 0.5002236870241897, -0.029655338284584647, -0.4734637308905818, 0.46024230806901884, -0.08091728888903975, 0.07083428080259246, 0.23889565257297782, 0.44647318715589435},
    {-0.27847914433930476, -0.3273350111410827, -0.35500306833697004, 0.11519935522586182, 0.0254516577203284, -0.060537931386057335, 0.008795983918550163, 0.041246560378082206, -0.5950064639697179, -0.25832703674163343, 0.24458030390254085, -0.15811484615067958, 0.19467725580183676, -0.3601573345324401, -0.4851167686833359, 0.2796409910938732, -0.4060758626415345, -0.34594396868379684, 0.3868311242808537, 0.6164884541230315, -0.5373313964758687, 0.24475499242171198, 0.29814145887904225, -0.8462129445175769, -0.3547048307595586, -0.03602134240070224, -0.0015095700277072558, 0.43205274655315307, -0.38781644647416763, -0.13205869193173245, -0.11024333864475058, 0.37533183737367054, -0.13596534696743165, 0.1997856645822169, -0.08152974771779457, 0.27896890310875205, -0.40387999624260684, 0.1304874867483197, 0.004257744866506904, -0.2787955564204831, -0.5496849855392847, 0.1370611486940159, 0.07963452317157499, -0.6307571930690761, 0.2768388354795237, 0.030294279606884366, 0.10477982666205476, -0.6009570312423193, 0.3094598460079745, -0.7948042774372436, -0.4576333738677668, 0.03977148030456594, -0.4501170591994737, -0.6040872673461527, 0.05581799011667854, 0.38086750285068727, -0.5883991984703338, -0.16811509974050862, -0.017463904709325784, -0.18832680290665288, 0.24930511013479856, -0.1958098614701823, -0.560871512198456, 0.2854734980302141},
    {-0.583772739086588, -0.4906852293384602, -0.314580529570198, -0.1087823933061964, -0.2153881563649209, -0.6976761438381825, -0.1470452936078611, -0.34912693035224845, -0.2873276864960591, -0.14970218016747194, 0.26301396642711566, -0.09761689127133924, -0.12058504982636375, 0.08666378843489501, 0.36822322386040063, 0.0006430655720786082, -0.5898200752678453, -0.26402285095847056, 0.04368235801096589, 0.026194268039789047, -0.30620103557591893, 0.09769160183010463, -0.33813861249718463, -0.1836650261697887, -0.388443518194693, -0.03828756464928544, -0.272064310105321, -0.1414682971033957, -0.3941257854727694, -0.1916374757733987, -0.129656580167329, -0.31857699362131037, 0.056666266007722135, -0.5299916995981989, 0.42625735304869095, -0.010114941254133888, -0.46161418656957326, 0.2575526998936499, -0.4289002274707947, -0.02436563216377039, 0.11387958144171319, -0.02085079472785573, -0.11227895700060539, 0.5632274350335439, -0.33610875206478824, -0.4472945714476919, -0.4426158501982194, -0.38932114174920945, -0.48043883689593614, -0.2160602901031799, -0.00700321005679051, -0.3796131663508896, -0.006030080857195148, -0.9175516519795146, 0.4364607131245711, -0.02066776076403934, -0.4366112328046865, 0.029765094511173713, 0.451760746239378, -0.6257328648229026, -0.16971034208631583, -0.11165770774107835, -0.038624517672468175, 0.07206627883583001},
    {0.045084839275032935, 0.15728782510697492, -0.49470783574036264, 0.3026290349154329, 0.15370180723551394, -0.29755799342029027, 0.2682966008465793, 0.0333015794460565, 0.07230703198927171, -0.1421766077898123, -0.4322474827492303, -0.5122774141728225, -0.49984015748798527, -0.2797445506070401, -0.21120482423418144, -0.047294406346721905, -0.1956579520433881, -0.4666039428472557, 0.28319904391652073, -0.04171056832239845, -0.036597567153853885, -0.293623419636769, 0.10310391470878925, -0.2269486304717173, -0.21111527503808475, -0.28325339810648664, 0.7474588698800045, 0.12510356308393678, -0.6055808604774815, 0.2215664102972132, -0.6713469028787441, -0.21124333515092125, 0.0575952613140372, -0.25311467337865157, -0.002047903367921714, 0.058372694406212455, 0.1889983339129477, 0.3005599566661269, 0.08591665366444491, 0.41638289183178423, 0.06505278016463835, 0.1335238002006269, 0.1732714038205868, 0.1681619908338864, 0.04572623946805239, -0.3212318842477034, -0.017822269029618098, -0.4506450671643243, -0.5619230921713964, 0.4754789737274139, 0.5469137273160912, -0.7978143027737602, 0.11505256676657949, -0.5979760826975047, 0.18113611954432257, -0.07894760078431624, -0.2960901358287543, -0.21356626306971968, 0.22300033267443814, 0.25914865783208874, 0.06900355556983705, -0.9167820031468839, 0.547570530211366, -0.639880924394452},
    {-0.5766608308236252, -0.3450605384258397, -0.040888960335867426, 0.06903011354700081, -0.06397121891981516, -0.4369514681775277, -0.5750255307303767, 0.12620031231709178, 0.4880090236354253, 0.3480956114810947, -0.35587075889980535, -0.1732414087499014, 0.06326278437359084, -0.2351951544892386, -0.49198229944900873, -0.46075236187417634, -0.695737247557974, 0.09667268209044313, -0.05628275800695156, 0.3291663233167001, 0.3440208115297409, -0.41078752981019356, 0.2855018250950154, 0.3483217433910267, 0.25528252450335753, -0.5406417310206457, -0.5798683034669208, 0.0727835805438362, -0.09430143497448651, 0.34721288077755447, -0.05916581130247512, -0.07176363167285928, 0.1406266361632015, -0.6791065489396623, -0.11372393326777407, 0.18232474933085976, 0.37928731991976755, -0.4429174256262971, -0.009446786302172118, -0.11470937804177102, 0.008801818876174925, -0.22572222981057735, -0.2791083766531584, 0.3194238141680801, -0.21145731035358023, -0.25759625303323436, -0.1844800298904662, -0.32317677875353185, -0.21081224008660454, 0.3934396948024707, 0.6432977997599507, 0.1899287411165082, -0.16512613526630804, -0.8055806999740139, -0.06195675417666591, -0.07819815107725508, 0.01095744584012226, 0.09487796924188208, 0.042345106406353, 0.4354689296882931, 0.21827269908901684, -0.46463178685135975, 0.6224994901967704, -0.5171600212244836},
    {-0.2603898742370574, -0.24363372000964245, -0.24021559189814834, -0.1890727361557284, 0.11153301775714587, 0.047262989980187534, -0.009863016339314223, -0.4782616849281588, -0.03287990880719724, -0.41231904543854797, -0.37760944076959513, -0.09160984182796052, 0.357942548067634, -0.5068156979651377, 0.16886213107521944, -0.8341886192717872, -0.32434491708044455, -0.4211048393043849, 0.0009125852143197012, -0.7525201745243902, -0.3277704209484821, 0.020306047694977434, -0.4243577552043937, -0.2568188422780745, -0.3569350423923079, -0.19158700292792363, 0.13866517125273992, -0.04856888746738239, 0.12618296043634267, 0.017188572437952264, -0.048402861680395884, -0.44297914274360106, 0.1293044064178809, 0.06176774934391467, 0.04486941439515148, 0.006422412970390419, 0.03470934957784788, -0.48921394155872056, -0.5769616636422304, -0.11492405264271369, 0.2078792269228659, -0.13190916805697758, -0.21901844450851068, 0.10038526311745286, -0.22315881259832998, -0.4371035344995635, 0.037137059368762826, 0.04685562374612165, -0.12597702585152906, 0.09094965989446056, 0.3553203844058734, -0.056267777396244174, -0.05245530569339154, -0.5609358417290411, -0.067087510115708, -0.47920291810411797, 0.032574851467263695, 0.10574997395818905, 0.5934892453610626, -0.18245472977717875, -0.09291958698351815, 0.14261850178793617, 0.4785126188319062, -0.0875952932918441},
    {-0.47269958393522366, -0.4138477367895296, -0.10594235360829592, 0.1230684750976517, 0.5280689861575218, -0.30875507225803234, 0.19038891405870723, -0.5543204711309467, -0.03420913299557885, -0.13181957080731888, -0.7845882668558619, -0.5481805910966228, 0.0185342417054377, -0.014482757236540668, 0.7988268299562569, -0.3703816527363757, -0.19640466033852977, -0.6277945896262687, 0.37396020610231384, -0.5348336645091364, 0.11760264953819767, 0.14749201040625937, 0.08758407169933473, -0.35647301029795586, -0.062093168734779824, -0.18926604421677404, -0.2247707727051238, -0.442348323479141, -0.39311116078014335, 0.3255368723881541, -0.4742742112942356, -0.18324056405507086, 0.015850490923221303, 0.03167884170031909, -0.1456526225730331, -0.5482243694944146, -0.14439778606338283, -0.7746880239586722, -0.442841736557263, -0.13425079361723266, -0.197439987564635, 0.10733522707946218, -0.0889232491193709, 0.3542927454722456, 0.04744141398641375, 0.1220562121052867, -0.14737794855676092, -0.43936404035594745, 0.32880855619384425, -0.2680301093334073, 0.3954158556887502, 0.2728675484755563, -0.21735119488409177, -0.4564171738071909, 0.09539705282557931, -0.0441685237493104, -0.3430832584601747, -0.5107092391411149, -0.07750592848850396, -0.8844246718606066, 0.2871761649838331, -0.29054043808730257, 0.5933810208380546, 0.12409292145712135},
    {0.475954341940276, -0.7032637244972654, -0.6019034902664565, 0.11291811721835428, 0.3459128410690019, 1.5017380640132197e-05, -0.4568343638791101, 0.06542372062666797, -0.08527096561863912, -0.046391038871353873, -0.39216284516790695, -0.7545948259557952, 0.11303769726834823, 0.22488715793603864, 0.16814678123339516, 0.04412467729547728, -0.7374100399385308, -0.5166188834435312, 0.3801134753659444, -0.10691646989900114, -0.38222668210128563, -0.29110787239481495, -0.7878083484244183, -0.4804981404902926, 0.06525192823877361, 0.4429360076441341, -0.09343633708506167, -0.11138566594372243, -0.3077248882238031, 0.43761169311761233, 0.39914543971707245, 0.07064713447311041, -0.5537667631916169, -0.06004827524995374, -0.7679301520834136, -0.20481298069039403, 0.4291816343566104, -0.16670830625977298, -0.06976846271133211, -0.07176678215999913, -0.2647238254077492, -0.5022234486221214, 0.21278958375973903, -0.7216111199268871, -1.0537284187742935, 0.09685723341421056, -0.10854768408614413, -0.0916071658181244, 0.22325234981685227, -0.38456232021858, 0.3419984575596659, -0.5110589808066922, 0.15129594402414215, 0.49497793823215136, -0.0798354517346342, -0.30708790761897825, 0.4627997575859986, 0.023564984468499042, 0.18383715534004047, 0.5037158067668701, 0.01710740797272892, 0.4530771720239318, -0.3986505044029281, 0.18671473480439213},
    {0.16946124959564346, 0.009565436998785629, 0.6247608930431968, -0.011204229420468278, -0.18295401725877483, -0.16399322144246611, 0.22144870508473039, 0.5796677456547744, 0.36258479919857745, -0.7204712285697499, 0.15816148752423811, -0.43757972162852454, 0.27393897858677396, -0.3513992737252741, -0.7369930135237127, -0.16127993657601544, -0.5660002702791196, -0.0693951491962511, 0.1026765436876196, 0.5311874035053221, -0.1602382514339013, -0.19548608262724, -0.6747535366497496, -0.2245740149940395, 0.04071639060190699, 0.16952869558941416, 0.3394398102626081, -0.08048410713133751, -0.0790582887550679, -0.26600355824657695, 0.2526967174583727, -0.4619256506124722, 0.5995148037728367, -0.43756342779513546, -0.07251306485902415, -0.2694502788913778, -0.1376079338337292, -0.5324967620473742, -0.43056920124166287, -0.3744474591756883, 0.25256511174276625, -0.4812306586953958, 0.3096173278825159, 0.06909743047474212, -0.5119021378811344, -0.4258256696236688, 0.2881729066113908, 0.440508320845026, -0.023855657050445282, -0.21957907245950725, 0.1067188077640902, -0.2311607460372772, -0.5270662297474507, 0.10837712011771265, -0.028702402614861247, -0.4861588868921665, -0.12711992285963034, 0.22892162221162132, -0.029133119079845945, 0.2931128680118357, -0.31898502939121076, -0.23743485216386528, -0.1572881307140019, -0.8857217673999678},
    {0.7368732224146222, -0.5646896830006802, -0.18813073612380007, -0.007958816703739555, 0.20238514852107284, -0.18846288139884168, 0.396354158693977, -0.5514103034887765, -0.03506896381935692, -0.1040944156784173, 0.23618777380304443, 0.6167439561676109, 0.4071854424403837, -0.16612568595007715, 0.01179713310560638, 0.030794046112898706, -0.554248071357381, -0.5017940795757625, -0.3769846362766414, 0.5850821087051894, -0.06952170229672834, -0.358093042533165, -0.9051405933462184, -0.1683807475132143, -0.07301770802249019, -0.4813018780004032, 0.28473126153872597, 0.010056326881162713, 0.23721679425773726, -0.426448667239495, -0.047723964276755876, 0.11552493530209822, -0.5907701543689768, -0.23769011639118298, 0.15275288920937763, -0.6019821599082461, 0.14708119260861963, -0.273872354792342, 0.2791472720646128, -0.23537458967749664, -0.1978109134334644, 0.3227612313062475, -0.14976876626541094, -0.26109816269605585, -0.44266261982512595, 0.30913126162724064, -0.5856082816052239, -0.02586525391810894, -0.13348948480612646, -0.49492538399181385, -0.36818265348504137, 0.021083003185083517, -0.24411297678999339, 0.21306161391598633, -0.27142710197778025, 0.3114903573068097, 0.05611376247231302, -0.823353489733172, 0.17562985870080983, 0.3549935795970695, -0.22289313963433133, 0.3521850460158895, -0.03757631695957797, -0.5232171299314957},
    {-0.15541800592763227, 0.06061299311979388, -0.08878051199220832, 0.48161614209843207, -0.28051552575041244, -0.2337473963450688, -0.3129160369891341, -0.16317541832813343, -0.06366880623147635, 0.008131398688889518, 0.13234865009953675, 0.16807515370546625, -0.39739148671694835, 0.6940529796451274, -0.39917037324917987, 0.27375493763635217, -0.39755133364062556, -0.22902076696447435, -0.5727586452621476, -0.5422258433053736, -0.4432171201078409, 0.15031519845785074, -0.6233435236213539, -0.02837845208393794, -0.24626798591286567, 0.594943421779057, -0.3408348975676522, -0.15574070425157618, -0.013843696771654132, -0.4573912304182415, -0.40362008019011747, -0.16503057805455046, -0.2648940880450331, -0.25493592473833565, -0.1378701619997214, -0.574725995871982, -0.15146754007519572, -0.1993575560714845, -0.16990258923620466, -0.746768588787772, 0.7195401970497917, 0.25151725883783055, 0.6158411096604037, -0.5156282947788685, -0.3494757113616167, -0.34203275762460283, -0.3494308161879896, 0.927658808914589, 0.1888205378284604, 0.3433872789005975, 0.3045635281600066, -0.7242663987283795, -0.8311427259948432, -0.3565551204602593, 0.3973567514311128, -0.4217429930018644, -0.23957652109647473, -0.506904739068958, 0.15991587835217447, -0.14640079100338857, -0.14439453986464704, -0.37435206493858836, -0.41225082071195157, -0.3568207090537798},
    {0.17356592978609903, -0.13608460543558062, -0.2428396515432413, -0.07069028787181869, 0.09884138578625029, 0.7982033105840264, 0.32553587516080035, 0.705641534269895, -0.08522162196252879, -0.630579825645338, 0.4387150897627183, -0.021152873725548228, -0.1615746757861873, -0.08117591532139648, 0.11128595756183779, -0.15861542028162637, -0.5381417789058415, 0.19174720141690402, 0.29054074256065604, 0.05829937358645408, -0.04868681734460152, 0.2999252991405057, 0.4918128773206533, -0.19805319950805783, 0.3889642549644318, 0.37736265081612935, 0.5711774741980588, 0.3755545058425698, -0.15974270454773812, -0.776360831510735, 0.40012008129562565, 0.12245970306677004, -0.09218810905181901, -0.20482113762676196, 0.06818182811141305, 0.5226051498983632, -0.2889129108872951, -0.045768354446449305, 0.4854324271169832, 0.5979409354359431, -0.10133784367917467, 0.35993921735289996, 0.29598300200056227, -0.4224756326196903, -0.22585988282499675, -0.16447858648109134, 0.24084236420407537, 0.6544204646537313, 0.06747199871982781, 0.3939591101118801, -0.5318879276725722, 0.15007191087614266, 0.2788464403684158, 0.5738650283924606, 0.4654739095359834, -0.020943292529583633, 0.24047113360757863, 0.0011143559208822023, 0.5527762103151064, 0.3863398409173541, -0.5266098647409171, 0.24701781228517594, -0.24415918511561185, -0.08381121153176398},
    {-0.38962551004461615, -0.2444396011547882, -0.03484266364100927, -0.32335823319202933, 0.07299653489634692, -0.7003800556207755, -0.10777309750814808, -0.5343479465039878, 0.05021236084323925, -0.4569837403613748, 0.4087625172666538, -0.12833669575341478, 0.009192962454817814, 0.134636302194017, 0.37495048089796185, 0.26095233326092776, -0.3628423438353458, -0.2630210253263028, -0.20802945849335017, 0.5389325219047145, -0.03625558372790383, 0.5976929577671422, -0.5754703580945075, -0.24307395165184054, -0.6298627286911538, 0.49005744090018655, -0.6282055815417072, -0.06155005214165264, -0.3277782228360768, -0.8161616037432201, 0.03882352326019463, -0.6083441686102437, -0.2745768013426815, -0.42765927303233897, 0.001335616650997598, 0.42616114848568776, -0.28284014399770563, -0.31316128560773604, -0.1368669130997301, -0.5324308846842327, -0.4166368519692837, -0.26513521589677685, 0.017092077274834753, -0.3679368895994477, -0.5542336370627129, 0.6597989703736705, 0.680748506709166, -0.22745839836751341, 0.09946610790433956, -0.32455985726129755, 0.08498829892404011, 0.3018056482781134, 0.06013495515482564, 0.26997085126842235, -0.13138677236339097, -0.2682537520432466, 0.3779779616806721, 0.001346249424707764, 0.09955754639358191, -0.40219577838966214, -0.6229721270067062, -0.12066830252556937, -0.13702600037834628, -0.0881291333325719},
    {0.6411501625057493, -0.18449173504049618, -0.4134074045465292, 0.3550913965830137, -0.633445978671745, -0.04652411670903118, 0.07496867386573118, -0.043088118925236014, 0.2009735509197304, -0.17320799945274168, 0.37219373569577013, 0.041345157954280363, 0.37008410419504456, 0.2809365389856274, -0.03081989180337166, -0.05576061478188701, 0.34161691306780345, 0.34952254712500114, 0.24077767836390626, -0.04042529499721017, -0.7610191199623063, -0.3059158194791373, -0.3387386694524375, -0.3465929803497308, 0.15118750599816683, 0.20332575554858373, -0.12690915901099908, 0.13436832979340388, -0.4617607459226683, 0.1623874578143642, -0.45489398094699995, -0.6767555373126428, -0.08723650529449099, 0.010543323114545542, 0.44106742631636703, -0.6515841560814826, 0.032990458472198836, -0.3422786036974919, 0.42446294159609704, 0.11072169602665938, -0.23302964345738203, 0.21606249580759837, 0.5738902121679061, -0.31654149430286777, 0.0927055300062691, -0.09423851485796997, 0.42806641709025833, 0.04863326860685526, 0.4826721724892183, -0.18019556297960418, -0.09426331885112976, -0.6444732433790767, -0.4835163156290183, 0.11888082811592197, 0.1854689522060681, 0.19509182392957647, 0.10972660416427908, -0.8059957310071623, 0.39927859088891254, -0.27668628465376344, -0.2771002416065015, 0.11491239718118382, -0.37150709890735356, 0.3040210998757337},
    {-0.1289563247220864, 0.3261568618538576, 0.19686289158354747, 0.5741751730334331, 0.012415412844378294, 0.4184093022280196, 0.2446397801478448, -0.13157206241762331, 0.3547305201754695, -0.3883315671918018, 0.31226507659243863, -0.09264323010573167, 0.4053823796041221, -0.11407234708168372, 0.20227284174208487, 0.3187192957746474, 0.15617845207779488, -0.26581879064269753, 0.48289595438689775, 0.5555796628642381, -0.39957099087073317, -0.24623947200746588, -0.5202686475075504, -0.035030250774908483, -0.4697145780264738, 0.24794344877684987, -0.038848924854265096, 0.2987453962164713, -0.08122616526807458, 0.1118619674497438, 0.027661993674121328, 0.2423858175247008, -0.791142110163624, -0.4281256842315167, -0.21078048791440393, 0.013996569648778432, -0.04878697421801828, -0.412856659001773, 0.08110011602886791, -0.25111675816596424, 0.4980709466331352, 0.3205337281708552, 0.40072648607246303, -0.05156045988990187, -0.29981587164086987, 0.45433557343291214, -0.1236280876081798, 0.5698445282948377, -0.24835520668801614, -0.3236075431676813, -0.3967785593424991, -0.2014064899204703, -0.7594881629820674, -0.05934955079818934, 0.4207230522645352, 0.3531658188084159, 0.12612934278146024, -0.6449846607137337, 0.28423694310313874, -0.02937824756521625, 0.005054397950544873, 0.5828654257908923, -0.0038936453950714337, 0.44814776685301716},
    {-0.05990702306088546, -0.5327645247021484, -0.3319885070906112, -0.21239705390442243, -0.30579767440803507, -0.6857296184766029, -0.1868884981036799, 0.3187379196781319, 0.3158372620153343, 0.17084417263209786, 0.3485938932427778, 0.06115993922820432, -0.47540173938063396, -0.15428464109950804, 0.04600680758641661, 0.47910379622676186, -0.6165961988668058, 0.6485498088447376, 0.2868963690934829, 0.3117514051413721, 0.4591742978902323, -0.08584733081398559, -0.15301349514387858, -0.5568135479930688, -0.12374403724203442, 0.39562208257244813, -0.3361462174833436, 0.2309241211348802, 0.13439501299863338, -0.21792407425417476, 0.16227102390976125, 0.2378769318981127, -0.6244768790340536, -0.5226426212069238, -0.09685306332121586, -0.06535316017857593, 0.15614086209989475, -0.07449788070053419, 0.7144111866780657, 0.05404000977876539, -0.22858773375429664, 0.44829130362914377, 0.5496813611089868, 0.23397263931612106, -0.017541739024518808, 0.3030714240114053, 0.5525931849438932, 0.16253269160947673, 0.601209942828892, 0.2448957745171197, -0.5720572143467022, -0.09284766554934437, -0.29942890079897905, 0.24283960669109333, -0.11168554550217441, -0.16754844244792297, -0.028543162016429775, -0.008993579326970508, 0.0979203029974978, 0.1228944236070945, -0.5580659035911317, 0.2637789616955081, -0.08988473630824535, 0.1314498694202611},
    {-0.41583602401813285, 0.15740545418025031, 0.30398937955038513, 0.11141357637390328, 0.05462265471068701, 0.3755869378468593, -0.23871779063972393, 0.5056781094609134, -0.5235060512362201, 0.44687631275791273, -0.16301190401435028, -0.2884959843622927, -0.455971203263643, 0.028809640206983508, 0.09181119188584604, 0.2730566904800428, -0.26341903321927096, 0.3677116087764901, -0.24899879050121027, -0.1555276273637275, 0.13282924646364758, -0.14882245175792227, -0.24615408950095152, 0.3522975443039375, -0.404062369402451, 0.037254492860056956, 0.12250203036932897, -0.04378074378227587, 0.2626729137932762, -0.2165760500808065, 0.08599532173824272, 0.5247600630432782, -0.43588813727688147, -0.09692541493897432, -0.3435912967918153, 0.5031807857133574, -0.0041503003224148665, -0.25411066593239706, -0.3828532425982774, 0.5279119751418466, -0.1896044703686268, 0.014177468581487062, -0.022431519452456854, 0.3217575808021671, -0.031483578954771406, -0.5401070471839611, -0.10775392866089493, -0.21172936884980173, -0.24699542631940588, 0.23108048337611475, 0.16066915825996722, -0.11165821768918759, -0.24200446794523606, -0.22651069873970822, 0.13022975670983164, -0.4225036193687045, -0.3144694959988133, -0.2233988684014863, -0.2668976273721431, -0.039218182295143976, -0.4859263852695001, 0.4931361045945119, 0.7129329918456333, 0.08529552337268759},
    {0.41274332760779736, -0.5804014280913843, -0.3715115972790701, 0.15069412654153908, 0.0320828365471943, -0.3169352267095841, 0.010414017763953825, 0.13949060426394327, 0.3383835176013473, -0.019171678217119077, 0.024983727321787653, -0.2068137978945591, 0.5197441287284219, -0.4575086774199037, -0.39833516042535033, -0.01645423049948113, 0.5256975915100477, -0.5230432532055711, 0.14336586329813367, 0.1036364272510988, -0.09606876427157915, 0.2459036146128101, -0.28356034299811517, 0.3553911500965848, 0.08530484660174516, 0.041640197530549275, 0.17055468902392157, 0.022817561341131484, -0.06826251160584043, 0.4044755509749982, 0.30911332695149407, -0.2781231103878145, -0.4369363434599404, -0.4841871919518017, 0.1856278900781262, -0.49812702749090065, 0.04469044751468163, 0.20405248459611286, 0.48290910288152916, -0.20674245616302614, 0.3988976616164242, 0.19211000483033733, 0.5654788132806094, 0.6167502248564224, 0.015882982489495812, 0.18642698569968533, 0.1567777702417753, 0.0008525363711247776, -0.17967789876957274, 0.008135855303342866, 0.44564084001798965, -0.011224734125175473, 0.5337363676735347, 0.32108153998886735, -0.1214060764229403, -0.026153134301130924, -0.1452666105806576, -0.16034267932188218, -0.14533873716400195, 0.04354622013150576, 0.27962851295943875, 0.000692263928664795, -0.12075223561534229, 0.046754148133079},
    {-0.44802914991949344, -0.310934440951005, -0.05707344781382277, -0.4893908111981716, 0.5121295927152214, -0.20289071271460216, 0.15370000348126056, 0.11907446916013613, 0.00788271250451891, -0.2928967031234236, 0.6404928169547363, -0.4782977146714926, -0.10555075231403693, 0.23830869708217758, 0.1409641353749774, -0.03397773895425567, -0.21105566679734952, -0.2121687612869684, 0.1727370654663516, -0.19006237633004372, -0.3473324735883637, -0.3825456435980536, -0.06520477735930924, -0.0056928159396419835, 0.4681338600144774, 0.30724764421393036, 0.24564599024755074, -0.373469068999469, 0.25568483338139075, 0.020577971726406033, -0.2863417021439467, -0.3260701397541047, -0.0025060151320008754, -0.47619667914461705, 0.16520072171058348, 0.017535744422048877, -0.23690136999665104, 0.4454812694594675, -0.05279329084463299, 0.34276172350685474, -0.256482601182478, 0.06283329832091758, 0.03229484671515076, -0.1309303573807976, -0.08432281934781437, -0.23820758465830788, -0.24824756148426647, 0.08169766173714703, 0.19499465259953844, 0.04098590281698389, 0.43978570229103825, 0.31049146325095944, 0.10374692650630468, -0.06483347206162911, -0.09298130562974535, -0.05881251335703536, -0.07937152150925561, 0.2617653303512337, -0.4389978082440936, 0.32373791974984123, 0.1471391244865938, -0.2146864228388947, -0.3240222311636079, 0.08442418802675307},
    {-0.39125123481958507, 0.08753591131920045, 0.3284816691743393, -0.5246501274446457, 0.3083539087461801, -0.11306544861429858, 0.164943972512965, 0.23998069007851605, -0.4780644810181914, 0.019256429940215838, 0.4079303933458639, 0.3561049965866104, -0.08239277847830528, 0.22781463364125237, -0.26866382413783985, 0.4435736752342689, -0.16610103704149481, 0.31942394068923186, 0.20064203463188368, 0.2276986505451017, 0.1034731432735974, -0.3202450386181977, 0.7292917145305479, -0.08870682771461923, 0.32295569639970895, 0.1975981109953863, 0.10157655201201883, -0.3272548106031115, 0.12658967879913205, 0.36098603865594364, -0.489910235092021, -0.15492280313590656, -0.09325096913316615, 0.07985400829058607, 0.07127223567644442, 0.19546782603148338, -0.20708037408184007, 0.1071874797921431, -0.11359226410351285, 0.40182981459261946, 0.15797356493908318, -0.18569625646535465, -0.1741042470515539, -0.11497230378177199, -0.04653164360889619, 0.12195203646581247, 0.46294188660985214, 0.17888529972054912, 0.14008112205241158, -0.12428530136370701, -0.13104354150803618, -0.2722091299826382, -0.3799085111696959, 0.08814094202891666, 0.17623037197500935, 0.7857001078085056, -0.15013591585789154, 0.41332375500278157, -0.06712195995815165, -0.04815452449326126, 0.08527391602855995, 0.22517288447224673, 0.016684728208878178, 0.559860853560872},
    {-0.23316147294168443, -0.29431958542740433, -0.12092137645200302, -0.11021156084197602, -0.14168616282984656, -0.3264389355584465, 0.1567923750760572, -0.03548919144089544, -0.23723166271223603, 0.31852984680755525, -0.20580669087475784, 0.057763102269665446, 0.3142283256307162, 0.07233970376549163, 0.05982622012219483, 0.0028582198394316526, -0.030976917281048, 0.2102484630382807, -0.009581496931541639, 0.11874824466194035, 0.1992598161989786, 0.11004816126244585, -0.15930753536917452, -0.31637438536849966, -0.17072100656915773, -0.012953824767873963, 0.03457124874979707, 0.4278970460009814, 0.031154787360728905, -0.18998641264505203, -0.04170275424962595, 0.20197408281213913, 0.17354229115744638, 0.4587747772241201, 0.3962251690329519, -0.12217819942748222, 0.004747152560090741, -0.2924785518497088, -0.3616313105475327, -0.6179673150402512, -0.19258840823653706, -0.24749255922053365, -0.35859885080687587, -0.2522721723898199, 0.2219177534780861, 0.439793359925083, -0.30013491369802087, -0.01795503959826071, 0.293834825177509, -0.2667974523312621, -0.3214737991892834, -0.1863507756731525, 0.3097831794589976, 0.16795374256755802, -0.07333857073348805, -0.1744296847192087, -0.23032924912039493, 0.40332712150937683, 0.11595131133686287, -0.39141601665958, 0.5222603344619579, -0.20149875699238018, -0.6191243918779128, -0.4799154563842007},
    {0.09356478261888744, -0.5520825558371113, -0.10203232992838586, 0.4408444321281153, 0.06925730147545948, -0.09007252244535785, -0.08033239930074525, -0.2431712306838614, -0.35490667456645963, -0.057258491416789105, -0.21181384306591466, 0.1256210681343941, 0.3285093883208123, 0.13812578532885333, 0.0033536908510032044, -0.12242538115443045, -0.1305390965963209, 0.13812088909809517, -0.2817359191563833, 0.1459627204331555, -0.4339228066174277, 0.2354875944100094, 0.48300477899853694, 0.030406893497527215, 0.3046895637919586, -0.1582563489529952, -0.22569082367920532, 0.3780939391321462, -0.08695134853740442, -0.251337582912969, 0.32768950240947, 0.393874071785769, 0.2506265223209393, 0.8390534946735655, -0.01186540578891268, -0.40292035451567493, 0.5005357906526549, -0.05229609517751099, 0.036432561789447496, -0.12139692346305193, -0.271794136229645, -0.3796356256714633, 0.03289418433587127, -0.867016577191038, -0.022537119253107477, 0.4308641561096754, -0.14332196361121652, 0.3131387501926369, -0.01116992986835097, 0.07991861840115796, -0.11278593488022767, -0.1891247284502641, -0.227571283505586, 0.4002144898988556, 0.05977543340584122, 0.16954351590629296, 0.6288225188877007, 0.3550013132421291, 0.6256003627939111, -0.09798700801897023, 0.17477242040544338, -0.028926335822859396, -0.1468789836137735, -0.03895131466947448},
    {0.8752893000661048, -0.05821668134977852, -0.024390473720404014, -0.10001985448120262, 0.12775367152600986, 0.43734387526240676, 0.13408387096349098, -0.23971053602402861, -0.0745869904386411, 0.2447728109472544, 0.39066524861141194, 0.17570156724817493, 0.03544439594678546, 0.20135651033660518, -0.04437392983049812, -0.2871899266629955, 0.38655313139751885, -0.09324832565835223, -0.10011587708860556, -0.06528613120164743, 0.5246508830461338, 0.03166681844129597, 0.4996111006804552, 0.20577287815333026, -0.10944306578941704, -0.2781246013971997, -0.16291293993222022, -0.16200242063177278, -0.312623228595144, -0.38257725882993887, -0.2557865108197472, 0.26987540028387147, 0.23648052434375816, 0.6157949812340611, 0.061486967639066636, 0.3049610958936684, 0.1270188343861974, 0.02255636744870775, 0.10972080567224748, -0.15098977695137142, -0.15657369451263, -0.13588904360433227, -0.7235315591422713, -0.3282833303151365, 0.19298649152712755, 0.17100514001648906, -0.06688539343576218, -0.11855899887373467, 0.38771347579657683, 0.277006979463649, -0.25071434810670723, 0.01394038637528889, -0.10622601007668654, 0.2520815024357409, 0.32892457337429515, -0.27343245726716475, 0.6556517945859917, 0.18310291953387633, 0.35834959616318657, 0.22015128161643283, -0.09389776833081341, 0.22055270994863477, 0.07000050208590854, 0.1908714005118176},
    {0.15279360432216899, 0.1601094632610314, -0.056153460166566756, -0.3652619665191539, 0.03878932205248999, 0.12638933940694685, 0.2932305834219172, 0.35083926339308585, -0.19320963151546602, 0.04381135239132145, -0.3715445232886809, -0.23268451437343549, 0.5374901231724971, -0.34466488181086624, 0.25487361489461163, -0.15536805015694632, 0.009223878516255534, 0.1313565210280384, -0.2948278793522696, -0.1818352306525198, 0.07448181140891312, -0.13001583690320662, 0.2850953723374867, -0.06347077763654665, -0.3308478335969212, 0.10262692655134775, 0.13615431405000777, 0.27952317651832564, -0.03284520612701685, -0.6787242408373478, 0.165190503057349, 0.11819414977165708, 0.17966138040544063, 0.12091655732108667, 0.0339537360889952, 0.5138958054831356, -0.06744788901174806, -0.053695123544272375, -0.2405138725795512, 0.30306441856243105, 0.08067754255531671, -0.10612253803811716, -0.4438594969041897, 0.10372263619029624, 0.2448039928541264, -0.0765144588096333, -0.1451893531723844, -0.02453521246494373, 0.06735460889602547, 0.3077392742755872, 0.4027613014410959, 0.45759268696664596, 0.47836576101790096, -0.24392575590843155, 0.13092067164037305, 0.00983337821293211, -0.15723054339594492, -0.18696981269062746, 0.022771467369334563, -0.5546124135682537, -0.30589845580496805, -0.3076720602340466, -0.2712367710764886, -0.8299525771690107},
    {-0.6286716083536017, -0.05683803446781004, 0.03357827572512893, -0.42525803904034143, -0.5671354512317708, -0.1461347294270516, -0.17194251368658287, -0.8482710745077755, -0.36001649480111086, -0.08148846234010532, 0.01244631510637112, 0.17811749268804503, 0.604560007745395, -0.1386873471015047, 0.22667766888748414, 0.18303200336262995, -0.48179286301251634, 0.5350019209767153, 0.1498645920651763, 0.33565057487281863, -0.300904449609291, 0.4844842013138303, -0.400697057188979, 0.12064961358744498, 0.4315839869963036, 0.22949750197835306, -0.20702247410036476, 0.16622522816020174, -0.13636851435912203, -0.33961697268005414, -0.17295464875381433, -0.20894991919970754, 0.5862333654057957, -0.00972270705085155, -0.011563679856783346, 0.13337839633854756, -0.18172301566959922, 0.14394976481712837, -0.45691320534277724, -0.04122687732916509, 0.11422601663988267, -0.07541624949535551, -0.2436672906677194, -0.032861678529781786, 0.31205341220405486, 0.6716275022456939, 0.10527115120384939, 0.4691154514287288, -0.27195630070317556, -0.26821245840515556, -0.07504616606559701, -0.1346654140161754, -0.04811337421475325, -0.34119009514256454, 0.3130235666861947, 0.4290236821566765, 0.04564634076488817, 0.1912121518098042, 0.08836256573859434, 0.1887503914904543, -0.11920190161753735, -0.1563480056341388, -0.7152526136454321, -0.4502782708908422},
    {0.01833017937097287, 0.472426624333343, -0.22644151389236888, 0.22014358549874416, -0.7820827861776581, 0.0016493228899783668, -0.4585143283561117, -0.4553050029959957, 0.009837038719578561, -0.39160034248299996, 0.09511476941391514, 0.3048881293857025, 0.8183623333997905, 0.38010160980951463, 0.4458911278324713, -0.3769467770254784, -0.2647645764112387, 0.09282895321584278, 0.3077397723463909, 0.11873827199597062, -0.8102248059867186, 0.2072646161861963, 0.22640370088499723, -0.17800741514742502, -0.1583054464933168, 0.06181876475077666, 0.22490365872129453, -0.20547064904504736, -0.44069323271776517, 0.5607861910207519, 0.2114515750319899, -0.325142434737296, 0.4873827708776355, -0.40033790498299276, -0.21653117701508176, -0.3003836631572931, 0.017972042047721414, 0.13904901943797457, 0.03183731135036296, -0.15405981799511068, 0.061170507348223276, -0.4565844418896625, -0.006092672719481622, 0.09835274854455155, 0.07200137803929224, 0.4344406296100044, -0.29448845707528176, 0.671687147220967, -0.5991564645120288, 0.04110151333145326, -0.021402306456598588, 0.047842738031485796, 0.03361488234845599, 0.0311737324937299, -0.1994080938542814, 0.5058967718914316, -0.28854933736422755, -0.1608275574414573, -0.0975515609977769, 0.4566877821237222, -0.21318212463851507, -0.011199389257211898, 0.24614674227290548, 0.410814550002279},
    {0.21240845517165544, 0.43128769137985706, -0.3244207926025643, -0.24240387011935383, -0.3103687857133114, -0.12458416092627457, 0.06991974749528546, -0.44111477020963746, -0.03161764657556637, 0.4198651231616824, -0.28814166712287836, 0.17240356482447824, 0.5092652686785475, 0.05532990034417702, 0.4868412427993762, -0.12218108072315911, 0.1204938860563581, -0.2666972487359483, 0.1992232052564025, -0.2777901673787685, -0.3427060865246991, 0.11029466809208212, -0.23422843064549329, -0.044251566093822914, -0.4271123521234699, 0.34945221500702583, 0.07870810469804553, -0.06166489314631806, -0.25036418386989123, 0.3088244203398679, 0.3182788443688705, -0.04527866941115661, 0.2435448013388359, 0.024169316590480314, 0.24962440805902106, 0.05226811686838554, -0.12073602168334992, -0.07356603172648879, -0.41615641805920256, -0.6631720245077501, -0.3576100963638013, 0.10707410007571416, 0.09670829515212427, -0.4038149929915433, -0.03143099929321013, 0.07791165753312689, -0.3949354779117843, 0.23616436360417636, -0.18277080571257254, -0.5331010879715943, 0.376774166173399, -0.3921409973597988, 0.32083571324923665, -0.08752140028041673, -0.1694139752559596, 0.22419892490384127, -0.056710845141896275, -0.01773070690663864, 0.1339702434453984, -0.36785382779664233, -0.4651222970665722, -0.06391989289831689, 0.5332581935952451, 0.1649164037950541},
    {0.6150093695913554, 0.0014896579145711882, 0.5593378083558298, 0.5005309298176714, -0.1307622981262692, -0.4094409866563949, -0.2272105031318082, 0.01503720494646251, 0.11204802681990773, 0.3229505594963114, -0.3079243103875123, -0.5784403179795974, -0.32119162865673034, 0.28355976536594096, 0.1900023655774374, -0.20850878269427897, 0.09595852481242155, -0.48937857231593135, 0.17666838261099327, 0.2925731405007896, 0.40883811793536784, -0.336926493647265, 0.04915923727242721, -0.24936082682549152, -0.22283840510692687, -0.007042086060453738, -0.127264675789129, 0.41656780382675945, -0.03724679266624262, 0.18386462418934615, -0.34376455765540165, -0.6573917322537903, -0.04841316848670552, 0.05550816028251212, 0.23861374737569427, -0.09496076359985628, 0.08332256048709641, -0.0634060613847273, 0.17397888471243497, -0.07089282948148601, -0.18532991415502248, 0.48460117021845067, -0.2106816194399592, -0.29381401266908724, -0.2740480200477704, -0.06430693749177309, 0.06018780727263588, -0.8003666755882788, -0.03974663399662568, -0.2528849818845951, 0.40823899929731466, -0.18530928887160686, 0.37488187163881725, 0.5159905176427206, -0.11184552636234839, 0.12873703969589786, -0.3463820315442626, 0.15366576678364158, -0.2184159942493489, -0.2584191560001913, -0.16017982687613247, 0.12982254448142655, 0.2980162812348966, 0.29783081877217904},
    {-0.7341704490399206, -0.6613232470454843, 0.4808917379742874, 0.3045213122462516, 0.09766880533641031, -0.23928583597473213, 0.07168436523674465, 0.33911007707892776, -0.41497906550118546, 0.1043275394312735, -0.5338709814976832, -0.45276399678902973, 0.16349458947869452, -0.3536286893933209, -0.1481502396262336, 0.05781578489637522, -0.32717559057319473, -0.13483470884026819, -0.25756975665297405, 0.37314452874579923, -0.19252460805629293, 0.0731670341338005, 0.0032347962865701295, -0.7407368049652255, -0.3143253505656619, -0.18200821247773596, -0.05399252464693764, 0.1596463532072154, -0.08041628230108157, 0.6365630106098573, -0.04637037464059471, -0.5166429555335585, -0.44160306668114546, 0.24368931259431095, 0.08918259628466822, -0.5503404033283418, 0.02882258068753332, -0.09147350424299333, 0.2814598532043743, 0.2767883758271496, 0.10561241965246723, 0.5645531326648752, 0.0731905171932173, -0.13736025306369049, 0.15578796196440584, -0.12178474342539662, 0.12004382235818248, -0.39222857878051864, 0.010136922225309182, -0.08483927676986065, 0.02855322826552945, 0.6782822454824428, 0.08494403046132204, 0.12462318574226323, 0.34044339256227585, -0.2257215111453807, 0.21449555786589275, 0.0158216815409817, 0.295701300336373, 0.21666678409054643, 0.3756057432008156, 0.11287131283143682, 0.6335968324690542, -0.4190645947480858},
    {-0.012544845308746787, -0.2606991363480519, 0.5939618826698393, -0.06264734568450932, 0.41973441712240644, 0.05969677411311932, 0.12871197865505365, 0.5316899848911629, -0.1464753405263706, -0.13882137529435934, 0.19012537224644, -0.5387489056647066, -0.11928304110204925, -0.26513325257025955, -0.33343773985915637, 0.32132935860735085, 0.040453247439317205, 0.11559278253934656, -0.21054628804657202, 0.013850277730885194, 0.6458658003870953, -0.3146856907888761, -0.32862532909825, -0.06192789424278937, -0.3046630003101008, 0.11941290250870015, 0.01060813302705028, -0.4666823055793859, -0.1990463163123856, -0.23471929990538173, 0.27911757160210227, -0.2845236076131342, -0.23818586445072318, 0.3413376842935105, 0.10937799905957987, 0.0546504035206132, 0.21264307801784255, 0.17592881235879304, 0.26504801232088043, 0.007289575298056961, -0.1374290849379403, 0.04895420434540371, 0.2623643603634121, -0.06118306548273112, 0.5475741926550084, -0.15615380299279458, -0.03348254902567233, 0.02931542819786773, 0.06455791428848388, 0.3543560000485296, -0.04019368069378836, 0.029736965424760276, 0.03432192586689767, -0.2469129457135266, 0.14611374597922197, -0.593066610338706, -0.23115960386321105, 0.7287095083996911, 0.2829232860994817, 0.5590194791196405, 0.25794739308990117, 0.31506538218751323, 0.10497366464875865, -0.5279016603269956},
    {-0.17207728686841905, -0.2435487508822958, -0.21604373424590192, 0.28683029569327373, -0.023668156422809238, 0.13914540452198873, -0.2664768103074176, 0.3524575302122874, 0.4366598009729053, 0.03731252254207707, 0.21330747772383576, -0.4720886123620366, 0.20116087190786738, -0.2963565407521967, -0.38683854898916015, 0.26659562838199896, -0.2888824148829889, -0.11095077477863242, -0.2147533554298126, -0.24595124622859932, 0.27095901228144464, 0.31208971822888776, -0.2688184992903518, 0.2447230139326652, 0.4732905608331714, -0.25596126120865353, 0.014704337297470184, -0.057302752964609766, 0.3166084470429071, -0.0167096074369172, 0.36453416705966496, -0.3000021318477089, -0.2793050033346241, -0.15942979429460097, 0.055180509071557346, 0.08737373633617586, 0.38477734898132765, 0.21893233275599935, 0.22459840356639882, -0.16372805024130405, 0.6017495162716554, -0.3906786581154088, 0.29069365211073606, 0.673368220816323, -0.43476415293936904, -0.0398037177868742, -0.17961494909645478, 0.4876574240947439, 0.25166052003649353, 0.3646732313842964, 0.032983827498263306, -0.19275268926312994, 0.1288111577547809, -0.3846832256503747, -0.28699223457053846, -0.14953339163311594, 0.15570126136472817, -0.1130392714211288, 0.24767419535426355, 0.5032282636503442, -0.24458662795778788, -0.017268132736726685, 0.12328828927965657, 0.4380104965679383},
    {-0.3753843560238943, -0.1372637576498029, -0.2193376563546678, 0.2146950947491194, 0.21841151589081406, -0.1465356793801819, -0.2526331323760303, -0.12270005903372028, 0.36277902326194233, -0.6403036236426135, 0.06402980487852608, 0.210914113287651, 0.6216435652185187, -0.09786729768842439, -0.31134419147405046, -0.1300200330514893, -0.029994593052478716, 0.0279735075878577, 0.067457517894891, -0.7172881360024015, -0.2409578558389492, 0.42782148994116803, 0.23361469515010233, 0.34036047512120576, 0.48731183524502114, -0.28070110855808017, -0.4373340170919598, 0.13807254606320926, 0.3962757615759861, 0.3663609342767734, 0.12468881852566596, -0.46017002412209657, 0.27154407320634766, -0.04331996933300076, 0.4627260025638159, 0.20381795980048265, -0.3406477450973336, -0.3642556344251792, 0.1993126999512223, 0.3571110916797151, 0.5767802792848584, -0.34235767437672937, 0.20216841155574503, 0.44968001586357753, -0.19473611510157654, -0.059111450781396964, -0.24460624552494617, 0.3606427126617881, -0.006076225356437965, 0.316187406414421, 0.012688896078263378, 0.30825794607266266, 0.03494209257571757, -0.7165077861542909, -0.2177483318057338, -0.5376247060799451, 0.2500347540694589, 0.17722781653013236, 0.08959385003313873, -0.5901109491933038, 0.5924088772411253, -0.08116089407836473, 0.01695897632285781, -0.15456077203343324},
    {-0.3603552231189079, -0.007826122712600005, -0.3561293407901588, -0.04842500038310456, 0.3244202153731941, -0.10328239332339503, 0.09461912014411539, 0.22861304851324754, -0.001179675874139611, -0.3417636494835303, 0.03433019543598115, 0.21889136318708557, -0.4775115858072394, 0.2309304664589443, -0.3685515987388212, -0.04328193430299749, 0.6770838399363688, -0.0063983458450328715, -0.1693755225115182, 0.010829839921495187, 0.39564555667549306, 0.07547405687454756, 0.2777031384082145, 0.550018260275236, 0.21852503300530626, -0.04307931843271692, -0.27370362416979943, 0.11374434542454237, -0.08510898731671787, 0.5880916282576312, 0.19986532900201653, 0.4808984711406599, 0.13394084501463466, 0.4086417311346227, 0.7067985016055269, 0.4525326381419732, 0.27307970608705484, 0.1092038763465141, 0.036878342179106065, 0.2268644123214012, -0.09101941312618488, 0.6375184297270459, -0.47872994640002864, -0.29932672180564746, 0.25510795196424196, 0.15115772440644665, 0.4216458603511686, -0.12631818826657612, 0.12544563379599355, -0.2137095116615073, -0.01869042195117944, 0.10028229716554722, -0.2461423688982034, -0.02661075661230171, 0.07881079080346227, -0.3848656395832633, -0.30458583640317444, -0.06953014545828796, 0.025675639471110515, -0.23787337109216025, 0.25712226020473294, 0.03683668670466125, 0.3615059850485412, -0.08605739197391273},
    {0.19061127284667587, -0.34732139813455465, 0.1246463967755009, 0.13940458258714256, 0.11114355760445088, 2.3771999446274913e-05, 0.3717562944718016, 0.07733753292997636, 0.5675236307658832, 0.2988391911762941, 0.07228348821434881, -0.17242116396761356, -0.2407983493859617, 0.25312178638531446, -0.2917324955774836, -0.023494514419986418, 0.11267181031466714, -0.07487373513492415, 0.04709105802593163, -0.0038814513062641236, 0.03855587522744224, 0.0007021980860667523, -0.03797746558791434, 0.22975432977672952, -0.3581100051482945, -0.44102530039036225, 0.457407737845814, 0.044480597640127385, -0.1665372991879061, 0.08907633352738624, -0.05364823750728027, 0.4721966174806593, 0.13272381878263345, 0.09052607808369696, 0.4268132229947947, -0.20754425721808253, 0.2771436013478083, 0.32947443870092497, -0.1386213722651213, -0.3894417284332785, -0.556699280152534, 0.3720935805680685, -0.046343975390621954, 0.11379617186462619, -0.3596789217365128, 0.0725572936597831, 0.46029059057444327, 0.11875554735077194, 0.057987778548389976, -0.7476064030542293, -0.7646799558037433, -0.2882407321464028, -0.30261154658700407, -0.5448962095179718, -0.18855271315023173, 0.2131253967579944, -0.09002270161668982, 0.029042733124946356, 0.07817264013059107, -0.3508025059311882, -0.24304229794810908, -0.025884034750195805, 0.4339660477011786, 0.19010065696548703},
    {0.5750205758934595, -0.48857578660463186, 0.156723355920224, 0.17322532663052417, -0.4193117177810889, 0.6086080715970503, -0.4539905375497826, -0.1484715361316439, 0.42004721986923166, 0.3341565666321685, 0.153304810004541, -0.22543352649201678, 0.1850628197210144, 0.3306955173523614, -0.24926871720237992, 0.24123937249184205, -0.31220870403109535, 0.23096310561843642, 0.17299468442880453, -0.33551120680028546, 0.29971572104058214, -0.024035483408748254, 0.45103361687878374, 0.5378685907152521, 0.18767133467657449, -0.04810862272416053, 0.1213559744255185, -0.4168969305926375, 0.3961703746435306, -0.12980074676530376, -0.14027900662774997, -0.19986695051881223, 0.20161792284874167, -0.014377250833108143, 0.24522264744368313, 0.24485563280962439, 0.2661849486476726, -0.013902491083123589, 0.1082084942670348, -0.22044772845178998, 0.41942400101075805, -0.3816030371784627, 0.0979198133928114, 0.4168334576977752, -0.2989956135109562, 0.03580631204674093, -0.013144286795673756, -0.22849378784209892, 0.32046341059740363, -0.08929961361128008, -0.19112006294805436, -0.2969156923669337, -0.13153108678467573, -0.27136259197607926, -0.14570503169736015, 0.12990605199775812, 0.39460982950640916, 0.2157948656033999, -0.11376000663459307, -0.6320426054911752, 0.14231991640572944, -0.45042444350617583, 0.15495089610327928, 0.3093790428246919},
    {0.12313424359583303, -0.38638586160220423, -0.2284694560564181, -0.21846372350898763, -0.14359418095985832, 0.053232418024313846, -0.024537266084448676, 0.06428250517410974, 0.15799913439031354, 0.26480259627148084, 0.03149451271801779, -0.3150443496249541, -0.12596870871674878, 0.22755010401356224, 0.19055055211241068, 0.036020570923709444, -0.13388549845148678, 0.16575187710286035, -0.17764794014196147, -0.05330594000353321, 0.03577672322775505, -0.15974175612202252, 0.25032401410497596, 0.046759475912695865, 0.1716798341435579, 0.6186432869870965, 0.6355639891457033, -0.11724750936827363, -0.12290358566383636, -0.075906500167325, 0.2966379390344054, -0.09259107423213751, 0.1647835045477242, 0.04064143465338656, -0.536165392683562, 0.26472747836876825, 0.2442961116897826, -0.2257959380038026, 0.07151498490697511, 0.03384189056163541, 0.21071688002434733, -0.755103274630863, 0.057455298921636096, 0.042356988379820874, -0.5756126623802219, -0.1724908677546499, -0.028602826714462088, -0.48393599068650306, 0.17288588897188342, 0.7007567565967292, 0.15347873321262528, -0.060749655983412344, -0.08061342221033704, 0.33728522174365055, -0.0902470977736304, 0.05149405875215929, 0.46190958079848654, -0.10346436519162702, 0.23341401621579924, 0.1555487273015442, 0.3016276954003928, 0.053729280527292506, -0.06853686132957666, 0.5629765787415493},
    {0.15439370143057632, 0.35964792422994896, -0.36289245869069636, -0.019200933191129185, 0.05634225703820279, -0.36757684262671014, 0.2497101852636242, -0.04694472552676287, 0.6090205994538708, -0.10840271241602752, -0.411322722665146, -0.017584375550538905, -0.25479841173018714, -0.33306154941831845, 0.7261938761994798, -0.19126336078957887, 0.15880640749886704, 0.27188308138451606, 0.27138243360354675, -0.13108082865890155, -0.23930099638283564, 0.49479562733616084, 0.0957834443178592, -0.6379741713779453, -0.16120312022538844, -0.07113235194694068, 0.2617107135552269, -0.14911946258764944, -0.1811295700128104, -0.03490914549248239, -0.1409906389626736, -0.21163320507142389, 0.12804622245238545, 0.037828153655521994, 0.10260711928399556, -0.03296663607419557, 0.29670021712050504, 0.5122242975853224, 0.07023831912489813, 0.25019662254015235, -0.048602414191008074, -0.1095872822887379, -0.3165268550057776, 0.3261847671131946, 0.4582628148394932, -0.11155696281764, 0.2887052563065582, 0.014819186813996205, 0.14197476676833326, 0.3125691459451624, 0.25377055019369216, 0.30959164962960767, 0.5734937685036868, 0.5466660953434747, 0.11220875684782854, -0.5016022337190542, -0.11201890953204201, -0.17181040603280284, -0.21741777919921348, -0.08175693296982033, -0.12109275974589166, -0.21982208746782417, -0.33239420723806923, -0.03377501783078354},
    {-0.3105132098615046, -0.19267501975286572, -0.008593196921026194, -0.09756413634944479, -0.21552723599654125, -0.03767495869074084, -0.061387774506778, -0.03874377947335933, -0.2353925553408114, 0.02597885813778452, -0.09373352640697058, 0.45537108376814023, -0.13175264563727074, 0.03488378427555826, -0.09853125568663725, -0.3283460080905774, -0.1648443821124647, 0.2044150471925496, 0.10996948308627562, 0.14558227404016125, 0.18623575133982082, -0.4272384241526137, -0.22483699237060892, 0.040042657108836574, -0.21011279728749685, -0.12274117932117079, -0.204239756430121, -0.0682763420438574, 0.01772215814053399, -0.13175921959944983, -0.28541417071680686, 0.2358679768734155, -0.04183579987098226, -0.2270142632192287, -0.6343331780178451, 0.2842116157160466, 0.1026230975480852, -0.23437868763113293, 0.04629012995868032, 0.05506098984745191, 0.046745179584578016, -0.4039811290068623, -0.2599042281847147, 0.2606013429787366, -0.370280747709198, -0.30160984203806074, 0.18828439767980112, -0.09987167140814557, 0.011810404362403137, 0.11385672166863922, -0.18521080046634078, 0.11332557397858355, -0.2284364619731444, 0.24231869152061916, 0.309587034865508, -0.4439951373122177, 0.34085533765515974, -0.11634422694625397, -0.03815143360184226, -0.06583836121471263, -0.3098967296122397, -0.11466758915588975, 0.1965280981261767, 0.38036498232748395},
    {0.2991804526048547, -0.2444955011942672, 0.11301607490177061, -0.3582901477956726, -0.21630666092486858, 0.17790669160160086, -0.13270135554192808, 0.03783195764287392, -0.2511538479140392, -0.2328541197061999, 0.22461141158194112, 0.2286827860894323, -0.6233033435473233, 0.040461856833150206, -0.014187285935810699, -0.037117420217948824, 0.3336871853831501, -0.15604772699239303, 0.057533439455900885, 0.35635255189751563, -0.2556497539240605, -0.3090150229299467, -0.5843130156399157, -0.0939133777377226, -0.04704108162931253, 0.13857574453650956, -0.07429930420340712, 0.1386364945764744, -0.28951504798662264, -0.19722285625526711, 0.41521472547570193, 0.05332837552187414, 0.12549989804701217, -0.7221173019145144, 0.5059274162661435, -0.14576363919655078, 0.24623717885354235, 0.43917517739120004, 0.04135807577599056, -0.0506577134963943, -0.4922344871535858, 0.33566953251086734, 0.1465108264207514, -0.36725173357665153, -0.10032087661434441, -0.6123535057783713, 0.173691167893224, 0.022413442434952045, 0.018007881424772627, 0.07394795785220139, 0.37433570396400956, -0.05052797094843793, -0.12113934760402703, 0.3903078103708744, 0.22566219038807395, -0.25252381498241316, 0.7113948625499403, -0.021513213888122027, -0.04834027113691616, 0.49805713250598943, -0.13541884688999592, 0.2915199937493257, -0.5641286000223213, 0.05564951475955952},
    {-0.24244363487027232, -0.17007191013813666, 0.18687424967293573, -0.32854940621574447, -0.0021552122447078045, 0.26871848822925676, 0.12738888237571744, -0.030596609264553255, 0.38132788154091707, -0.27202518177613305, 0.32594957807402786, 0.11837193402839728, 0.3071226452953113, -0.07400999838357225, -0.16697867820445142, -0.7381765707674749, 0.03483099298678094, -0.3523394573806594, 0.09264803944883049, -0.17233569210252775, -0.6925706420906113, -0.5803910511892041, -0.4731981961994525, -0.2119249184272322, 0.06843377273382319, -0.002562935098315788, -0.14999625217295903, -0.37885514326922454, -0.11822207937832573, -0.5228480287591902, 0.1538995596846045, 0.2588633695305204, -0.5978666841180726, -0.33511645805958956, 0.15241816354782328, 0.11574526840839944, 0.1278902119076516, 0.08154200940952064, -0.005545719774227189, -0.11641463087790574, -0.1786205640840768, 0.042585822274144695, -0.08340692688573184, -0.06701826967559824, -0.2575571611208358, -0.10172926293587964, 0.1985470161870008, -0.14546853442212382, 0.3346112145372478, 0.027297270363454147, -0.285089323219046, -0.05088103178903761, 0.2165032148534424, 0.24487496438299705, 0.06022542984181124, 0.17565266716844946, -0.07686053914490527, -0.22928368748663708, -0.15537653917816757, 0.09646934905274322, 0.016150151279649097, 0.5123013315329308, -0.2595317903943456, -0.44135728546320196},
    {-0.376833420902217, 0.24138663055120038, -0.11352939144903948, 0.18051139283856954, 0.004312242791989129, -0.07285800698625411, 0.17038503395712054, -0.3559443073598212, -0.24418098554125145, -0.005732834950565305, -0.3133605145353482, 0.07663885338189953, -0.14760980462967252, 0.014645810298169868, 0.08385280017405794, 0.170677178855757, -0.30858306978767724, -0.5476052084645211, -0.22365097139841306, 0.11893724693108082, 0.09815551764194444, -0.428891492249319, -0.09038463462783045, 0.07532613369138656, 0.08921370323369952, 0.3295863304552502, -0.27764600553584373, -0.23660679835866716, -0.333324217747168, -0.2975271585986693, -0.4804544372634009, 0.501981635981915, -0.04471674175659065, 0.08601845017743968, -0.07501907264321078, 0.03993809773205942, 0.4768544649336598, -0.009920673261542192, 0.4073769583945735, -0.13680428506627873, -0.30376309850936434, 0.06031435245831472, 0.3455588460393313, -0.7816196312268411, -0.4091387894490506, 0.2457580430281856, -0.3920258500400838, 0.033002452177561585, 0.025411588689771527, -0.14077034463094273, -0.7181822275602604, -0.009775085952617099, -0.3012098392609002, 0.3947024439227519, 0.17336324893885607, 0.12141129937284184, 0.5982818370554825, -0.00032449462864747613, 0.005293597801673587, 0.054255159203685864, -0.5849073697689301, 0.12387327234780225, -0.28585007440558413, -0.326383739300392},
    {0.29614057533485777, -0.24470103037476842, -0.35619427269417636, 0.5440444690496463, -0.18797553384968455, 0.10227051119545462, 0.28885514801215895, -0.20728496015983425, 0.07471912762020337, 0.2776401388399214, -0.07438033943190965, -0.3370091737156881, -0.1895959442714029, 0.13017854814822966, 0.02721879628610451, 0.24527861368236398, -0.035236473404302686, 0.09742942632406713, -0.24083750707832075, -0.4037605338289032, -0.15805774955159957, 0.4286312751864725, -0.5558599671516268, 0.30301402474604283, -0.31727321093873645, 0.3472647844801905, 0.10763226568463022, 0.3228421067315394, -0.3957443834993564, -0.26704530611137983, -0.06092138305142012, 0.08048183214571783, 0.129440304072712, 0.10575839089579943, 0.4653117892850918, 0.02631566939176937, 0.1944589932427831, 0.2568083516146375, -0.47199707193261764, 0.004166199778032823, 0.37824856336392976, -0.07431171913511625, 0.23294475437261894, -0.0651457627980176, -0.2747549189620316, -0.4968636179494087, -0.11933489234852827, 0.13457025718650426, 0.22641844991187943, 0.26827413771277836, -0.017902283518106858, 0.037942309004850495, 0.21535801987981673, -0.05791992793735805, -0.4450367837410395, 0.2056498891055236, 0.07492675719264363, -0.6263066520570709, 0.07277069792145403, -0.2352081859637258, -0.43664840506278574, -0.061695161654566205, 0.1263204646221339, -0.13833552916155425},
    {-0.11730206330043541, 0.2707084697454776, -0.268352794993616, 0.2973941488990333, 0.2657733531011413, 0.25288244302262847, 0.39517249269076055, -0.12397541475923012, -0.33024551759382254, -0.2941358486320522, 0.09871358772343337, 0.004341774180004851, 0.1815015825416817, -0.5981406776701831, -0.30289633701347746, -0.21895944233436737, 0.23774988156415675, -0.1108299139690545, 0.5780434909411358, 0.37307613972162645, -0.2561926426329294, -0.09132734722290498, 0.1282870851376306, -0.3082570171074269, -0.6038699549562214, 0.2323931315306968, 0.5193916712590009, 0.04809865243098056, -0.3931280576738583, 0.11505048052218293, -0.33757719826605753, 0.07099390726545811, -0.2044349701156647, 0.5625738876766345, 0.352158735776281, 0.24669973279520538, -0.36774400073839547, -0.34705629505481417, 0.4201034188956743, -0.036792477646116296, 0.1853255396945333, -0.05236784871215642, -0.2356406844165122, 0.1304577963466578, 0.38758735734063016, 0.18684171501219127, -0.13471765191780669, 0.3715174586127123, 0.1815238253955732, -0.3672038555872701, -0.3451450811021027, -0.20266926333238658, -0.3542324903328035, -0.461385768085275, -0.23964591908692223, 0.48529518392609916, -0.28868206490498427, -0.6048676418969969, 0.10021847075850407, 0.08933067496056547, -0.3831696622251273, -0.3942876285090648, 0.11924886245418267, 0.15778688905212504},
    {-0.4463909954468638, -0.04045200513162864, -0.19954040284911695, -0.23384888109964022, -0.07543370773362161, 0.1395917329204687, -0.14980022883270364, 0.2424944998466068, 0.06524501528386996, -0.004511736949238658, 0.15972760431203561, -0.21524605673653813, -0.2950099217295266, -0.11266305590160891, 0.474041889689661, -0.025036502813660752, 0.10728536913299778, 0.41093033647804006, 0.026227905194112174, 0.2859419140173405, 0.42684491875167313, 0.09852023873534893, 0.6570126812382804, 0.36361195154259746, -0.2588084592281712, 0.04654975435299553, -0.29909428161118196, -0.30673195794092845, 0.5858248922871752, 0.2005700206926723, -0.21447703536643536, 0.7009522629725002, -0.1317671532388091, 0.22545409803462457, -0.008154769633426375, 0.19677237807882206, -0.019994092628925438, 0.5719692500381902, 0.36247698853466354, -0.35401023532491516, 0.414059152107808, -0.09681227488123635, 0.024324025829271803, -0.11506216553057404, 0.3139215474987141, 0.12483976566595478, 0.05644971318555662, 0.1580060125562708, -0.03755954381874228, -0.4041983645136861, 0.2962498817587277, -0.025828754492522803, -0.4246740742632635, 0.1205128651326429, -0.16302953767552344, 0.23252139393897944, 0.5047232183952788, 0.3795174913129044, -0.014581903406327664, 0.5711574696296838, -0.17706300362351135, -0.3170631379181274, 0.06902030643946065, -0.12109147245137429},
    {-0.41218723610101987, 0.4509104236004839, 0.021081852014779523, 0.20266266404258101, -0.23416290378965957, -0.22027767297338086, -0.4738848737414607, -0.1949009000295345, 0.572816784112369, -0.34659823758989355, 0.34241603049141506, -0.20436542616480977, 0.3031443300871523, 0.25647442497916056, -0.15635306133487686, -0.38842206713201943, 0.06324335740582432, -0.6160405670584175, 0.2827576040106499, 0.2613602672581606, -0.880008264215009, -0.049440986326641824, 0.33451192287096027, -0.3143666393959194, -0.2363397228717615, -0.23970583861344397, -0.314966079504598, -0.007179504497481653, -0.2490090987655789, 0.12295623414870305, -0.1041142908070396, -0.29073637205270736, -0.2979506515015078, -0.48422340038020417, -0.24024047722124509, -0.1643140955416384, -0.276964916023484, 0.1087489810980743, -0.7689543045293704, -0.2423856790893288, -0.5838344382814161, -0.06284427175412878, -0.5482485011901249, -0.25919174808668105, 0.20104876481985323, 0.12008878202088243, -0.2704008957502531, -0.4435386287483241, -0.32977576102049855, -0.25468871147771366, 0.19012284404590318, 0.22303056329362542, 0.45076153234006056, -0.17282346723543934, -0.6012674609510298, -0.2717097161225711, -0.6007654067548099, -0.10407007514180451, -0.41639692596289146, 0.3122000408025583, 0.10554291279836506, 0.18166150002829062, 0.13784295380409764, 0.3266110829462915},
    {0.07992919646088442, -0.2720356787843335, 0.2553209622284024, -0.38986577752132867, 0.11659972726037639, 0.5699272233064924, 0.6772301205961692, 0.4069623782744151, 0.043873162128675695, -0.46433036893487756, -0.0706029645342821, 0.33101850309558073, -0.6141298329117216, 0.02248794866547753, -0.1468394130120435, -0.24352370258831302, -0.14155493628150698, 0.023803287515985934, 0.1968272176434242, 0.33928939415247844, -0.2777467975104988, -0.28919856480903566, -0.006981689397148127, -0.2008395938755819, 0.29347382266370625, -0.020928380222697888, 0.09779193035293601, -0.534222280033856, 0.22762735447226326, 0.24004974173735885, -0.11230737076129653, 0.16585801572816522, 0.22177701856668894, 0.24293551137808142, 0.2653560422206401, 0.32976812563072466, -0.6142951053965509, 0.2819847754727026, -0.0521486930767361, -0.06706209873022044, -0.05968180688990618, 0.27608358197924654, 0.31230611991394547, 0.3066994786971897, 0.7835626759314741, 0.14999194072123295, -0.021390818276487856, -0.25362303165090516, -0.2466790962002195, -0.16812942289136215, 0.09631435705591973, -0.26816014339730865, -0.5430120211819048, -0.17507718559586483, 0.6243504267675432, 0.22544226583865, -0.4823780466409842, -0.3466746949460004, -0.45869053349996186, -0.3048828029984446, -0.06008285177415397, 0.18089524967132065, 0.591371468863104, -0.13819328321779592},
    {0.23681736175089532, -0.6462144326903199, 0.02434321132550892, -0.587435824475888, -0.7688310454609323, -0.7251832363306213, 0.42250792853008673, -0.6803871202374768, 0.02275997765994597, -1.051142507877409, 0.4151948504500527, -0.9248736151178808, -0.01708441620884511, -0.6457417846030739, -0.8951441698995817, 0.4189703436822705, 0.07445029094226333, -0.5077562925417166, 0.44048903146806717, 0.6322501991913181, -0.5317782783153685, 0.22697898510578268, 0.2039937257293282, -0.7414916119207481, -0.7092485079093876, -0.7684178707508368, 0.06878870383775991, 0.930123798362504, -1.142352586765582, 0.5931919040279152, -0.28081515922461814, -0.48315033913292404, -0.41683530981087646, 0.45411745598445497, 0.3730742416461392, -0.6232804831235239, -0.7778082152440642, 0.08096967281537411, 0.4984117560241121, -0.8701209816496607, -0.6067799979776268, -0.5779591276781486, 0.21432510263117469, -0.8773081402126949, -0.6433316587297337, -0.03679052365406842, 0.24802706729803078, -0.5985778882304752, 0.7250953089457385, -0.6795155993499666, -0.8586207358673115, -0.5398674590615103, -0.5561250290201201, 0.2601009654270749, -0.9646820651625352, 0.3283477719577019, -0.0508085275679726, 0.11400453024153712, -0.43139156532722595, 0.2191326063078279, -0.9602405146461904, 0.6734556841365673, -0.8917804357950866, 0.3560177376560563},
    {0.09074055892353047, -0.33133206584602976, 0.019332277266970947, -0.6555645419893652, -0.9894115735447018, -0.9216721489574206, 0.4860669296433284, -0.6990080560499876, -0.09886056625363196, -0.6563588248105947, 0.9097373845637422, -1.3551527997903197, -0.5211274217516597, -0.6686675499280228, -0.6612200429347982, 0.3845803471429386, -0.08784182744836445, -0.9887585647756783, 0.4575675299035775, 0.7093940739719524, -0.6514464638143601, 0.1468635851590333, -0.5101353853513615, -0.7302822507306445, -0.7452380562874308, -0.9168499559415836, -0.030238896582056186, 0.7153396503463414, -0.9192640328418239, -0.2511877109715575, -0.47548233376297433, -0.47009329810992007, -0.4709873446723534, 0.07462571693483275, 0.10991668145184175, -0.4005336643192687, -0.6079498970691712, -0.24348179595712874, 0.6321861852626995, -0.9169112496908944, -1.1195053171293772, -0.1271198816184692, 0.6684459265205231, -1.0235220817094852, -0.6034586826577172, -0.09709001099242084, -0.31285866285565656, -0.2555392654280348, 1.0060097970238533, -0.6836679194926335, -0.4933146644451622, -0.7943970951952051, -0.28601495614832795, -0.3763916732806925, -0.6799632764266321, 0.21388559386088424, -0.3218306552131267, -0.23272212694791056, -0.08180831960570076, -0.04373063538462807, -0.9582255749663432, 0.6718399546650443, -1.0715254410543884, 0.45820411585279885},
    {0.5830749822763988, 0.3421348774966712, 0.33712555925447, -0.5765535130863062, -0.3785560759276598, -0.6745651221968565, 0.04428113715145388, -0.4261576678523169, 0.029789240747687674, -0.7037244858741419, 0.3052177877016599, -0.14270266181090582, 0.7125492778722687, -0.10870801580687299, -0.30966607337777075, 0.3493533646386675, -0.3568635876996492, -0.7124277860149949, 0.7851271792873689, 0.41223278578641603, -0.5294203216533246, -0.13870313756385558, 0.2430915448632125, -0.4931429911785349, -0.628600681109384, -0.7804324127560276, -0.007110548432851849, 0.16974870115852336, -0.06490388817088795, 0.22761041216855704, -0.368813712364123, -0.646029766654958, 0.020815361060349962, -0.3129057825894604, 0.03799094702965587, -0.44744250437868804, -0.44082085502750235, 0.2379257026119227, 0.8869339987713996, -1.0706853108399448, -0.4211130097954866, -0.7477121513121597, -0.14419060285101234, -0.6721326221090119, -0.019184773715595377, -0.025111592998265472, -0.004298883452702438, -0.3505259959727306, 0.24565008302680758, -0.6942285239684727, -0.6614859750715468, -0.7582530731272247, -0.15022369800031424, 0.1896480651830039, -0.284349063881045, 0.10268418674156236, -0.21863078227488203, -0.6026295749154489, -0.4048680091772446, 0.3290199702835318, -0.2500764318537061, 0.41097131809126575, -0.41840633073322453, 0.7044726305092494},
    {0.5785794763920241, 0.07618204093306287, 0.4668925656254747, 0.4855708019146864, -0.23347541783102121, -0.5769592434808878, 0.10420981256567073, 0.09188403598443699, -0.5583485621958105, -0.31892981167550094, -0.05598864953349281, -0.7271424994074882, 0.3121721963302192, -0.70605829239315, -0.4819036028828279, -0.11476309803142817, -0.08087128569258989, -0.3100980306659872, 0.5933662598923688, 0.580905959287954, -0.012114300564907967, 0.27388945316952434, 0.5295058714901513, -1.0966941253646636, -0.4214487322875823, -0.5666446614744087, 0.3518515940580226, 0.3874103649071884, -0.4421342911389181, -0.07648975835330363, -0.6529283410452654, 0.11348358225672397, 0.20612808634390958, 0.041342964780594155, 0.7139141960053298, -0.6303056644626133, -0.5148713271942572, 0.12560369956127831, 0.6658339164434219, -0.6274516207316144, -0.42248430915882934, -0.31512929081284463, 0.03956428735307994, -0.33517557163567235, 0.026933623959286387, -0.25770077232313204, 0.46839444814383613, -0.18285013768135128, 0.24486401496049678, -0.6034428566396752, -0.4891791964741487, -0.12125040319410132, 0.2908995749147052, 0.11765571280515771, -0.3032624109389737, -0.007975744305237769, 0.7001742018592112, 0.3515474700763125, -0.32137784083768417, 0.16290874534219466, -0.7577405590907388, 0.013930393399287418, 0.05534275683607529, 0.38529990653850765},
    {0.11835628187513551, -0.2640878378986201, 0.13512332742695626, 0.6385992236151227, -0.46873421010473393, 0.19335907293686938, 0.5035037112804884, -0.21859958223374715, 0.10771554048997788, -0.34625864413355684, 0.0696273275270259, -0.2861892114625253, 0.19001325578090256, -0.6152187511169227, -0.012808704770915053, 0.22009290721596497, 0.005893863887565165, -0.1752544585655947, 0.7944574453135459, -0.054771874627115844, 0.2836864716286009, 0.04068249099294181, 0.6235309370112662, -0.15532427986686645, -0.21727221954018122, -0.38798422488535333, 0.01418712822511327, 0.6297169704050566, -0.4029435053798362, -0.19484729196346948, -0.5157778941434487, -1.1082543010543326, -0.1694085586514929, 0.681077856045868, 0.014433836812409144, 0.11329157768414409, 0.5131690673512066, -0.09417428819206274, 0.5556129862446805, -0.17670069309317832, -0.28814041975561, -0.23276297849396332, 0.23999344103360246, -0.26145384464979304, 0.24508225189269345, -0.658983523125724, 0.28025284886904794, -0.37872482781264044, 0.434580196470682, -0.1288115514455392, -0.15184468614463317, -0.6163812253431956, -0.1869004550283902, 0.08182556962334533, -0.406500006003095, -0.3220085700308719, -0.027863155007185145, -0.04075351420379588, -0.039757280424536794, -0.05326241616272232, -0.5829998377087653, 0.13332184989503118, 0.3829768815713112, 0.2316113567024561},
    {0.619120326660644, -0.366399184195412, -0.5514389462561671, 0.5176214780145295, -0.487002569346057, -0.09377953946876383, 0.39810450572849376, 0.18453459135689765, -0.007452488553638156, -0.45617893305898743, 0.3457177834320638, -0.26625132497619497, 0.30632402583347806, -0.541972945878354, -0.2341208125243432, -0.042652485940589374, 0.014445444849706824, 0.06889799625062804, 0.3256800341228035, 0.08126530999568, 0.12534357387870596, -0.12341590567971701, 0.5343891620562974, -0.06233179599918271, -0.6130095104123447, -0.0033161877450616118, -0.2131658391284411, 0.311282240716438, -0.6159818201220274, 0.0031883386661727435, 0.11613581266087859, 0.18945072958862275, 0.3132319671071297, 0.21814968405690222, -0.12306394979705854, -0.06897897755198008, -0.12784812596133024, 0.20158508835023353, 0.6946354404402116, -0.2497604562329256, -0.6278417393709069, -0.47680577009345143, 0.4918500946949471, -0.7625459850758542, -0.4221062245336716, -0.2744638730923999, -0.04222977863260424, -0.011940003156276802, 0.7097076015797349, -0.2665953077700234, -0.6772742933262381, -0.1046470832136989, 0.16254091666663184, 0.027450468080845867, -0.21388419910624765, 0.1341018332238823, 0.09741978121795104, -0.4502298809409038, -0.11075727234745411, 0.34635327116455195, -1.093025158900489, 0.6293383813408525, -0.6502722744415133, -0.040117999326956866},
    {0.049427377889803524, -0.05901364360465786, 0.5661864614341419, 0.30985285194464113, -0.3117076256912341, -0.39059490385925627, 0.12945094946676486, -0.4257206129843652, 0.18810107592284298, -0.04057540745711074, -0.03907319021674192, -0.6809647457266641, 0.09862935723956914, -0.27157409543456434, 0.18014098315014243, 0.49835664751047326, -0.5413557114859282, -0.08056120877182776, -0.06491365293990534, 0.1628904682133612, 0.7279135208216001, -0.046944978300648636, -0.4402515572377487, -0.49762003275635186, 0.1416122411739632, -0.554069579943201, -0.59507978849067, 0.598427336863733, 0.6654697714477192, 0.00083906172606745, -0.36729247810479865, 0.37626298562000343, -0.3651901173356493, 0.7073381624504894, 0.20928916262415292, 0.05424502668180367, -0.04342278394415249, 0.3948965384701208, -0.34673227954092034, -0.6992836780334797, 0.0852893973498997, -0.18871455015264582, 0.2958514267642374, 0.2559695262925687, -0.015616750938896666, 0.3635382895722473, 0.10469705165257998, -0.1452298942149875, 0.4498248661389284, -0.6325789466627785, -0.4122883621567152, -0.38821100909148293, -0.2195371992270345, -0.23177827898762202, 0.16086687209963219, 0.4986096349266157, -0.38790626028916175, 0.11005535339373243, 0.04510009611799273, 0.02792928009424606, -0.22298955130701534, 0.22861249528005279, -0.40677369695508026, 0.0008420837627960417},
    {-0.09241473031628378, 0.6103765274516979, -0.30126465850447925, 0.022398265071018213, 0.1043034752585902, -0.10188308786392396, -0.2516935033184601, 0.2599187097531185, -0.25014577610276895, -0.5233511478436205, 0.429915478503914, 0.576220198519366, 0.39604930791374, -0.2806770534787155, -0.5663033982298576, 0.2595468870480868, -0.6309300358002238, -0.02914487517510092, -0.3057518433654617, 0.06425138437260326, 0.2422334775023216, 0.09098416354842276, -0.9270103893926316, -0.5889142520026592, -0.7282031651357251, 0.1201924769431006, -0.31858793519380124, 0.33325593556232813, 0.25285513396793624, 0.12756138524044186, 0.4418104602150808, -0.023677523248248705, -0.48738412885847404, -0.3225993904602409, 0.6468348264634486, 0.39720560167550695, -0.4277530559557038, 0.5792620551237269, -0.032234968809950706, -0.014557046584876296, -0.24391401987444666, 0.05231795405928933, 0.3923829679152564, -0.006477442775638049, -0.2561676641768936, 0.06733795092902047, -0.4392507109222266, -0.22490920200036713, 0.4283823956989923, -0.11227721124137428, -0.6452971149659785, 0.23961909676575854, -0.039743855225749185, 0.051335797221482536, 0.13915195975208763, 0.28406689582530376, -0.35947190511390936, -0.7260852414204085, 0.13739171524679356, -0.06739368481773751, -0.43417078384234903, 0.6045747960263617, -0.357198343318944, -0.1958454312586906},
    {-0.5124554225204827, -0.7327038014761406, -0.7447687796365808, 0.05882763450471556, -0.19483073420186336, -0.6360250948063061, 0.3381125013010044, -0.3471315697002031, -0.10013706902915873, -0.25415549256678766, 0.38364822202338017, -0.225611045430241, 0.06095398157875899, -0.21490515366877283, -0.4729709181044929, 0.28810739991408274, -0.454110056660846, -0.13561328336446193, 0.9867567153746456, 0.8597101719562074, -0.45867337874242275, -0.35154187952378335, -0.004422705426263008, -0.4753151931266462, -0.8646402915691277, -0.19597853251962077, 0.3263423814710493, 0.382459474748084, -0.38659383259139624, -0.04171525813679507, 0.11008173215988216, -0.23287674511433576, -0.5244350517390366, -0.6365509185013267, 0.34412698636156724, -0.0602923095709102, 0.607735882637447, 0.46220286940075633, 0.26159123395577794, -0.5762538458007027, -0.8518512371223632, -0.005067202590953572, 0.7317742530837625, -0.5468036608355745, -0.636925616190113, 0.04294883755053879, -0.03534262779603835, -0.5536333733410271, 0.8349634652968401, -0.018321030823220345, -0.5460144920681317, -0.7892052400512157, -0.758364944456532, -0.5319972662366559, -0.24036325965044475, 0.28723143835304943, -0.44968431142015025, -0.6094346213861073, 0.49265313910054315, 0.37219370148862574, -0.008882591747907708, 0.2920816377483992, -0.7419800490672958, -0.34256081601340727},
    {0.009082389822201728, -0.332985735861944, -0.03206294808977887, 0.2563597175415426, -0.22452250271093313, 0.08545081422291428, -0.45483285955453223, -0.07659869343392758, 0.4190016479491868, 0.2170532633946996, -0.12383523364802658, -0.32561669185784303, -0.1891879405072611, -0.16983028901088418, 0.11615408638021804, -0.11247331911368341, -0.8728062195656677, -0.13899074850641577, 0.41394217184312093, 0.38863098663452267, -0.6026505179319502, -0.03213362060223873, -0.3329017850880022, -0.15173795770092632, -0.34875014932471166, -0.07486559797277792, -0.16308629748462483, -0.1519364751574463, 0.0660950145839881, -0.0760536212639789, -0.07837960241546371, 0.06388073456500064, -0.10148294019480407, -0.1775136977080518, -0.2017230795459751, 0.11838414178031917, 0.27485271165939124, 0.37807382533890443, -0.40139102130089543, -0.2158457913889365, -0.4807590477531401, -0.13428514729076313, 0.11339250298442391, 0.23105148415364282, -0.399632600729287, -0.46587246486059775, 0.007606552908160419, -0.7192715573543367, 0.49021193973041444, -0.2263367428248298, -0.38353444514008994, 0.1767649917150149, -0.01450202704736618, -0.5170501542042574, -0.29545053344979333, -0.25939277900925756, 0.3695034191277411, 0.02554797352288726, -0.0683720770063659, 0.12328857224519997, -0.44485136059163877, 0.5252251028218581, -0.42270098417061436, -0.1415938133521902},
    {0.43849978685792834, -0.013895113211805938, -0.607552842073629, -0.0461909112107008, -0.33432361929488963, -0.07534889401099774, 0.47739857579813494, -0.5570631472580911, -0.1638003858276263, -0.33124984844975636, -0.02815173014880012, -0.5357858822306332, -0.15538298447102036, 0.010131418289987563, -0.09219220892496463, -0.32215645365195184, 0.09156979710785533, 0.02247804516663827, 0.1697674902881188, -0.20116307889649057, 0.18276789313108813, -0.09083788920604675, 0.40722991932706926, 0.1652378777508335, -0.7817264191646147, -0.1656191923385823, -0.1344672952125696, 0.11818666036878425, 0.014829834471722876, 0.6191562392455787, -0.07529068340007297, 0.017363969149415646, -0.6484967861637639, -0.1687386781715531, 0.1501725184393651, -0.5419883607126066, -0.34687572104269676, 0.41279108416489935, 0.2709956820934418, -0.042849796067238884, -0.21080173292073492, -0.1751711195178505, 0.48814820331819037, -0.6749384787172492, 0.265625739891101, 0.14565503785924963, -0.5538607899891606, 0.06616288462485954, 0.2588231219190359, -0.09712828870626537, -0.14122821177918174, -0.30900626446741775, -0.11261454946139364, 0.09226888011419834, -0.16781454987584662, -0.6591563407544407, 0.6291746578782798, -0.23291496934705896, -0.00952917384029938, -0.4070721165126524, -0.09114613151166223, 0.5377768861044088, -0.4945470343668621, 0.07479428853353327},
    {-0.08235984065411817, -0.2905789307435654, -0.09663071004898605, 0.6641873810377785, -0.054122452172158185, -0.474749972558142, -0.01996955131871437, 0.016950008367508894, 0.6833098865789792, -0.19610947657906272, -0.23390217202796576, 0.042650632027483086, 0.4176609085034911, -0.43089485544732997, 0.1964124192144632, -0.3013975758030507, -0.1447878877999967, -0.3291105113368834, 0.4210542204025349, -0.0006760976899824786, -0.12830934837987268, -0.24619878780669452, -0.279618840660958, 0.3702026261207507, 0.35500420449514625, 0.03443064141774559, 0.7096485692801614, 0.2927759347708707, -0.3023903955719452, 0.5939038934060781, 0.2429879560277546, -0.3258467632678568, 0.5410065248758519, 0.35074820573184995, -0.28783038964546664, -0.18451000834371847, 0.010857573134169168, -0.4269914672241001, 0.17478226119599097, 0.3540408676597397, 0.34742633426647446, 0.023238282106086236, -0.10378071534786265, 0.10457408588444955, -0.02860709595957413, -0.1541602765813883, 0.1979708709695068, -0.4282695483318017, 0.14429036331605652, 0.16432106166701277, 0.4010889561646196, 0.5656263174323095, -0.015328164960254164, -0.6478477926800382, 0.4534881259724581, 0.109744391534107, 0.17511930490177188, -0.28657905693083274, -0.025210607063638625, 0.4005264045314348, 0.33289642439336886, 0.4167119903532477, 0.11816036234102732, 0.05296272295673986},
    {0.5146863845224543, -0.39987673153920955, 0.2414936512851201, 0.3241716429957259, 0.2431083571113258, -0.43188728840651686, 0.2884490793343896, -0.18208503834762643, 0.10881244079536419, -0.7731385324856764, 0.15529630288090718, 0.19602049517097314, -0.08484386429984617, 0.3017082594619844, -0.036974188166014645, 0.3664599097135383, -0.10785786045561316, -0.3733292504605184, -0.23295959782309306, 0.6764825163737876, -0.2264020610988091, 0.6257790108632512, -0.07790208410924862, -0.3042242014299944, -0.5155624409243955, 0.7662947339908036, -0.8084585215062184, 0.200757306855282, 0.10156697881003977, 0.05545367904995668, 0.39217305021428284, -0.061547172335245495, -0.5356160972740638, 0.03172530732364743, 0.3024145350947386, -0.11940508519720454, -0.09463958218857668, 0.4302021425889638, 0.06907310965233558, -0.04571376769678133, -0.3992826786844189, -0.07582436084909489, 0.4477372118363524, -0.09325042568569794, 0.5328625757537395, 0.8795056211033679, 0.18882302602967535, 0.31852384448919707, 0.3610541276868882, 0.26265369238927005, -0.030045847023900365, -0.2993904536737733, -0.6277031041344351, -0.1282701232778443, 0.25977937152678415, -0.4280687162423001, -0.28608624315704617, -0.6997438064827533, 0.2473502221349706, -0.04492757368123747, -0.36715304117919995, 0.5113511349782821, -0.5537345048233123, -0.3289143766547714},
    {0.09120552990600718, 0.21763284804635583, 0.1962666647701637, -0.6905527415318127, 0.5343343283523591, -0.08137592703998572, -0.10464579043258342, -0.11388186640791706, -0.1463467675661262, -0.32910181118334614, 0.36184759416383494, -0.21615628999580322, 0.5046619073817797, -0.15924592630607132, -0.39288551405166183, -0.18254389345111394, 0.06174863333346341, -0.8160621831664417, -0.10649571885458689, -0.026478156803890093, -0.6083645066179109, -0.2851800217635188, -0.5572369270832056, -0.4001924361085994, -0.06508998909972907, -0.3314625812418652, 0.3768350422994618, -0.11984378426924484, -0.217305483472522, -0.11515166396736495, -0.6399535789695526, -0.22450141302013266, -0.30417605903458583, -0.7471553873617948, -0.3352691249998918, -0.21649611578369896, -0.1746283679090947, -0.7793732125993901, -0.4076434080803931, -0.4503024793228297, 0.31542059219788865, 0.296847082006773, 0.5334286534963041, 0.24669899714975177, 0.4892134455004001, 0.11662421927995967, -0.2619222594381203, 0.18401932790058625, -0.3128287258732209, -0.09084856999618923, -0.12590304809401087, -0.37345253123392697, -0.22159301444643276, -0.38181829325392047, -0.5191454404677756, 0.4633497523882842, -0.8061986588242321, -0.36162316550842727, -0.2966625870047492, -0.3008802215358329, -0.47796239783020555, -0.14642141679486417, -0.20692890044975099, 0.35924162126038756},
    {-0.17661862664560993, -0.35028183735876445, -0.8530324615668681, -0.13771000963074678, 0.5062277252253411, -0.09564398480144595, -0.20956741385687053, 0.07545075882826881, 0.047470868444278405, 0.013334650530444891, 0.09724712637234975, -0.016717644770825893, 0.25062156715888356, -0.08940838719969624, -0.6374369317397224, -0.16823278894516844, -0.33409079129671637, 0.04218129737211478, 0.20564981092820758, 0.289906769725903, -0.2224859556475399, 0.4604069633111373, -0.24304338948886087, -0.4716806775699303, -0.4008185320364375, -0.2870599545454837, 0.01938913188156573, 0.030587557314400802, 0.6100131969596558, -0.2684753986564674, 0.016905657978846834, 0.4348259756520332, 0.2729345575003683, 0.17314929889490677, -0.10013780083707276, 0.032914841494101815, -0.2277769659225749, -0.6678599685562124, 0.21030897931203263, 0.42663786138098614, -0.21821960728987286, -0.10162285065676847, 0.46001622854747054, -0.1371981486357835, -0.7518510045576465, -0.21395093427941173, -0.09595976625134849, -0.16060317000639346, -0.39909797648621065, -0.03574800551747606, -0.22467075463810424, -0.12771254876307553, 0.04549297499453417, -0.3953010913220413, 0.15510020762042281, 0.6086044710483809, 0.5404049486900222, -0.4736928865568913, -0.7222147499472151, 0.5322648789859904, 0.15880876790791795, 0.11480341519621239, 0.2081575441418649, 0.08319487533556705},
    {0.0830237253989228, -0.37950229773168837, 0.12365130922119882, 0.02994872736183588, -0.25850311951420735, 0.21643037077867447, -0.6845976006489775, 0.27705359631467197, -0.0646645773848647, -0.1728247989062077, 0.5126832642868582, 0.18470944846972953, 0.3695015931956214, -0.2816799754500593, -0.41585365866752516, 0.291352721347003, -0.3754431012833798, -0.3061630208340554, 0.40733796206081785, 0.47444826639034077, -0.08032337051665123, -0.17544034780312176, 0.11640652298397412, -0.6708099663684481, -0.6961265884032406, -0.17474687205895836, 0.01534849177710661, 0.2763594002385174, -0.009144533734458256, -0.41050003586362865, 0.10539391240105977, 0.6535952823928819, -0.22912376828730108, 0.30331468622547797, 0.3845465417088585, 0.27576979168409244, -0.27779737473161, -0.18496802181141214, -0.07063128413050665, -0.22694137725878505, -0.6757788046625686, 0.24080245853034582, 0.43296473172844635, -0.27323513526898224, -0.03609627119338371, 0.08879315303025102, 0.07995020070840299, -0.43524656081421836, 0.6412356473828278, -0.6342199990963407, -0.4042177194253398, 0.04942754445857607, -0.379909924778921, -0.46275380377811903, 0.05639597302632884, 0.15265814824481735, -0.7620235665650982, -0.05337454935472778, 0.25237031667721876, 0.3428310259974718, 0.37986426008884916, -0.15441033347924807, -0.6061974503841041, -0.27578672179490177},
    {-0.47877140057548684, -0.3378858186012395, -0.3020915735691885, -0.35887633418466763, -0.542608130499901, -0.4972266046152328, -0.08141964430656011, -0.022128158064576013, -0.1273052569948701, -0.052257940946900235, 0.5507111929865537, -0.0004631874668872179, -0.3240681898115879, -0.19698282783127183, 0.3594847674527472, -0.4325048155647536, -0.8381263191992613, -0.2762591053332479, -0.1364904996742909, 0.09643586927962948, -0.5216462147964949, -0.019432409221322985, -0.18793879962043336, -0.4950704659466553, -0.28904433090063925, -0.6098088302805913, -0.4183606087863514, 0.3167391718206136, -0.7138241334627557, -0.6334553150342568, -0.19841958455002953, -0.3529869308487259, 0.031232838178389392, 0.38535045962746084, 0.11754369932951383, -0.012440477590899083, -0.46131516269078365, 0.12516003008858376, -0.29844276848447393, -0.5074710824048354, 0.3477256992571389, -0.1967060870152043, 0.010170396426990714, 0.18406009352172525, -0.5890235066036505, -0.380959590421397, -0.4628584334030073, -0.3943421786682379, -0.42995510006176324, -0.0983247678682761, -0.17930461590745336, -0.13360633132902822, -0.047701505099462235, -0.7433293704346793, 0.014105221779752479, 0.33714780866580857, 0.022100670126632145, -0.15748585180662358, 0.078072578102067, -0.8205607593547793, -0.20595615355100097, -0.2332631839500847, 0.16367476468737058, 0.3495425002111885},
    {-0.06949552709804904, 0.18749813977147375, -0.7250854601880315, 0.39949942086150797, -0.05944461884703413, -0.0029801083588513683, 0.7745593060989104, 0.18142648761103924, -0.35442148674472435, -0.45223104945182413, -0.15960237208102068, -0.2571368428934051, -0.42644372970367556, 0.13840797519533518, -0.16025226624146505, 0.4076952430065173, -0.25403488045725114, -0.34100183094277436, 0.2531725888215046, 0.08249729616612689, 0.33024257524971967, -0.22090177724285243, 0.08568081606039103, 0.25020933613270174, -0.25122040984712957, -0.33983136526865537, 0.8289706138400793, 0.3968760240007262, -0.4880731278622748, 0.03011874738198637, -0.5070458257999477, -0.3063653498448186, 0.32009945835759496, -0.38868704060821674, 0.3145053223692075, -0.10807137322790847, -0.17639379197360064, 0.2703605297442201, 0.08112673920108604, 0.08867374775731465, -0.23420843388658388, -0.14451722728806132, 0.4480016995352916, 0.19778136354850084, -0.30705266480397814, -0.7355366934261155, 0.08014951613358606, -0.38662764725339804, -0.26349057893622346, 0.4507693967141786, 0.3135361842362643, -0.44695709535932787, 0.31757439513508356, -0.7935431541964688, -0.21624313240512225, -0.04352146413252448, -0.04322619869978018, -0.5156282380527524, -0.06038030604452404, -0.16451855473717994, 0.2825072611577198, -0.6804642232301878, 0.37237039867777794, -0.08354034511980331},
    {-0.3298956315202148, -0.17292265086092837, -0.467835169639228, 0.24909175789483665, -0.37067595201681686, -0.04530881951028372, -0.645060531965533, 0.3861399868245852, 0.7059742318130177, -0.03827641568615334, -0.0862370999381471, -0.552578825182907, 0.4641996949869926, 0.03424800007356194, -0.15930540943571078, 0.05816276232604825, -0.5834780255951961, -0.4299441010950221, -0.14780661246681243, 0.3942782280770979, 0.12165507439267312, -0.22724589773837467, 0.1009007180984777, 0.583427968113311, 0.5105013348690791, -0.3601998370783701, -0.1674553895913879, -0.013695915488670978, -0.5128952655124501, 0.5268224983046276, 0.09240172290907579, 0.23760092036186406, -0.2219972065902157, -0.47913881965662336, -0.18359129912187233, 0.4632506961493124, 0.22948544567271054, -0.3156494790500219, 0.11494981209564371, -0.23116976990013477, -0.29238460033546043, 0.02094302738426562, -0.23492019498842154, 0.18285813188361835, -0.40495350595543966, -0.12797629236669872, 0.4552355571882356, -0.32490984728251987, -0.02328636426446893, -0.21532113426607474, 0.3303254430205124, 0.1564907185141122, -0.01833501480294298, -0.6385577546243268, -0.44920079811532904, -0.26694144865836417, 0.2001807533882218, -0.23768238322396534, -0.11942227250250326, -0.09332662943382755, -0.36931407083212436, -0.021081400658909694, 0.3572717851991604, 0.11094840953311215},
    {-0.12417298115320186, -0.34243966711495516, -0.4349818721596704, -0.21725759195848718, -0.18195426410296073, -0.35156997445145344, 0.21819176583660702, -0.329792179337691, 0.15477261508637144, -0.47030247645717127, -0.26081924954712254, -0.3845231789324144, 0.34717243070824927, -0.3905824739923478, 0.01887291278866275, -0.6383200943620224, -0.01895153540031965, -0.36965349858192054, -0.11962568091335303, -0.06787914036477391, -0.32019097161809823, 0.29940064998123, 0.1524263912172332, -0.002349369894830136, -0.3611250452860393, -0.004398269838703471, 0.0711476306734494, 0.19772853190938147, 0.06211791253827638, -0.09792365649931838, 0.3449853736863921, -0.4730605388133329, 0.0946144056511786, 0.3983758005067733, 0.1989018534729764, 0.06703470672877035, -0.03332282675168426, -0.11511760565243812, -0.2317695852152074, 0.047236809014141505, 0.4122581384011571, 0.03160714336556859, -0.29787176523435455, 0.4732840399530685, 0.06508457258430123, -0.6022383922823189, 0.13600590359667683, 0.15766422486196832, 0.022974778591036076, 0.3051919032080204, 0.4131292238229378, -0.1784205748102657, 0.27901622717863245, -0.8143429887254118, -0.28417574156250536, -0.32091272109348007, 0.5395572190785232, -0.3312118930821098, 0.04133330715904812, -0.33338637069521365, 0.20170804342283646, 0.35186875851347305, 0.4673726400202061, -0.29746707194401667},
    {-0.15785991037349556, -0.37551104408243774, 0.08940379103839861, 0.13948776050123102, 0.3953204520406615, -0.24813695786334242, 0.328233244907243, -0.014459251766528177, -0.23063742310825472, 0.0922737923960577, -0.43924240189800046, -0.22735533345915684, -0.16849204897907213, -0.048208931557492236, 0.44503038644188553, -0.17488803877379824, 0.1015863514801246, -0.4938718589937837, 0.09738573770747158, -0.16118936501777603, -0.15717360743814665, 0.32933242142784036, 0.41741548040098586, -0.03740288187597113, 0.00690230839460169, 0.10227998610183493, -0.07032964050750035, -0.06886511563670969, -0.48359622775087235, -0.0375581498905808, -1.0239665820939559, -0.0711869662817324, -0.03596695907066688, 0.3157708695430758, 0.02927862739876407, -0.4994332674205927, 0.019089976988323962, -0.5227579148447978, -0.11469998971381734, -0.07691986096902491, -0.5720942641479364, -0.11578556640766106, -0.3373897833296577, 0.38791427665243333, -0.07936366251467952, -0.12757050486039911, -0.2223680453758283, -0.43091924095039175, 0.3340251241986821, 0.03550242464366309, 0.33901398911404046, 0.23740820282353198, -0.055545369684347985, -0.45755784316364473, 0.17260143400213443, 0.044319347978736004, -0.14840738175028853, -0.13081618037639725, 0.010983390659889684, -0.5103519885224187, 0.4096146604347188, -0.5565170556484684, 0.7780860271983446, 0.3826932639511841},
    {0.33067308952482083, -0.5922101953539852, -0.28406452557033735, 0.1730072548958029, 0.1340766824846998, 0.1447366357251348, -0.16016170841476982, 0.3311277868995857, 0.5709971797826817, 0.301889744745015, 0.006751374120525268, -0.05604829576175256, 0.5489503764999824, -0.10731339416896914, 0.4398317495219419, -0.007802451266901218, -0.4167986973166587, -0.14293413372665328, 0.9698802649456317, 0.5478070357238868, -0.7953512011789792, -0.21713455230010054, -0.5229997800551193, 0.059782344158940987, 0.17350435083194712, 0.24454668108751432, 0.11003892934629941, 0.3927939362339148, -0.5485627099545797, 0.32871169761070496, 0.37200518443339176, 0.3071320568759405, -0.183283985675172, 0.027691744816523464, -0.6885636637668073, -0.3239097469941915, -0.08734583754986314, 0.5136568159975392, 0.6151991218246097, 0.5733731585594852, 0.04857568929962331, -0.274500923674554, 0.45949719969467695, -0.2394625346235039, -0.33327516968025517, -0.13777426206041493, 0.4784070633888621, -0.15046383749051415, -0.10580153894579578, -0.15074472209593745, 0.08392118098054875, -0.010316054433858466, 0.3757538397223997, -0.08054399397621538, -0.025810894306225945, -0.1625933606309296, 0.564175544430528, 0.6602692871366201, 0.3486075446157149, 0.39580392518456514, 0.48826594293221354, 0.5292547348842879, -0.03476394332950741, 0.35274488348743405},
    {0.003930150932615269, 0.3665441066134678, 0.48805682194510985, -0.38579146255389957, -0.23113371393278478, -0.4246478443704096, 0.4310339385788181, 0.19084965274577353, 0.288168665152491, -0.14050464225446394, 0.2637116594562209, -0.3042293400615683, 0.6049003094000319, -0.37173420489785713, -0.462343971528186, -0.3774883264182226, -0.043812587655217, -0.3320361648409523, 0.011651826391387794, 0.6122677279916698, 0.21503311281328957, 0.11877676730640883, -0.5587002129315065, -0.015518861458629404, 0.12478652745541531, -0.6100131352307813, 0.23478222084647637, 0.24059100977706097, -0.2521699595457564, -0.7878296527453466, 0.49202165963026634, -0.5591091018127426, 0.5814350906191871, -0.5095063095350768, 0.2628466897908337, -0.6184589128998412, -0.2663282231404676, -0.47916670006488865, 0.2722985159467629, -0.004592909207560241, 0.26721192200309335, -0.2534688766978248, -0.08157670709128303, -0.19782005692731422, -0.15491588468675788, -0.26887135723076033, -0.0007751757434389398, 0.13570656344951612, -0.1447788971563609, -0.35202254821375495, 0.017988688642724404, -0.42093401231406535, -0.0128417464202441, 0.2783919200135414, -0.05286499182610384, 0.043869203692476204, 0.06300403335028364, 0.1943446666564914, -0.18991111024781768, 0.6967909093527456, -0.2012742619715837, -0.4250853437736643, 0.23401443660766033, -0.449772248603177},
    {0.579583708853412, -0.5838343158993093, -0.173984462086393, 0.3267868302083591, 0.196185300896892, -0.30048520940760126, 0.37082412001442683, -0.5970011306731254, -0.373837576467142, 0.05924571615061899, -0.12958029444210817, 0.34894271014485306, -0.28800037382340193, 0.05001033348247383, 0.35444563963768905, -0.35114150082943085, -0.6180566288477835, -0.8897659701458825, -0.09811373487587918, 0.6399799868760636, 0.15739948801361878, -0.27498269290954824, -0.5277107630555379, -0.17142510892612067, -0.07586943447545322, -0.2670454347422921, 0.5788973210187527, -0.5920750153262229, 0.30009174839911773, 0.06927453716416872, -0.03392223958185622, -0.19126482991539492, -0.6578271812675099, -0.1233510645715841, 0.14977364642890187, -0.28998805035155234, 0.1459667218798858, -0.13782560877758826, 0.29916162089154824, -0.3043620644943806, -0.22712399064329433, -0.1524528518777244, -0.06853362419506347, -0.5491906870569339, -0.5345621282498035, 0.12040273133112397, -0.36798464464982794, 0.011679725516599893, 0.01842920440260456, -0.6453776117932837, -0.0793665198256384, -0.10076366433216044, -0.06702619131715046, 0.01682375728891529, -0.7689011223961328, 0.37295512574577555, 0.05447519238005291, -0.21563476176305482, 0.24964524397439364, 0.5581204034393588, -0.17590314784476724, 0.16257308811595367, 0.03550728952388229, -0.7444687461653933},
    {-0.04129044847278253, 0.02664383990411388, -0.13442350451451243, 0.2346711044219077, 0.12731581301593517, 0.2776636714474059, -0.023055198905480166, 0.06623048016838574, -0.4173247334708445, -0.3799262851898228, 0.050661527990717097, -0.04389881280621886, -0.8014078471627678, 0.6872520049509773, 0.14797109274489711, 0.39072250643141737, -0.39007463019794775, -0.14476129241034963, -0.5229770949431699, -0.1574600676117053, -0.47772500125880873, 0.12182175102890651, -0.10745229363868389, 0.4108521601967603, -0.2860134992951442, 0.39434823360072396, -0.03438854520242932, 0.01151709216948117, 0.045124756352178726, -0.27892168204977674, -0.5243989514482504, -0.07367238326289292, -0.03640952463404002, -0.13312814745853108, 0.13095507034615572, -0.3486322666292669, -0.45434424175953797, 0.41568656470583876, 0.04752447443267846, -0.5354791162166902, 0.6508507792863373, 0.45725276205751575, -0.00839383082151368, -0.5375662601474358, -0.5490385607188383, -0.24230676778523713, -0.43505217283992736, 0.6643105328611407, 0.31438887227000417, 0.3288685246099417, -0.1862456341377995, -0.43853690055180533, -0.5898448712549638, -0.41391652381087124, 0.2953969934589176, 0.01134266101347783, -0.23028597048756788, -0.3029139980521405, -0.09194673973295985, -0.08471497056906174, -0.11303218743864574, -0.19577011065367117, -0.30395382999070225, -0.11912117921500338},
    {0.5569043226015159, -0.06479760269913863, 0.2126029994358884, -0.20026449246994488, 0.45063081680351824, 0.6082896706178063, 0.17221691872355602, 0.671589681189552, 0.0736434670717164, -0.38716870678750015, 0.49149286620530697, 0.23474303702519123, 0.2561033840700335, -0.15276977495366958, -0.4574440542378018, -0.1959681754456053, -0.5989051180493575, -0.3202200522458318, 0.15094199868616248, 0.2786187039149718, -0.07709913906603214, 0.04734322509472497, 0.15495660967731006, 0.060179468326009226, -0.09480193692641813, 0.3806717255033419, 0.5232454839919106, 0.19683385076518456, -0.16716324942366448, -0.7190845629758165, 0.4060405412809025, 0.02288480284655797, -0.41008895703661724, 0.07290004656589806, 0.01826316978194115, 0.5884844654068109, -0.21315748292056502, -0.1562168429408582, 0.14361932154393406, 0.6848559559592213, -0.3126938999531965, 0.33018759131977826, 0.1947387311669048, -0.24528542909281326, 0.05644382267354841, -0.07412145419928534, -0.06705745103851826, 0.546289471780768, -0.35018627394410046, 0.5386750626147254, -0.2773051074948941, 0.21455608682007743, -0.30568076754030243, 0.4403569942920371, 0.22758524939641162, -0.013408711871811523, 0.14604467537552246, -0.10730018126419408, 0.3592100555413866, 0.4279497333638221, -0.4640201589029515, 0.11097104655470494, -0.5925164945579277, -0.39611775947919403},
    {-0.6173894894729454, -0.21509949088410607, -0.04836430011662975, -0.14122591997309145, 0.3094753806609293, -0.45103982046390684, -0.08485222226571824, -0.35779655664127635, 0.1747598225658518, -0.41545263851684977, 0.5025204306075324, -0.05211206706441716, -0.003559875169894039, 0.14741268857303144, 0.8363476735189801, 0.13761762572076916, -0.3676722242708298, 0.0015322253393106726, -0.189457147320002, 0.25695425380546466, 0.06484189647097958, 0.45146729787580936, -0.6387639789667738, -0.06329148274833384, -0.571397337189448, -0.24082218599694236, -0.38806097095218467, -0.16765628067178348, -0.3929526185896764, -0.4027918373180216, 0.12209012013486971, -0.29496018092980003, -0.013737036033539648, -0.27666486064621315, -0.2044897900750752, 0.10761902943871551, -0.6547964393525669, -0.5040519629434383, -0.037051716284017974, -0.46719871116051986, -0.4542008027317932, -0.6283003084602384, 0.06755918980084089, -0.6207147908346157, -0.2398146677579235, 0.7094782254530161, 0.5327524786833154, 0.2624547389671274, -0.006208874069467979, -0.5568843682762066, -0.012499818112228412, 0.03742566763748114, 0.5281706337642372, 0.19442017239137782, 0.1383153065396589, -0.3086627423149174, -0.30255605783434597, -0.15655045510889476, -0.20404887175717878, -0.00899667212937274, -0.3433017134635961, 0.33173928729956204, -0.16788355404669322, -0.0827592359443856},
    {0.5738949698664338, -0.2156655279426167, -0.2325292235131931, -0.23074816254364355, -0.1727677193120478, 0.34943888333225326, -0.2338588171833224, -0.20414756911349236, -0.028973785845799762, -0.07857013695105207, 0.39394336272299363, 0.20085828791889088, 0.3984672388748513, -0.143439072559616, -0.17477322186222022, -0.07553702861905326, 0.016704263649001582, -0.05601769361498007, 0.17160616806152101, -0.1592838647264751, -0.2458030741784559, -0.27543199637830157, -0.19411486644738363, -0.5847020270505644, 0.26098170846053365, -0.2287996964412401, -0.09251068221844568, -0.10913619884718227, -0.06296207146991785, 0.4842365427266877, -0.09389030762582147, -0.6822604687475451, -0.33327983857117277, 0.003833365164090865, -0.1083178205802603, -0.299138369590721, 0.12395663938241408, -0.06110153653614343, 0.2632582422391278, 0.4881504916881431, -0.17305645830120944, -0.02051887758950329, 0.8692708763998606, -0.3281385978651346, -0.020547844095769437, -0.07241897047087946, 0.04298481257686876, -0.17639679270609543, 0.681292460003895, -0.18302166010292192, -0.1695901965907189, 0.21818161725767216, -0.6361638311932271, -0.09121833485428683, -0.04292202593449066, -0.07449704001795661, 0.049316075399582895, -0.8990729832509037, 0.20073398057522898, -0.1228383341504599, -0.28980574271856435, 0.2090602332763802, 0.03297869865023418, -0.040402199401914654},
    {-0.27389557121198727, -0.1271447908721048, 0.22359915179618234, 1.0773479532909092, 0.4235636757919355, 0.43314849172322467, -0.08636610115136271, -0.4004912688835185, 0.5591061226358972, -0.5950709855234347, 0.26002877124981166, -0.14514728865216478, 0.40668726839251174, -0.1317061117711834, 0.15154958375308222, 0.3415817547192529, -0.7065114884561031, -0.28764851974105543, 0.13506047693521933, 0.07159859258780572, -0.061248030538096854, 0.07489166072836415, -0.17320256513051502, -0.28280120515178914, -0.21747146646701068, 0.1502904074379455, -0.08563166424636434, 0.34708737515091936, -0.255091822785752, -0.12861737216999058, -0.04916948608317755, -0.15951280740050255, -0.6271277340329477, -0.5502566683661587, 0.22060442659057497, -0.2810831802248771, -0.08509280807792413, -0.523819678479825, -0.040752322750046276, -0.07047362687899757, 0.06332421756924698, 0.32447893407083606, 0.6304583138157175, -0.334167055739531, -0.3143001622082476, 0.30132596189242655, 0.3062575704866286, 0.4903829419392516, -0.06617702224743244, -0.1879643415843404, -0.10741842289813328, -0.5467030646003601, -0.6598707352725868, -0.5150853194768257, 0.5823651995868444, 0.45814346916159077, 0.16992570537841115, -0.37887182809775444, 0.16905107848471054, 0.2428053544506889, -0.1488616358456772, 0.6878865262107882, 0.024926853476637745, 0.45420784435262723},
    {-0.06840409902548074, -0.34015147816305336, -0.2813696989029724, -0.26614045793139024, -0.14288549563709962, -0.4114874462350491, -0.18795590337452323, 0.4919362060630633, 0.24929616994224346, -0.13478744664310488, 0.5724507771599807, -0.07473222535045806, -0.12403283632042904, -0.31243692475230306, 0.031209280005005474, 0.47598826923682325, -0.5480621767078107, 0.00783611136971248, 0.43536773473054785, 0.33283609742033576, 0.4203520777728104, 0.11615801581915798, 0.014272917454343916, -0.45902323490049857, -0.2555730015375083, 0.1716640445961531, 0.06330826526866894, 0.014338078118157675, 0.40881531374060553, -0.6534531981415447, 0.03460084667851678, 0.5258262617009273, -0.6119973345698825, -0.5692026182513741, -0.506647669892942, -0.29874711277437077, 0.03503535216519634, -0.015071480462061903, 0.43687896115396785, 0.15908251727351144, -0.5486879755873002, 0.38225930262851976, 0.39314456576445417, 0.3282980330804255, -0.3987670765726573, -0.12638436265056174, 0.053889888785947214, -0.0751746553596604, 0.4046176839028428, 0.4860748143110491, -0.29641178442740035, 0.09220568878737054, -0.20721773762528803, 0.6068165020893984, 0.018747324039025032, -0.13722219075269115, -0.0395603906886451, -0.2595548320771825, -0.13444484855799857, 0.3195677687239979, -0.5220043522051548, 0.04711201076485838, -0.6143034798717731, -0.2691865753871088}
};

static const float b1[64] = {1.2030055613906827, 1.1945603246236216, 1.0116161803836854, 1.1491165858775325, 1.0920741575974944, 1.1741124332540067, 1.037032928081625, 1.083593969232751, 1.0176247074739564, 1.1307571332099433, 1.085969254673986, 1.1510619678352247, 1.167042400749095, 1.1076019422653476, 1.1206797795037502, 1.0754777015418042, 1.1312225693149107, 1.1265523815911407, 1.1126590996586716, 1.16284141767804, 1.1264189070715316, 1.0427086189534471, 1.1584470857325604, 1.1538779281999065, 1.1698425874918934, 1.1889099356780115, 1.12287335609748, 1.0582974164890333, 1.1602827790873638, 1.0815797804051823, 1.1539755406680945, 1.1554698251389433, 1.1179427609012693, 1.1295694724982337, 1.0515909109523873, 1.0896193282647932, 1.0874624665660264, 1.0851096592129887, 1.0735732718239321, 1.1086112429483952, 1.0605317934797895, 1.1103795549525841, 1.1906838436664378, 1.1242561195200897, 1.1982409134275163, 1.063935236145253, 1.0862917359629998, 1.1470729420047563, 1.0152827671655567, 1.151054910128566, 1.1190528982091985, 1.1052914526939108, 1.0631674049725048, 1.1122788653495481, 1.0982336952460239, 1.0695704794257614, 1.191522252246323, 1.1070351845536768, 1.1003187880078413, 1.1637626949006457, 1.1589534828596397, 1.1754225683382755, 1.1918584187902392, 1.156266093232257};

static const float w2[64][32] = {
    {0.7160138275960759, 0.6330047480383799, 1.0318363998614841, 0.9601300987242919, 0.5313719388960846, 1.158875226032568, 0.7471145990843795, 1.2118694013750941, 0.9386850377218173, 1.1402779068567515, 0.8818290514393448, 0.6272870035409537, 1.197154819022738, 1.1234293020270825, 0.9958911958055474, 0.8060071033872624, 0.9286125178239256, 0.896446955830902, 1.0146511213530176, 1.2660436577695429, 0.1573362805180929, 1.0363006430026034, 0.020104735307968524, 0.3815801135581389, 1.1642892378275662, 1.1800718065086495, 0.9291595407386568, 0.6308240535149215, -0.22129420819316503, 1.0597838721738815, 0.9152104849142242, -0.04343538410213367},
    {1.2760229085670474, 0.550874627735014, 1.296375434482896, 0.8653464508860848, 1.0924276735219425, 0.9065858823739881, 0.940717335123808, 1.1589829426696594, 0.9031421243900073, 1.267858733117692, 0.7059464635304133, 0.07478939061320022, 1.2657462493558047, 0.8985441068346987, 1.5577598577725387, 1.0129883861109104, 0.9147510018862869, 0.7631023635300761, 0.7179061598211998, 1.1851662850774827, 0.5111733044799016, 0.70939267761713, 0.11278117319961627, 0.6845890319094488, 1.1268728554039296, 0.7287002367320543, 1.201300627331969, 0.6400349965075484, -0.164546059305023, 0.8092613482663308, 0.997347304007704, 0.09151600694141793},
    {1.1605301661572567, 0.7180422828822058, 1.0373435172336027, 0.9884214189270057, 0.8818548626347824, 1.1804736592584706, 0.8153995968190698, 0.922454972514051, 0.999948923606181, 0.8047900938110965, 0.8170503385092971, 0.021526683007461096, 0.6481841513365072, 0.7697089014895784, 0.9574220384523844, 0.9361621072915437, 1.001370343205338, 1.0820199604683938, 1.0245174145782392, 1.0201759503069603, 0.5900119571829945, 1.3294641572492716, 0.10755166425956185, 0.5372332544176007, 1.0464688817721584, 0.9398144939828116, 1.1109950048144186, 0.896407572064574, 0.021305815754951683, 0.9973135828578251, 0.9686379093466667, 0.12100362016841437},
    {0.8689240137862388, 0.8637033574862367, 1.0709768111753537, 0.7788517021295426, 1.0971935888501803, 1.153370140668882, 0.8447097497632722, 0.9310777272492863, 1.0113661787718138, 0.9628014879721359, 0.7399226407476109, 0.24909835909042347, 1.255581680094139, 1.2353120621701592, 0.8317707687413987, 0.9885184212939019, 0.8249163855545719, 0.9530500377103057, 0.9800072429548549, 1.1494919916164197, 0.5261961306024471, 0.734069766717756, -0.18085220297489357, 0.6856578835670071, 1.3283768956118385, 0.8870301702545091, 0.8105781587853174, 1.1307107740270752, -0.03353828970509009, 1.0098111479890455, 1.1821032938046268, -0.17880441739976688},
    {1.0471749489170226, 0.6805057589350233, 1.0982101608636197, 1.0397484760740798, 1.1364423922680371, 0.9755221552300537, 0.5376350263604988, 1.1217844672408988, 1.2341572842360597, 0.8584548619061738, 0.7293033935617539, 0.35562520027427036, 0.9953674097646463, 1.0721574694900629, 1.0663983537774322, 1.241714173101558, 0.8348636729076568, 0.787581491390057, 1.074382580187623, 1.0642676941289404, 0.4590460715010657, 1.0359123715452492, -0.18743539750416893, 0.806514562057992, 1.4362604205062108, 1.07871822027095, 0.6225305291018383, 0.8742969470601615, -0.01151643186947589, 0.9365120999649398, 0.6986628359144353, -0.31356131768770507},
    {0.7419906409510482, 0.8015547326708818, 1.085695714647224, 0.9439976176626598, 1.2808247581219507, 0.9791376670025528, 0.8368484747122573, 1.1558750817638075, 1.2674670127987087, 0.73558374745931, 0.8772545857634358, 0.24259442930513342, 0.7788133266415608, 0.8800112665093212, 1.4274589376647113, 0.7725348820672844, 0.7135683774280607, 0.7348716298753548, 1.005198640906722, 1.0718962452012792, 0.6960707962119529, 1.0398600628157197, -0.04935113267669119, 0.761840552680103, 1.1661718317064194, 1.1347977865993284, 1.2175015791257797, 0.7399392433103216, -0.11305641792623786, 0.9893420949195171, 0.7870919822407478, -0.3200822926216173},
    {0.5584636738939901, 1.0163811849163797, 0.9281443745309192, 0.9264729122628357, 0.7489988590444103, 1.275552719791066, 0.9324935731905526, 0.9565721680208421, 0.9330731550123832, 1.2232789446911703, 0.7773323952850317, 0.33055734316806723, 0.9883545012365644, 0.9939545311340109, 0.9988112149109545, 1.136231981559733, 0.6080850459227198, 0.9921552292156197, 1.0407700014839179, 1.029179339245593, 0.8378324776967055, 1.2423808127971148, -0.10534735234520506, 1.101215654226262, 1.2565346945178502, 0.9517856296870533, 1.0668765733829129, 0.9953215498733252, -0.19441722250783489, 1.22299992715391, 0.940240376330725, -0.15032629198428443},
    {0.6553925121293734, 0.7710776298489754, 1.0413699460191939, 0.9788622035767264, 1.0597487526563476, 0.782720043159531, 0.8705848835124562, 0.7947728768451832, 1.2082891088547043, 0.9830023285406173, 0.7134254225124054, 0.07913505738315223, 0.8593316303427524, 1.1954374775900294, 1.1480240814998846, 1.4234580575612306, 0.9120072672425673, 1.141576193116762, 1.0096098391996764, 1.0650850006789663, 0.5274890853130971, 0.9793600794287294, 0.22426552938072658, 0.5860903028743207, 0.991760498378902, 0.8088019604552187, 1.1131590823007953, 0.8576092409516776, 0.030246002793783738, 1.1551829465840575, 1.030048584878506, 0.33537712015365145},
    {1.059056164141557, 0.767062417790665, 0.8285621583993502, 0.916576050621146, 1.0645799258466546, 1.2273848705746828, 0.7623040699976065, 1.0794183732500504, 0.5847397378337723, 1.2124312661188494, 0.6858135829182171, 0.36772617390206, 0.9203483480958862, 1.0826261316101657, 1.0723151669544628, 1.153063051621262, 0.9849005335448553, 0.6867002569026037, 0.8766071051563604, 0.8327967695402776, 0.5282729634569308, 0.8217106928134686, -0.451900813968099, 0.8050981584714859, 0.7645253997977949, 1.0627139758844246, 1.548860386217764, 0.924253874781554, -0.10954886569126052, 0.9255810496910294, 1.1005347667535488, -0.05504780122536523},
    {1.082955108695705, 0.8804947259078401, 1.19769922011924, 0.6563173212006015, 0.9661158666659121, 0.9078865904063611, 0.7938914860547511, 0.766515168347411, 1.1640538317811093, 0.8396343488089985, 0.5893342181160774, 0.011565731460052414, 1.0809541153220648, 1.4530737306491948, 0.9942596738635671, 0.887761676905126, 0.9987008457637964, 0.9217259558753093, 1.092297967090468, 0.9798325692376469, 0.3381272915023731, 1.1441633915287668, 0.02701856696816095, 0.7096886094077662, 1.3060241342274617, 1.0330122238861879, 1.197506266050063, 0.6974124461410174, 0.07919900581637018, 1.1410088661011732, 1.3009631258920462, -0.2054543733390785},
    {0.9947874141580614, 0.7591595878946071, 0.856596750739271, 0.8137121994835763, 0.7609615643552736, 0.815620730822412, 0.9535980677035371, 1.059253345233161, 1.1869301683392435, 1.0634591664946917, 1.0322564178392524, 0.20879513559391258, 0.8888939691248514, 1.1504734131379688, 1.266052342450316, 1.0357602693713293, 1.0511734145757148, 0.854901748365311, 1.28036848436797, 1.1410083398781217, 0.7679372236212119, 1.0844412707202749, 0.06254930009028639, 1.0416654763691757, 1.2134708422555804, 0.8071944926144051, 0.8684880748644115, 0.9429634270960372, 0.10274393784925173, 1.1237946136266272, 0.866474346796846, 0.008390997190066005},
    {0.9109641490386133, 0.4586137741399608, 1.570283582921863, 1.0468042578976764, 1.07049675981495, 1.0962013049691692, 0.7562459136965649, 1.0063944454435076, 1.0241625887574897, 1.1797656402674856, 1.1458920432421906, 0.11717604274613219, 0.8347149726427141, 0.8065001241808184, 1.0824414694772084, 1.0089673097199487, 0.8298202011474695, 1.0240979052157406, 1.0589506366235804, 0.9746698278036123, 0.6475918521007599, 1.3539097071593806, -0.4177697978846418, 0.881030733247369, 1.1785175245573596, 1.1634474212580903, 0.8205524974229531, 0.8142112627161087, -0.043271842350295235, 1.2239108304904558, 1.2250591391075918, -0.13012318136848036},
    {0.9415339301097049, 1.0424189003128357, 1.1676201961058503, 0.7519714098898012, 1.1268132885676765, 1.2173620743249287, 0.7779068219363389, 1.0686264857896957, 0.9554387658820919, 1.4012963369936668, 0.9488317118873179, 0.3517796216115291, 1.346049472072847, 1.215948588361636, 1.071486732949516, 0.8733016381448488, 0.9961200056400912, 1.0567465187453404, 1.2823110887974531, 1.004494845186044, 0.5184167736555297, 1.2638529079256924, -0.08373498986407052, 0.6022491746784185, 1.0476253363648238, 0.8420653835763473, 1.013079378092065, 0.6658363621243895, -0.0878763985807691, 0.9223222005867571, 1.1717033991363317, -0.08842245327617206},
    {0.9742818087126504, 0.6492856119952704, 0.8926109394659287, 1.0936772434211697, 0.984951969544837, 1.1883754139247695, 0.9371645623975673, 1.0728118662659325, 1.1068773116552804, 0.9081132838468624, 1.122272498077854, 0.35074655308064895, 1.0028676616548418, 0.9495310853113678, 1.0181590799708191, 0.6879346073296089, 0.694144733977234, 1.079761611596662, 1.389749799298321, 1.2139059707708144, 0.48654099026244507, 0.8843283619577611, -0.15913477340454923, 0.37917944388054636, 0.9739299055047519, 0.8861453585693252, 0.8784931673090322, 0.8576351711779047, -0.08263129741930851, 1.1438003270802748, 0.9694341099456932, 0.13050666586555063},
    {0.9654349971148913, 0.8865931398970714, 1.2265731371375137, 0.6301480657063288, 0.9653495424178641, 0.8109899687053882, 0.9105347245927725, 1.0589146905838593, 0.6963780141510848, 1.1763580984369846, 1.0172158555208084, 0.07173687973601137, 1.2499717884055073, 0.9982197320292969, 0.8162590146889113, 1.238356726702015, 0.875847367005795, 1.0450948044325135, 0.9736236962679045, 1.1610925217493786, 0.512605930607382, 0.9050027974907632, -0.08628187375105492, 0.3973341983938291, 1.1959680880676022, 0.9306217668374102, 0.9521479316986686, 0.9666801385404798, -0.17342141182172996, 0.9358136161962878, 0.9794454768595862, -0.007323544767032229},
    {1.2769875127999146, 1.3335538472935737, 0.9222315493850528, 1.0795035211662227, 1.1172038420175325, 1.2564736957567093, 0.7668745920630534, 0.6991426011815904, 0.854158910900317, 0.9448293432855683, 1.1717540749634698, 0.25115371156591515, 0.8299529058603855, 1.0588957720907688, 0.6723057210386515, 1.0295274344490124, 0.8411201200305067, 1.2314155752419416, 1.3011286592826883, 1.0583648086010673, 0.5519736696729189, 1.1563633190966274, 0.010793606153318243, 1.0021005248326205, 1.1732182343492974, 1.0356785383668126, 0.8314801317672416, 0.5933981147206369, -0.060286977964110644, 0.7090017399392678, 1.1219794921261985, -0.10944921202321835},
    {0.8171478747732939, 0.9181597363403798, 0.825856278748196, 1.0083106804498154, 1.1090185866003035, 1.0863287715091916, 0.7207598473346519, 1.098301320975701, 1.0680526089982727, 1.145951706060725, 0.9813618416535743, 0.10345681806823925, 1.1652395863945604, 1.0966646561704327, 1.176754156646073, 0.708192136514234, 0.8234534858338488, 0.8207091999594139, 0.7417143814972347, 1.0384766309889413, 0.46271547465573093, 1.0122831443831724, 0.06721058163348896, 0.46562957549891515, 0.7396166312532485, 0.845721461406831, 0.9917971744492378, 1.0154215552256556, -0.31615808431684644, 1.0629823867468586, 0.9077555027596537, -0.2157473563151072},
    {1.0852776391784784, 0.8662312213076955, 0.906112343930924, 0.6921242711893673, 1.0362320939387635, 1.059761430922315, 0.5603266144991099, 1.133133983682391, 1.1056520731910708, 0.6669250079175174, 0.9362088034420003, 0.3223033256012756, 0.8782541660533647, 1.3041228847212374, 0.8332521056268127, 1.2797860789465525, 1.0995387065916993, 1.0623769095846851, 1.115211773054144, 1.063118273406612, 0.5765827854064566, 0.9951849852344213, -0.2845287103627014, 0.6403013791168461, 1.1287705969278161, 0.8455709357159936, 1.3613848951837033, 1.0250272312359219, 0.04256449580010075, 1.083212213302096, 1.0073486640297147, 0.05038487010989387},
    {1.0900111808541773, 0.6606224291140482, 0.8925611080393552, 1.0303704666369495, 0.8920339982809933, 1.2387601167640894, 0.9337922008139832, 1.0848243887876623, 1.0027889630683153, 0.8122099007895127, 0.8907836845294047, 0.46526537020216746, 1.1123524086643801, 1.2620358597857986, 0.9834849680668422, 0.9476062338391085, 1.2736625048867836, 0.8138588533933161, 1.2083814157506143, 1.0342188282142175, 0.2817636803195147, 0.8541601403750743, -0.11556552568621759, 0.9927397160896365, 0.9936169082039904, 1.3516315549606774, 1.252430929566416, 1.0177498833268839, -0.2801630374384967, 1.0189230081894858, 0.9444441871170096, -0.15017470489454987},
    {1.1125978925344349, 0.8375328913434641, 1.1232885547137768, 0.833377921977403, 1.0356837040652251, 1.0190314598558674, 1.1024110286753275, 1.1973045189328888, 1.0502729042359134, 0.9013075893220721, 1.0596474730856191, 0.40053787350420744, 1.0065759734096975, 1.0594624426183035, 1.1903343393783499, 1.1260343865266618, 1.1293606803327065, 0.9062656567488471, 0.8060796818478453, 0.9307225038076663, 0.576440216613237, 1.5669887808725989, -0.30011750284931443, 0.7174241292445888, 1.0855646515997415, 0.9914722181725312, 1.114543502903895, 0.6133842780605073, 0.026056464724908107, 1.418021565983896, 1.526225678826029, -0.1941412491591219},
    {1.198628634027747, 0.9852355498327066, 1.1376189789248783, 1.1695110663996249, 1.0008544262323298, 1.214507721576284, 0.64306699603034, 1.0561061497271418, 1.383439071706827, 1.0363551513472737, 1.2652017228432264, 0.23240786763530003, 1.0365497746205703, 1.2086927552459044, 1.0663358498189472, 0.9015416394524355, 1.068030103401895, 1.1425852420842904, 1.0980333446048058, 1.263235430262642, 0.20990816679254704, 0.9521776899548716, 0.03041983563428253, 0.8027039301588027, 0.9618813975758783, 0.9926544473580704, 0.9759637181475778, 0.8166603065370635, -0.10676528482542545, 0.6264379359855512, 1.2194275149868476, 0.03954120069380137},
    {0.8819092165645763, 0.9442099088350769, 1.0792809251301065, 0.9368961440132547, 1.029762093321445, 0.838267235041622, 0.5600015724350069, 0.8076575990547376, 0.6186353180293962, 1.1410938518801834, 0.6187584401143079, 0.365332657204345, 1.1836941167345023, 1.11791137377628, 0.9225464453975387, 1.3339563312061795, 1.1451905210876334, 0.9544703218190461, 0.6574376473662756, 1.4409239469082038, 0.6578445995281916, 0.9837018881503217, -0.007032351027314365, 0.7881200097586389, 1.2189887525888725, 1.1273055956227211, 1.1930347856504961, 0.8355583455745764, -0.129943186888573, 0.8807325537814102, 0.7227203159184497, -0.011184376827698055},
    {1.018185477741126, 0.7534731693859208, 1.2145860009061535, 1.1430132085217224, 1.0250745419730005, 1.2105869658351898, 0.6741690365722512, 0.9232015759359937, 0.8675706148877204, 1.0067273596954056, 1.02524841332177, 0.1993135166840516, 0.9493107937285913, 1.052069684528865, 1.1477947876531793, 1.0725597768837365, 0.6779468753840309, 0.7042324559405995, 1.1288674578027136, 0.9131631422969655, 0.14309858997383923, 1.042697979934297, 0.03172989975095677, 0.7387018678791794, 0.9142175347080416, 0.7543037646188924, 1.159403682259194, 0.7043629832836507, -0.00018121807337122107, 1.0234240853466332, 1.4012733276446974, -0.42645292887143504},
    {1.1820467087598965, 0.5567039002293261, 0.7301982695228945, 1.1550121636539086, 0.7703000927043288, 0.7640739505724287, 0.7713345193706511, 1.382254304531757, 0.9886923458184779, 0.9144934559520114, 1.1061998473856773, -0.045197046267073805, 0.8853417013459493, 0.8888083658137862, 1.2245024159091253, 0.7629906411836986, 0.9024763112282252, 0.8801502613040334, 0.990320151802158, 1.3142936146333626, 0.401693698382528, 1.013377170267724, -0.01939554218855481, 0.07137051136889838, 1.080895916275747, 1.025137920974918, 1.1960422077738724, 1.0580502857161989, 0.08402717055267432, 0.9795443604211265, 0.5859164256572675, 0.22626009854568505},
    {1.1787803104348946, 0.5944995033150563, 1.0389008209620039, 1.0225919027304982, 1.1810183435006862, 1.0777119916465727, 0.8152966234178837, 1.0231993699081139, 1.1800849723896718, 1.1946087568688146, 0.7482588579115714, 0.3235260454707622, 0.969542252926678, 1.104671299333615, 1.457663419819795, 1.0827598842259154, 1.1107338816261991, 0.76116215067152, 0.8561153032674966, 1.1064584205257415, 0.27380531179243967, 0.687355170099821, -0.055586137811767855, 0.5308611878855944, 0.9480960691497874, 0.8086001401949723, 1.058401107122932, 0.8335686456461456, -0.20106027834976747, 1.290230582112712, 1.303049167806863, -0.33420256854704977},
    {1.0711125556643872, 0.7792187762244186, 0.8569879295735324, 1.036265922540631, 0.8838731030864183, 1.443094903679273, 1.0746132652561438, 0.9774736389495094, 1.3362494770756195, 0.9506548516545473, 0.9747254891664611, -0.06703127708480809, 0.8917513765951338, 0.804935261508217, 0.8970414675638658, 0.6944916260239837, 0.6274402010137995, 1.1441227841470218, 0.8938075069981053, 1.18206021820361, 0.5037652183051511, 0.7938619120969299, -0.2876023287897384, 0.5680925905654695, 1.2473148144901247, 0.8814509106515028, 0.8287622790153912, 0.6759132469914192, -0.2561771166170818, 0.9052601962435946, 1.0819835218707525, -0.22934733727878467},
    {1.0457941320857824, 0.9410836246654666, 1.3016218427073503, 1.200565455494343, 1.0607609784213738, 0.805882253261225, 0.8542669597966638, 1.1314427017877573, 0.677746630668129, 0.9202051710223654, 0.7151115505521931, 0.20506573459003566, 1.0018475183276547, 1.1294956308576825, 1.0260826710174302, 0.7970686745099893, 1.0846159514221052, 0.9124076349632938, 0.8088245935803882, 0.8307210220749097, 0.40134129940221114, 0.8187930005634965, 0.00903833252256967, 0.5314907083642392, 1.0156983027626374, 1.059487155165077, 0.8552155237565487, 0.9031091849276961, 0.09290739007028632, 1.0544329995193251, 1.2356164438946802, -0.23249619805562974},
    {0.8538929433714274, 0.8290040246803254, 0.779968098843564, 0.9671880184123604, 1.0027180507995201, 1.2089301095564389, 0.864025680595444, 0.7250592632350864, 0.8898069750224024, 1.0797776818957519, 1.3573277628065816, 0.06841318801088227, 1.1822827657409947, 1.0401721591721516, 1.0834864085237943, 0.8937411254020762, 0.8702703493522057, 0.874128240002395, 0.9738478977461211, 1.1684557513070757, 0.14210193238670138, 1.2008893640590295, -0.3941777806774004, 0.758092320758989, 1.0641096737643079, 0.9602489560242129, 1.3628077747216227, 1.209725035717007, 0.13933629026513544, 1.1352776288503552, 1.0324420315735277, 0.19467656583912898},
    {0.728013468171752, 0.5841019531427575, 1.0419521387074653, 0.8971751363697509, 1.038449552576382, 1.0815117080193157, 0.5645466117398182, 1.033392301928666, 1.4518716104452762, 0.8634162758078519, 0.924415821850537, -0.009146825850066143, 1.2165083485348218, 0.8468305673062946, 1.254185538314525, 0.6269102277484879, 0.6099143788649434, 0.8206571956932551, 0.8570583349823346, 1.1274944655294412, 0.4405389010526096, 1.0931939130962725, -0.08605301516405012, 0.841679892926852, 1.1033214843027495, 1.078639923478674, 1.167639462346511, 1.0553097920145302, -0.06717895291027019, 1.1004918550267413, 1.39642145494507, 0.09805742848985276},
    {0.3965849437313551, 0.6993433260411999, 1.2368559788096485, 0.8761701820155059, 1.2334381677835462, 0.9685590495582883, 0.974229838766021, 1.0303956037597264, 1.0130695674584915, 1.0217150332560083, 0.8907491854398303, 0.03990046144282383, 1.184812785821121, 0.868771035977957, 1.0929131902346043, 0.9276058869555761, 0.903256719629715, 0.6850970437851804, 0.7674000888153955, 0.6546897797698935, 0.6678653391884616, 1.1887564032761226, 0.09163871445753385, 0.593246245595676, 1.1882328406848763, 1.0479286111922776, 0.8634044380412416, 1.1010632845570059, -0.17567753032879901, 0.9500394606732661, 1.0413930568183347, -0.11872639120749108},
    {1.0837930922569166, 0.7008905230529564, 1.2915833407430406, 0.6910050003010848, 0.8526488492537451, 1.1562846472712804, 0.8565765862310132, 1.0616996681956272, 1.1842115460271079, 1.2272604767922148, 1.104086259908898, 0.3889487849455243, 0.9316674888329934, 0.9874824757831817, 1.069738022114281, 0.7847733213858947, 0.9256209746302849, 0.6218404710291543, 1.1386874294101845, 0.9291302907169586, 0.08524733969453789, 1.0802451627538894, -0.12116045564641692, 0.7700590447990092, 1.1911406099741872, 0.9112959927558266, 1.2501032956392326, 0.6149120103243452, 0.22701713369205195, 1.1782709894975636, 0.9572006986547718, -0.04801619273254221},
    {1.0353349194582824, 0.9960212098964704, 1.1880846456075287, 1.0490250066558229, 0.8647625324422369, 1.2247359665935196, 0.7731114355691485, 0.8313942204487369, 0.9569266766204014, 0.970723886638923, 1.074851565709723, 0.17174410278725297, 0.828167620680184, 1.0763238365410106, 1.2716756966319367, 1.0529501335871863, 1.066580233797044, 0.934736805321242, 1.2691218161049467, 1.1196703584277694, 0.6994722495927893, 1.1083315478648772, 0.0037423589572982696, 1.0285800404730088, 0.7447077111417378, 1.117806192910395, 1.2057561617920172, 0.9505222748593014, -0.5053919690436839, 0.9250508021923282, 1.2111902814710038, -0.024192603251892975},
    {1.112982682468684, 1.050120877141146, 1.199258812644331, 0.8441049037277717, 1.089733813801242, 0.8940372415426632, 0.7556039759592161, 0.945699695918294, 0.7535571645544271, 0.9034009623202444, 0.8705729123149621, -0.041502260707019074, 0.9235880213398174, 1.016831910128597, 0.9769632748558018, 1.081289720003914, 0.8430255282606477, 1.2211551268140695, 1.2329236200789049, 0.8552375277879091, 0.5007371915068152, 1.0428851869640694, -0.007228230975840886, 0.6689729942607527, 1.222286423548013, 0.8982228695467218, 1.1659643205963084, 0.7925373184209417, -0.2348448552994233, 1.274936815345056, 1.213572733164157, -0.1062400536862528},
    {0.9011237851565871, 0.6191535547566953, 1.0367345955762064, 1.04373606481189, 0.8272972599570241, 0.8035109545866684, 1.0350192057556178, 1.1273212624644557, 0.9733228908357232, 1.0238356923830987, 0.81801462419433, 0.1613879472409879, 1.078672938607166, 1.2893180090212102, 0.877368783524634, 1.2509510019823897, 1.0886120507609962, 0.8328730068128626, 1.1137015784062678, 1.4255174553972316, 0.40048343237876155, 1.068378944703347, 0.013956151790269952, 0.4257362039190516, 1.0241112463483724, 0.9758458577795612, 1.1171788724606564, 0.9157516318890706, 0.47217268429808945, 0.8720172800377204, 1.0186916474924343, 0.3610153030644354},
    {1.1712193309326016, 0.8475157880119499, 1.1334946719477867, 0.6050554384376038, 0.765372762736621, 0.8182029031249182, 0.9344773062422901, 0.8230650912631551, 0.967805176701905, 0.9861974053002004, 0.8298822857091763, 0.2893362291251251, 1.1617607455251255, 1.1161827058224032, 1.2781840806712481, 1.0826479776816786, 0.9559055211022343, 1.3930165360652382, 1.103771854570895, 1.1036700793642829, 0.6619803253491905, 0.8753402701465397, 0.10804614495074283, 0.7394313227736174, 0.8154732678523342, 1.1553651914411327, 0.8684677087619703, 1.0218564431188246, -0.24321175813591658, 0.9283242220594099, 1.2765152693766537, -0.16089881475653173},
    {1.0282716423116636, 0.4467746522888566, 0.9135855361710741, 1.3227852549112409, 0.9104435958980144, 1.088819940738375, 0.8933736376384397, 0.9013336177599661, 1.0195373611721321, 0.8101522531737437, 0.8435887195270697, 0.23718465378423895, 0.9768082923490062, 0.8509332382136781, 1.427433084320963, 1.1201146779797082, 1.1114170754412516, 1.0382392338508775, 0.9859141869196244, 0.8678291951002832, 0.34160326933269064, 1.0084497815807874, -0.023205027493654273, 0.6814826536357304, 1.2739870479596132, 0.9970113399442602, 1.0586489404853825, 0.8051883386461148, -0.22378284081103197, 1.1627118689140146, 1.195942720408201, -0.013792681297982272},
    {0.855596282931988, 0.6644271212081158, 0.9531894832491933, 0.5093377746552777, 1.1864572804314744, 1.0146722149718246, 0.6364216954810162, 1.1926788111381994, 0.9764930955809223, 1.1153174566814932, 1.0518611241970746, 0.3573056154289368, 1.187023878534502, 0.8214766233066204, 0.9347453669090624, 1.017643758001181, 0.9463792290649995, 0.9451374974639488, 1.1190833885795695, 1.0427478144320548, 0.5051983473080228, 0.8801890858250477, -0.3604962684526644, 1.0663088937147052, 1.2405874675594666, 0.8607573605461606, 1.0469556281467416, 0.9752721157968144, -0.03415164599140837, 1.125201203362017, 0.939396831332226, 0.1194740920416224},
    {0.8563585840649285, 0.7277953321564541, 0.8817192654281272, 0.9218518083517778, 1.0600826400131038, 1.2297389195123845, 1.0996036434676904, 0.9856508053144541, 1.2413757602184274, 1.2858739445500305, 0.8701009371525652, 0.12097331994110434, 1.0015307055874207, 0.8220523382009209, 1.2223585228934153, 0.8098351166485307, 1.226470264310284, 0.818225835501306, 0.7307106303319514, 0.9160768981706171, 0.40881048152292976, 1.2876574987174765, -0.217889547034168, 0.9394597975452648, 0.8293496946609538, 1.2348030526800915, 1.072607076283507, 1.035448776293021, 0.12857843214056958, 1.0175249669797872, 1.0841847148833987, -0.02186902238544727},
    {0.9381856100973, 0.5632315919900373, 0.959066525714684, 0.8833478676933296, 0.8852211271439802, 0.9540495925475849, 0.7888190753755547, 0.8447448868807532, 1.2105657963913277, 0.8954438857089992, 0.9172968746994475, 0.1855982882923908, 1.0720417139694467, 0.824216968848025, 0.9406571687500629, 0.7994235112770299, 0.9277868401254838, 0.617199210053967, 0.8101586640827473, 1.0546324543158163, 0.5825045353084466, 1.2032949510660191, -0.10038284400799175, 0.6900811226779684, 1.2451677033269528, 0.9256746356442463, 1.0001891407163812, 1.1830397685259153, -0.024437378675720982, 0.6492958053598613, 1.0104872381988723, -0.1653808449473813},
    {1.0821156809856387, 1.005808506937248, 1.2894054267894353, 0.9009932873330541, 1.2345923326914794, 1.1746678258972905, 1.040804274006327, 0.7425882416689331, 1.111756042753749, 0.7881616365660665, 0.9031115785540383, 0.15687217635781284, 1.0236511721675559, 1.0230925501878922, 0.8872672811801793, 0.7835500097916106, 1.0053829174885456, 0.7905541186121875, 1.0495106424827443, 0.9205825486467503, 0.8183577473417828, 0.9873201423159081, -0.18197503094326095, 0.8679100890169443, 1.1249246424855193, 0.9341770582379934, 1.0231623281295863, 0.8063074710073669, -0.26907090452846905, 0.5616196551605671, 1.3351523221192256, 0.16358792817717066},
    {0.8392365063570728, 0.8134725589195814, 1.0602157281356168, 0.9605147139497648, 0.9967617845352098, 0.9457502649663417, 0.8984682525003057, 1.2975041298609158, 1.0487541912335259, 1.0802025851697066, 0.7615179561541646, 0.17799389252628284, 1.1263627653303192, 0.935740548487043, 1.1652456726523162, 0.9294311173283375, 0.7762070094922315, 1.0659786018551614, 1.2233658241105636, 0.6650885897246482, 0.3117358481274448, 0.9235898503207272, 0.21193643093749823, 0.967728685414164, 1.1399701104833124, 0.8254991304176694, 0.9262338406134975, 0.7350046713991173, -0.02387333864191209, 1.2524466882869147, 0.8390010670387245, -0.2629969982547655},
    {0.9800774694374473, 0.5967811868010393, 1.0803920597244483, 0.9481255075749019, 0.9070910227293241, 1.04795918399545, 0.8891853239537226, 0.7932117430925465, 1.160499792853476, 0.9456304859461564, 0.8472770804420577, 0.201920215756528, 1.013983426899855, 1.134899493519847, 1.0252964061437897, 0.9177625823377293, 0.8687147076364403, 0.9786859671022974, 1.0914453136661968, 0.8892611780443813, 0.5396426331179445, 1.2377260655507878, -0.11479970175565492, 0.759382827814888, 1.3428274484698792, 1.205987233533239, 0.6912156303322526, 0.7610380765589365, -0.36984339566041496, 0.39607948042500735, 0.996219466523574, -0.11303168147268544},
    {1.2496976097484078, 0.6585931777727293, 1.3680131262531985, 0.8296844673765221, 1.1369707322843468, 1.3250583649246617, 0.9335883794208963, 1.0442067692486328, 1.0875163087984965, 0.919716533004853, 1.0613562172243691, 0.13121671723946868, 1.0168785320329732, 1.1640566825866379, 0.8440114108841106, 1.0428884824739646, 1.1448946694157127, 1.0673477137163698, 0.7241222530733461, 1.277344632678115, 0.6927843194144035, 1.095901896532276, -0.3196062878334859, 0.5897388264974694, 1.2383049924754235, 1.2631968514468426, 1.3071422263931756, 0.7295838210070655, -0.011339982586864389, 0.7535975375905023, 0.9773022408700675, -0.19533949328976313},
    {1.1468586736798032, 0.8308220273828648, 1.1266762351951574, 0.5834704130007201, 0.8734218574216733, 0.8820108260633184, 0.7253807623226854, 0.8793994798533371, 0.6809331070446053, 0.9960932709072384, 1.0619668371927995, 0.07418322842610121, 0.9589533637655862, 1.2048823748037802, 1.2720176121429172, 1.064818192491579, 1.092993218933387, 1.0100206765626003, 1.4920478657384797, 1.25623945553139, 0.3325016940230189, 0.9368566263693162, -0.29164072998660584, 0.6076390648165529, 0.9360984593241862, 1.1535370805921878, 0.9920801297867602, 1.0705128741945957, -0.12137996342978391, 0.878495517215397, 0.9222473543393221, -0.14026172698307396},
    {0.8488743538118252, 0.6844485206274283, 0.9267147666022255, 0.81759385733124, 0.9320244035331935, 1.080505131156351, 0.7859351481448582, 1.0691147363904876, 1.1584817197118937, 0.986417134839115, 1.1231559516400667, 0.16206428488015287, 1.0019406188665305, 0.9433435568037678, 1.1330769994481242, 0.880059885126897, 1.0830048423290337, 0.8794195173174583, 0.7101723066264491, 1.2028083576235729, 0.5576447565736187, 0.9208792600012078, -0.1047860593641835, 0.8108971489881118, 1.0872102595001112, 0.8932102179323205, 0.9755162844035654, 0.9693712655657399, -0.09218717421234857, 0.8193051519587647, 1.0538101990233517, -0.16124670426600543},
    {1.1690428815797933, 0.8249853254977492, 0.9372289012648497, 0.7549352517041484, 1.1862613138958207, 1.0090160564574588, 0.8151769343157999, 1.130580755880682, 0.9708806554707579, 0.9096819212868723, 0.9336509668154996, 0.07459258598210722, 1.1715224513400193, 0.9011314814896091, 0.9967483104103465, 0.6482494983183392, 1.1108110015566834, 1.2253079999562044, 1.0938450297378919, 0.6578212471626395, 0.31590841195745833, 1.0901899511329276, -0.086852140040147, 0.8486962017654289, 0.9836333618554302, 0.9612648576162853, 1.311974039648954, 0.9169610271654628, 0.052517290837340316, 1.1416056126201353, 0.9262626166859848, -0.07950510893763174},
    {1.0076068451339006, 1.0008484240778837, 1.1164223397020279, 0.6035105958747107, 1.3600547449411111, 1.2211821890473462, 0.9477289658340076, 0.9515403056877975, 1.0783753790462405, 1.4394117164056446, 1.2145362440173204, 0.49321540108097256, 0.6338603801570165, 1.035701047436441, 1.0354903022413111, 1.0590177452249838, 0.9955861583830217, 1.0686106744927617, 0.8360358420450655, 0.9320995178517271, 0.30267656661303105, 1.0058188223051525, 0.16615789795477887, 0.660588625213795, 0.8624145225677144, 0.9747812785505796, 1.2592204891404006, 1.0715043656070258, 0.14841665134958093, 1.063389847345003, 1.0914197680847717, -0.03182895846827819},
    {1.1700333531977418, 0.5032235992817936, 1.1357508450402733, 1.0829076328823661, 1.0075518878859677, 1.0048841237684016, 1.0666322050110513, 0.8360386352045768, 1.1065845779949202, 1.0007803192267921, 0.8580748724186561, 0.2862479500725477, 0.9172010654489894, 1.2372583621309656, 1.1578265260020677, 0.9511374939159115, 0.9505217646384087, 1.1593851477977282, 0.9044921597715878, 1.3310681357949274, 0.3954223901464558, 0.9743432596774891, -0.1410185745708139, 0.7096248425393492, 1.058029840205476, 0.9321627979075288, 1.0612144213834458, 0.7690532267072983, -0.199012592987277, 1.0086703830360135, 1.1789293523145228, 0.0880869482351868},
    {1.0938096152273158, 0.7088998769088878, 0.8640593963267378, 0.9005541333843358, 1.0050220913131358, 1.168928865416664, 0.9962454219514002, 1.016304925233053, 1.0084677353770057, 1.1358585981018459, 0.8545186861611621, 0.30876574062149836, 0.7951543768745766, 0.9391327010006341, 0.9674830644471112, 0.9405690296123687, 1.187381604332361, 1.1051111028044287, 0.6996210313786969, 0.9755997045829856, 0.651190264764825, 0.9890787879171284, -0.3324917910164046, 0.7431552513517882, 0.9040207322262909, 1.0297236416196571, 0.9991246877879814, 0.781874911836347, -0.22464039230837973, 0.9268363226537614, 1.1116385530880104, -0.08284150638900448},
    {0.8122324804725505, 0.6736926838620629, 0.7687244078328124, 1.051081766614747, 1.007574905795028, 1.1232142614483154, 0.851608430656524, 0.8575253607678752, 0.9361046789897123, 1.387829466269413, 1.0322013548046884, 0.21309647983354565, 1.1048912030056866, 1.2533126945012232, 1.0644759594030342, 0.9098329035521424, 0.8095206969704465, 0.785740932151151, 1.083233534884706, 1.148035249992716, 0.45228969899702703, 0.7370350974122122, -0.16112903954357854, 0.5336158640521118, 1.0665052859231954, 1.2373662169825845, 1.0033810546786923, 0.8357265725928168, -0.19063984913155524, 1.037478077672382, 0.9217747841486486, -0.09968970799523359},
    {0.895369342861919, 1.00948939764643, 1.1096266951878009, 1.1403125349077152, 1.3497727389564682, 1.3430683885277792, 0.8550050806358488, 0.8429963970835648, 0.6841803149732175, 0.8008268014036889, 0.8055850417876891, 0.17769987753635097, 1.2742192948176057, 1.2629671375791809, 0.9269001606298738, 0.8131329584322579, 1.0515404918911204, 0.7389442754112723, 1.1994653839556897, 1.1378862257598512, 0.5522974160328658, 1.2505460510928175, -0.2641219082791206, 0.9161275309251674, 1.126624359817421, 1.2332028114310358, 0.8528741035879674, 0.9839046935929382, -0.2372816166263193, 1.1946671357884227, 1.1728597932672995, -0.006448077993468823},
    {0.9269974609787395, 0.6788112269168238, 0.820623547770272, 0.8613313580683994, 0.9442954485228358, 0.916035137392694, 1.182197622115273, 0.9835302105125746, 1.0104515617841752, 0.9033189176758902, 0.8747841202527051, 0.39579650095366975, 1.0367389492011918, 1.0879923947351808, 1.1924553982072312, 1.181162595448104, 0.7356683420090476, 0.9735229096186959, 0.9731173796697328, 1.1294622112120698, 0.3041663636891995, 0.9052794547004863, 0.16847555319115035, 0.8969592083823023, 1.0813975250818972, 1.085813702187689, 0.9834431877986065, 0.5380170634864891, 0.1892678569538855, 1.249797589737852, 1.1263708126276304, -0.3401001432146844},
    {1.0765827456146166, 0.9009362697390387, 0.637105445854287, 0.6618459291920219, 1.2285728037143384, 0.7416900550703812, 0.7534660716601276, 1.3733502338443213, 0.8978231518662613, 0.9487204033329985, 1.0699024499688294, 0.14054305876291145, 0.985055515882121, 0.721616723609057, 1.0142647467488108, 0.7611395309601121, 1.0098869860403585, 0.8424960681670209, 1.2009995476814597, 0.8759225861734132, 0.5631803551379656, 0.671305719506925, -0.22368919494101341, 0.5539273600716055, 0.9022872549126633, 0.6095409537006388, 1.1423035495975231, 0.8998665908753588, 0.09616669972317335, 1.1505200020322646, 1.3199749711721966, 0.03235815005470826},
    {0.6561777877116278, 0.7559131686911609, 0.8586533309125137, 1.1742673557161125, 1.206972795339858, 1.0206299072530496, 0.6252338952837536, 1.042373350395806, 1.0372246419566211, 0.7915640043269213, 0.947397716947576, 0.35011352438594134, 1.4260475148342162, 0.8628775713679904, 0.6732133683243746, 1.1689181495362047, 0.9905813474726483, 0.9727031012706804, 1.1631913164381582, 0.983244619654522, 0.5025646860476406, 1.1603156266766046, -0.075840962934782, 0.49141905292473975, 0.9516807974429632, 1.0651245613193896, 1.2512907747010067, 0.7413065037317667, 0.055622860947398226, 1.0267068158331056, 1.0097738294624456, -0.07935134538452687},
    {0.9037280742718364, 1.0340837955949878, 1.0220610756806872, 0.8589375057363248, 1.1511786139991549, 1.080264730985558, 0.8372270989196295, 0.8486684419016168, 1.216431861456349, 0.9850183000887973, 0.9030965504301843, 0.23358506133366527, 1.077033529934073, 1.0663153286694549, 1.1685501490709587, 0.9789127151060439, 0.7725591189107758, 0.9725812676196152, 0.9433372271134741, 0.9059368767812593, 0.2842077813747002, 0.9137497135665209, 0.13037009345391157, 0.7857893865319056, 0.7627231644976389, 0.9275280782127491, 1.096144560599881, 0.8895761309016154, 0.09598299053430455, 1.0560471291363354, 1.3303993205383127, 0.15915705150610468},
    {0.771679756987281, 1.0329654232734382, 0.9759047103999519, 0.9229881313360938, 0.9530824506079507, 0.6261106240706529, 0.7665484737351602, 1.1117547293546963, 0.8086457269116444, 1.05777761708475, 1.1442993132709514, 0.3298422106316982, 0.9908903900471797, 1.222974119277102, 0.9894728109443107, 1.0687220395041894, 1.1245277915662426, 0.7510372573740041, 0.9073273670139242, 0.9527708248470486, 0.28209933817306687, 0.8044627477900006, 0.09081355238898355, 0.34902042549580387, 1.054395918523031, 0.8110249980141201, 1.2531695468617179, 0.6140762574305273, 0.21645084160821915, 0.6809901261942484, 1.1167676237172794, 0.09294579644947518},
    {0.9536960127335787, 0.6483799583983865, 1.1280877375888783, 1.016877046428875, 0.9939402505868974, 1.089162466944722, 0.783148351575851, 1.3337073731707934, 0.8024282123957106, 1.1898833971265237, 0.6526312650088466, 0.17597324555838995, 1.0534380246202177, 1.0146125304454934, 1.32808720935988, 1.0306619200405527, 0.9124363047266565, 0.5435046937451842, 0.6172218745723032, 1.0274561933651656, 0.3313764619554316, 1.078248872965197, 0.15007165449356924, 0.9517730998419324, 0.9880456137613094, 0.848594495204193, 1.0576713529712822, 0.8505005109124502, -0.1441964945387103, 1.0750204642811658, 1.1132837459792981, -0.15864238329520558},
    {0.8954595098357285, 0.5812544618605691, 1.163684068102735, 0.7601882897982009, 0.8957918123899689, 0.9179056770106825, 1.009286127391958, 1.2161536888295503, 1.1041592328937821, 0.9453226439657569, 0.8374657622339335, 0.21542268298920178, 0.9218254248063461, 0.9243843904953537, 0.7599977956173647, 1.0747527101498866, 1.0078034428149607, 0.9634014218757327, 1.0738207615672237, 0.9407158427020622, 0.23526388424337724, 1.2481244496328698, 0.21280101329576775, 1.0106179892198701, 1.0853843402650343, 0.9915948084114736, 0.9641772563586487, 0.8604703174759591, -0.006923827598470561, 1.1194999829074812, 1.2141959176262018, -0.10049679363370148},
    {1.2650130387714418, 0.6254177934086762, 1.2283313912999063, 1.0794003377352293, 0.8142571116237356, 1.1836459487987767, 1.2765895447360445, 0.9293046680854987, 1.1950539789815973, 1.0738703023914438, 0.8781019495826409, -0.078849069248516, 0.8314145560822129, 1.1652655925001, 0.9705646320224868, 1.3195499272594227, 1.2521676548043956, 1.078025488773845, 0.8201474272828104, 1.2046571861846553, 0.5389198744186735, 1.0374736323788631, -0.20884926125406542, 0.720474356226908, 0.790915105650543, 1.1901274180095491, 1.0339566004148253, 0.9927463379767972, -0.6019711509993947, 1.135942360659112, 1.274820570074936, 0.032615715720246415},
    {0.8691953869976765, 0.8001265090689086, 1.001662645220917, 1.145812703419673, 0.9234808642170235, 1.1012899614074565, 0.86950440952155, 1.0968641933547645, 0.9848028930866541, 0.9967211523846244, 1.0936310941399536, 0.12023498835361762, 0.8985355303024364, 0.8560245870971672, 1.0823765899466007, 1.1049356833428114, 1.0735253440337473, 0.7913532260229228, 1.174637989879555, 1.253272327347053, 0.393482140466384, 1.2468856342411387, -0.0012015688509014052, 0.9643511188121534, 0.7646983752965292, 1.180722101411266, 1.1277757128058896, 0.8997453636407751, -0.028220215020865237, 0.7354391205644223, 1.033492670644924, -0.04649070573940812},
    {1.156348711769919, 0.5160109769464769, 0.813168871898502, 1.0681018631420862, 1.3378312789244453, 0.8401142691687804, 0.8077889956773555, 1.2836253646181741, 0.9682445957089756, 0.9452921508184546, 0.9741300924493628, -0.08494877129133718, 0.8349586875421662, 1.1144579087652335, 0.9171258907682487, 0.6477604176216544, 0.8123207810943939, 0.9628761857810004, 0.9353022454911183, 1.0628738051155284, 0.5443609323077971, 0.8744147193370192, 0.02658737152525956, 0.4595115350660473, 1.0208535712759466, 1.0345458160509426, 1.2978157316505847, 0.8731405392769179, 0.14011994023958174, 0.8604575089391215, 1.2893618111255285, 0.07667469018333449},
    {0.8284085380178712, 0.8372106167243196, 1.345147093194638, 1.0706523036557558, 0.9213741062409918, 1.2222994652643246, 0.971075299232863, 1.1900291601010509, 1.0444651048117066, 1.036452882156475, 0.9259101451958676, 0.09275324360077356, 0.9921694923491636, 1.4311660062145388, 0.7346915306411181, 1.0298567686022924, 1.0729796354432153, 0.9440728338949596, 0.6640303602141546, 1.0513347439529626, 0.7821674145541438, 0.9720389728488661, 0.05993340446719358, 0.5749756861959429, 0.710792545281285, 0.77488321446803, 1.043913200173458, 1.0650282080791584, -0.3418980389823045, 0.8081845216050659, 1.1986776329731408, -0.02753769881385549},
    {0.5818582263076522, 0.9753783222416798, 1.1346827770043795, 0.8331508942810328, 0.9484892989946241, 0.9083366472105698, 0.8074673303614956, 1.07112740835759, 1.0246668185255459, 0.7004967790857587, 0.9196901601042813, 0.20626596576822945, 1.334169324367415, 0.9703918866724983, 1.0712123849475528, 0.7592510435321607, 0.958423925196292, 1.1044521095218072, 0.9791298460810524, 1.206764989418512, 0.4747575398611492, 0.9912879427269599, -0.05749690684636699, 0.8657431099042723, 0.9625484456870053, 0.7790022968911138, 1.0548167813407539, 0.9689464101416778, -0.07787790308117168, 1.1630292953799468, 1.3215821958247476, -0.1711345011298472},
    {0.8365096673870497, 0.5725958267383987, 0.9500595820341151, 0.736337333978026, 1.0162457507965583, 1.2793526133406468, 0.5446163533932008, 1.1425402118970414, 0.9102117312610771, 0.7809143321885862, 1.1315156070851433, 0.18531196797862096, 1.0538038523020512, 1.19303928808909, 1.062404579844528, 0.8961060436850324, 1.0797576507260593, 0.9827642962118258, 0.8411704597415725, 0.954655447193057, 0.669832242411445, 0.7369905341909992, -0.07092970413020301, 0.9101503024502186, 1.4540724482098346, 1.006131872014229, 1.0206199991104694, 0.892533629440256, -0.3504649767674005, 0.8738050665167796, 0.9643489342042784, -0.18251335447266562}
};

static const float b2[32] = {0.925135584006797, 0.826098061097561, 1.010220733462736, 0.9305058047843644, 0.9831963747857155, 0.9895187134792268, 0.7941210920525889, 1.0023561785210076, 0.9603006702916506, 0.9729128696902274, 0.8640594886892932, 0.20396942447068384, 1.0352458326735838, 1.0151639700804098, 1.0279021935775643, 0.9649620879164441, 0.923930183705499, 0.9292811741772492, 0.923007092741987, 0.9807816909405428, 0.5075663054994223, 1.0482093986158247, -0.07161123512633404, 0.7318480251060863, 0.9889167500835419, 0.9389386123410273, 1.0350328299153642, 0.847160328288925, -0.06610823847436288, 0.9298148353253087, 1.0441055354147386, -0.08711647470507566};

static const float w3[32][16] = {
    {1.470592696697773, 0.13397390906195744, 0.10174059965470664, 1.0755885082012737, 0.8134600122013343, 0.18853906248175764, -0.34602273681801, 0.2060478556522138, -0.31088417513460176, 0.47719767404898256, -0.02347805157159465, 1.1950000918059174, 1.0194009638699666, 1.5379026343228586, 1.2526889613074892, 1.4859243829031248},
    {1.151577938046299, -0.3217802998103983, 0.08370326114097848, 0.8390945005180476, 1.0320058033790493, 0.29056736111018167, -0.3048205266017032, 0.0519606089416876, -0.2829274982425742, 0.6606718226856257, -0.3423096839975756, 0.8656390118483203, 0.8225196429938048, 0.8264791058594309, 1.2075733716821904, 0.5540523327159788},
    {1.4802342284218182, 0.443290214472889, 0.21932234263167857, 1.052987940810169, 0.9412129334538534, -0.30624854641032806, 0.09738148119512013, -0.10806063036633401, 0.04740059466886316, 1.1412374643207468, -0.27973588807702404, 1.377353447508225, 0.842198555897036, 0.9221137338836187, 1.4166632236747498, 1.3532490504004226},
    {0.909401345149428, -0.1565151917409569, 0.08554949243329557, 1.1764741595956185, 0.6479741871425185, -0.1275540116027774, -0.5658993728613302, -0.2757282743696711, -0.12926833244204933, 1.0887438693294813, 0.10527524153360908, 1.2184503399477364, 1.3927312453816882, 0.5978679421162925, 1.2618794048451403, 0.7561841677220045},
    {1.1180841311480674, -0.04158851779675078, 0.0684042790645537, 1.726249870253723, 1.2319301641420484, -0.0384113266727238, -0.26425414561787086, -0.044010308829119625, 0.11873024510447638, 1.263837774142661, -0.059864960703821135, 1.0462586096863626, 1.3732956669977063, 0.9862058825364621, 1.3192324063280505, 1.2967557227460407},
    {1.2392552518259212, 0.018524941204594705, -0.030092161731632785, 1.4019552961248742, 1.395151304088132, 0.3116547287660825, -0.5426693942048246, -0.07974859924133085, -0.010692419814468383, 1.0180412095900244, -0.09519341247905425, 1.41375901638118, 0.8238956339669166, 0.9010586819311303, 1.536186750125552, 0.9285913827600532},
    {0.7947552447855168, 0.06963135469056628, 0.008163574998632586, 0.9818087987971623, 1.1383610988535098, -0.48217540135011655, -0.49044727236874736, -0.2956139300294851, 0.2787692031333702, 0.9271009913426894, 0.12743518758192351, 1.1574687758869358, 1.0310883818563499, 0.920118644973276, 0.9131226716119605, 0.9113118665001904},
    {1.6507150619524826, -0.10011865383775696, -0.23073224727700548, 1.1761019886939774, 0.6642620423122829, -0.17556122772903113, -0.09511466822551992, -0.12816611490694635, -0.047418402982369406, 1.5228505701959778, -0.1690180883651231, 0.9771723472035141, 1.0911966223805163, 0.8569002058874956, 1.294789600670124, 1.2990742601491092},
    {1.4952786949357608, -0.004000944882136883, -0.1723536772068859, 1.1995778666593635, 0.9962084654082674, -0.06903388043290136, -0.32096035308741216, 0.2336779142553082, 0.3112250400125801, 1.1442972609964337, 0.03858019173547642, 0.9417853485899607, 1.113913336961339, 0.9779327927399478, 1.3860637355388918, 1.744015703606203},
    {1.26435923952704, -0.0877677950988576, -0.04758070938031615, 1.0621753479496365, 0.49476266892274584, 0.03545350182759926, -0.20336409854581314, 0.2774177189587542, -0.06622418168927899, 1.3656580271817884, -0.14120931163043712, 1.5673564792424497, 0.9035653980469577, 1.3867724305343772, 1.1494435336533808, 0.7137912206816667},
    {0.8407610663339026, -0.4252228845766305, -0.11875182506697456, 1.0335902772885894, 0.2554886646638006, -0.3137078228438153, -0.05993089024157969, -0.31589140540207, -0.4765358792505619, 1.165815511046702, -0.01992550179821362, 0.9887528337862775, 1.206952688624315, 0.9796002576287228, 0.9415525545730213, 1.078424552188075},
    {0.22241641768431658, -0.054471033297455326, -0.036375607441508646, 0.26200196117819335, 0.3864494430533005, -0.3240660132024181, -0.19351754132296262, 0.17048297778376859, -0.09388140352392037, 0.6550463167369783, 0.08125685558546412, -0.10911162955026533, 0.462430543487999, 0.24024253998770528, 0.36731819025972046, 0.6188304367734666},
    {1.2519935196551357, -0.31962921109089204, -0.0037478520620421703, 1.0467865890475418, 1.2851723777264183, -0.21021270642097073, -0.38160461913349936, -0.27187593205996247, 0.2831534853255237, 1.0038915565654078, -0.05026690797051043, 1.1673235210156634, 1.5202632505850606, 1.0496697100770527, 1.3564372342194622, 1.0061596401570836},
    {1.202804174352883, -0.5064428884682295, -0.39502300116244204, 1.1037072141144777, 1.0273345163033683, -0.3601221718207821, 0.0687701471989017, 0.18588341890041074, -0.06015341984363548, 1.0875482615697079, -0.07161591036572013, 1.4418994940500387, 1.7455288873845047, 0.8556884714950618, 1.2484322687072444, 1.1069720021083769},
    {1.27636369239882, -0.3791807351554855, -0.046779317181004004, 1.0133599226018188, 0.8980827822856856, 0.1392476895278247, -0.3398791674309, -0.1544993488485948, -0.24190656973708827, 0.9716357683057255, 0.04310164337746202, 1.38040172927478, 1.0146345992697845, 0.8589786821096984, 1.1846313782221034, 0.7363408743276832},
    {1.1927247166016826, -0.17253996805130398, -0.11207051671448164, 1.121941847925979, 0.9509206518890747, 0.22127307978925345, -0.12845201122371558, 0.30461811065301303, -0.01635234720345343, 1.271166312212302, -0.0704014532302829, 0.9999229142133617, 0.8851492427371817, 1.1822841930011347, 1.2481107583418993, 0.945908557424346},
    {1.2088590843209803, -0.12462435895813065, 0.17871244102096714, 1.051376383243966, 1.2100522285781221, -0.3636856480628175, 0.4232457981503479, -0.27173986625858326, 0.089958385351239, 0.6923017653195637, 0.23764651970561831, 1.4092901073173987, 1.2379108862269155, 1.0773540792453713, 1.391280978751112, 1.0421313164286996},
    {0.8072205158028228, -0.06206643094284873, -0.4169602062795733, 1.1630164814546593, 0.7554171319125822, 0.16432253769386126, 0.12236043998387071, -0.08225816439971173, -0.2777721702189768, 1.325030134301318, 0.22488740774351262, 1.3660202829045254, 1.1304814947264927, 1.0593415823974555, 1.1403112230493284, 1.0095388473035611},
    {1.15839768455178, -0.06256304584519166, 0.35773298764135175, 1.342026277529169, 1.5135894828117977, -0.39222092165932004, 0.16974968476414298, 0.014068101425772035, -0.5851955138045967, 1.56085533626934, 0.22226001693548006, 1.1120214301929325, 0.7480815979549855, 0.572058125442896, 1.346247024544031, 0.6276581747313459},
    {1.4678144186421684, 0.31323541739582, -0.01129849240663937, 1.44537828783077, 0.6511773511277781, 0.009914619345013927, 0.15550667774312302, 0.02481571809076323, 0.012961203847556075, 1.374901426090809, -0.16524134656881992, 1.0759731715881975, 1.3986667829884116, 1.415166656054367, 1.2975305827503052, 1.060822505333254},
    {0.5292739650478074, 0.46289355803525295, -0.5803031121863984, 0.3939480520849458, 0.5737278344640678, 0.2714790094196237, 0.45564282054914973, 0.14920477690063863, -0.05542655161613247, 0.7986346441570069, -0.10263735749250509, 0.9664921313729945, 0.9465394006172314, 0.7628114144773901, 0.5132490257663436, 0.04349506316872646},
    {1.4154213749849136, -0.18461270277602354, 0.04398256715188143, 0.9992361663922669, 0.9999237876318351, 0.18264722295103838, -0.50924175098126, 0.07983181181273825, 0.005945410177680934, 0.9854138962939284, -0.031034782671202996, 1.5720285754092875, 0.8435523108263028, 0.9933451533977047, 1.1091259540828597, 0.686873907695647},
    {0.015431438765143425, -0.1725997810326089, -0.1754559584963346, -0.421670353658085, 0.32442834009847227, -0.18600138597408566, 0.3374740564286121, 0.25573329529087585, -0.20449467197600643, -0.11516912780649066, 0.04228806400072945, 0.1447225907504926, 0.5430302448715445, -0.3587057190489533, -0.34331735967705024, -0.009362220059470095},
    {0.8164511829758287, -0.39955253464148244, 0.4608451858785134, 0.832445135693387, 0.7419939307843946, -0.03229211334257977, -0.0704294876315668, 0.5348501745423311, 0.2512999727403418, 0.8351583166359204, 0.2620674084270934, 1.0692802113880577, 1.2013112848053447, 0.618267814039463, 1.032357455749643, 0.47178577178752207},
    {1.1928363210907762, -0.28089972089947807, -0.10741715073336038, 1.582242453463351, 1.1223113475555417, 0.00715777761494487, -0.2534846322512919, 0.14216246160412, -0.13959426780209594, 1.2696760042121948, -0.10988546417268967, 1.1335750412743228, 1.0762973240848308, 1.0271808159086198, 0.954277142691807, 1.0207732437191042},
    {1.3274598716871007, 0.3041150683535485, 0.45090912802870925, 0.8239546197800454, 0.9664229533446426, 0.01737083670535989, 0.5217650474501607, -0.21772510264270412, -0.24804903302037792, 1.2293649728972178, 0.17415118245892308, 1.3627731380093158, 1.0907198291746065, 1.0672592120991478, 1.1101253173137215, 1.1675290499993018},
    {1.1567890098237132, 0.045034125444313663, -0.22088189998570398, 1.0543597337331072, 0.7799517296296397, 0.3653066702275057, -0.07543356333463422, -0.5547646469195767, 0.1899515910503382, 1.3850345681902314, -0.30748085997268526, 0.905988538709014, 1.2831543504100746, 1.243132941685461, 1.2533368560064582, 0.6505461195317634},
    {0.8505067611599506, 0.16278499650605957, 0.1554676787270759, 0.8635025380148368, 1.2524037410133917, -0.16106115513844868, 0.28980614155234824, 0.3544448903520886, 0.08579480476090567, 1.2654259845114293, -0.4022808827457515, 0.7647787963554222, 1.0658353527069324, 0.5913653564281008, 1.21588631582511, 1.2117331693945603},
    {-0.03780288223642726, -0.09303102874408138, 0.18743347757206855, 0.33152869848706246, 0.10917375515762033, 0.133406042041946, 0.04211756340147965, -0.09817246319937094, 0.1307782733305384, -0.18069327544683203, 0.0026766405358813476, -0.12380999845467021, 0.020453163277257935, -0.07066151714734013, -0.2847919232942063, 0.22166763350621094},
    {1.2486033804135306, -0.011715900208048012, -0.39677942069147876, 1.014097160687525, 1.1184208263482813, 0.09515853051687949, -0.2309679052746521, 0.3184156405792781, 0.20880915931455135, 1.0061568860778696, -0.20970998156188858, 0.7556533185775807, 1.3969020401735375, 1.1499852764983332, 0.7181131756201993, 1.344988857324529},
    {1.186135536851925, -0.026162334865374632, 0.0841978180058576, 1.2942097040317861, 0.8820090151382807, -0.12301163445229311, 0.1180744907814095, -0.3414482580884553, -0.40410620007044074, 1.3412700105507387, -0.1553241232057005, 1.2465873227738011, 1.265625621416683, 1.1449148293384679, 1.170711395105307, 0.9323076705971965},
    {-0.2355264952606819, 0.007188080354093988, 0.05970398519657256, -0.15911991756502994, 0.060763826532552204, -0.054607800639706355, -0.03461963859455196, 0.04163995542644923, -0.47511820046757897, 0.4167640228973926, -0.141006156390465, 0.08681332328243624, -0.1940998604303477, -0.22999840505034577, -0.21179122017644858, 0.25296063764335713}
};

static const float b3[16] = {0.6898980763077404, -0.03486923494164433, -0.05354044293858822, 0.8036414049497679, 0.6089885196316156, -0.06447295788867916, -0.05139279191600378, -0.04248193474253415, -0.03611514819292446, 0.6936573915303548, -0.031421231558623045, 0.799694434657029, 0.7739460191191309, 0.7185958162223035, 0.7401771806754495, 0.6338702908481291};

static const float w4[16][12] = {
    {-1.1066214677796726, -1.593520662983788, -1.6202798547194426, -0.8849611245911766, -0.7810772634240061, -0.7248286722425221, -1.1951146783274496, -1.2262244725863642, -0.7540370071187321, -0.7385458813461026, -1.1894999977900496, -0.8703770234736944},
    {-0.40937151100743346, 0.09205417003476558, -0.08081405757122312, 0.08578065400702227, -0.16805709570603675, 0.3153940624524906, 0.15855476215144115, -0.19850690495457848, 0.4377572457135688, -0.1010715527948695, 0.038636350462083136, 0.15970989814861833},
    {-0.32237665620338046, 0.40131872326045015, -0.1432103680420922, -0.249490389201527, -0.26354055310853064, -0.11255184088248583, -0.1768901809641052, 0.09877484859075741, 0.23219177730255983, 0.6273959238274809, -0.09530525784029135, 0.4138827183676656},
    {-0.9035175154531875, -0.9985552538645446, -0.5272824970604127, -0.74125333735068, -0.8123263678890225, -0.9204166981496087, -0.5411809320473541, -0.7466453322345353, -0.6399794978402008, -1.2755702876505746, -1.2314991124268302, -1.0396004334052238},
    {-0.7771027480422822, -0.8852690720713527, -0.810467313335284, -0.1746786150363697, -0.7451083959447397, -0.4246847001971472, -0.7765963547390045, -0.7074322311893533, -1.2595897208050497, -0.2593816756035093, -1.5231958618983228, -0.43857327472834046},
    {0.36091919293332175, 0.4449333421509842, 0.26163320861786293, -0.0037702881706668935, -0.006638683203916304, 0.0382128563284895, -0.16065526900999183, 0.006912942270983686, -0.06663678096943702, 0.16570440547686752, -0.4151164082313662, -0.19298221981742394},
    {-0.012037641716489609, 0.6691931103040502, -0.07310184108403113, -0.21066610869205207, -0.37648615241561995, 0.40804540273136003, 0.1574735545743684, 0.41267534754322205, 0.5686352547407729, 0.31412982497150105, -0.845678220140645, -0.10173004624203016},
    {-0.07964188226790907, 0.14770420046431035, 0.09843200386544453, 0.24155712203624116, -0.17268735877833602, -0.375675651888208, 0.17376238929970303, -0.6455980977853086, 0.5992193573175728, -0.04381546961396002, -0.3967294754483792, 0.32179423506546956},
    {0.2795064603899808, 0.3035035301968625, -0.14420802875505329, -0.41386884069258056, 0.46255155665648684, -0.7978948634358135, -0.35711821550829315, 0.1082646975481635, -0.058798003814809915, 0.5006196589748998, 0.09846484182909908, 0.0867947031037724},
    {0.002192791014949239, -0.7642845700983291, -0.5767809816838101, -1.5519117658312411, -0.8455661074710266, -0.9132567007065487, -1.19971145624548, -1.2476350684836974, -1.387426327342291, -1.2209502469887292, -0.465076028072413, -1.2024722266684247},
    {0.08569385392918762, -0.26708726071240146, 0.26291830409548195, 0.07859983882422968, -0.4821125461696116, -0.2419598083914654, -0.2506411040129284, 0.2200026223203731, 0.2870408070496262, -0.6371539007004194, 0.05419768797466981, 0.3197599234352416},
    {-0.8439252258202078, -0.7386968410711151, -0.7966644760067595, -0.7567356140148398, -1.195559984500933, -0.7445687901706896, -0.6654370554253962, -0.9166967339937856, -0.6796364770524763, -1.2645489651447113, -1.4813979454148614, -1.0229409431446306},
    {-1.4796289680838055, -0.6592775925264259, -1.6417071809560388, -1.443180878291267, -0.8253264729284921, -1.1274234370399332, -1.1057501418222029, -1.2521287084688775, -0.434359997819657, -0.7176827055901773, -0.5395441159413352, -0.7178634283552185},
    {-0.8154270279093261, -0.6844761214912927, -0.5935937136168581, -0.7170509109376259, -0.7791545530641176, -0.9157192480299349, -0.46624887424725925, -0.9779363548250781, -0.701646871823543, -0.4870394043148537, -0.810222392812326, -1.013159771652224},
    {-1.0950534875432532, -0.7239823563643876, -0.6360639761244039, -0.46300904556106337, -1.1985660374174105, -1.2971535038346929, -1.0479408737568738, -0.20644904032181333, -1.0261103800448999, -1.474491025844489, -0.7290280427767191, -0.6206966540321256},
    {-0.8355525065830423, -0.8566827176076333, -0.5704674702726769, -1.1663487931500192, -0.6762699936650292, -0.7971727564403075, -0.8671885939803083, -0.6856818738896161, -1.0963503009006381, -0.3174358863272754, -0.0262223151199619, -0.9743633944866557}
};

static const float b4[12] = {-0.2806900942762744, -0.26259855968557955, -0.42660008523584014, -0.4067339508327764, -0.2499567709863682, -0.2937980057676412, -0.45838923969361717, -0.38843275189404924, -0.2898339188110185, -0.4222822935868041, -0.21984197199772548, -0.3056708579832889};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
