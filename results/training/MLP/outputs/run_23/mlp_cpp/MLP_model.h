#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][32] = {
    {-3.2719988400540854, -1.9644538076286278, -1.2903949891234991, -5.068925083779167, -2.207974601544996, -1.8103124831659554, 0.8008875795617758, -2.538911475155386, -1.189671326795796, -1.2616073102734324, -2.9163546462153342, -0.5141904886777724, -2.0939788995860673, -2.3726860401338854, 0.661727428012344, -3.8408854896591937, -3.207485054592074, -1.8763900790227963, -1.3457422911575778, -2.1774075507704485, -2.1641821026210972, -4.027299636759954, -1.438818826540287, -5.210309342387612, -3.390618268548337, -3.6894498702399283, -2.394693344403435, 0.5777412353442666, -4.06559896614439, -3.748088436063154, -2.1565241303834592, -2.318886816336641},
    {-0.2689506783457339, 0.7281636546595248, 1.522084518359826, 1.1532137415879786, 0.41655564816598484, -1.3265659418683249, 2.6069422390305714, -1.1717382035893966, -0.508914210699418, 0.6107861410795155, -0.32113696917918844, 1.7253320484486177, -2.6670941327358983, -2.021833712530101, -2.7832966986230705, 0.5341896341845563, -0.8529630788609616, 0.46654061445702355, 2.2301723487055964, -1.8358111747122365, 0.020767115276849997, -0.1325031237036151, 1.7712473182120678, 1.8318650486984305, -1.5249373978913865, 1.1823618033627548, 0.6313736570053183, -2.832548653276519, -1.5730206322481988, -0.8377453658281879, -0.7892326861189384, 0.8298029096479155},
    {4.405528513891955, 2.8726618933633086, 0.2195438280816143, 0.11455560244951495, 2.7443310097287434, 1.3615762169195667, -1.7940269050985191, 0.28925488469929134, 3.2221380861720634, 2.414616093640709, 2.0767818274902603, 3.9870462714208936, 3.7148608900161793, 1.6309729808136886, -1.0530160128537582, 2.6694281917011065, 4.106863540394898, 3.897409203651638, 1.0415168721093515, 1.344072999611794, 1.1248677306572368, 1.9693585457075449, -0.5979521829219218, 0.6645124417392327, 4.272347506815332, 3.0584557690382037, 0.8451433636332675, 3.066836591077725, 1.723962468383767, 2.730440920611088, 3.502227439327184, 2.779435097630249},
    {2.7448932697032786, 2.5871996553412018, -0.8375841574424674, 0.5126085074932211, 0.4484387769020218, 2.7258378927377094, -1.3509063572127584, 0.5599556209744478, 3.6131555636655914, 1.7957136527032294, 1.8153434303862142, 0.7087264976940394, 3.0912129710518212, 2.618593935591452, 1.4306846034340688, -0.09543486652687655, 1.6125104609487182, 2.687061902793628, -1.8159263412551505, 1.6333623199714773, -0.142370493309946, 2.174312618264374, -0.3194495768854122, -0.035230699642214876, 3.6674220245969096, 2.1050405473286196, 1.5733568975353036, 4.606770168099153, 1.868605338659475, 2.024742577213231, 2.008042997923731, -0.4724831679165574},
    {4.579339945052725, 3.2998073226972933, -0.29477319094040455, 2.753897121437827, 2.973472055068919, 5.2024346405706465, -1.485498258725314, 3.120783934654407, 4.621383992250699, 3.576837773021657, 2.8160825022133977, 2.3747084052509213, 5.326188511195798, 4.936035591203757, 2.6497741916233197, 1.3680285342870664, 5.87421064933162, 3.653940939306772, 1.7395986784983415, 3.4978198279685735, 3.0275933377016147, 4.3714349296486805, 0.08895234556277189, 4.6728410726695335, 4.584867037015163, 4.806357613454368, 3.2477041831922175, 1.2198642555301367, 4.6750488832075074, 4.366143116460885, 4.7216081306837685, 3.2576652768430776},
    {5.3350310881794805, 4.939798633568263, 1.5746657433696336, 3.4284265851814117, 4.026097458387695, 6.115159016872706, 0.3477453113923093, 4.941778354022543, 5.025759690108545, 2.9668297226285882, 5.042569937292637, 3.4854165873101053, 5.611148826492577, 4.716881390983736, 1.810755429584744, 3.5679784607577, 6.0101039783699886, 2.7460615365523493, 2.2003934385715374, 3.738699483577306, -0.46605859606944866, 3.7441879637241833, -1.0139997798662057, 5.50935158459088, 5.577282025969822, 4.416935375344767, 2.9543387649345303, 3.7435080532665497, 5.34925018237304, 3.7111344133794817, 5.982182101339029, 4.695421963756541},
    {3.395747660170036, 5.435465353196247, 2.9734570220566288, 4.532349713361038, 3.8739817244290635, 6.1581653546686095, -1.8032649742769609, 4.047687645645874, 3.6077773987759065, 3.8226453710812263, 4.753442769349309, 1.8187600448350956, 5.46137726148197, 3.5738096377648465, 3.1917063112085913, 4.246647412575768, 5.6028045892596445, 3.769568884939305, 0.8016612521006737, 2.3084660997326383, 0.08948648520536089, 3.8595159884806205, -1.6853059285472705, 3.9784058451595534, 5.575450778671688, 3.4851869588861537, 4.471951614145167, 5.197738783631515, 3.1074390500739977, 2.6281175092462092, 5.644446728891239, 2.4067451373717375},
    {0.9102710189771905, 2.6577325233479274, 2.2729400778085633, 0.2598016510286454, 3.202735725750507, 2.644106288408722, 0.9422494482879012, 0.904946429762837, 0.6963042190355706, 0.3028260192252403, 2.7574573632069397, -0.23038893973542962, -0.34252605192305385, 1.5636549977587457, -1.8936671314892684, 2.6625124822490074, 2.2743380321075914, 0.4307311174584279, 1.9830667804214208, 0.0961288315491023, 0.705745806201711, 1.1562714627360646, -0.022666860848867734, 1.704893376970189, 2.3613881471540132, 3.096363688559507, 0.9342871248267633, 1.4009222695741745, 0.44469693841128094, -0.11806476827369124, 3.0917223541416234, 1.1620752208114762},
    {3.658358317912334, 3.60361992744897, 2.9829683826875018, 2.6974960410046176, 3.414864607950449, 4.27886769036817, 2.4476572103041563, -0.14202822840169876, 1.130741848272964, 0.8563892990559896, 1.7123754562956044, -0.32694249749222853, 0.02121888666080041, 3.1972100387588878, -1.5511996179503604, 2.617855422826865, 2.262013247063831, 1.9497237673078291, 0.6961868006955727, 1.3245279873602998, -0.5107083018456394, 2.9193842049980834, -0.6851579380692444, 1.1226226472358987, 3.9235260062483026, 1.8686277342435171, 0.7132337948703679, 2.4419698901432434, 1.8460162863231184, 1.8474571342759114, 4.016186426875254, 2.2931892467458512},
    {0.24567565001310324, -0.9406101091773064, 1.2552443497271675, 1.541766746533168, 0.0697154636947762, 0.6161880737927216, 3.050110728282632, -1.3538951212418924, -2.0571148792860283, -1.0511307625330373, -0.9739521351185618, -1.6129023029053715, -3.4864934930280556, -0.9349819714945008, -1.051946783658691, 1.7108915809575587, -0.7558827173651856, -1.3587847875367571, -1.1424785875653596, -1.2152492563058708, 0.06239130087202454, 1.6815685552130246, 2.0365814964489246, 2.9723836765126497, -2.0665472225199926, -1.0253773376186754, 0.7340301720852894, -2.5061660507883956, -1.007755247882692, -2.608160868292239, 0.9156222274104239, -0.38258229689855444},
    {-0.332378961292264, 1.6274979508262915, 0.267583828538773, 3.3034851274870536, 0.7675290338777466, 1.4788796868585934, 0.24301520697890375, -0.7408115209123739, 0.5018919100935558, 0.8552940188417935, 1.4837545215843961, 0.17137856346356173, 1.0747899482047591, -0.7488566888819327, 1.8705875891151194, 1.9378528569205704, -0.5550066983035132, 0.5666775844226041, -0.774702243801941, -0.40998661189257407, -2.2824102990010604, 0.7287089431978951, 1.3217786159878981, 0.29290248774773786, -0.9240914071295337, 0.5161501207727381, 1.7377538536701354, 0.8683066927499011, 1.5401128060882663, 0.9564236979214416, 2.747672633859978, 0.1569945293127564},
    {-0.042145121891527214, 2.80184979491301, 2.900664521437287, 1.652260577138771, -0.48585102225505933, 1.6021036135284292, 1.70576975948972, 0.42224627057048486, 1.986433690217166, -0.04321470867178788, -0.13484820956405824, -0.9126126010498838, 0.11902111432477877, -0.46513301525659756, 1.421462929484576, 1.8924929269068858, 2.5550704700335602, -0.6352153250686243, 1.2369151143575843, 1.3137365317568752, -0.04243810934532064, 2.6245710260577857, 2.5771364770029392, 1.1476999205058074, 0.006526386228973367, -0.48584118343462385, 0.9991248860727411, 0.6371020332988063, -0.5977385880610229, -0.7927583776782949, 1.8750645789384734, 0.6421055453976641},
    {1.167333809519603, -2.14511347357679, 0.4581292349947549, 0.7799520080154941, 0.5686037469235491, -0.5477964815918832, 1.428761292892696, 1.4149156701397387, -2.2111155484420366, 2.276591391483703, -0.08451042389149989, 1.2754749775592353, -1.3444004604995956, -1.049880966701701, -3.2143706982568525, 1.8394815961955626, 0.7310742397292104, 0.6622997805731644, 2.4913706721348676, -0.7840214537303866, 0.3507363556216744, 0.5866623663360323, 1.216102948019001, 1.344240303398716, 1.1724957797797584, 1.3949350506666038, -1.3556536276901767, -2.64123806093644, 0.6314598692699981, -1.2730099562215913, -0.385028666498185, 0.1297448684494054},
    {-0.8673903174542067, 1.9563580669701406, 2.566263963234781, -0.5864194022216986, -2.8489061649537857, 2.1404535306992893, -2.1064646752432163, -0.9222891162432131, 1.6619533330175067, -1.4780899270084058, -0.5054128384280568, -1.1426823783617936, 0.6005503993615912, -1.637041912985919, 2.205546748086013, -1.1274209988204271, 0.6268013007837602, -2.5138114492174095, -2.0802752611245516, 1.8372608499723704, -1.9802010809390458, 1.9814189951593757, -1.006204948544409, -1.9923629333539332, 2.4001679419903517, -0.48227543754086893, 0.489735479646167, 2.8704862666662705, 0.3634226599778387, 2.0430926770874946, 1.8602722720085207, -0.3796507732494691},
    {-1.1534635812747998, -1.0392986400140636, 1.13894467503942, -2.0864579635565947, -1.6303819522104104, 2.1822126370216055, -2.537815447336221, 2.3400373701745547, 1.608762351218245, 0.11783871493303047, -1.0488691955708545, -2.0412493372407803, 2.811135894625617, 0.5853134328640258, 0.8270862874374717, -2.8194232591890205, -0.465324296792719, -1.5351652341793842, -2.429585613488341, 1.9437997746715008, -3.8865708231873533, -0.4960814123698081, -3.7191591506821795, -1.7349217850986536, 3.3140100902035914, -0.8319644369603935, -1.9969104109172628, 4.227071674690156, -0.6449511837904083, 3.730668365061666, -0.02055140164634148, -1.0530282202437853},
    {-0.39931171045386843, -2.822112167712972, 1.1181320419081748, -2.1665172138013964, -2.602992768949293, 0.15777527928633164, 1.162300917908624, 1.5175309714574776, -1.2436435008108606, -0.41327962801207563, -0.7344394836858159, -0.3072452683949196, 0.4544756728931637, -3.2546416828454015, -0.8834174787350403, -1.0660047796687253, -2.7774866251862296, -0.7400197168226801, -0.12089423340778552, 0.4308601972991342, -2.8497075657616, -2.848559719216713, -1.2521788312932065, -2.7216489106635775, 1.6469167369527937, -2.3906411121989404, -2.177353618395204, -0.5015864228980919, -2.4896736019134442, 3.2364526850037896, -0.5822389695477991, 1.3056973960931615},
    {0.20646537401506537, 1.8664120989344535, 1.1131314841014281, 0.41212564810475727, -2.3516765602324603, 2.0884951013226383, -0.505270928800957, 2.461294133311693, 1.974589019998405, -0.19921270947198325, 0.9441956194667086, -3.190765184508368, 1.093665271600769, -0.5152272979710217, 2.415387252395237, -0.20093804486430766, 0.11376101492215603, -2.2242933869017967, -1.7063341164595958, 2.402791154800979, -2.3766851995548968, 0.7828041972497863, -2.048743299517233, 1.571056143307171, 2.032461747365799, 0.2568173352030146, 2.605116529692737, 5.147072867095302, -0.6336340064197827, 2.8197149915257675, 1.2684133232141044, -0.21431352880675264},
    {-0.9256626710832174, 1.5068552978661607, 1.635978760590305, 2.169353880348996, -1.935127898045413, 2.3182878925730406, -0.8774142947312323, 3.1121795336286286, 3.210502905073733, 1.1318266924760703, 1.0174203007622251, -1.3592500623443766, 1.2096346559237463, 1.9835131623429143, 2.7765185036479423, 1.1426201963534621, 2.347802602751903, 0.48944756984625204, 0.30290159661974314, 1.3948159709638088, -2.2145972201085864, 0.8428715748258461, 0.10483645415925061, 0.9740275920912972, 1.177599352317235, 0.7027441617503575, 1.1633012603012036, 4.1803646760208855, 2.2450268183683786, 3.4457526632120654, 2.017784057175435, -0.07440932839870228},
    {0.16082804237295778, 0.1299631848247322, 0.29754831110846663, -1.185994612572942, -0.8204045726046033, 0.012050119215339914, -2.129052601690394, 3.0404170097588596, -0.050505270842593236, 0.36309664022094035, -0.9041694769201108, 0.5350994659821123, 2.2548434647947544, 0.7988458909782226, -0.4576531557204893, 1.1164540282196376, 2.3596306611327975, 1.879927553779492, 1.5944560899338178, -0.0816723259344956, 0.5371123932861338, -1.2708785460288008, 0.7120808854487245, 0.7597174116725531, -0.026066120811313088, -0.36583450344145435, 0.013916015013528875, 1.8118470079243916, -1.928728574679439, 1.8494902947116765, 0.22421102917607155, 1.4023827360602192},
    {-0.3781889811766977, 1.776213342240233, 1.8612480846896369, -1.3705592092122603, -2.2241448402450077, -1.5298180260635257, -1.6063599778211763, 0.7341177367298966, 0.7960328529984875, -1.032996829074268, -0.9284272790108904, -0.7010861402932715, -0.003541653498971308, -1.0068115040211596, 2.683123823023831, -0.6050847647286834, 0.3580273421658985, -0.6769033998000326, 0.12441587868074531, 1.183093622191484, -1.9111968317406616, 1.303402092903661, 1.6183672238670632, 0.9278770236549689, -1.1999401013202928, -0.15745908889722443, 1.1719762133982685, 2.5594005187046247, -0.9505374152392865, 0.5875891062306491, 0.8913407601063685, -2.2215792759531388},
    {-1.074744526859331, 0.3889397638479252, 0.9282282730395999, -2.8935473143600183, -2.7119282442624146, -1.8965497174152894, -1.3845297315146299, 0.4547371804837526, -0.5298853395098332, -3.3101368308940486, -2.7386455957977236, -2.672494924385131, 0.3988631670151643, -2.6133374090474657, 2.7454601587128398, -1.1972239224691823, -0.9828178810597262, 0.13845825998379785, -1.5779056999071497, 1.211638436145672, -0.655241709398026, -1.8459483705273458, -2.747763990193539, -3.111938572139329, -0.19827989361804776, -0.9312400971646259, -0.7875874059561044, 1.3508738422191613, -0.7144869556888808, -1.2837404817111242, -1.7306715576819265, -1.9782292142135147},
    {-2.2506730064961125, 0.462325548101577, 1.350130689277922, -0.04119176044359155, -3.3227409632218112, -1.2388519863724128, -2.1759398291779264, 0.48621565471268685, -0.7666514061082084, -3.7984120489968958, -2.2239251642488242, -4.0962204426927125, -0.7464313464504366, -1.3032344772906812, 1.8595429006687472, -2.5715255391811827, -2.054699104698222, -2.5419640173944917, -3.7130760451805203, 1.7033429984362942, -2.060476760919767, -0.6503389145287062, -1.2213914842590805, -2.1708688127082456, -1.3376527626282722, -2.1846056967646796, 1.42630617221193, 1.122485474668458, -1.5731198713273222, -0.38756925267562725, -1.0151839721563283, -2.181752261274783},
    {-3.989215175635753, -1.6096753222412425, -0.3380028953069314, -3.5615477258544113, -3.081838064830173, -3.73425741536654, -1.7335969145080763, 0.3369842781201613, 0.25360524940398377, -4.261598463387559, -2.806147643284202, -2.8761452061725077, -0.9777848644311531, -3.546965268503486, 2.429026842778638, -1.6337309274081617, -3.1790955887209664, -2.098074139441516, -2.9316278656578167, 0.9337922650264314, 1.21323837129509, -3.7932867564151223, -1.4772686478223307, -3.6842388264098407, -2.5202480337548883, -3.112177511516628, -1.4559424485543215, 1.0264689285163084, -3.2119238621358166, -1.5470348169381158, -4.241487367496133, -3.705917227318351},
    {-3.295911274404535, -0.975746821543976, -1.2170266230736155, -0.2923598047639156, -0.5993717969301847, -2.941944999053449, -2.0491734297762916, -2.733246530439124, -1.734961992105951, -3.2276912357868905, -2.8579972979781845, -2.4613601488762455, -1.0925112640392798, -2.3114524886363967, 1.648740581482878, 0.7187461683848727, -2.557503186494644, -1.6094873927271884, -1.1277782176591964, 0.26667215448245374, 1.8738358995726456, -2.272695905181896, 1.626704986661928, -0.06841439768813821, -4.27127388442446, -1.4928523849376343, 1.493403945971602, 0.19370768925968077, -1.9745488963517075, -1.3987959262397185, -4.5216815500654395, -4.13182429559244},
    {0.6211164064762713, 2.786144488312488, 1.5062722529157198, 0.9965642246488092, 0.07916575247796247, 1.3664000489641324, -1.7834173729254765, -0.7992828318660257, 0.8641487091534465, -2.013143849999872, -1.552285183978297, 0.09561550599566003, 0.7615068491167373, 0.606895888794783, 3.944853896313377, 2.52296897029208, 0.1240209498939598, 0.24182160711146924, 0.48797409143339376, 0.5912644546489317, 1.0070577436196362, 2.3739522859626647, 0.7989536043369704, 0.22521817965101887, 0.018622936854075296, -0.7929632906636924, 2.1954148484678746, 3.9589033427888807, -0.4525760280782497, -1.8060340534238064, -1.0638527777157465, -0.7409075235748201},
    {-0.7490025172539309, 0.425625934950826, 0.0008438898792237292, -1.482605631478899, 0.11976667424078405, -2.373068506147183, -0.7383855028753352, -0.935510702556528, -2.058081604659737, -2.02871656575174, -1.766571795788147, -0.6755092692904996, -0.5193863971907235, -0.6457709245572424, 1.6959828696225432, 0.7161727948464288, -0.5213062690005394, -1.4822630675591697, -1.580544052929774, -1.1744719578254144, 2.6034130296144693, -1.560668603211667, 3.590050446960667, -2.358723077664457, -4.007571626908809, -1.6305010399480417, 1.1871144005747551, 0.7150459872607016, -2.203254693591964, -3.8147800088408585, -2.0300875660846778, -3.6764978084821505},
    {-4.324751907941253, -1.54691478469709, -2.3417422594802715, -2.176873362062048, -2.5238664556267043, -3.9340300073009455, -1.7870180446272224, -1.9619312504531778, -0.6123900743339002, -3.5733851601764703, -4.002650800468512, -4.394549005197285, -1.9049489557140966, -2.4810513532512397, 3.6873804672853225, -1.5920229314236891, -3.3653403292571737, -3.449846758606831, -1.7160388493284808, -1.0224839521466904, -1.189719623978205, -2.989298214442338, 1.1392897341817212, -2.782713070598927, -3.9173887090541553, -1.9391699232794843, -0.8662486818070981, 0.5061170890977861, -1.8548711364062163, -2.8330611207433067, -4.9514414492912255, -2.900793829555665},
    {2.1858787117813603, 1.200621140392898, 0.9920931864260226, -0.3607903991655801, 0.16352690340709403, 0.4040396606290212, -1.346003576892637, -0.7890276684086015, -1.7001858830653198, -0.2839615013363775, 0.3744614885424563, 2.4858431248230914, 0.9932964109583869, 2.2916576313340156, 3.105545401582303, 2.8086113815065143, -0.026126263135422458, 1.8272716429340372, 2.344209394138795, -0.31715639770203885, 3.0238014366186485, -0.4217333501908705, 1.670555583791972, -0.6622561736383803, -0.823183998025369, 1.3726992031399639, -0.6453570166695699, -0.7440231372243861, 0.27848064326330385, -1.8611050412259482, 0.29660160852114426, -1.3528757340042241},
    {-1.5149418340987924, 1.535662891789105, -0.23822657129993546, 0.946410171576964, -0.3349012519371474, -0.45191263889208827, -3.4788543372481535, -2.1084893044455746, 0.4587413892074319, -1.3700115399474175, -0.9189982022358671, -3.220093264527539, 0.6148292567323702, 0.7489104476021337, 3.4454949975337867, 1.1829093523817604, 0.2142457745187279, -3.2723357132276156, -1.742254014947708, -0.6125056954509323, -0.6516973372588528, 1.0510830686717842, 0.7398174118429515, -1.5389120579487718, -2.4671149513099, -2.5963039755333726, 0.939754816430894, 2.343164700348002, -1.8437299592945693, -1.473499125886176, -2.235146999723224, -1.352014231293305},
    {-1.4372140846780608, 1.3065797711389755, -0.987684519877056, 2.086521662226897, -0.9301806870808119, 2.0709908659942498, -2.471231355172643, 0.14403355989220012, 0.3525410267509016, -0.2899777769696788, -0.6648353220945954, -0.09233866677616154, 1.535578976375837, 1.3579749349359547, 3.7237741755918576, 2.242935086379211, -0.15277214488530874, 0.1719441844956064, -0.17333852501672542, 1.9057503630317274, 2.0414393642397695, -0.03700824581757853, 1.2984653712472392, 0.2261306114428242, 1.5129369048973405, -1.4518574147248509, 0.5937711098026804, 0.9051856664126368, 0.8723553466943657, 0.7214510826831766, -0.4883068996156845, -1.4347463880586016},
    {-2.9064278934908665, -0.5590705431702782, -0.8686704615274282, -4.649985691348579, -1.9920522133281338, -1.981902761866491, -1.2769908382301693, -0.6766578145173722, -1.6167588087279905, -1.8251579033751604, -3.7869822878802952, -1.8593662532588622, -3.071363729496022, -3.5235247550473243, 1.7760303540765578, -0.08931019505482939, -3.9353558601504384, -4.258426351187895, -2.377516084774979, -4.67753621613932, -3.525039686147459, -4.997623541668918, 0.8833431693920353, -2.9830449170521907, -2.8739869751391978, -4.422305839673603, -2.415458708696694, 1.3055936557541392, -3.010724912112155, -5.507268863196271, -0.48954580351180904, -3.7330319381909662},
    {-2.5449846969358494, -0.3939636589316162, 1.5777627286593758, -4.235824541840975, -2.5453643405176685, 0.10643884578736337, 0.2264153071075724, -3.3363742211754297, -1.5513726605819353, 1.1330596663319763, -3.115670668109658, -3.034336306566814, -1.901814440180363, -3.0526373562380127, 1.7616230375990618, -1.5073918023751536, -0.8547179012175059, -4.685807945882552, -2.0187327430241044, -4.479392384615726, -0.3047154778565959, -3.0581951587108502, -0.16887332606504674, -1.4245646152518299, -3.0444616201064876, -4.418417895469143, 0.34824987189650924, 1.2537636629504862, -2.613386677169836, -4.14278645964764, 0.1474677902649132, -2.6155566897059392},
    {-0.3126922271674446, -0.46533271856076214, 1.6207250993867655, -3.9709405537001743, -1.074227645517333, 1.825183821230173, 0.9480218372336187, -1.7659493467428473, -3.11526046541779, 0.8765757996122906, -0.8774612882423988, 1.7959737523653274, 0.7220509030540709, -0.761044926293296, 1.641386788387692, 0.9121685240609253, -2.548731450475241, -3.4034942357892297, -1.6723609273708104, -4.379975982512168, -1.3223923125466386, -2.7823038057247307, 2.9645799005339, -1.1912974472513769, -2.0059187836249457, -2.1347637728347633, 0.11554785979815937, 1.091362955605317, -2.9016190973528504, -2.8658712858991158, 0.13190959731493876, -1.0100912181270456},
    {-1.1977445893776346, 0.8953900695577954, 1.4938345842960965, -3.6300600019399463, 0.06976573506288546, 1.3218960275897185, 0.8174893373450317, -2.8154876391265162, -0.8489187883313277, 1.0512634943070767, -1.4925681020038573, -1.0701998095926517, 1.3670336423797596, 0.26187693973298215, 0.6755036027386977, 1.4219694760911499, -1.734134695477647, -2.6292611907909698, 1.3209882204280678, -1.428793665934679, -1.4472045138149927, -3.611570711533351, 1.48677118828314, -2.691200158133417, -0.21171901759943335, -1.6357326565262331, -1.7016585929112351, 1.2283395916307347, -1.0108461475106683, -1.3717803663054202, -1.5744693865004584, 0.8401390323772054},
    {-0.7409022900867108, 2.5795106706214015, 2.267667465659267, -0.08093805964244734, 1.4036735367999025, 1.1168197059450755, 1.9641284054394377, -0.5259867561355444, 1.3227204762797464, 2.325503626330262, 0.04282095220862658, 2.285017522031976, -0.09535494884862084, -0.9433407402714944, 1.499051183259019, 2.229137992155209, 0.8469317817211399, -2.3177507694052606, -0.1291706741044056, -0.7349701731016689, 1.3999100775492073, -2.2007237710755754, 3.1210066151893625, 0.49864664800899217, -0.3865776354823879, 0.3639259556668543, 0.6439831900449748, 1.26267432198273, -0.970612376580132, -2.5822998028640405, -1.1521721080510672, 0.7957736774792784},
    {0.5732122776280771, 0.521212934246026, 1.9541529841190015, -1.4230948091621458, 2.2285786836233217, -0.9852520338292532, 2.3423364496408414, 0.9903211830608798, -1.6777187718225002, 2.650574589517699, -0.7443399213230775, 0.7198308724922959, -0.11190745228076285, -0.9688132877071404, 2.252886602335418, -0.9930074350657917, -1.3731076920095615, -1.3586497573328757, 2.652005510681481, -2.330209710611428, -0.04731263451422779, 0.7343255393674539, 3.5603867880820945, 0.28974321489291477, -1.076241001422605, 0.7927612000131148, 1.743330354698232, -0.23411660430067419, 0.47365180983245536, -0.9178933865881734, 0.9950747745855297, -1.8203724328118873},
    {0.6736459343794817, -0.3647598454893561, -1.3349578691495674, -1.4593546158479485, -0.6463475099851304, 0.13653649894421407, 0.15409463282955516, 0.1894916073247096, -0.9071346854660698, 2.3281859362194517, -0.5716067662554859, -0.5379509503705097, 1.3340963807266677, 0.0349058528453852, 1.451365388933927, 1.8091359398074276, -1.599357552321242, -2.860227261995891, -1.9058727963891129, -2.0769591173244453, 1.0519939246919223, -2.901552407410733, -0.8935191350746732, -1.375540889503098, -1.8269282725122962, -2.9039476353399833, -1.4286262535541912, -0.16143029121011604, -2.107245349590007, 0.7053605019041894, 1.0598542710679602, -0.17052035202403948},
    {-0.6790412669773784, -1.180667966382467, 0.3194901707479554, 0.4943025195929884, -1.455532072722273, 1.357443510157311, 1.050014308264547, -0.9124992911549505, -0.22034931055678836, -0.6566264458587681, -1.368728452650109, 0.12117229300600264, 1.2756394213799844, 0.4700116974565122, 1.393632929954822, 0.6523025738527275, 1.263502931497574, -0.7549020658555854, -1.0309482153227847, -1.2526305162840445, 0.23033690836641532, -0.5541104373827154, -1.6773926360288711, -1.8456489250657833, -1.6710482967939306, -0.08953946568255045, -2.4704761884887163, 0.9231669916723929, -0.22901100532563554, -0.6863476281615577, -1.2688500085371108, 0.7993399050449314},
    {0.6340146676355423, 0.25567148596604355, 0.9547687226335307, -0.7875922636887034, 0.7660211551084605, -0.5975206351912733, -1.3420286457333273, -0.44409679665939134, 1.1902949387251607, -0.39074013505197486, -1.0099616554019681, 0.3456838570335825, 1.150506291435665, 1.7128774276870882, -0.6632753431535509, -2.14186123065312, -2.832458517131011, -1.4929171358527988, 0.0007985509823098408, -1.7957962694535847, -0.4668131592488203, -2.0799898556882863, -0.7879694643689283, -2.385985685107635, -1.514115758937174, -1.4316532961061048, -2.2098049379473204, 2.0079825499552166, -1.689981913265949, 0.6111396098411047, -1.493654284853792, 0.8428037222752975},
    {1.4861190162063227, -1.006205438564989, 0.5974277353351446, 0.6090099863863793, 1.7034088150828914, 1.4282333777380665, 1.9278823169980848, -1.8915372355151054, -0.6348359976298242, 2.511204018262787, 1.2704565099405496, 1.033669142006828, -0.686140134345464, -0.12829278356257193, -2.2632861985762895, 1.4827755771254323, -0.09065567053668455, -0.4718532149653683, -0.02864346252347588, -2.0564319372418343, 2.0866154247341573, 0.30225205438143854, -0.7750033950420488, 1.7143860018821544, 0.9740598489753161, 0.948253602658824, -1.1585851770004305, 0.0733878885328182, -1.8106718373571087, 0.8453796385498004, -0.7362219569249429, -1.0982748675642346},
    {-1.4140893305860922, 1.25967662149687, 1.1873864798385576, -0.10324401611754676, 1.6272918902627016, 1.7675538683215415, -0.15782404296928848, -0.9311085786674664, 1.682409605726494, 0.11039655807477447, 1.440114263338432, 2.4067437371613756, 0.9493544300766716, -0.7572030706082472, 1.0439866569732486, 1.6778473277378108, 0.9192179044588709, -1.087092600313211, 2.3910653319884925, -2.034134587249217, -0.4989790074019201, 1.1463898934442815, 3.1393263587275944, -0.9630592453165772, -0.8182087143653962, 0.764597626162291, 1.0180042417359165, 0.27368964445969474, -0.15784880669729742, -0.9958714120095278, -0.8619954365648282, 1.399951640904687},
    {-2.290535339836308, 1.584235385741524, 1.4864358102607864, 0.9690268873913629, -0.98637423560117, -0.8917252457802353, 2.299302787759906, -0.046573463551154916, -0.26452188031824553, 1.4411047601843094, -1.7397603657920984, 1.2362961313788778, 1.850250321301655, -2.080375526477488, -1.1057956876561739, 1.143089905333769, -2.1066364912287745, -1.0924045691869422, 0.6577500945226574, 0.1672285325022267, -1.1480129346233368, 1.1382983730108283, 0.656658925835189, -0.4282745799299567, -0.1930136529557495, 0.8160067319262405, 0.722235853703391, -0.00848688550343636, -0.4935531014113399, 0.13345929959916272, -0.09092216873613998, 0.4047282978132509},
    {-1.386991797893055, 2.080860665919713, -0.7596469160557552, -1.922116514917592, -0.13546055946615634, -0.013943841912732197, -1.5371013648069396, -0.9567636252665412, 0.06641130131309839, 0.20215197475642555, 0.7671540055032622, -1.4476421462383313, 0.28501608722399874, -0.30709451726913045, -1.4514108054697008, -1.4778083304973217, -0.8840954573644062, 0.07487848823720988, -0.9754361367158044, -0.017263785016268355, 2.182362882769545, 1.4679849110603185, 1.5029329523600972, 1.2991076390825531, -0.4265974235905447, -1.439382230669477, -0.17094670868628908, 0.9335665122954577, 0.6548604360549514, 0.7302622915248642, 1.7095589391807593, 0.9907590744219702},
    {-0.04514139700909607, -0.5449678742148798, -0.6227346342841491, -1.6435325466908215, -1.3863312520013638, 1.572290939070045, 1.6315290949033743, -0.6253554248686873, 2.1838711471451284, -2.355265649514204, -1.7934479924200422, 0.16063901006978476, 0.3905135382491352, -0.029864050155968182, 1.5847777304489248, 0.20548851321437736, -0.6415642965577892, -1.3807820613207775, 1.5452971640657673, -1.3432832074117735, 2.410975455669784, -3.036801691827208, -0.4739847369568932, -1.5117270318527898, 1.018241813544103, -1.4582570016658698, -1.500324762544089, -1.0602190510921405, -0.03081420177115335, 1.1732755778395747, -0.35752209618436587, 1.7525409867061876},
    {1.24790958761316, 3.2723608003776192, 3.969706396461707, 0.5515417676703124, -0.3064046579327399, 0.10815147582084586, 1.9971066208643726, -0.8762009794481882, 0.39779970770150835, -1.4975627816315458, 0.4478720471021232, 2.614036990266543, 0.9549870253494581, 2.115342614559527, 0.29749738888386257, 3.5707025237142904, -0.40899138164569454, 0.2360983889966356, 3.1513095561127034, 0.10947088992659122, 2.0173447979486436, -0.6959414170571899, 0.25637557007442896, -0.48810650399745675, 1.139021516154681, 1.8131464459131423, -0.7176021537184346, 0.6762637816085074, 1.3073022559597693, -0.8300419201178092, 0.8079514576613336, 0.1925581042595751},
    {0.11600646986143319, -0.7889119929523782, 1.9033234709384685, -0.5000784599808934, -0.20969908360815204, 0.5511449215293198, 0.14093336583812674, -1.6053891573112624, 1.0585605654154466, -2.1844612781171553, 0.3394601358567288, 0.5656535359017036, -0.2087029976402389, 1.9954399583840141, -1.0917088360253828, 1.154844642308318, 0.8329462519632742, -1.5229857984855872, -2.5417364475019073, -1.3965022914413752, -2.059092258965892, 0.9462727920592068, 2.382806047384738, 0.7842122908394837, -1.0099232445298185, -2.5667830836091157, 0.4331654807866205, 0.6460511041871725, -1.2077190109083051, -0.5042096767893648, -1.1659351395287059, -2.5778205111187527},
    {-0.5983730958455704, -0.7161735306645124, 2.528528681377669, -0.057100351965954976, -1.0588556038337913, -0.017324883565947653, -0.2703348119355918, 0.7515821733021055, -0.7918369705784267, 1.3708784600640012, -1.7737689308517415, 1.5620768663619355, -1.7357337616217894, 0.683533635939015, -0.8806132432859134, -0.8303699886042618, -1.2279966180232633, 0.586738133500167, -1.1083188150035819, 0.7376880563258494, -0.028875410364004216, -2.0200708286146414, -0.9571156062586268, -1.8584990742350742, -0.04841910448988694, 0.4808464803360433, 1.6243864706343905, -0.06712468351156974, 0.34234776551302126, -0.7450819941569203, -0.4633739045122041, -1.2704111535980847},
    {0.5140566099511631, 0.7748818438524098, 2.3126740136681145, -0.9522790847531833, 0.5777107198689679, -0.5478532468180263, -1.6332658171128862, -3.0394857077131134, 0.8799184636256018, 0.20088525347732758, 1.191725085691361, -0.043691217339187925, -0.7550162864529172, -1.134023455597169, -2.9165668437942536, 0.9001028176459476, -0.6019218445308678, 2.0443354868983405, -0.6310168270613942, 0.40833293582338925, -0.3485064539317255, -1.7950883807415472, 0.14223195474562958, -1.0030230776600013, 0.6416430073378999, 0.4081031723247831, -1.5955339039706962, 1.2841568007728545, -0.042807050280873234, -0.6912006468701647, -0.8414032044137975, -1.916607196009881},
    {0.28715601564180676, 0.5711095450318551, 1.4458536541733271, -1.7659986966977508, 1.1642775197965858, 1.2699648423857621, 0.3048089294798053, -2.4041165104162707, 0.6481193346443663, -0.478324387810447, -0.9746808603785898, 2.6925066776917856, 0.5080709283409155, -0.5323049614584798, -2.200853477041894, 1.793605998393289, -0.6544291223734328, -0.4917137871679322, -0.5657306423581613, -1.5877047059336182, 0.9721551837919967, -0.6614848276971398, 0.9249238808900125, -1.1883826097652066, 1.7432904771413553, 0.6370301598805765, -0.6793552837266384, -0.6146026631239144, 1.4056502143258447, 0.5691156015557245, 0.2981934302469443, 2.879813378871526},
    {0.7078975405788172, 2.45406760950493, -0.5022340840206679, -0.031651580626632606, -0.1388350161533959, 0.4251715585092795, 0.5460154836226271, -0.8591524676699698, -1.9978797017392864, 0.8080763060200121, 1.7785677334515073, 0.8474077961724805, -1.6566991637462019, -1.0579938457743807, -1.2949895540055274, -1.0239581073943251, 1.0319251077612444, 1.0821542594362779, 1.3348160801988762, 0.050357171601522005, 2.440677091084881, 1.988094020257231, 0.5365624145065142, -1.0464194746068196, -1.2675338939347756, 1.908872654748055, 1.0999151464356585, 0.4923925597415049, 0.8254871263867296, 1.3501461837065483, -1.5414756424105989, 0.5320830425405391},
    {2.562839315267064, 1.0353687757143242, 0.23867229327697714, -0.9976690298328404, 2.2012462996691533, 2.1946664456317224, -1.2323964647763543, -2.530504373403287, -1.2510395509216379, -0.007840304528009372, 0.8893588562712351, 1.7679949477351546, 1.3026236888167737, 1.199926056550793, -0.6146568563360163, -1.0995161626595022, 0.33426596008415776, 0.29028970777463275, 1.100012615640455, -0.062069280268539195, -1.078291180144635, 1.3412986005946104, 0.29880912535660104, -1.7140898892399978, 0.8464795113971504, -0.37049492154832536, -0.2988965982275699, 2.16836709056672, 0.05621800212535141, -0.012741168686033286, 0.6412166698801554, 0.8769347453987352},
    {2.5552205649678457, 1.2953522057912332, 1.1227308360133452, 1.0807178857632493, 0.5634493511278981, 2.280688770948981, 1.0648032009373771, 0.7683594779968351, 0.6982783683500634, 2.285651577179653, -0.1952301223445652, 1.4928456630873002, -0.4896036646220867, 1.024067723188376, 0.23873807703522915, 1.1835349317340391, 2.7168895896849943, 1.1540611560462204, 1.6322171971895976, -0.7391139422705795, -1.40185922891317, 0.26243055697829537, 1.0262116211852166, 0.38121147964164476, 0.43977592225660317, 1.4115437085662919, 2.5521522558537475, 0.01944277124260909, -0.45558900446523753, -1.0548476976606076, 1.427561821769525, 1.7205079527765363},
    {2.3282758260738, 0.9462818031773036, 2.454635446852065, -1.200336376523984, 0.5539200137942382, -0.11904956875094214, 0.11809056598956108, -0.7551820068292825, 2.878515698127851, 1.1639541877957935, 1.5747678236914828, -1.3261538521901821, 0.8330791035757718, 0.6836314474996052, 0.7521181526370686, 2.635015236735195, 2.310120518498351, -0.11596715453872555, 0.6794179061775887, -1.447089543842739, 1.8171753616629185, -2.0144386103934133, 3.1781384941636066, 1.0250882692357104, 1.429290543994342, 0.16729815817978125, 2.3881394550285617, 0.14143865555578314, 1.7812561423154756, 1.6398450781303766, -0.21644992901641275, 0.08035497526272693},
    {0.2993020531176933, -0.28119783918875146, 1.5307513621557653, -1.196242409598114, -1.6017214901911123, 1.0891999408791262, -0.8598131469986952, 0.025480588596528096, 0.901144550101161, 0.9075966630060938, 0.36100492647283416, 1.241977894665041, 2.0541752196620284, 1.3351931094867138, -0.7703374983768031, -1.5412040804935594, -0.0954400966230079, -2.382316604759426, -0.08078311686682899, -0.6506612921653181, -2.6864172574892913, -1.2573705302315543, -0.004539289708337817, -1.200249381095491, -1.336141972979592, 0.9172610069856506, 1.0872851664404999, 0.591748711305544, 0.3784683714279576, -1.2566236497326206, -1.7300656930228362, 1.5883452193546568},
    {-0.2908053308967188, 0.04705009486704864, -0.16890667511221166, -1.637907571064976, -2.3584304083011065, 0.4911202102626933, -2.444638166442015, 0.16126547971594155, 1.1370935521546863, 1.4522317951864057, -1.6948744626608554, -0.8461044211401513, 0.5441351660058608, -0.0961045465446679, 0.9548062799535694, -0.6601174691278667, 0.3596447228330196, -0.7033420635671284, -0.6793620979285722, 0.571212917255179, -0.0737194193616001, -0.45732744104919043, -1.4834213830368335, -0.7384533511246579, -0.10832929987839363, -1.9479354603317673, -2.1166804734953715, 0.3914007046011851, -1.0525400380537022, -0.9428705392545589, 0.5650981729921337, 0.9134967642119906},
    {-1.506939910016308, -0.49043579127895065, 0.006943319674931747, 2.951930711800062, 1.3754230272343568, -0.709529754733248, -1.8770088322377818, -2.02353704279667, 0.3149593977812289, 0.8134738898043012, 0.42877907713192265, -0.9046790631853564, 1.4382227853823446, -0.27921288955226614, -0.6829065399594912, -0.34319756466672774, 1.6928242065845085, 1.3126070512745704, 1.5791345717830212, -0.4806309668113826, -0.6329130964833388, 0.8330438641339087, 3.056062235909652, 0.44279009310197054, 0.18686692738071564, 0.8003783264460346, -0.13513766287247975, 1.0775978001193922, 0.8264305449211953, 0.09204283896575594, 0.6489871608297806, -1.9021202940327466},
    {-2.3235479914742547, -0.10122413727748807, -0.9762976027565654, 1.929260029788316, -1.1831241300581896, -0.5409839535506181, -2.266896382024108, -1.0976938061057548, -0.6738287913279428, 0.9011068231582118, -0.9439263120599333, -0.7631982226257533, -0.7838592285103789, -0.9286267416568015, -1.639066881954255, 1.352587710360254, -2.3315756097031866, 0.25322664741892587, -0.8576668161899647, -1.3486141484898697, -0.006622123643176626, -0.06530137986178043, 0.6176300534390987, 1.8362802937200995, -1.1182517611393494, -1.8998964941321776, 1.6712117888282045, 0.428414944896914, -1.2075179215876826, 1.7329065661460192, 1.1437611593630665, -2.893761044347472},
    {1.5016463571779952, 0.7904915905247925, -1.5871113388158073, 1.2732499264914912, -1.0653394365928688, -2.053395132829016, 0.7851530949223842, -0.930915705806611, 0.3099740181195783, 1.8229210125562119, -0.55418977600913, 1.3046496104748455, 1.8030044378121381, 0.4991064589093663, 0.6020646714889504, -0.9523757763805467, -1.4496863491387275, -0.27443473567339355, -2.390714667302115, -1.8337105598860035, -1.001629023504549, -0.8388118354098406, 0.10314165222652277, 0.9480761045648525, 1.5483119713672797, 0.5149718031646099, 0.7222955087665912, 1.7616351079573414, 0.16564927055962553, 0.17317211237559496, -0.6533591294000097, 1.8203111715640206},
    {-0.7016137966615271, 2.0370761635829404, -0.44758368861096776, -0.21532382078391993, -0.5686989267022284, -1.8481695858571558, -1.9941469322592869, -0.18136246865910852, 2.291112819174054, -0.7635381888016075, -0.8802950685114612, -1.4697426407793102, 2.8420992581865447, 1.344447014906302, 1.5918135620462406, -0.33542089318196444, 1.2388241727044, -1.7093376908785878, 1.2394762839262885, 2.1263317904629133, -0.38799005450771673, 2.149839642679148, 0.15419962759820635, -0.7668761063947122, 1.063213543166628, 1.200967472350813, 1.9328136260151434, 1.075692786307924, 1.3528539093621363, 1.9675670047857716, -0.03741475150437751, -1.4281259613937767},
    {0.10630193404583399, -1.2047309429297979, -0.13671292285986836, 0.43183482093346176, -0.9655571499298133, -0.4199821177957644, -1.7397514159151215, -0.8642672240901592, 1.0533964791938564, 0.7380350285204205, 1.0397356282494452, -0.5698861234894478, -0.18884637434152537, 1.9371998159055024, -0.37575350479444186, -0.13093633739275595, -1.1724541558604347, -0.32695113829360795, -1.5698477118923564, -0.14071257567987952, -1.219464334274227, -0.16746183560795533, 0.880413435976445, 1.402309158812314, 1.6447947874673148, -0.9087047503845307, -1.0121351570411226, 2.9742333743594, 0.08860655091511678, 1.048543393785042, -1.3000954183054012, 0.8331035413706356},
    {-0.69762895058086, 2.106727649319682, 1.9149498140373196, -0.8405340376365595, 2.14243838609307, 0.9056085259265338, 0.21483262213968918, -0.8947143189555113, -0.3509692868737338, 0.058423257007338913, 0.3113568511422972, 0.05532161762087834, 1.9132360133098005, 1.855558352096604, 0.9200065094896834, 0.43428709575011887, 1.6092837803122158, 0.3852756267718835, 2.547399611689093, 0.6408259542886962, -0.7011349037405779, 0.1301842095289575, 1.3550786024589145, 1.1229190162625207, 1.3479648742409365, -1.0261897740595318, 2.2968033299547743, -0.7967472419879656, 1.0001373012826489, 0.715999504668238, -0.6811872244215889, -0.030008132064401363},
    {1.0060638437490248, -0.9868684680323262, -1.0568059622025217, 1.8446186444164219, 0.037249791408767836, 0.2436306134801299, -1.2749269822322762, -0.8407282785308158, 1.6353079575570184, 1.8450673746084074, 1.761490599289261, -1.231305909274712, 0.8109739031118872, -0.6780977053891626, -0.2856239088682393, 0.171454843235503, -1.011190865180108, 2.080480411997148, 1.4156151643389354, -0.42552988369239214, 1.8473785616851028, -2.5394545206180297, -0.7876839159569443, -0.07759587364876537, 1.168068916093481, -1.065017128239782, 1.4731274170806343, -0.7093072237503363, 1.0601512905571169, -1.2786642266224169, -0.21572496457281248, 0.723169529676867},
    {-0.7719481306147207, -0.7504545703022891, -0.9624183262379518, 0.2116068154002615, 0.4590919399481331, 0.19376876490813597, -0.8496858694999867, 1.2619898990208076, -0.3117256583434229, -0.26368303222001405, 1.1546524357967414, 1.1225450396060452, -2.1122805704901304, -1.2780526113926667, -0.4271237321264081, 0.3940641958784949, -0.6334246841980119, -0.15066257006514266, -1.9169677793182662, -0.7452504866562665, 0.49480536545443315, 0.10605576009473362, -0.9382804715883987, 0.9584791444064389, -1.1492710994946966, -0.21135018007093012, -0.6274433090647339, 0.761908767763157, -1.8997712883043736, -0.005292429250654906, 1.3764980913762486, -0.5425492488422287},
    {-0.27404056081327327, 1.2244288878783223, 0.7586855342261472, -1.0198400938463557, 1.4054997882167932, -2.059905052733042, -1.789966062957954, 1.7386192040607715, 0.6370809609499385, 0.3567948466821411, -0.3424211678146677, 0.5053807057024541, 0.5438941853642858, -0.9019998343055116, 0.659351128196769, -1.5579680947090975, 0.769681270922147, 1.3478677490151116, -1.8181974467541246, -1.0216848674296495, 1.0352662442708327, 1.2229931229279238, -0.4373322694737648, -2.3154917837480062, -0.765868754127424, 1.1052964673725059, 0.5010420162819346, -0.4859808008463363, -2.1983427196448306, 0.3830077214135678, 1.0780693861416517, -0.07833627337831167},
    {0.7214585895496054, -1.307961246421537, -1.891752417934884, -1.1813647383445094, 0.7574475087915952, -2.006413750864609, -2.237991126743104, -1.4553120344331514, 0.7395239956589982, 0.5700996178638795, 1.048735778787005, 1.2227685798376504, 0.09741844086464164, -0.32397917166373347, -2.2704840703301565, 0.254621130343391, -1.541559970346518, 0.7764891785983127, 0.3497738252324837, -1.944239818523123, -1.1267909709739878, 1.4691594737926543, -0.9593778582733807, -1.399096041183683, 0.6105792962330586, 0.7983291043680504, -1.4373711678223258, 0.7546545202503823, -1.008496536647652, -0.32515864427097896, -0.7440595391135693, -1.1770714805261473},
    {-1.8781001310216243, 0.399329870116278, -0.5057350614930762, 0.7280180896748596, -2.1522165672881464, -0.960060085842766, 0.3071420244894078, -1.6106897732390726, -0.28884595057122636, -1.2349502352074315, -0.3517381316691555, 1.4316502991045823, 0.11810500181854931, 0.4149768239439201, -0.5482683274251376, -0.6152054112829987, -1.026534772439223, -0.33540269401567013, 0.5327890280774612, -1.6265756952940815, -2.086544259050484, 1.7041214799465099, 0.8710171936724899, -0.6081141593420147, 0.48722775652847183, 0.010527056799623994, -1.1772027616703027, 0.029864562396935475, 0.8179300036369822, 1.550784790333875, 1.3422218423837193, -1.28949767483071},
    {-0.000647071964367118, 1.076518365611153, -0.7133327219960857, 0.8191738342130607, -1.700974727312247, -1.0225256075015041, 0.1689096973171671, 0.4084121476128329, 0.5936425669600877, -0.11481374629565022, 1.044156291467073, -0.8430049538635388, 0.42476262450569263, 2.1840651051917637, 0.838919341339395, 1.442774880395329, 1.6794674497221591, -2.1148767905516532, -0.3317216086805664, 1.674738288475138, -0.10904030653783231, -0.2277362473397306, 1.1652674627354136, 1.108957520626091, -0.7599626844420814, 1.9476291725962633, -1.410815027252108, 0.15104555376967935, 1.1743604428739796, 0.7306955855556774, -0.9445941406356047, -0.9068588972871903},
    {-0.38739549640747567, -2.136867395411994, 0.4469570265330479, -0.6884281546082524, -1.2012389339748741, -0.8933737315247903, 0.44609628404397383, 1.6840903445741575, 0.11866580998374147, -0.5590002552042646, 0.13620189290518211, -0.4285231894162878, 0.8291809262144854, -0.44383801889535035, 0.7907561785086751, -1.0889897554015642, -1.0463881814643428, -1.7471151001707412, -0.8945894803622148, 2.1978226055873518, 0.05502086462498053, 1.1063255244553636, 0.643144226484303, 0.49458681299946283, -0.7103522828248812, 0.8851579687502205, -2.428954603541803, 0.5065098019179013, 0.14718999160402835, -0.9290255592263263, 0.3019561838940057, -1.5361387469224588},
    {0.6318049366666904, -1.5687080348599645, -1.290218618895376, -0.520515744564579, 0.9633605742883311, -1.937939536824945, -0.7939284409361141, 2.0148633546236483, -1.2781714106732947, -1.765489791736671, -0.5585173677088711, 1.576670494785087, 0.7081555196713483, -1.8359759028701597, 1.0575788058581284, 0.29632401910598044, -1.2865530436976833, -0.08866830912976074, -1.8865549504304577, 0.6204857621088089, 0.48890977119916507, 0.5493401528838219, -0.5107813953670315, -0.8924822155132297, 0.3710628814495324, -1.4003051122196604, -0.8088943129968825, -1.717505742616296, -1.0372387154849723, -0.6977082156770554, 0.7488680798092314, -0.9397581186380543},
    {0.5791693438337705, 0.779972224255052, 0.24754865517387914, 0.41840921147467464, -1.2316825888699747, -0.5349233783745826, 1.9051836907022155, 1.3036600530093752, -1.9907142134088693, 0.23567750240279886, -1.2621761584162714, 2.362837853548395, -0.42692082286648375, -0.38291819135973537, -0.1653696968568144, -0.9645146365958992, -1.5442254122658416, -0.9496116243529911, 0.47604086477811813, -0.5107482078534554, -0.556252202299836, 1.1496182122550838, -1.1490023007286556, 1.2324234494327488, 0.827342223636345, -0.8709240116224232, 0.0030480277430081863, -1.1495721174333582, -0.5593079923471133, -0.9385729935732118, -0.9162994419890368, -1.2409139891612402},
    {0.5426650512776853, -1.6273885494789302, -2.0467418268034825, -2.10477091889542, 0.6275548768228031, 0.6839664510051604, 1.5599091302866883, -0.12405742718113065, -0.9401302091633894, 0.49644279396685503, 0.21266116045292124, -0.7787732795079298, -0.08327871620104949, -1.4294208414857226, -1.7900940170049762, -0.7126790119756529, -1.0206852553686026, -2.1001256992341513, 0.0893350279500409, -1.251716776076722, -1.0385058312300168, -0.6201948734075097, -2.217455246424709, -0.8890177520438196, -0.007288328438062465, -2.304617763143959, 0.7552146212297497, -2.012658398081382, -1.5013106182626914, 0.8069106157883165, 0.9504996898432089, 0.20721763441165134},
    {1.5912828236823147, -1.0820594936773726, -1.0124736296359826, -0.6154843156628369, 1.7729021589356075, 0.3690339175731695, 0.7860340814621029, -1.7800169105147972, 0.7042483528445875, 2.7642218460708547, -1.0300493397836485, -1.5496363334075678, 1.363387270721996, 0.26728007797632203, -0.020581775009806475, 2.0922426510377035, -1.0657759071774375, -1.1654204108002808, 0.8320283198931093, -1.7435579764508815, 0.8188222409007879, -1.5694495769502175, 1.1221152252569517, -0.4387284892439198, -0.08999522379754671, -0.6932619176869604, 1.8056009142706544, -1.5085959279161343, 0.05081312538993824, 0.06018384826338692, -1.0767587803952665, -0.2788898616331683},
    {0.5304493333856037, -1.6710410268040856, 1.1132943776252573, 1.3003674495503479, 1.5383018314472332, -1.3018791532065292, -0.18898923408516297, -0.09246571901476336, 1.643695429901184, 2.3447036684848688, -0.4560443704165238, -1.481874969508537, 0.6352379884426281, 0.5320192645664346, 0.7085008928886843, 2.267601861258193, 1.0089766612357915, 1.5934286300978404, -1.1166651870787505, 0.7728623702832685, 2.5889981487295346, -0.3154872836480073, 0.07028215457979403, -1.176858734547445, -0.29992233431213944, 2.2386647077428723, 0.8645777071625264, -0.07550381370251359, 1.6153196222955195, 0.6487883512374274, 0.1721739801888745, -0.06857100505638976},
    {0.2407332671069221, -1.2535693755147521, 0.44612565288772466, 0.8686822633996052, -1.3067942590183037, -1.6851868989218344, 1.228349291416878, -1.3185639169806243, 0.7611698665268755, -0.8266180553677837, -0.47729292025832865, 1.0963491777044954, 0.11530010673833176, -0.0572080740871063, 1.391201290319336, -1.8930927626024299, -0.5704254761184051, 1.5108535313540086, -0.45311126084368253, 1.6210990851673845, -1.3615300542822568, -1.5549141760013534, -0.5203798799942403, 1.3768012796715008, 0.6538146538073787, 0.8932325505778979, -2.582099189473949, 0.8941372024285454, -0.7603358433298016, -0.5839471141617972, -1.143015860772291, 0.6431063557175669},
    {-0.2678920329751374, 1.468410145462687, 1.066726397784513, 1.350736741245762, -2.6048838762885667, 1.5367940052913462, 1.4469988600642552, -0.3094080747294615, 1.1999580072722686, 0.37071042207135896, 1.272792063311439, 0.6607199910102044, -1.1900750149374826, 0.09099749050853487, -0.5373934631752112, -0.4243112674864843, 1.5861011391014608, -0.5337613208518647, 0.3930802946128023, 1.3596599643654486, -1.4013205460784284, -1.1356961220835042, -0.3445779026329072, 1.3415499966671682, 0.7180168858545553, -0.2638875135955664, 0.35772225731153173, 0.4258787514871544, 0.014666016433850829, -1.6622052177973217, 0.2520179151221598, 0.7489548544681496},
    {0.7069902900961692, -0.2522599936177875, 0.650871677786297, -0.25363295359275895, -0.22582030407973075, -0.2653586416545422, 0.5248543043346798, -1.0345373760322, -0.015763263692448484, 0.25263624717487976, 1.1475668904875993, -1.5747737064114942, -1.2078710696854504, 0.2757991851658944, 0.7338626498083278, 0.5432728759645044, 0.27764707283458956, -1.0819398512793768, -0.721830345180294, -1.1650798188808724, 1.7813358694671424, 0.7638483903808331, 0.7846219300523937, -1.7098787311713382, 0.1789489875199609, -0.19967206915687208, 0.18183530744629228, -1.538021865783828, 0.6977588049366669, 0.7245521465224835, 0.9542854678017302, 1.0492823500494806},
    {-0.03384637186132135, 2.3225948537834546, 1.176976609689272, 1.904760886003722, -0.05096609691342882, 0.0844835552198276, 0.5616801507744102, -0.9806663517981422, -0.5985412632531768, 0.32625472000272693, -0.05508438904789428, 1.801794712018952, 1.8261530345815535, 0.7005915574593492, 1.8973308804132174, 0.8865698293487364, -0.7217938552121107, -0.5399194040761797, 1.9640771457191808, -0.0323087592195913, -0.5841061671768601, 0.9848915969975551, 2.113193220489409, -1.2351683262952997, -0.7984373817761844, -0.09077799472408975, 1.559017000583832, -0.6000967923167781, 2.201571991852608, 1.3700754822710492, -0.5695707169471325, 1.4645434616031532},
    {-1.177041672233353, -1.3163418888922644, -0.24936455212188557, -0.36472690962222976, -1.812838429828599, -0.9896293213806507, 0.9128445876034278, 1.1829556129026881, 1.1834685627139334, -0.6895262095689293, 1.0607790021030397, 1.6433711845831265, 1.3691022908617678, 0.08316028171728979, -1.152201215004203, -0.8845176335342086, -0.8748348339941234, 0.5361895149929151, -0.9924804103961452, -1.9268428530119257, -1.7343461787656107, 0.021522179963556733, 1.4361045245993127, -1.3147356475896512, -0.2436525522600125, 0.013064682569000941, 1.8723242148791486, 0.5369982230100995, 1.0060006669356996, -0.09382900764537608, -0.3224347157669545, -0.15832737776027828},
    {-2.050559383496867, -0.31837255170291157, 0.4173520783623701, 0.1716872155856873, 0.9379705085159047, 1.0030221452866708, -0.4577191628500744, -0.4802588015310043, 0.5756331544253496, -1.8429122948741947, -1.38206922513439, 0.8284521357520919, 0.64812026037937, 0.5797437589879159, 0.7146028882322992, 0.2799560687353726, -0.797071346271054, -0.14766892754516028, 0.3481064623417565, 0.24866043621316253, -1.7185523345608655, 0.846984360280297, 1.1132081494379005, 1.3141282137772141, -0.5103442762444288, 0.9563471429668634, -1.3793290606308277, 1.8053901557772265, -1.934113086994366, -0.11251323526298118, 1.079454225358706, 1.742736323089196},
    {-1.4478438508937221, 0.8871063201410252, -2.0306928490739105, -1.9043780307847813, 1.023999631505824, -1.0828889469875138, 0.31694476267530197, -0.9157704209465903, -1.0221926464090934, -0.4402142694570673, 0.4219795646776498, -0.3612322143369673, -1.2568835951418955, 0.9541450092461564, 1.4043321219745333, 0.7096913484907964, -1.69641690040192, -1.590745927462778, -0.030776990828422255, 1.1684274297289003, -0.12974542261800256, 0.7519414462283774, 0.7138440496979741, -0.9316728566610427, 0.4874276523129239, -0.1526664870756115, -0.07893299557316706, 1.2341476478161661, 0.6884479021119975, -1.145391142734565, -0.612910798251506, -0.058085257618495034},
    {-1.0834339416953018, -1.3891198276887702, 0.7618019885965096, -0.5129836542673436, -0.7798222511698584, -1.2124195603984032, -0.24635906325506063, -0.14031868110086254, -1.6673750270072714, 1.271186572265129, 0.8741391765493164, -1.2566832979517812, -0.7864831262316279, -2.2813259588918426, 0.3403087072083209, -0.24808019124276687, -0.7949697051689842, -0.17108016999084616, -1.3121963857288048, 0.8441452058495466, -0.8840251184965136, -1.2376716373840484, 0.009309940212122475, 0.36276216210588413, 0.6283844923674737, -0.5623786209114052, 0.7383024288052538, -0.48030540598561916, -0.4564315653184015, -0.06370769643242145, -0.647605879528898, -1.3553415088242073},
    {-0.057399652262830225, 0.26343063072721723, -0.633005896992115, -0.11853759951785259, -1.3400370663361731, 0.4023846076178153, 0.1758601684582009, -0.24409275466049113, -1.953509649210421, -0.7896898876148465, 0.5719794080727618, -0.6546927007822798, 0.9870396293460143, -2.2700685323168925, 0.3047549351122976, 0.7465693688262196, 0.3628877010017648, 1.1056277465136701, -0.3946180174786848, -0.8859535598153542, -0.5293451625213188, -1.03589802502459, 1.142119063440112, -0.7222846647471352, 0.7744144973236768, -0.5319857280286685, 0.9110190582825842, -0.36771887654815905, -0.9351131340023183, -1.1568188033182267, 1.5108057767770084, 0.9404989196245083},
    {0.36471761997682295, 0.4842562975984219, 2.3557070355268497, 0.4847958803156318, 1.413501320056008, -0.6468855102989456, -0.8003043342388267, 1.2179253279133202, 0.37013713274682175, -0.010201370978060646, -1.2694152817700695, -1.346519592111306, -1.2234997111846042, 1.2537443976481963, 0.059849246765211354, -1.5388450716415567, -0.8155147593155329, -0.16068689651109658, -1.6020703156792655, -0.6055969736854359, -0.42467467424590566, -0.35709782688883424, 1.6623710064802877, 0.7293278028284889, 1.2170794787710113, 1.9794272318841644, 0.4419677984811995, 0.4853194694701125, 0.5091638666370437, -1.3842807240836805, -1.0445818050240845, -0.9884493976884535},
    {-1.8938830354491925, -0.25487924109576277, 1.0742782353926177, 1.2984834734863644, 0.6291615947485812, -1.6711532878553068, -0.8709981401940649, -0.7933655985910376, -0.18709645629690755, 0.4903242658088696, 0.7178444477179308, 0.9218390444057322, 0.585820128317541, -0.3324579292123039, 0.5885736215245004, -2.5958570330723605, -1.1091906234783453, 0.593022290187286, 0.6012866581708362, -0.4181364645728724, -0.08669605748504682, 1.3847336414863063, 1.6756304781304374, 1.1039544521542493, -0.9160159557081085, 0.8493429000882006, -1.7815293980140805, 0.8885132806412834, 1.7704418478245794, 0.7962630144426089, 0.3108316314851202, -0.5735821914681412},
    {-0.8738560775669959, 0.12423841500011995, -0.5277926825502158, -0.8892535389059961, -0.6556682863183588, 0.24623391523640575, -1.738375539642179, -0.35520465510421273, -1.0176611982237422, 1.0447098704103444, -1.5331640750210616, -0.31408746842110163, 0.6803692030927349, -1.9875289925130033, -0.5308429427520485, -1.5095231728017824, -0.17313070248254286, -0.9308643671196439, 0.07555542304619514, -0.6048169616360175, 1.3044860165805712, 0.1561191588429816, 1.2907128683541669, 0.726551080283277, 0.8134255897296213, -0.6598449301071534, -0.9204265163113303, -1.6028822377415985, -0.8819114985904282, -0.8300982953533212, 1.4882050377509535, -0.29387626328671906},
    {-0.6675386146816763, 0.19303781643206572, 0.2938099457313323, -0.8053845102685349, 0.8888329716824409, 0.24326311214453905, -1.1683436950312618, -1.4545781567488798, -2.0489101310058677, -0.4881027775864917, -0.6377923399318871, 0.33188030972326443, 0.009857579982216843, 1.4972807479101566, 1.3873223821868375, -0.9856459844012605, 0.7861707931558386, -0.520467816484406, 0.5882685765606419, -1.6762639214876784, -1.4434112900471927, -0.11576233195678595, -1.5413694815652395, -1.1179435405879021, -0.6107498423758139, -1.4075204684658116, 1.1280007571122892, -0.7886161853751676, -1.0473404628985348, 0.7746070806478085, -1.4743627111882978, 1.1116782321355916},
    {-2.1473001623291585, 1.4630946919336356, -1.4941368139787237, -1.6862723957154098, -1.1584956201982854, -1.2047048970854473, -0.9234186377584451, 0.1965144328841037, -1.6484446018818342, 0.49365875641641416, 0.7450934742283326, 0.3962800751694801, -0.7302942273473836, 0.4979806294858613, -0.3358674015016906, -1.608155070842395, -0.6578957339599565, 0.5678426195858408, 1.5450912233729281, 0.8375242888405074, -0.15026343630143899, 0.9680658552430127, 1.6699159001639572, 0.06585040778309724, -0.2896803327062014, -0.4521971652571377, 1.1478858367940883, -0.26101919643906807, 1.1240169474521424, 0.17687576632827737, -0.17298499359872221, -2.356314377382894},
    {1.4673398815329406, -1.4458594473524016, 0.8234230581503905, -0.049777231594240856, -0.8138610635021984, 0.6002597099680773, 1.9096823417168984, 0.928766736405671, 0.665785362576498, -1.1121417343493272, -0.6884533442926792, -0.3656337145326695, -0.8130713179517867, -0.855441365178885, 0.1358842696492127, -1.095510265703894, -1.32376693411639, 0.8092624694125683, 0.6107077080125587, 1.9301627912921189, -1.10549492919879, 1.2185256832367086, -0.925485322777891, 1.5081248844652797, -0.4157942300360991, 1.2442676347215669, 1.1728132278078698, 1.7317274641126241, 0.6079683679120877, -0.10144446368129355, 0.8264448069834811, 1.7458732183178685},
    {-1.4682166154582823, -1.762697835304288, 0.5697809656993608, -2.012167943951371, 0.45667605883307544, -1.3848316096428763, 0.9188251725177723, -1.634095326468545, -0.15395012608098246, -2.1919126497017913, -1.1052722745758687, 0.4234300609046009, -0.16266354957046758, 0.4014420720429426, 1.0416018245881156, -1.8734898238492401, -0.6776190750781477, -1.8175162833019063, -1.888157112953315, -1.4725299503814369, 0.31660873812541757, -1.0814073414615344, -0.577124435136432, -2.84837477584172, -2.0975119725165334, -1.648918617107922, 0.43761590663759137, -0.7141575064331898, 0.14822461187968972, 0.21969005147952314, 0.20493219076421934, -0.3771299161481735},
    {-0.9831289891003097, 1.466255240549307, -0.09593698964592805, 0.29285688340395327, 1.7883502910210496, -1.110726475289291, 0.028247506181295474, 1.081230145703267, 0.31362652391290136, 0.7363599130213143, 0.9750643561431701, -0.09100780575154269, 1.3807976479175441, 2.1826174377628784, -0.6412945158181171, 1.9038687446377522, -0.4929827716063816, -0.8513015365813627, -0.8032120052270585, -0.5751252900399557, 2.1369894771344518, -0.6125877533415516, 1.1628787093607726, -1.7513850238770643, -1.26739039200389, 0.42394435132775427, 0.3756321920967545, 0.5508624184373847, -1.0372594985417372, 1.4141447495974921, -1.2541296670227728, 2.111712754501717},
    {-1.4469560589331496, 0.5020180447164252, -1.2022216165662314, -3.5183523857220838, -2.0095023154048213, 0.03306901175892239, 0.4369469443867712, -0.6489623540633221, -0.25562726631803745, -0.5488691567671655, -2.979424254024334, -3.533023176919753, -2.1439051574171035, -2.4380348724426764, 2.8587179237846505, 0.001778430811918682, -2.156389998900427, -4.3590615560859165, -2.4254985468909402, -3.733147712749684, -2.540015519841376, -2.454965343677942, 1.1286774672190325, -1.2802621948370558, -1.9547707317329601, -3.3273268614813993, -1.3909660220883544, 0.8143403644807614, -2.5704876081258465, -3.3238493568247294, -0.7235229521203981, -2.0580750487838886},
    {-3.812944450153702, -0.3752069553608871, 0.2145980289982311, -3.896466028962352, -3.5383906368183937, 0.014188990690897558, -1.5414367467362804, -2.1598046128277453, 0.16230701834265324, 0.35322212016266835, -3.051600241423674, -4.921748174090742, -3.169805232367256, -2.244486168058684, 2.1943329532197406, -2.07257784728578, -3.355442282231396, -5.246562730241097, -2.2491218727738502, -4.563839701772632, -1.600795150881259, -2.16155176820735, 0.7454266910899474, -1.2043550299378394, -1.578994153583359, -3.2667233732243233, 0.6775035656331141, -0.013532748946187256, -4.30588748653803, -3.0375521308847167, -0.2868893223477316, -3.8402510370084877},
    {-1.2415993410672532, 0.4755432503604546, 0.7797036040284366, -3.2818154155267267, -1.8576449127246848, 0.7594963995494379, 0.8174896121653941, 0.04671945167134565, -2.8209227261712417, 1.8116390869420875, -0.5459487337497149, 1.3974782965011163, 0.23423988147164207, -0.10648339846161761, -0.18819961256797285, 0.29099555376241687, -2.9466944745872574, -3.479544172293436, -2.295558453595062, -4.175114090175683, -1.412953402843875, -1.7838258755730967, 1.1438700335060212, -1.6141355492866343, -1.9240954610169776, -3.5511796952858736, 0.24864535793376005, -1.092382664267501, -2.768587408779613, -2.381155694180419, 0.46453690480703086, -1.733423577315853},
    {-1.2922414179969515, -0.14346964762092318, 0.018128106713573428, -1.8092079395992477, 1.1775342893846739, 1.3882868638725676, 2.266368327594625, -1.6023524527345083, 0.3270909444822874, -0.126153952974604, -0.6744925764540182, 0.8954685696532403, 1.3774541254876278, -0.7791551597083249, 1.8743302915060862, 1.0104197135557018, 0.5982965518148025, -2.13145740057653, 1.7924000192381309, -0.9247060162720706, -0.8285797690195452, -2.6444200209532034, 0.7972114808410081, -0.9180808691082645, -1.5108800143862924, -1.578361448529959, 0.6074436964584007, 0.6390918561326873, -1.2627368533831338, -2.2605766271453227, -0.48609143800784615, 0.951703095384275},
    {-0.3942906219998153, 1.6115360803130463, 1.8393366711760994, -0.26505450634074096, 0.46666556497392814, 0.9157028951219092, 1.2145998444616537, -0.7877594395820381, -0.4141954018762442, 2.4758195448395446, 0.0675867630722614, 1.9027546646945046, -0.18295857248350253, 0.4422627526273439, 1.5602549751543922, 1.2623478117032525, 0.9693727583728386, -1.441296962678269, 1.6786297064266198, -1.4924453376052818, -0.18069925301193365, -2.2292302437841207, 3.0736424180590034, 1.2625670294940383, -1.9944361454882453, -0.03723966465385307, -0.8701806432447486, 0.9325035671067065, -1.2365684789870008, -1.4568295026890452, -0.5099497934627403, 1.3960375944090107},
    {-0.2789123622655086, 0.6162619902030868, -0.1767355165187475, -1.6821315817000668, 1.449285788866901, -0.8365068639782904, 2.2294038232887625, -0.9320665587424843, -2.084568603058788, 1.5410919240698484, -1.883535143241396, -0.059047081255393395, 1.8904731698962163, 0.1823468764091974, 1.2653365513428219, -1.7023362167649059, -2.3916268562391063, -1.4028168759887811, 0.4515008048455883, -2.3410290800697986, 0.8061517636457416, -0.8591568710029014, 2.565771381427549, -0.6928916953262352, -0.9036455128074953, 0.3391598049681006, 0.3072822164905221, 0.6485371030946601, -0.37496226716147624, -1.7964761144234171, 0.05940691177893703, -2.2258172396266827},
    {0.23964439909175578, -1.1632510762969661, -1.2178869998023074, -0.48137924322102915, -0.5893916992117494, -0.8636390330127924, 1.2021039949269177, 1.3814404354352243, -0.05564046045861385, 2.005197932081168, 0.7834958615972696, -1.4918477928621474, 2.3463911368114805, -0.5634175857458645, 0.5287176124772455, 1.5958340139377918, 0.45592105948049544, -0.7999654148976911, -2.1881684565461548, -1.8605937124208602, 0.8512191679472967, -1.966849974722557, -1.7746765158987239, 0.36440580364454894, -1.9303863498156257, -2.920752527476663, -1.1233438858011786, -0.2944040275385322, -1.7580306701509836, 0.5077443542284693, 0.022689010755219657, -0.9282108912698811},
    {-1.55989610714085, -0.7278408651925558, 0.3984470118052608, -1.017638963192764, -2.3915690550235142, 0.7356656663318419, 1.4339613308321628, -0.6997103168387415, -0.44087509027989313, -1.0971998524358384, 0.5784427421849377, 0.057277923824473886, 1.6305294972541318, -0.9320798938845376, 0.9590414222013309, 0.09943123619170068, 1.2816570824742344, -0.6765241310503877, 0.7485147071857774, -1.4871890222401072, -0.3581108469192802, -1.5287986559249955, -1.2719689316559033, 0.44929391807560004, -0.8472901677217909, -1.8246177967387749, -1.8988804271957738, 1.3943936296821218, -0.4295507620731811, -0.340506552760604, 0.664398522118581, -0.31537175403008494},
    {0.8798055164111341, -0.03534346907845405, 1.805858006723948, -2.0933717406077377, -0.28451351483225956, -0.0546408861237663, -0.5976627349974746, 0.7027605275405392, 0.4505098465225271, 1.1943074261479811, -2.1582739564822533, -0.4001145092245489, 0.08996085257764477, 1.8908861622063822, 1.3856420157789529, -2.1653758562609977, -1.680904655504186, -2.049166957314461, -1.2070115570084887, -2.6959533221966514, -1.9909058534285187, -1.2707302385864674, -1.5420215101444574, -1.806496227107512, -1.2370898756084179, -2.542563861721803, -0.4834416112112081, 0.21496701920974576, -3.2752689192683917, -0.7813798401029147, 0.09942509489714156, -0.7755558890230768},
    {0.13324176416769418, -1.7377734040361217, -1.2438188964378973, -0.5552269346339084, 0.06606728794164657, -0.664125072839353, 1.5656152396220655, -1.0597945808501066, 0.240780263745466, 2.192835537982471, -0.3377424453235935, -0.9775294674005598, 0.21951341446105496, 0.2995385310937772, -2.6924943672525505, -0.9003268379928342, -1.5330451123230324, -1.2467589343895102, -1.3289095443426178, -0.5596931265800692, 1.4359596964889352, -0.7736402369822001, 0.6049085260923975, 1.1443439741247436, 0.7128771525404256, 1.2454671230390226, 0.06506235585398523, 1.1181309743052141, -2.7397696005384318, 0.038457628363858944, -0.9884143969132222, 0.45540284520035285},
    {-1.0903463648742202, -0.15839622832385178, 2.4060160955009056, -0.3779363769330096, -0.5221834665173868, 1.784765158166188, -0.41465591154084036, -0.5927600762526557, 1.0272143076495457, 1.371342129011435, 0.3934132471145276, 1.7040609213648727, 1.0813193044321914, -0.28643179252509293, -0.3431471286052368, 2.3124857960516856, -0.24011321575186756, -2.5578972038801653, 1.7236792326089196, -1.4913519205606574, 0.3530810456201911, 0.604657945469819, 3.0302056583924726, 0.3657553720496093, -1.075076724329056, -0.49174079862485326, 1.5840324884583163, -1.3880075865424693, -2.08150647203088, -0.30712239600194446, -0.6989492094205543, 0.4236162652273591},
    {-2.4083015437797997, 1.697366580643331, 1.0589840739882772, 0.699283088836452, 1.129665195741049, -1.26365563823677, -0.08141680225593997, 0.7482619880497118, 1.0439948611682057, 2.416660364119965, -1.2618371546030334, -0.434732749097487, 1.8783187195502276, -1.5598556123757097, 0.005468439657862197, 1.6850119079746293, -1.0558310081587385, -1.4083492554497725, 1.1006059531098906, -1.4079424464710246, -0.8123450904233874, 1.1029296634070063, 1.9271027087996835, -1.0325849062067887, -0.46754404649473374, -1.1502151632014732, 1.2414939459573406, 1.4694675755827482, 0.268007492539539, -1.1882919079970784, 0.5763502705024214, 1.1695593786470713},
    {-0.4090674700339446, 0.8924076643079204, 1.7863619958910046, -1.327943271799059, -0.51523301645441, 1.5044786986258485, -0.402288147209662, -0.5244983133644986, 1.090021364110958, 0.1224250003140217, -0.25415372492173655, -1.0337986692364223, -0.016884074721797662, 1.676360847498764, -0.8239246597808636, -1.1170801914178456, 0.20382143129453992, -2.2328865682790604, -1.3486549273745418, 1.342038301970221, 1.2212901997149395, 1.4945112232902011, 1.8784411727384869, 1.0552039318432698, -1.2986220591204216, -0.4812946271789938, -0.4006740216148145, 0.5135046274274514, 0.6527721869739392, 1.4758365291337385, -0.600386915901027, 0.9343417591016298},
    {-1.6832128282946572, -1.0375681960713439, 1.4421313967712295, 0.1897703500373993, -0.2632326259646249, 1.3778083505057257, 0.6215845716494482, -0.14821642294106582, 2.20486860238952, -1.3682103675541415, -1.8882777426565676, 1.2042264988812617, -1.6320976791054453, 0.5905446649866445, 0.17526874761526964, 0.9813364885783532, -1.0557019117412758, -1.270530624951423, 1.1711740857406505, -1.9630184067944336, 1.612930131842923, -2.763938842632094, -0.44097112052401755, -1.420241458386708, 0.5682982572893911, 0.07896213993985579, -2.4640629502722318, -0.5078440866281235, 0.6410592858694982, -0.0021720095168879434, -2.2381516726655475, 1.6401403753783639},
    {-0.23130544824771948, 1.7423663326343661, 2.9113801063766687, 0.26362144796682757, -1.418707055894165, -0.24881465014503507, 0.633308864007361, -1.2362149456803009, 1.4209263513865737, -2.331313342835825, -0.4021021559177356, -0.29957831579673655, -1.3529458667812198, -0.2039314994380394, 1.4805577072426024, 2.642934188131103, -0.07182406543050401, 0.6459999036583648, 2.168215404858897, 1.106281773177166, 1.116531677029444, -1.1542476767746332, 1.2064089975257193, -0.603311235348989, -1.6349152787733694, 1.035281942319774, 0.6084859994706019, -0.5613552638484396, 1.5539627214086682, -0.16983439361463956, 0.28333476535607155, -2.1054319251027156},
    {-0.49529461212783193, 0.11260161365633413, 2.7467525271385798, -1.6339867645984705, -1.3866108595585915, 0.5122227726972949, -0.8856816283270103, -1.6722780277585032, -0.294564583489387, -1.8704508791088341, -0.815360910760565, -0.5196700838195387, -0.001296046550745076, 1.5293727231915089, 0.8469678354965192, -0.22837385804081262, 0.03866419547943514, -2.2707710301475297, -1.3149282648139198, 1.0768727123595028, -1.7645266358460976, -0.45735691745195695, 1.4681035892103134, 1.807731382262291, -1.2545475871222684, -2.1552515603664184, 1.2840519448600072, 2.6338448662038445, -1.2088425861317993, 1.0454266270444164, -0.06533892151567036, -1.7111027712008264},
    {0.25127688318729846, -0.22073477519513401, 1.7376248864828046, 0.3883144346959888, -2.794801940398626, -0.5819751686793173, 1.1309719590305016, 0.4899631915896953, -0.32079732556736584, -1.0587374563285745, -1.084993705965489, 0.7096819819475457, -1.2603316748239337, -0.37815481258908895, 0.6057116434852933, -0.050013285491975576, -1.951811140957136, 0.6478155547888443, -0.1069239836555288, -1.824824076158014, -0.7080920581361275, -2.7330258598066495, 1.386460919691478, -0.44904383149148336, -0.8108455338637653, -2.016867717558896, 0.1437803482040342, -1.4848709167317569, -2.0602626559732222, -2.387015933955546, -0.5411146624349901, -1.1603843847430673},
    {0.6576510446456871, 0.4556880145714383, 2.750843219395322, 0.9232200593107203, 0.4243495992964183, 0.30107956409834935, -1.465564625394705, -3.032966324262966, -0.18287435129462368, -1.7759335871696194, 0.571080043159941, 0.4947682591205963, -2.669793505459343, -1.9517098212391484, -2.3015597605512594, 1.1330550913872282, -0.21227370745764412, 1.5842328517807494, -2.307046152938735, -0.7999334921202673, -0.017527927993162953, -1.2804472776947797, -0.1903344770926462, -0.3618832133428113, -2.0255030923673027, -1.5840972434932294, -1.0433168194736882, -0.6955807014076872, -1.551671713192655, -2.545580264849846, 0.710329123671218, -2.202493243670829},
    {0.6819839546893002, -1.8608192594048685, 2.336030262824383, -0.82952786596411, -0.34996702013782116, 0.6967879681873644, 1.1543645253514616, -2.4788663016217196, 1.3045242499027674, 1.2886010162712576, -1.989754615290957, 0.4468110795209295, -0.5973665126478327, 1.2665253649263786, -1.1657887925469672, -0.6234745699603054, 0.36866705615290474, 0.23133571025347058, -0.5747895145361956, 0.0654512620608883, 1.423454552111076, -1.5686161640482235, 1.371303778837349, 0.5282827106650134, 0.6949413537111002, -0.7093380300018595, 0.0574507370336507, 1.2399634271245323, 1.168783041839878, -1.661379545377775, 0.4506225114457534, 1.7438318854954198},
    {1.2977080919548007, 1.7712469921285368, 0.6439328072805134, 0.6166162022450078, 2.163228217937306, -0.9043042187716905, 0.7713041790242801, -0.458423594831597, -1.5332406035513633, 0.9391711848803327, 0.8681375461308652, -0.25497707520238133, -2.070796889114835, -0.17197469828371964, -0.17061040711808798, 0.16534868656432117, 0.03566418851430154, 0.6179482473572832, 1.0601895817802938, -0.5367631416976706, 1.7104816055809835, 1.1309325639234442, 2.069347960426957, 0.3607433260100547, -1.29380149689426, 0.28567291521396354, 0.5047015069569232, -1.3107590096188675, -0.5426538326735552, -0.15604268198258522, -1.927367878238949, 2.172944124179647},
    {2.2782686415035363, -1.0186976294900227, -1.0199793127685757, -0.46540952302529986, 1.078485448628546, -1.0946909487644418, -0.7109394547234444, -2.872509548810917, -1.5251692769667797, 1.1147474281574357, -0.32079732567482483, 2.326717725272207, -0.20067489659186946, 1.7497257940528799, 0.19707655623788783, -1.493726493216538, 1.3758030582099432, 0.7719734453261441, 1.4582746360437142, -1.9375984590404673, -0.788135060742933, -1.0331665238825694, 1.1378218596587946, -2.1353814581798356, -0.16752709927681203, -0.3807683563400306, 1.3851114877329438, -0.4214915318760262, -0.5145638736964008, -1.7352206986229866, -0.44640212475097335, 0.37348593778817946},
    {2.05945961964348, -0.4583960086513012, 2.2196588546637472, 2.129891406220586, 0.6099247480584431, 2.7623143828380634, -0.2026820210544438, -1.6921327973404503, 0.11105457123264185, 1.4806252533723367, -1.483071094648663, -0.4877137855436386, -1.854145325333366, 2.199153543472694, 1.1875178464967822, -0.2722945993268197, 2.6093228089638667, 0.0009756951482171967, 2.9256612230962964, -0.6805974326088967, 0.2576333874746737, -0.24528009483660593, 1.9988920726609767, 2.3097772232099194, 0.8962612233571543, -0.3924484297435448, 1.936087808303896, -0.3558696569439773, -1.0202173928581852, -1.3957318077237328, 0.2643715274116971, 0.27455736564740607},
    {0.9995970331096122, 0.9381556860882047, 1.918962255677377, -1.9118094172975622, 0.12990435985929505, -1.293103007282076, -0.8766522067672721, -1.5465949985114344, 2.176905714416999, 1.7708209954464498, 0.7364297419825626, -2.389388773157451, 0.6992772058623139, -1.643834021944456, 1.609814112622455, 0.5878859719221126, 0.9158685893616965, -0.551578775117137, 1.5693987372155505, -1.1179723920549323, 2.0992421489984587, -2.0675073747713966, 2.1821381915198645, -1.619084159935065, 1.1210924728291967, 0.9078452466804657, 2.0277895985818355, -0.6413631737160788, 1.7008745752265741, 1.094717964602205, -1.578962630396827, -0.26640565569617414},
    {-1.5822825771246303, -1.5922789723214612, 2.253479554742667, -1.366448889093723, -0.6477690706065584, 0.44318350851319216, -1.435053557763063, 0.5380159375840315, -0.22574497642451327, -0.30857000852044436, 0.39274018869363125, -0.8471201893919964, 2.117724890352254, 1.579195815895851, 0.2571654782162254, -1.3503656036578746, -0.26531704752217894, 0.013714973207426392, 1.5758540853720102, -1.6835953373734491, -1.8108892478192307, 0.17742183590001712, 2.207403961282886, -1.3633436917903883, -1.5696181430051257, -0.510144961902308, 0.6298951808422846, -1.152661384521438, -0.9293445488327149, -2.0050798205961744, 0.20934923560113403, 1.6825324614438744},
    {-0.8992587043208021, -0.28794763103983484, -0.6519142811482815, 0.6053852454661103, -2.0940699616400584, 2.1095775229723857, -1.6889064961156808, 0.41589773731289315, -0.7221396046327132, -0.4526631071959119, 0.3438849287321503, -0.10618609161040816, 1.4136531115426274, -1.5476514346059722, 1.532539004104577, 0.9567440740334939, 0.11453704265985097, 0.6983747262079272, 0.7609645708533685, -1.8278066306757073, -1.291196721478548, 0.5508967084615929, -0.17922050299919035, -1.0909801731827613, 0.2777869435580284, -1.485165334621223, -0.930155688465435, -0.6689729611654839, -1.551959189739566, -1.5303771374301502, 0.9576536642228696, 1.5006825299856028},
    {-2.132301272232581, 1.3575986664510586, 1.6976250695199477, 2.6124527455210846, 1.5822597127153977, 0.796746999422697, -0.9087711004048151, 0.006084703486609295, 0.15532027053912964, -1.0503112988911938, 0.4598319999977887, 0.667161768475256, 0.8382066548060744, -1.2025843652953412, -1.1168127322023684, 0.10395917775756651, 1.6491299455691912, 0.5997631650162192, 0.24275246306957154, 0.28421385959183376, -0.9717725828047277, 0.6560684550198997, 2.525222743089956, 1.180670309871443, -0.8920638600056326, 0.9402356721834182, 1.5682236609277926, 1.2188574489657849, 0.9883349687106083, 1.3459218829257968, 0.07283908246053471, -2.63729860998842},
    {-2.053865030347636, -0.8587983821701654, -0.9736506667142315, 1.030467802502331, 0.2873803092127214, -0.5825027233581452, -1.6391588428536745, -0.4908334632596171, -0.8304650988706591, 0.6936712753795821, -1.6442954961571927, -0.6569884922831766, -1.824156024373061, 0.3257290815130848, -2.005089653880919, 0.9964111474969971, -2.0611700058893088, -1.2982609480759972, -2.2627712728808027, -0.2698982665104694, -0.3745001954148004, 0.21412269487639482, 0.411530730524453, -0.05914957744466074, -2.132599764580687, -2.658361352915826, 0.23447577595449276, 0.7862843095399809, -0.6572936014265591, 1.535122223378644, 0.4022285050907163, -3.245335468745352},
    {0.42939181407112215, -1.4001045919902186, -2.231130409353278, 0.007705093216759279, -0.37272546987082, -1.8693994458996246, 1.0826979336276297, -1.9747157857633661, -1.025904182046225, 1.8592288840880495, -0.8274694371670688, -0.6737896614144777, 1.788922522790751, 0.28266502894227596, -0.15027564883110692, 0.550760125093631, -1.0496260142282732, 1.0334805240027929, -2.3476229904611623, -1.2743563499575343, 1.306167296468434, -0.309201430039459, 0.6745664283073693, -1.414436989512338, 1.204477576821941, 1.246760810116127, -0.3861967323361383, 0.6120151622127429, -0.7348926095380958, -0.8088748046339395, -1.558739913089346, 0.8811744894319014},
    {-1.8649679214135009, 1.6412802224109568, 0.1523114191306559, 0.3728891049217209, -1.3779423895849645, -2.155631373319794, -1.72595626192162, 0.13509873761852503, 2.3483614650789173, -0.9223569659350542, -0.985550391512283, -0.8940205208481331, 2.1770178522824533, 1.1554244477333944, 1.9445339363836915, 0.9437539622712593, -0.5524838834868421, -1.4573665747838673, 0.831177295727141, 1.0013746596923532, 0.8186275311833086, 1.5264347147249981, 1.3823659723779262, -1.2800437944524068, 1.0594071908039586, 1.427533709937028, -0.45989396052866216, -0.6298272904782908, 0.907273744253415, 1.0370309300853857, -0.7672148970100622, 0.23423937178612408},
    {-1.0515454129948918, -1.1870044122574372, 0.0785416016524623, -1.288125690295248, 0.2699244189634448, -1.1292609164836638, -0.44853126846278507, -0.6574376951023078, 1.2301171781509532, -0.31592421944530996, 1.2214949895231286, -2.1606373799900975, 0.31029445971372144, 1.634462498104577, 0.8720255886903951, -0.5392308542827337, -2.436685382449745, -2.0931919547414797, 0.951146621110526, -0.11980451971185696, -2.5176546644115407, -1.1180728064703036, 1.4097023434233915, 1.741760024682475, -0.1460398158255755, -1.4934311018336885, 0.4857714296700524, 1.3279179647731987, -0.028309071873358464, -0.2809466506872986, -2.152977467211859, -1.4475438686824773}
};

static const float b1[32] = {7.9693912758404135, 8.280435019497828, 7.873863323448282, 8.00153211141875, 8.14036819754216, 8.053629440411562, 6.911597962311687, 7.204233263603438, 7.931038285736092, 7.831851170900536, 7.311490040889642, 8.200356852322644, 7.4304677942594894, 7.907625160033326, 8.131078084877394, 8.029194384453387, 8.040007945492016, 7.954217129329256, 7.998190486025077, 8.12563324109616, 7.89797409744547, 8.084791488046314, 7.666210874613347, 8.072279077838122, 7.4532226286505185, 7.835588127674986, 7.820322971242162, 8.298250490539473, 7.794272408519067, 7.727205385138917, 7.796954227600961, 8.185214160745572};

static const float w2[32][16] = {
    {6.415346691706595, 7.398336098682987, 3.6839835059559496, 6.849097526345202, 6.933919431085768, 5.5803539753849725, 5.188819963003634, 7.388228154872996, 5.800177205265474, 6.607487844323869, 6.563773818974073, 6.403732956474772, 0.20337120083161897, 5.46045485365338, 6.276879549044018, 6.329163033090677},
    {4.858480794679741, 6.895242713157375, 4.024755483742322, 6.426378765443185, 6.577493598959355, 6.456233221389218, 3.371112320842843, 6.132403042372492, 7.159182725224968, 5.638898915756679, 6.065193102261912, 6.307275656523378, 0.30389243337382715, 5.426056978783688, 5.184826989303209, 6.574878029659869},
    {6.159239491144108, 5.598981213880922, 3.80272640852928, 5.77009686126729, 6.985186908267797, 4.9139740479069465, 4.080140263748498, 6.331275528865799, 5.879969433719346, 5.947771060773587, 5.620189343179607, 6.037810696675743, -0.6945460952892449, 4.387003273244198, 5.571744885448237, 6.485051094948947},
    {6.441670400850308, 6.899571476080968, 4.302378524291885, 5.893924748864892, 7.21506264993673, 5.715854331126662, 4.678668282044163, 6.812588189263459, 7.1137830659788746, 7.334531769588745, 5.574709799737986, 7.116744397536093, -0.7720602840750848, 5.691103239999012, 6.118900839652458, 6.492881597840792},
    {5.0817468319403325, 6.60206640668838, 4.075650680928253, 6.710989057074901, 5.80283560815249, 5.308013189422828, 3.359939662053296, 6.2350186063382305, 7.2700881738512, 6.81796804761081, 5.416465186251283, 6.681757367908964, -1.0657943406892298, 4.706674065186979, 6.1743795874821314, 5.382403063098282},
    {5.401861168996221, 6.465652084197701, 4.9108860808744765, 5.612507066101636, 7.361309065764074, 5.421524825223712, 3.590900607071628, 6.343039717308894, 6.355121549218047, 6.141885748197531, 6.310991935795695, 6.117671124974752, -0.8560472098302792, 5.977072932735301, 6.758080063681847, 7.152155123581624},
    {4.950333160730545, 5.384945639951007, 4.695967213451061, 5.55145778878736, 5.717460034623914, 4.576211034793316, 4.468745581276325, 6.333055843344711, 5.732490627631682, 5.927844609031929, 6.028988923766491, 5.722346076078207, -0.522973693935023, 5.325705267103285, 6.188301412130983, 6.26152554832415},
    {6.246138926727676, 5.67358978340146, 4.707496683546407, 5.905673262365944, 6.3691699348470125, 6.32364323744541, 5.102513024757217, 5.872224493097738, 6.067426605384313, 6.250433684725518, 5.529693706917419, 5.96989146622482, 0.04690852927292469, 5.453047629413838, 5.798322416505349, 6.464259189183768},
    {5.11907329897961, 7.371524491307019, 4.20397955836391, 5.821343878338292, 6.456478849269511, 5.465229410297099, 3.600386707232951, 6.347283979335872, 7.2133885667398605, 7.190994198004389, 6.0943417733036025, 5.7805968508587044, 0.35753777758054145, 5.286415223157724, 5.927431658918413, 7.026444075482947},
    {5.868892423366305, 7.346745734221975, 4.249782721731001, 6.776476155482814, 6.490599810519165, 5.724526598387885, 3.4925428752847343, 6.964307586184116, 6.774942087496828, 5.582018544882443, 5.870522941178801, 6.565566696823729, -0.1407216469741382, 4.979919318706238, 6.335930806162004, 6.781933200868076},
    {6.6417215794312545, 6.179695322897498, 5.041917261814045, 5.723724917307205, 5.97514906540909, 5.239779015183416, 3.368804634623418, 7.236236087565349, 5.712815466594558, 5.866500429460133, 5.544349098697073, 6.901563066034866, -0.8871216706231342, 5.365058476431305, 6.588390707632423, 6.558639488922239},
    {4.689592162480708, 7.101468199355451, 3.8521893260667883, 6.14204805836512, 5.887513704526975, 4.554991623018534, 3.747192851742932, 6.909909527101669, 6.004543714921583, 5.700932628659425, 5.777578033059953, 6.381350590244569, 0.3709119605025624, 5.625231192095304, 5.467984725473282, 5.548179144303522},
    {5.391174321139793, 5.48395154249808, 4.02501533293896, 5.063053626240877, 6.262823505607236, 5.477489111652715, 4.328873379422795, 5.677899365069557, 6.7245931699599115, 6.748458889064434, 5.5437786984052115, 5.384308238873006, 0.3427580965215787, 4.539989569433691, 5.993350837678715, 6.191537222827127},
    {6.5499124493804395, 7.326836243382321, 3.932194091503501, 6.547168434270417, 6.838151956032238, 5.226185023409396, 4.957444569248837, 5.497915962211651, 6.762414885849722, 6.942461260508028, 5.395210562475147, 7.106160397216396, -0.035136964532631175, 6.331179284288636, 5.943847508649509, 6.997941057074921},
    {5.148990606411158, 6.97483311987414, 3.6520188281333503, 5.581513700836267, 6.3157249962169795, 5.779517797872054, 3.70905002381363, 5.832957591213276, 6.973240513468643, 5.674125513668785, 6.274138275053681, 6.470399826495478, -0.8162397112997454, 5.3803170186027005, 6.341390001350439, 5.684519147280897},
    {6.002993307292017, 6.714053779674487, 4.204908533714632, 6.275539825960443, 5.749644243663733, 5.610867607181753, 4.50325467875404, 5.556261436714957, 5.6948639547084685, 6.1825236850853535, 5.875612487691165, 6.22567508404291, -0.23665190267520356, 5.20567540960074, 5.404538949705009, 5.204895272141011},
    {5.902629517158969, 7.376864370211858, 4.200410587341594, 6.0324292488603355, 6.313294142009791, 5.276242056600487, 4.670310543226588, 6.328171468115366, 6.8783741851075515, 6.61835322701046, 5.699090498913068, 7.039418147426611, -0.6750597700495433, 5.267442967712163, 5.861195447754187, 6.4498929004795995},
    {5.547455368956125, 7.132789942712817, 5.219067706546667, 6.451522580799645, 6.80446653239621, 6.246548931187535, 3.319105965026336, 5.5226294037509, 6.782909181424182, 6.147041380555928, 6.816165171166099, 6.507591298103529, 0.3059825645097519, 4.640239524179046, 6.278431013399987, 7.008247423160747},
    {5.542900055316871, 6.780730485069569, 4.919380872702426, 6.373741283145161, 6.863326923256173, 4.788448917525496, 5.10972423882442, 5.861492568742551, 5.425473771388616, 6.232862155793795, 5.102115197339816, 5.894024344395904, 0.5113140183500231, 5.3425588120677086, 4.96489159298428, 6.400738959585461},
    {6.420637089903317, 6.550617061119534, 3.9334841006855585, 6.2494273850466495, 6.459856731987254, 5.289682363927328, 3.443343223950205, 5.756560735281279, 6.177755036218579, 5.8656963935822946, 5.705266094686926, 7.1577180313006155, 0.5432504939036544, 5.366620887825983, 6.719574048730194, 6.41744903096726},
    {5.028266002068485, 6.059971230015908, 5.333251816805838, 5.600215930415388, 7.27331392240286, 5.476202157580083, 5.183009589090048, 5.642392608277936, 5.632206973765672, 6.537514248381361, 6.877399307237158, 5.995702902890085, 0.537539487108714, 4.707531377894112, 4.895334422442935, 6.881909112231736},
    {6.4476955424399796, 7.4138943717286905, 4.63863677298034, 5.256067985758285, 5.836512038135839, 5.500437871221493, 4.4745762130532345, 5.5168488412629895, 6.276749625509381, 6.625532005925147, 6.862369783476075, 6.587335359468493, -0.5590653590150562, 5.65887291004219, 6.132743034176768, 6.15413262990301},
    {5.433911914419107, 6.712185168516385, 5.022403744687475, 6.2574257411518275, 6.000071901350139, 5.93795940947248, 3.8867062102729752, 5.261366591951301, 6.322959881603538, 6.775111660417148, 5.362199476852597, 6.64421754117283, 0.12271546548272139, 4.872893408934365, 6.045690504040125, 6.308855485006387},
    {5.353841270646752, 5.771791727162639, 4.950089122795168, 5.742168972754021, 7.461793375597001, 5.104070421745899, 4.433741971090356, 6.58841813250762, 7.108445695938772, 6.464904760474539, 5.668711584620478, 6.227024439291209, -0.8334038214902599, 5.642709517750722, 5.470759890480563, 6.755375366876715},
    {6.549155866606069, 5.672078599292543, 4.410451914662314, 5.484521522847353, 6.2521616978033485, 4.940347715255741, 4.266173396029411, 6.3247369621591325, 6.4666965830855965, 6.721100439511854, 6.089934829569081, 6.942232016146263, 0.17386883054366561, 6.04222127018988, 5.66105681137287, 6.21435724154561},
    {6.28601544067611, 6.341919202707279, 4.607884635965782, 6.5946564305058395, 6.766530667389933, 5.102639459176583, 5.0392862505087255, 7.184391913420143, 6.695692138281501, 5.828380610675369, 7.172681483185434, 6.848946354785858, -0.9188102000749037, 5.269581597080515, 6.057029494534387, 5.862937863979213},
    {6.618231605923668, 5.904841274882396, 5.564458467779033, 5.322573838370655, 6.748383908298358, 5.194292867067913, 4.401783312841228, 5.5289564555366075, 5.8097900118853065, 6.766724396361273, 6.774755839647246, 6.228832559011572, -0.7427172317985966, 5.334442662231095, 5.727708998290534, 5.543563776915916},
    {6.11009399385445, 7.067727608946632, 4.14391359694012, 5.754544849936336, 6.694119128756121, 5.604241279705667, 4.8490795727957305, 7.0618343189160875, 5.816436870152291, 6.219230295215092, 6.80338132896144, 6.149725949070726, -0.8144646042962606, 5.00058458020658, 5.384778641694173, 5.788632298734855},
    {5.9600185630889735, 6.266144204846814, 4.762140597904878, 6.6862329493545545, 7.261334983003958, 6.034919713721281, 4.510293959893416, 6.997540453007806, 7.305457221195457, 6.014062448155487, 6.3799613992044195, 6.472322287337101, 0.7629436079739345, 5.475022368269614, 6.670777079311713, 6.627566517539926},
    {5.123739743711795, 6.506668411705009, 4.433554386674447, 6.642118109268826, 6.398470749783377, 4.925941369419535, 5.3094220149936735, 7.167528947128702, 5.811803682422992, 6.723712737593866, 6.074926926835481, 7.338962907988876, -0.8051295756380984, 4.482385431909801, 6.467579294974242, 7.08713299722793},
    {5.566204528962811, 6.185969479922692, 3.950840711194203, 6.6375671081865235, 7.18004440981364, 5.152365087134406, 4.99036002574594, 7.137071846257273, 6.199334463104729, 7.584968913027289, 6.153012240558015, 7.318119802726908, -0.9047750023836097, 6.3947911868683605, 6.432921300083919, 6.5988984684380965},
    {5.901260875983779, 6.546040278351152, 4.715675404904778, 5.915515362822725, 6.341892197348866, 5.905354900795413, 3.8211324545951757, 5.407772690086515, 6.318090665864096, 6.508791176079914, 6.320398927877768, 7.277920629359197, -0.6170807311040635, 4.163250335029095, 5.972419277821057, 5.688258983709314}
};

static const float b2[16] = {6.267733908316438, 6.825879361098028, 5.404218302900071, 6.379041207982598, 6.910893373028915, 6.150908657935959, 5.041015881118569, 6.8706735601437, 6.745195934525871, 6.791344026327455, 6.678987639971541, 6.687566645502988, 0.08703454869142066, 6.024168334013734, 6.482682426331367, 6.5144532846743815};

static const float w3[16][12] = {
    {-3.4549292199247623, -4.24300864670718, -3.537807383697513, -4.800961879408639, -3.2510497786323915, -3.675500917898905, -4.040480971376093, -4.285915241844356, -4.719707394661583, -4.806571483650739, -5.252396333518866, -3.8891231355024054},
    {-5.817550166363975, -4.4636898968659064, -4.265709230812989, -5.217280087538258, -4.685237420520263, -4.925487836685227, -5.1981804787355035, -4.886286607292059, -3.8667981004158114, -4.9140001762575976, -5.1983442691658395, -3.5917854599713377},
    {-3.6949642524423627, -3.1860680143959255, -4.373213214915776, -3.342782720024316, -2.940492584465157, -2.999517336474055, -3.5445158399211247, -2.15892213817116, -2.37784819362578, -3.9419323490027933, -2.8792398971315745, -2.887988190109854},
    {-4.397016778906795, -4.051041163581552, -5.048810130786813, -3.412889371108205, -4.744397414792011, -4.371878669381635, -3.848875158635759, -3.7283242806718966, -5.289083103782537, -3.98319341402566, -3.8990474457535567, -4.89981623150742},
    {-3.9099069301028173, -5.167926606424883, -5.199850259381982, -4.432441757470872, -5.060100057203992, -4.749773763580699, -4.566228091478071, -5.202279411913962, -4.560668146213571, -3.518779419710746, -4.921569909810704, -5.122385053593473},
    {-3.288262809861351, -3.9586900271596273, -4.3170843465415425, -4.892634337682279, -4.646316779073495, -3.3274952154384225, -3.3893145037834214, -4.739768879712979, -3.298734220946342, -3.984159320648299, -3.3349727357454713, -4.436842536202211},
    {-2.755761397124156, -2.5536201254340525, -2.95611780092152, -3.610559502757051, -2.2872101934153273, -2.3850170231550467, -3.4167392480380645, -2.713023151635742, -3.6065737008342214, -3.270515653215268, -3.2978430437951927, -4.097594785329781},
    {-4.119173370522863, -5.38918708142691, -5.082721313838782, -5.0855069792832595, -3.8319233852574546, -4.238723290681015, -4.679215127258892, -4.746396810721126, -3.8025050991251175, -4.279110228733211, -4.191763455236264, -5.0317310561184865},
    {-5.564143939246304, -4.654696589609208, -4.2269049330742225, -4.464936704097419, -3.8249295276748487, -4.6907703650017805, -3.5827056774172568, -5.090122744757173, -4.692408944023083, -5.0682691912364985, -3.6978820920217776, -5.490249155773205},
    {-3.914793675948596, -4.512204237932277, -4.872433240116916, -4.922249660366789, -5.676759374750168, -5.671049848376742, -4.862150061173139, -5.589652017842512, -5.574066057225716, -5.309077871323141, -4.527607660774657, -3.618083159182543},
    {-4.893977029630997, -4.083835870967921, -3.370233683411881, -3.6498858290040017, -4.706359216466704, -4.735954311084666, -4.930894573283312, -5.135234243601837, -3.552573093919439, -4.384950175909499, -4.119684164102076, -3.7253556886834254},
    {-3.9865233893860186, -4.745504163515438, -5.370117209650218, -3.5035742003664434, -4.532646673708245, -4.775055270532165, -5.177977715512356, -4.308531616996767, -5.545777118383016, -4.254143843505344, -5.5220910970617165, -5.522161166729161},
    {-0.043709719682147076, -0.7799128684000005, 0.5739529767560397, 0.6869175367519799, 0.8031908729271121, -0.08045423543444359, -0.08957346168714468, 0.21225868965217565, 0.45472397059000724, -0.9078201096179368, -0.40350226925799104, -1.2141122174921484},
    {-4.821403235122806, -4.79105102889111, -3.281486917150723, -2.7707144853469723, -4.516359967121909, -3.594530819634133, -3.850952280678294, -3.6748041924676227, -3.9317315709529446, -3.254871673915486, -3.4908946167032795, -3.2043040020101827},
    {-3.768244456671226, -3.938186862820991, -4.842723955520624, -4.733381494400888, -4.555005562148931, -4.118969780095355, -4.856668539868671, -3.4962183916339664, -4.098891671764079, -4.274468426102609, -5.0140060299884945, -4.917022305928712},
    {-5.65278335076439, -4.267234296791106, -3.509435616067368, -5.464363597941395, -4.618149992116754, -5.298365902064223, -4.298240459289656, -3.873050840061468, -5.059978905790673, -5.0502971567719435, -4.601343911011008, -3.855224330740846}
};

static const float b3[12] = {-2.778091406960379, -2.8073167228118354, -2.810933105037228, -2.8187785964601977, -3.050863960666194, -3.1252780920934744, -3.3219922458319187, -1.9470619695886142, -2.4736355314834695, -3.10851130594359, -3.2648935094584512, -3.1266050404993044};

    // Input Layer 
    float z1[32];
    for (int i = 0; i < 32; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[16];
    for (int i = 0; i < 16; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 32; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Output Layer
    float z3[12];
    for (int k = 0; k < 12; k++)
    {
        z3[k] = b3[k];
        for (int j = 0; j < 16; j++)
        {
            z3[k] += z2[j] * w3[j][k];
        }
    }
    softmax(z3, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
