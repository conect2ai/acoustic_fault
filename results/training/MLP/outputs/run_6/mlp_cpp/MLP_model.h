#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-3.1765719260179073, -3.7881230935857957, -2.370956089014725, -5.546220611877535, 1.2947165543746433, -2.042469929724835, -3.591720030306253, 0.32440420863527103, -3.4024739441747482, -1.0982921923434483, 1.57106281230573, -3.0306958402685105, -3.8193007034614292, -0.35157669230737243, -3.671146345620141, -2.7258227011139975},
    {5.1770829953718325, 4.411155654495477, 2.4874258622125236, 2.745502498114495, -0.8152849551554042, 3.1652556974901094, 2.7837064816155577, 0.8282330441844338, -0.20900461325663441, 1.2668812043699709, -0.9665751879564578, 4.126577144194771, 4.235753948404075, -0.9618340582741844, 2.0814429874335754, 0.8813071355441942},
    {1.6686598801876715, -1.861058822621688, 0.18282833689406763, 1.0336924805119545, 0.6231246969291608, 2.616436859807274, -2.300890014477222, 0.4906056678431105, 0.6196935660962702, 0.04232787553066425, -0.3995770497315025, 1.9581462178051978, 0.5830576789785351, 1.8207895152889533, -1.4485101346296154, 2.5248088467848113},
    {-2.3663414002581122, -1.2768151733130315, -0.31375716058312664, -1.1188628154486344, 1.893984538341258, 0.8651331999640864, -0.18143897668894673, -0.4290668367764788, 2.1595619193677953, 2.354631496778101, -2.2366339421459083, -2.0130891873528554, -3.5609206564723923, 2.8010134752757776, -0.4334189083601849, 0.6889742242933604},
    {2.8393846992986886, 2.8046060807123965, 4.097743537957612, 3.454681775431747, 1.6360551066001925, 2.0196403158370697, 2.1737845716574364, 2.1957686463588217, 3.545064789470431, 2.6529526921209077, -0.25947284119970926, 1.7549241493235739, 0.3380503558169316, 0.6431120067856623, 2.1818237764049617, 3.7026834400205693},
    {4.123429397321327, 2.9514873230935934, 4.697497663070729, 3.9389328722839227, 4.85183095494116, 3.862591880883753, 0.9917576317507364, 3.9072628609785043, 5.376842541989778, 2.7255368679803906, 0.7164893868366023, 2.6597482927914853, 3.111679938629453, 2.9467398418907678, 3.5165871982138346, 4.556037474339895},
    {1.4853770146035785, 2.8155291550168915, 3.622125910265538, 4.7992820266208565, 3.928036365462824, 3.87851612030677, -1.0255841554846608, 2.1084519624763964, 3.425244968299534, 3.666353300246117, 0.6894572798203604, 1.947833425590565, 0.6837068345985474, 3.2364058830931346, 2.9741653969428192, 4.528924091474391},
    {2.3117424208471835, 1.3069954778644108, 2.6542589270400425, 3.9073329003600605, 1.001713665190093, 3.6291949476202765, -0.5126812222188163, 0.11414578112293608, 0.08666072072713227, 3.024257615441991, -0.37994358554640967, 1.111702247954998, 1.124479772509564, -0.8988201532470211, 1.1817208646548323, 3.7042937111650573},
    {2.167977089066887, 0.18335097931988545, 3.885550887484866, 3.6932835874307743, 3.6472228180409823, 5.083686657886631, 1.5968870751987967, -0.7513257034864483, 1.8753964239017598, 3.2590531466606056, 0.7594308776379809, 1.746706089179629, 3.034263792719734, -0.46499344682440924, 3.0256733699083327, 4.9050827602191545},
    {3.2661609411760857, 2.295369820023667, -0.8340554725060393, -0.42848788699310775, 0.7433322677032405, 2.8077149493005713, 1.5075936255315545, 0.01077394620850509, 0.34118859082157815, -0.24029073942682988, 0.33975800387798977, 1.5838918207407957, 3.3015822645902735, -2.2606805836416353, 3.1822809126789324, 2.255451752687522},
    {2.2577966883332463, 0.8962232153770088, -0.9620720835107707, 0.8685704008230867, -0.3528104948600547, 0.9565916327669038, -0.2933355041366623, -0.5621189392434227, 0.6339726987384873, -0.8469909843004764, -0.14158189349760747, 0.9670501155769837, 2.609032706643972, -0.02699738335745944, 0.43048609413730754, 1.9566719529454264},
    {2.288248607686525, 0.15410425032802288, -0.37131968057125847, -1.2226126665176609, 1.1540507487635672, 2.4027725695767312, 1.014077579233026, -1.4623827297682392, 0.25806265358748565, 0.8915109221244103, 2.116103456678867, -1.4007080312376639, 1.089077532457094, 2.1311072277223326, -1.1987828626209167, 0.9656491554956648},
    {2.595021623569251, 2.4446492619979243, 0.36757652751637404, 1.611238527611778, -2.328761841573302, 0.43696134247786583, -1.482901344025635, 1.3677865388273034, -0.6641809141098172, -1.2760492276837565, 3.2284317851752, 2.6147191560933334, 2.504954403643657, 0.5313243247512471, 0.33942880070726206, -1.03913192016048},
    {-1.0565108584457397, 0.5963530417351627, 1.6288743510824342, -1.3761108077276363, 3.7237908034619402, 0.9996865203868766, -0.28040038724580063, -1.9548338473086948, 2.0878573573866843, 1.0801640974490738, -2.118734867772787, -1.4887493908645502, 0.9716651344834508, 4.357772730205599, 1.3966896523294559, 2.016388090129037},
    {-3.6882324495172103, -3.0569451595916006, 0.7466669134135211, -2.9043152989944474, 2.9604938980358075, -1.272518955989301, -0.1468795913221083, -1.1968012805615538, 0.30884716778949756, -2.3652073447471684, -0.310438858326882, -2.525598898819045, -0.7811210666914419, 4.225856411885575, -0.8433136739427196, 0.7138784447661063},
    {-1.3507294875796332, -0.35982846102585914, -0.9706632023112411, -0.14438742763048226, -1.3300818497138793, -1.9451385331588937, -1.6381975645720568, -3.3922556691994745, -0.46842920902757285, -2.3023677385627708, -0.5406688814533144, -1.1054000083498616, 1.5104282933982855, 1.3338045684230955, -0.0681432136573745, -2.7193425576004198},
    {1.625164455343645, -0.4615071042420845, 3.6281996482806353, 1.9608461763126643, 3.213469014084495, 1.8316359298536589, 0.28337011822469665, -0.644141526107062, 2.721292309818377, 0.5553942785945949, 0.1892661865811862, 0.26005509254174275, 0.7584310600401738, 4.1478381415873935, 2.9958624958759867, 2.638137836198505},
    {-0.28058266585004504, -1.6910259666669842, 0.855017908020486, 0.9597262033261053, 1.158666634933219, -0.0790870372311504, -1.7906380064666985, 0.3625515456132312, 1.7844686422351612, 1.5838160193086714, 0.5208219500094344, -2.8246379394363825, 0.5225886943463707, 2.714573503696287, 3.089895146803763, 0.23048247392373497},
    {-0.2346530022892217, -0.6593757858780378, -0.5967787798445626, 1.2082089436313033, 1.2088192455224414, 0.5808666744842237, -0.08184511735492862, 1.574884969173774, 0.5533694546331275, 1.9545863055961028, 0.6820741001830734, -0.10916192154613553, 0.06537737332871127, 1.577091379000455, 0.466070349259926, -0.9338287125453735},
    {-0.7083323672524826, -0.3245675662430095, 0.2246150939578361, -1.4891188079742903, 0.7245458751998454, -1.9516569196446096, -0.03893587438875181, 1.4671424123711163, -0.09737538466688894, 0.7608414278027971, -0.9213694526057276, 0.1543690903343866, -1.485162025432784, 2.17922256401602, 2.3644927419659436, -1.5283346824374267},
    {-3.4832070322324107, -1.526972096297198, -0.016265642806809012, -2.7516716770523146, -0.9909860241063421, -2.2241412273677055, 0.5149736506020924, -1.9655927175986547, -1.1186009918930575, -1.1044375763324243, -2.2814063945964174, -3.66891161980864, -2.6553069606179114, 2.0390518766142325, 0.0779321313434603, -2.225281056823416},
    {-3.987899367327101, 1.1755101054777999, -0.29514767048279367, -2.6778599935118637, 1.7432460787800423, -3.2946997974010537, 1.8508898985515538, -2.4168005185437846, -0.3887573322517512, -1.2845710110952127, -3.1936980314835055, -2.374504157864777, -2.389196810167879, 1.7029491852622314, 1.3726146562763983, -1.4106768797476723},
    {-3.708881149323347, -0.2207965027340932, -1.4859326387590865, -0.9203706713055747, -2.424298766793828, -3.4972118144882702, -0.5593926037374974, -2.3351874771790975, 0.34112169393515895, -1.452685807709155, -1.7969662246240128, -2.0463528909685564, -4.082388724278399, 1.4591844866619712, -1.760796308073778, -3.3815718485751063},
    {-1.1355662393451202, 1.3945035472467713, -1.863091957902683, -0.4578562503975115, -0.8980682875049094, -2.6007058757054557, 3.0872971382083696, 1.8401725123391957, 0.16889502745817916, 0.9697536658779223, -2.6146517418773376, 0.35376640739027637, -2.034178886600117, -1.7323609685827428, 0.2764743553798121, -1.202915176052981},
    {-0.40828855405544967, 2.121859691194977, 1.463151456732382, -2.18838301176006, 2.8953439061392263, 0.2710178887475597, 3.245519361357621, 0.6205958271635195, 1.4058363836005165, 2.6398311532637657, -1.2109289020033387, -1.9576954239584394, -2.5070488836909575, 2.1872730868984758, 3.3264639303446555, -0.7218530823421346},
    {-3.2536102131925038, 0.31590503847775403, -2.4655465006763264, -4.364819869870261, -0.597977892272723, -2.3400299436664684, 1.8255315675492934, 1.3930792463540782, -1.9368705385821336, 1.1760306066539035, -1.6807983404137703, -2.0691159655997438, -3.5468908687226413, -0.5634980175718396, -0.4464989323198703, -2.0077536624320835},
    {-3.722870697728053, -0.7684213261554064, -1.8480759556449997, -4.003425470554386, -1.0586873500541358, -4.815991647011675, 1.569940337022194, -2.1674499990201586, -1.0618265804368996, -0.649926239455641, -1.6680428519594077, -4.649574998639434, -3.6139938281452966, -1.4121288691217677, -1.529574360417286, -2.5310793980957196},
    {0.2537488052661468, 2.1246236538761205, -0.3838546775637058, 1.7681760260332646, -2.28909253434841, -1.0973312350620286, 1.6518540029842839, 2.2779416784702056, -0.30227870961942355, 1.136519583853957, 1.4956726308032378, -0.4293867065354918, -1.9841436312426513, -0.10810612784112689, 0.2019220537541422, -2.7284332998336995},
    {-1.83852106784816, 1.3860549351609928, -0.16945345001348855, -2.110456804910033, 1.3741268306205965, -1.7534779368164288, 3.123341652039542, -0.27394531533080285, 2.5905241003072494, 2.3318159292853196, -2.490905877384313, -1.6346477145881797, -0.815055620700881, 2.6606411335675224, 2.8145126059324648, 0.8057432550564185},
    {-1.3434370097514152, 0.7426360812590564, 1.5435252581043961, 0.4837196912196218, 1.5969416982925215, -0.440809535617912, 1.0341655095898512, -0.461946262549947, 2.398025092950977, 2.2903865064956825, 0.3213318861766748, -0.5414563446790593, 0.08963108142371595, 2.303190598629903, 2.598221180301068, 1.0436058718406802},
    {-0.46037331234022244, -3.150991352236363, -1.0523626173085394, -4.39943044199936, 2.5963329106150734, 1.406508251672707, -4.1968699765986175, 1.8231609124309844, -3.0755813151074296, -0.7254099661258316, 0.6833131047264647, -4.975176073875155, -2.917195067212345, 1.5675187330312998, -0.5841157960997365, -2.9900984089145104},
    {-0.20298685573113182, -4.236365241089274, -1.6339907642024167, -4.601556761328453, 3.121681063054113, 1.7386362101299662, -3.124873422112108, 1.4757207283594989, -3.2158868331876223, 1.245618791707171, 1.1195096735389665, -3.7636500942011337, -0.9234454882158376, 1.6295410636427912, 0.3693616974068585, 0.6304154609855165},
    {-0.3352414625403429, -3.3575496600778183, 0.7297140084859886, -3.43531879908277, 1.4133045348071982, 1.254172279848643, -3.604118473542312, -0.20184702535056634, -2.0968107278842645, -1.5994164743890478, 1.225649423414862, -1.4356013219022978, -1.5955438039496894, 1.9975517049534717, -1.0449767923704412, 1.5095914795967305},
    {-0.5560744213819129, -2.4833585945216985, -2.350723978293424, -4.64834888034837, 0.9046973436649354, 1.2056469165057127, -3.1688321774440835, 1.8378368919700638, -3.0671995628170063, -1.7287629695682851, 0.3919480638214091, -2.174895321144202, 0.15041909168837275, 1.095566600949927, -0.7069483742562133, 0.4273687966989411},
    {0.07220712679705892, -2.039612811015392, -2.826486953517663, -3.1449781531828886, 0.3681134176406453, 0.45433928670069973, -2.077940069988167, 0.8173240019455975, -1.7961052644075894, -2.278778691931269, 1.1259699114073076, -2.711698218578601, -1.3651747281595006, -0.2729255558465973, -2.0419045915200407, -0.4550759725128893},
    {-0.3911889008549683, -0.5745342002451654, -2.3714209962899293, -2.704091863540954, -1.2749549330179535, 0.024943931133665526, -1.9732763583929513, -0.09708487943959034, -0.47852209555397474, 1.1314705842331292, -0.39497938268676835, -0.6801938191518369, -1.0583865694307273, 0.6564327756999973, 0.10422649557287028, 1.8127447600035118},
    {0.4395550724464444, -0.8815801771645455, -1.6490803860461045, -0.17739343610970223, -0.0634653532102937, -0.6586560748586965, -2.218934805582886, 0.19813858387123137, 0.2891820809961826, 1.0562968374760764, 0.8035302837450583, -0.09172565407729466, 0.04619220423231974, 0.05221399605282143, 1.0796913790661975, -0.4287193068206303},
    {0.0006804679770884966, -1.7384585449668997, 1.3256391176021343, -1.8787198001769976, 1.1587359491925484, -1.0349512327987536, -1.4312808049353125, 0.5847427022238275, -0.20530744988160377, 1.6656966010743752, 0.5440192286918274, -1.365703588646063, 0.7524304447444071, 0.8638504028783, 0.8618519442665604, 1.2577161860584627},
    {-1.262060422600228, -0.3000877068182202, -0.11757962379778954, -2.0356544054885077, 3.0355546053495495, -0.6363749759842812, -0.028279480129663772, -0.6239422418008366, -0.5306668711274908, 0.22187359150303726, 0.6194613909524928, -2.0165922812387933, -2.377995453711273, 0.9689370016277808, -0.34595631012506917, -0.22132217560288003},
    {0.9650831722450803, 0.2468458719967357, 0.9977983133849704, -2.807891581216119, 2.5953275157256503, 1.5730663322660285, -2.1570101661409025, -0.6715653914385091, -0.2065087857794555, 0.25537086436491924, -1.0721610336177763, -0.3149079070776192, 2.1832979860656896, 1.7081870618098765, 0.07753429016976048, 1.17094691768863},
    {0.9686007119440636, 1.813186479458152, 0.33335954740821033, -0.9130193238141705, 0.2804334454779185, -0.7612782933950737, 1.1830994056136597, -1.5411878522913938, 0.5179599762082516, 1.2526025979538382, -0.05096696249765474, -1.316634878763286, -0.4163307981530502, 0.28106074756517546, -1.4009648327779598, -0.32003069984050814},
    {-0.19166685117408006, 1.9772274953348985, 0.13827877569643907, -1.40710209338796, -1.1830471443639254, 0.37068082279014963, 1.6653589902982877, 0.9775548886988096, -0.8183902112760062, -1.073802655897775, 0.8337519933303513, 0.2830347570157794, -0.4002594522766752, 1.2287043130513715, 0.7605067110658585, -0.2961537676863203},
    {0.19596303500012427, 0.3455640154679745, 1.8999066249797862, -1.5014802405274552, 2.5340984530566364, 0.40276164104011775, -0.0598604634684362, -0.40571982728876127, -0.1528140762944585, 1.8119018600753476, -1.5992001681975252, -2.2808505358185447, 1.2066558751044547, 0.5426874815019783, -0.15994095793082042, 1.8131460498145766},
    {-1.7954716576191474, -1.9594095956083497, -0.6509539322445367, 0.7172294745175711, 0.40202292437878484, -2.4122426498831846, 0.2849482680076015, 0.4708264557048095, 0.8335321379971556, 0.12383199949855538, -0.4784511120546118, 0.39190812382042595, -1.1390258489335294, -0.09434050689409357, -1.483680282387914, -0.34273845572836287},
    {-1.2259078264984167, 1.422032634456756, 0.6334560657289051, 0.18213225472283603, 1.0091536551203615, -0.09754266403101249, 0.9216558526904811, 1.4714707135849685, -0.7882975493533154, 0.18937294462727577, -0.7204189169299845, -1.1644507993813615, -0.6050651437800063, 0.27145015336829065, 0.43271980592146797, 0.2080470981715843},
    {-1.4389586645725256, 0.4810012716226593, 0.901424803500905, -0.0609314372730254, 0.06626991447328112, 1.087785019950981, 2.1547847684186823, 1.523044444641379, 0.23863701650781866, 1.8269476309544144, -1.0590432509069132, -1.7616890548216082, 0.5842036955754256, 1.082063627697422, 0.2434234632452027, 0.6143353321742516},
    {-0.03874412966141494, -0.7277262511258965, -2.284058481283386, 0.17075759962859072, 1.1437268148006468, 0.5072780899802172, -0.1313541265593171, 0.4710486293068704, 0.1397924434118228, -0.6601226258764102, -1.9364211642320608, -0.022280581648480232, 0.8897100506386674, 1.2092160914282744, -2.5843677298163623, 0.5213182687190836},
    {0.57458981497385, 0.77321321571409, -1.1732723145005375, 0.2115662500753257, -1.539379512364092, 2.1257826710886962, -0.8913090913839763, -1.1987447640409865, -1.8625995609539763, 0.04224806152612722, -1.9717393194959745, -1.6624429215159873, 1.3430927321643453, 0.12678095237202053, -2.640705381062505, -0.9653680991281333},
    {0.4422447943135129, 1.4753654001886225, 0.04470917618281709, -1.2288029969419028, 1.4370355170596902, 1.1698909214420317, 1.2117738539251934, 0.025965714540804683, 1.2534240080270294, 0.9085520450827833, -0.5111727917772141, -0.0472132423771608, 0.0028226879742980176, 1.4040217215228923, 1.1391454576808955, 1.068091297578319},
    {1.0773602308988428, 1.1152268369314147, -0.43200134286637737, -0.22030918555412818, -1.2385071445249127, 0.7009869074717276, 0.5605317066666593, -0.9194776460341523, 0.9767003303663653, 0.32262276684285224, -1.1889694897370033, 0.22353227180128823, -0.18787713270419573, -1.0913987345478076, -0.5114188585562457, 0.28513767860786826},
    {1.5106623651254103, 0.5432613517046266, -1.3860763064949435, -0.22203876927442262, -0.6658421038521998, 1.6049597051766744, -0.22890602822367725, 0.08266866126174649, 0.26210902087690546, 1.029086510904847, -0.3679788750745112, 0.4123128878174112, 0.5462339893090438, -0.07747812828811582, -1.2904616187101485, -0.16724849544075973},
    {2.2872084568489286, 1.0793773007720457, -0.30397195226244084, 1.6958200982403036, -1.7258420960072058, 2.275061410305223, -0.4482061436085354, -0.049120070920449094, 0.6342015026996707, 1.1580049667343775, 0.21730615851680526, 1.6031929320890257, 1.8698758952835914, -0.07428467232874068, 0.6990261244013195, 2.998916327820061},
    {6.254889668799474e-05, -2.4105485980030066, -0.31909683926027727, 0.08505677956402587, -0.08236021027787328, -0.42571034969902066, -1.676130905366927, 0.7829008071169435, 0.12606399737126897, 1.002473927143933, 0.4005724254818869, -1.9024414925768343, 1.111967887249673, 1.7052964310234804, 0.48442151985982523, 0.38079208356016936},
    {-0.05511608001640764, -0.5906202269346874, 0.23148164766945467, -2.330171550342963, -0.5686769348574247, -1.1571741015427612, -0.5396325319626805, -1.267141836709213, 0.9403820654860938, 0.6514639249950591, -0.2373500616889761, -1.294088313243487, -0.9823048733917539, 1.0585009353072394, 2.3266121792111356, -1.1511004259786808},
    {-0.4765482744754331, -0.4753859170609946, -0.3919052171112164, 0.4991240949675043, -0.8488529376835366, -0.277144494047094, -1.1951405314839971, -1.515060476313088, -0.12068076898681639, -0.9761448594304962, -1.7758210663433327, -1.7432907324262976, 0.7415799523675903, 0.6089902657431518, -1.7714833101982213, 1.0181751562854875},
    {1.685918071572845, 0.40381666734562804, 2.8488582152827386, 0.029028420310407442, 0.3000099643924179, 1.6333819175515338, 0.6565591539101899, -1.3740563030225774, 1.179889466985163, 0.6046342105955069, -1.2622482061798868, 0.2946987156039823, 0.593819498823073, 0.5428979123060912, 2.2295286448188656, 2.104256984143682},
    {0.5303004535202152, 0.05987806468323444, -0.35716880953426705, -1.9942674114079726, 1.3781597146762168, 0.5231221078081634, 0.008850221814835763, -1.5182981164020912, -0.18045817853826834, -1.1743718839425115, 0.8746223488220388, -1.2301218913693857, -1.2036531698990371, -0.1282864132601067, -0.6718340521671856, -0.5813115877822654},
    {-1.3830727945454386, -0.6384729471075554, 1.2541464164422178, -0.36558987899834916, -0.9935407072612126, -0.7917349721155093, 0.16025368257679745, 1.3531511441392057, 0.3087373022746936, -0.33560087820991924, 1.9712759378083602, -0.9674679592478628, -1.3802782752435074, 0.7821944734515738, 1.6489239841638048, -0.299243574372694},
    {-0.37924423669699303, 0.5956892911230742, 2.7563763300394726, 0.9519443351542213, 3.6360507944529763, 0.05086806198445492, 0.682069698498066, 0.6068273114468727, 1.9582734436455562, 1.9213545257194247, -0.7098292421322915, 0.10946307297414365, -0.5866971393194096, 1.6150588264782868, 1.0129023589120694, -0.08543455400683368},
    {0.08466242650894537, 0.9019506822050192, 0.25211473879714, 0.5921079664566986, 1.0706362910247902, 0.7357751637292225, 1.7920332547265552, -1.5063919590067525, 2.139188528330221, 0.8142128217468659, -1.0544274433929979, -1.2632140957057059, -0.2707669623969771, 1.9525513672799102, 1.014194327816863, 2.325086980542799},
    {0.36311822771874563, 1.2687268422267963, 1.6899176370211475, -0.48486386187333014, -1.9878052756360218, -1.0472186556958833, 0.8973361502325171, -1.4453335490214507, -0.20194293600338628, -1.268830389101104, -0.9414466460938904, 0.9929696851108077, -1.1507030216785048, -0.38188165625755094, 0.7441787446954469, -1.0292291083170482},
    {-2.4171510073239726, -2.668010348837366, -1.7121327684339693, 0.787074932117177, -2.0817189337592508, -1.7511578468840927, -1.906159765972005, 1.8900691490024195, -0.23172154712906567, 2.0502935587768047, 0.8505431877963575, -2.4073139163011987, -0.4792326683790264, -0.3663706497017931, 1.34383604822258, -0.37325120748353235},
    {0.1476963121054341, 0.07546549285938292, 1.4805650543219722, -0.22019124290154474, 0.7025684116510811, -0.9255772046117586, -1.9156582979860344, -0.540346504744683, -1.05185683778657, 1.6344530955860144, 0.02363997591432625, -0.3075790615612536, 0.9473017893328516, -0.1964481006222194, 0.5698680136351457, -1.3196179556258432},
    {-0.7558950592213006, 1.1715934110595896, -0.10211979018532737, -1.518678339772788, 0.09680758951460455, -0.4656919789473489, 0.8377814667414709, -0.43951035946800193, 0.036146557271262335, -0.38133366074979075, 0.4083260328929496, -1.0998396484999955, -0.8373788380697551, -0.8629535316608175, -2.230203184187658, -2.0467156740400303},
    {1.8156232419397602, 0.30482474020276595, -0.7580895066254657, 0.7267693146879565, 0.7737844547207927, 0.14572375270344903, -0.2971219064706687, -1.3123387712399814, 0.6153919728793448, -0.5252411560268379, 0.3255465734669541, 1.8767276026533821, -0.7329365345575269, -0.26754290349139437, -1.1432895568997612, -0.8228957935514574},
    {0.44142031774971324, -0.35573783185859287, 1.5148696757164894, 0.3312629601996996, 0.24677613084230135, 0.49159719205109964, -0.1970086636578194, -1.1267543905501218, -0.6468827339907639, -0.9838480944310093, -0.3253444286413897, -1.1202186285889972, 0.517583031436994, 1.1847074871296366, 0.9624073779749133, -1.5549417000757582},
    {-0.8122224603052212, 0.9239489689718722, -0.1047905081618094, -1.2702860477876297, 1.8378657200520898, -1.068306587745326, 2.166476614484177, 1.0284591562825391, 1.326667296031603, 0.8760359427825273, 1.8905227685717312, -1.2402336549868302, 0.44800188033868077, 0.3568784425578052, 1.7942179884818104, -0.9275835397131226},
    {-1.1458657368620533, -1.106874437284187, -1.5267542175694404, -0.6837424651449496, 0.3609561838675143, -0.9421730325174219, -0.023042571921709564, -0.4072590636519817, -1.5360789847504241, -1.3486662321727836, -0.2500335994116323, 0.3173375138804443, 0.39839441578645013, 0.7492297320064614, -0.28357393893475125, 1.0354357219813122},
    {-0.7653330843716843, -0.4893246098149444, 0.8122475350367798, -1.5201755464343123, 0.29132270263041354, 0.6000587739142651, 0.7691710907021808, -1.4241605593672717, 0.016628233655705517, -2.0632681303924207, -1.2789496247799659, -1.0879682925106076, 0.13996992388113155, 0.8329778156463099, -1.0671257637266074, -0.29249768824799843},
    {0.44494921855457803, -0.964304996637722, -0.05811332504625956, -0.6927031738580425, 1.3790947914737728, 0.7953204563559134, -0.11810585287933513, -0.09584006551180589, 0.978650100787517, -0.31515367132234456, 0.1309835467867675, 1.8730501050888357, 0.9408486354998427, 0.7639962773898125, 1.4739517415196595, 1.936587631838998},
    {1.9589761143528577, -0.9573740408687055, 0.35827925304926916, -1.3347504002783106, 1.2817079588919424, 1.0112802397161524, -0.08774433983948865, -0.8296247657297727, 0.5800909520120131, -2.2692290352152473, 0.5448674341306069, 2.7951859178928036, 1.4823050771344153, -0.34766036025209046, -0.1564678515285008, 2.17891747309011},
    {-0.46369836134465414, -0.7869008868121468, -0.14323739945397304, 0.15071219412404713, 0.29139081618001866, 0.6063388692465728, -1.633543209484779, 1.0652104800363074, -2.0529637441070823, -0.9692841832946318, -1.17880787135604, 0.9144568021069827, 1.4517042572420376, -0.1533254393704065, -1.527454494435846, -0.7053343498789593},
    {-1.5292070868825562, -0.2406052987585114, 0.06935195386060285, 1.2935880063094727, -1.7422493084882875, -0.7473467113961053, 0.5014909191308161, 0.5917246621177886, -2.544290077729185, -1.1768193941437388, -1.3777566186069206, -1.7016997172889299, -1.1327041207572137, -0.745855199429632, -1.7092750762933175, -1.1317187098547332},
    {-1.0969892603097309, 0.6971387164629588, -0.6771343346297443, 0.9641987802910521, -0.309698877805353, -0.7264069942895502, 0.10776565393755837, 0.3438973140504906, 0.25620971620817484, 1.9678385866415447, -1.057846692250736, -0.5845336971651772, 0.12521892275901506, -0.39957538359726363, 0.08758204408593259, 0.5899451707824938},
    {-0.44463952507797994, -1.6510131785313904, -1.3091064819134015, 1.7783691709786096, -1.112929759228553, 0.9712948583794284, -1.213397423147382, -1.5033670363969438, 0.5297184376349545, -0.9176013651685486, -1.5062770043151303, -0.10830517674033467, 0.053401981019088905, -0.45837512010839654, -1.4936479585901004, 0.6410779940089121},
    {-0.2601063331341038, 0.19813859523135194, -0.47300998468310096, 1.9453898668343415, -1.5097257721815207, 1.0945009918901745, 1.0042505058865123, 1.2575684527682562, -0.19207183635523273, 0.9833709387184567, 0.9169491714311805, -0.5565805497241365, -0.6655048382288911, -1.3906428620020002, 0.4906742790554632, 1.697979133946656},
    {-0.11674841374148737, 0.03530677288322252, -0.6058657108695793, 0.3510308699557025, -2.1849245480354598, -0.25893630310673516, 0.9039104792072644, -0.03799627649571198, 0.8943680475418957, 0.411074525195288, 0.16879231813157802, -0.6135610063996557, -0.6379935108573654, -1.4209386239083097, 0.463260092625692, -1.3182084085180699},
    {-0.2874802336381092, -0.7931020310359546, 0.4420010781200138, 0.5637802379720717, 0.023851191465278934, -0.916236176987052, 0.6437822017837067, 1.2210484096077674, 1.2331165608297294, 1.0364632474389723, 0.9060039410506933, 1.1090666147912052, -0.9414401448397152, -1.1323350991681973, 2.5133503811597397, -1.0388601075285582},
    {-0.6065968133087551, 0.24706641368066895, 0.6930493608757126, 0.13954375349719272, 1.0618870841168258, 0.5934969563420003, 1.360266796304214, 1.700155335370764, 0.8494874345717761, 1.0570041280992926, 0.23385328043577844, -0.4414251810934697, -0.014159199516487678, 0.8789318155227278, 2.166041941689749, -0.36291704492916704},
    {1.858966170992001, 0.7415900808441582, 1.0036068051642628, -0.6979163143973408, 1.1569927009576306, -0.6159580423980833, 0.874899806473111, -1.23344154925787, 1.0066344269399616, -0.35209490350378103, 1.6918878417625263, 1.173915568310825, 0.6769840806189612, 1.3076567433499526, 1.079618511599579, -0.6996043734215475},
    {-0.8030798014088625, -0.48220286606815177, 0.38696738247447504, 0.4696694721126037, -1.415271716376563, -0.22433372621371622, -0.48771280228916364, 1.1507669099858264, -1.8415871983171577, 0.5161451860897897, 1.508903568389631, -1.0736825488617614, -1.3736966783056839, -0.9635849380656751, -0.7484671482791619, -1.932389890964013},
    {1.2307223469051298, 1.0726466697391035, 1.6685406733767787, -0.975332370398411, 1.4274497702263707, 1.862645797746371, -0.18087117090558102, 0.6329605060418564, -1.2000236038205934, -0.2956555142954212, -0.7438301240937766, 1.2128876536807576, 1.3213130991061979, -0.07496974999876017, -0.564760006494361, 0.889228374660365},
    {0.4151713351169198, 0.6801777843716529, 1.2133803103514136, -0.4835551095391894, -0.4759959121246167, 0.6620743015386709, 0.0025202253796288957, -0.45026385490157733, -1.4605372409402553, 0.6342095384746194, 0.3687023812447105, -0.6421984114130598, 0.689083640261201, 0.7117292449740654, -0.44481809152069124, 0.4824177156914766},
    {1.0381492986415257, -0.36248089438032827, -1.8267246004535358, 0.6704568494892896, 0.4814432705906761, 0.3153696811768814, -0.8616671124679205, 0.7009240795849738, 0.9355497362577897, 0.01941966778241656, -1.1311433687324, 0.6890331409521185, 1.5820752343446107, -1.1135673530368018, 0.3151048377237329, -0.9798304951130132},
    {-1.118772527539599, 0.5708186272131178, -0.206549159478212, -0.5054583607670563, -0.105549303099168, -0.37755464514291087, 0.5295022738518051, 0.4631095417910613, 0.8378948805697871, 0.06273468020730343, -1.670509776279668, 0.2081240208225638, 1.603339328719408, 1.2490752569912305, -0.6343695847827997, 1.7663032322454106},
    {-0.7444518500314198, 0.4350218653546956, -0.08846109704523576, -1.914498746662659, 0.35503464778567523, -1.1780675865981622, -0.13909710897209793, -2.0729666114518746, 0.12297938907779467, -0.5604801626655423, 0.05326743271915601, -2.1888579721316686, -1.1419482403939578, 0.036680948298909034, -1.0108766274712346, 0.7210778976305529},
    {0.5871726907377075, -0.9061237976562425, -0.27943174833849055, -2.7301019335714862, 1.6518295018998619, 0.5506415835979173, -0.453012887762411, -1.1114764592211357, -0.014600010960757316, -1.3882837728672737, -1.5802339617301766, 0.3958462145488763, 0.3343497800037924, -0.5626366385654007, -1.0540817460820309, -1.0769711070644552},
    {-1.4365555310039348, 0.6866530350200992, -1.219719366478397, 0.48501227899059995, -1.2275570916419323, 0.5617780686083412, 1.066551808385522, 3.082797113685256, -0.7314951856106418, 1.267408909949082, 0.35111469150801816, 0.9984096777576805, 1.0486675753822454, 0.214979949345915, 1.2416670729631734, -1.3600856239797032},
    {-1.0587129453729245, -0.4945117373440421, 0.48206698369321205, -0.10052517643196199, -1.7160746942396587, 0.055674646858973706, -1.177263378621379, -1.2174563845226725, -0.9311318544920346, -0.8805000824988464, -1.9212989489543242, 0.12986318508100939, -0.6933360310075097, -1.6063327101796498, -0.7370210319697651, 0.7473569538925688},
    {-0.8714694160190486, -0.40995233634193623, 0.2873968332501807, 1.2752207965953914, 0.5892382563343919, 0.20838790647276118, 0.8695790439949965, 2.139907048808958, 0.8128713564709363, 0.5632372682473934, 1.7775192838667937, -0.9392257777722669, 0.6634163857345354, 1.1231151525477485, 0.38288871809654257, -0.028850063382100298},
    {1.2581645684746239, -3.3057819246198776, 0.6243539544420371, -4.070841796337137, 1.5299084862495944, 0.7945271833292463, -1.3594468907239499, 2.1699134818920465, -3.276811152695761, 0.1813436058302112, 1.1181444244493834, -4.796099950200507, -1.4415538437897275, 1.5479975140414581, 1.9193032572184272, -0.23477175788618665},
    {0.8481209433470811, -1.8127289409166714, -0.9728222276662155, -4.432529942634908, 2.045914192025994, 0.14360682513166959, -0.749791579462115, -0.07931565280214761, -2.0288531202664206, -0.3985215708399919, 0.8004943146854786, -2.712404508181837, -1.80542918822072, 3.773764834337008, 0.3150588634920997, 1.1152045727389042},
    {0.30393893659334587, -2.3007481898974924, 0.7384656629155358, -2.613616628239327, -0.8240634588788593, 1.0966208358557854, -1.5784495432287398, 1.3257669441225908, -1.7859895566870099, 0.06043501302801943, 0.2994151217359038, -0.8570496306621411, 0.12161454520097409, 0.5468972050489022, 1.1520487636689265, 0.7500867255070317},
    {-0.24309678115265748, -0.6755069862568941, -0.5192459518527587, -2.6967850740147594, -0.7837375133207134, 0.9957859616751936, -0.3519394666544363, 2.102666500651521, -2.026265608954884, -0.2540356172800225, 1.0879279194959335, -1.3640771697177183, 0.05786521092859225, 0.5316812575650753, -0.7007356496284731, 0.913410391820227},
    {-0.3877909917325494, -2.141966196134857, -1.5725333376178663, -1.5584260146180646, 1.3631896584788643, 0.8391046459552842, -1.372925364742703, 1.291335513320319, -0.9927313392490833, -1.7013886078371085, 0.010298695150568471, -1.948006199469623, -1.393444157055011, 0.88936662893301, -1.967119363169784, 0.22266526196339925},
    {-0.6076424420968841, -0.734800756470774, -0.6442765099196278, -1.7803764634478, -0.6297306795916925, -0.313916673838515, -1.540307623650114, -0.6243407882143882, -0.7632185498965899, -0.8925223877256956, -0.7889102814701702, -1.0450684149778324, -1.102174886851866, 1.166238763088153, 0.0017400931481466478, 2.3796092525672363},
    {-1.5220235763760497, -3.5182109561632897, -0.9503116277729706, 0.5486141121393655, -0.6484784318116188, -0.8345928112006112, -2.1524151206862423, 1.4081183361870475, 0.5288033135989375, 0.1777182108097947, 0.5728890337758942, -1.4699138289918772, 0.47400216446534715, 1.243678340691738, -0.6360021018272906, -0.015922771312778757},
    {0.6135905634624493, -1.3587125818312071, 2.0585499482193756, -0.5059332058276043, 1.531292712925627, 1.6417080480783326, -0.9595429119080672, -0.3641136510305872, 0.36020967297523926, 2.9717466157936507, 1.2324701165365908, -1.840759430107066, -0.09295380420971755, 1.3445748087388527, 1.8499710432887508, 0.18960987942670365},
    {0.3968446215191994, -0.3194917614427307, 1.9320756454260393, -2.910894840991641, 1.5752652669755374, 0.8823943066106645, -0.5778347159769593, -0.49112481428117316, 0.11796938056118617, -0.1730703657552555, -0.7773045396643853, -2.248492866279925, -1.6392739363541091, 1.67549186430514, 1.0907606129342886, -1.0350147955965334},
    {1.6601716961470792, -1.329162810741263, 1.4661887872952413, -1.853513818897642, 1.5601185213464914, 1.0551081955129447, -2.4848078600830026, -0.778856539090014, -0.10567929516368801, 1.2736292115895929, -1.310712141221953, -1.3508384697449405, 2.3906067288764334, 1.8602752113371093, 0.7423204296441002, 1.465766040980316},
    {0.6241799778741184, 0.9306328382630354, -1.5894481491151928, -1.2360014467213682, -0.333458078049489, 0.0025220774439686402, 0.6229532530678412, -1.1102684183227975, 0.15094612594034518, -1.1427832753289497, 0.40837922487526634, -1.4710709014551349, -1.3192796664060469, -0.19871803295863208, -1.029832140107664, -1.3335894074416879},
    {0.32740681380273046, 0.11059784347149755, 1.1729764614455367, 0.9128722442128662, -1.3230295893696697, 1.0663999734732676, -0.5768356945111992, -0.381239921305924, -0.29427223778128136, 0.610618495838331, -0.021394122570182153, -0.5748479584452568, 0.613218415053406, 1.4560437650050768, 1.2773742178609582, 1.4146624185055001},
    {-0.23265389088208185, 0.3093409475015756, 2.1275435775486553, -0.3446370244809802, 2.250485656278699, 1.2728437588558772, 1.3206906778227723, -1.8208595202250624, -0.3019943252819325, 1.2171982271796091, -1.8129115777870166, -3.1683511223077496, -0.40360633631998777, 0.5681562858970902, 0.0016803600042674817, 1.5949214663004396},
    {-0.09643372230917928, -1.635882739442271, -1.5471999970896664, -0.18960499661168775, 0.8977436011789839, -1.268948737996349, -1.121180619556913, -0.9292404782324625, 0.46415123767885685, 0.7854443268402486, 0.11741349279392072, -0.6232587920707934, 1.4858883440402895, 0.18601004677661728, 0.14239666612250002, 0.36059109024889274},
    {-0.10432361061504486, 0.8918881143085393, -1.2049506505184235, -0.13362281512883756, -0.6473971256881108, 0.5175295535308426, -0.30616651321983973, -1.403875906847056, -1.383854050368864, 0.7827746323271868, -1.8296939993894963, -0.6952826442456261, -0.17331158057385143, -0.08249441467203662, -0.1856112849025717, 0.721602945890776},
    {-0.1993446037069937, 1.5042110625411647, -0.45754906034463805, 0.28297192519927145, 0.8455256629151704, 0.010729517291303711, 2.021136111858646, 1.8075221073685035, 1.5418402918095482, 1.0337863717949776, 0.37239371302696056, 0.4859411118916931, 0.33431654319875925, 1.892746424327107, 0.3582438597800502, 0.8029679174181563},
    {0.19006062033078272, 0.10119405073455023, -0.9832331744647598, -0.2646051532596487, 0.956145665474497, 0.7000835519519574, 1.3256267125702268, 0.22825639958325772, 0.49074767006137127, -1.0076711969094219, -1.5369707691260024, 0.7610366663261244, 1.6047533223695167, 0.999421257559473, -1.5669001260902902, 2.1144562134868052},
    {0.9505291773880519, -0.5675114146463122, -2.094639781695143, -0.6473610060215629, -1.285872836293833, 1.6551022580871864, -0.5629052230948499, -1.1609924293859106, -1.2507684557286467, -2.221044166963257, -1.6092951041114765, 0.6667237805880659, 0.8145209283776025, -1.1857080706858785, -2.0511909520752614, 0.7311787348137153},
    {-0.8246889119837439, 0.25211853804436957, -0.40384562421870296, -0.6622646461737637, -0.22813090838996775, -0.7495778003902828, 0.3284730490472038, 1.4558930570237192, -0.09642295455578853, 0.34944810145717436, 0.3897658576071335, -0.773322056403948, 1.5141762461457713, 1.59386886203937, 1.00143130218124, 0.2708369542768103},
    {-0.2770866690972482, 1.114016450920407, -2.0941101424968562, 0.4316772333306265, -2.531818749647646, -0.9857718669280116, 0.5701694553316392, -0.5326101225231328, -0.16312354154769543, 1.353871830952029, -2.1155552807253604, 1.021347935244598, -0.997129959068154, -0.41563207911000427, 0.7484095919380126, 0.730584286724871},
    {0.8725590745529972, 2.153674265296101, -0.6082677750506649, 0.5668337153562945, -1.846794678546944, 1.230383247633083, -0.5150683300928766, -0.1875437671444343, -1.6888700344506533, 0.14329315456430458, 0.23622900637773098, 1.243228261620513, 0.008996717324348652, 0.7662664358435374, -0.9285116283351128, -1.2573372997790169},
    {1.7293858776420885, 1.6047034385559116, -0.9307354630035055, 1.9525550537525218, -0.8642556722180116, 1.099557061842426, 1.2627148405532003, -0.47740159463598686, 0.01976809656224591, -0.6141819356983053, 0.973781383966237, 2.665627090522682, 0.10063339590612852, -0.8523821851306036, -0.41058681913199874, 2.634374629970137},
    {-2.03422011917529, -1.8635499030113194, -2.2480000444818096, -0.7171342047497671, -0.18526561419163745, -1.0062291227160156, 0.06771448012269911, 1.232523874984389, 0.776973591453278, -0.1012201584375871, 0.2614949638469972, 0.6558154884884174, 0.11770736443090721, 0.16818211021502047, 0.8954131762239855, 0.07426891863864975},
    {0.03538626243893558, -0.77264494643791, 0.05114097813528669, -2.086831002202308, -0.4771179953848054, -0.09260825485000453, 0.4004646348008137, 1.6929568141215576, -0.22075780222276725, 1.4283445442376357, 1.498299074813613, -0.8704216894907937, 0.7513701676608362, 0.819915821539615, 2.3658514730291977, -0.1965407742489241},
    {-1.3165237590162195, -1.1787853624790094, -1.9355154372614845, 0.7835155283781068, -0.8036505952553513, -0.3571972647905563, -1.7784327719413455, 0.05081365335432138, -0.6303488000451601, 0.13946508051200163, 0.7233543651112763, -2.3139732861946403, -0.8479682130336285, -0.20853282748880494, -1.273901028452793, -1.7416071266652728},
    {0.5521336849510199, 0.8784475489948045, 2.458181458915306, -1.0827966175617612, 0.8606920822125025, 2.1501725362021724, 0.361894988045628, -2.3677526038535723, -0.49351866137041106, 0.03097392890710059, -0.8630936290509181, -0.6262795793114413, -1.0019622812241231, -0.623371773946995, -0.07144471389742267, 1.543985391040604},
    {-0.470897328675964, -0.42148462938265197, 1.2065626082703813, -1.863680721509182, 1.8094558485543217, -1.0061884910989607, -0.7042493809272105, 0.06274392876211568, 0.30691640697000805, -0.5167218739863413, -0.7536190639280793, 0.1878539575621596, -0.30830481121950554, 0.5160066391237424, 0.3954793904685329, -0.7771526306042157},
    {-0.6794238310804405, 0.8869946919378956, -0.5023381010533856, -1.8686285538852523, -0.17245110611113082, -1.5248144082189572, 1.0715750179613592, 0.7486422015457742, -0.5187799711744215, 0.020203429336838098, 0.7729279973417849, 0.49642675167794553, -1.9392880431853659, -0.38615126959704976, 1.0462930087708517, -0.8646579764527327},
    {-2.1479492282169423, 0.8937213910659636, -0.3306396239373713, -0.8493464980371445, 1.5709286152896953, -0.4219341902503189, -0.0432468272237206, 0.3794012776766813, -0.05479806907460178, 2.445835282178939, -1.3032025542560914, -2.6680402308200746, -1.8882864285789716, 1.3105505653745595, 0.9359036534953786, -2.4476617699961296},
    {0.688238306601679, -0.6351056280314756, 1.1667631628290964, 0.28075316520821514, -1.1575266625656628, 0.8474241901970078, -0.09433109351414644, -0.8235271446166157, -0.2320003629903111, 2.063126219917342, -1.7234632017843536, -1.8325579813770807, 1.6020877047225102, 0.1712867900477176, 1.0683495402985248, -0.19202356660545697}
};

static const float b1[16] = {6.912675650282087, 6.503101699362564, 6.759244183851808, 6.942372619694643, 6.884891899981365, 6.883904880733154, 6.674400929357246, 6.846155876854484, 6.113419071618665, 6.63608205511798, 6.256109356457122, 6.736063541700219, 5.739114852039881, 5.755893639245665, 7.023723738390826, 6.924192723077753};

static const float w2[16][12] = {
    {-3.8431347783985883, -3.5262741404168865, -3.5487079499520644, -3.4555672481203428, -2.6828282646135846, -3.2445986203142407, -4.8794097244669326, -4.332631215264032, -2.9752179989045606, -4.401754681902406, -2.244613797073109, -2.889664412239349},
    {-2.6836422202386707, -3.1956563415462993, -3.7507964692896163, -2.8069906856139526, -2.9830730723587675, -3.8995213464279885, -3.4889656590962104, -4.01774932325171, -3.766930709580947, -2.7950501683359623, -2.75105838865516, -3.469230646281808},
    {-3.997019213806926, -3.530692144453814, -3.3617497932351785, -3.7360170361497294, -2.720377157734749, -3.585958477577041, -3.259317205423459, -3.2855351978947183, -3.777533925007266, -2.9736636005278387, -3.4752309926825853, -3.990520823016434},
    {-3.110375487446343, -3.7572334501529276, -3.990685658496773, -3.787862917247897, -3.2982746061160118, -3.238425900539679, -3.711024764155118, -3.8953881230672387, -3.479735192696258, -3.5888779272605835, -3.959034199397661, -3.9349970152600995},
    {-3.204722116048326, -3.034189594328468, -3.214376019997042, -3.3771068646018887, -3.739398420418738, -3.091747782719439, -2.803672493216681, -3.7268834674595146, -3.2953534090405343, -3.8945446900441536, -3.646318861649922, -3.5671894044003025},
    {-3.192760060475108, -3.7175099623111265, -3.983613881958738, -4.164270242141093, -4.371135306952337, -3.2737400751459154, -2.9625012025021897, -3.2191021975318086, -3.8728103222480117, -3.370048860077358, -4.51844530770695, -3.054283603135339},
    {-3.832791033354037, -2.982801693863404, -2.651292652205645, -2.9950505004148344, -3.6762251252636413, -3.184810523431452, -3.687025895146241, -2.5872836564201345, -2.5627400321357285, -4.182702258048533, -3.1530432353207303, -3.234772996303165},
    {-4.130163487657539, -3.307404651151197, -3.0235130186156733, -3.347982705138958, -2.341152908219992, -3.5959204579521455, -3.1085418242281557, -4.528086258954054, -3.4313880213095524, -3.4196529446553123, -2.1465551703244325, -3.1964116111714858},
    {-2.627044679963315, -2.958969726447931, -2.6583149626204587, -4.003890456271795, -2.7655665987811653, -3.445284045730801, -2.825051870324272, -3.4172195858940726, -4.012079323245451, -2.3638067051094875, -3.1455330526648, -2.9946204998973602},
    {-4.56042570308165, -3.552605092438206, -3.1357710005135435, -2.7870710604103923, -3.8838204171663286, -3.4286231564906213, -2.829037285802782, -2.579456787474772, -2.9699745017306576, -3.3764210280954834, -3.6099226510338496, -2.4855139141964533},
    {-2.7873228425462786, -2.4386983141858702, -3.55575140585683, -2.324300877821239, -3.720187778445013, -2.570615683584745, -2.8423009980719347, -1.8174003431296508, -3.2463571325162746, -2.0860873418675383, -3.159291945951394, -2.700437833550691},
    {-4.323999053875542, -4.1065552897700535, -3.8161036671547426, -3.4163872674422153, -3.979627484448896, -3.8620464257999605, -2.9370641644649957, -2.9181205130796246, -3.407575917138098, -3.475111695894797, -4.287122424656629, -3.705758748080915},
    {-2.362007735157945, -2.7995387202274147, -3.1375722649672695, -2.338829791076796, -2.845216346908739, -2.8516779901277887, -3.299068622426067, -2.0923194133708525, -3.070605057833583, -2.963501600912313, -3.2945848888100446, -3.1687482526042543},
    {-3.0587543017992833, -2.854594844906783, -2.5543632560291845, -3.2667185376734644, -2.5676730517882067, -2.67629272616587, -3.340864139046444, -2.8798960784305954, -2.0421131287175482, -2.2486356837349715, -3.41098175117742, -2.638249438717856},
    {-2.496845258741856, -3.2344843098493326, -3.7111488911615056, -3.722808184237301, -3.847855249468786, -3.001248277994496, -3.923914556603153, -4.3109232750383875, -3.4897545596657977, -4.163719651462915, -3.522996616754671, -4.003036860012301},
    {-3.7941638580010877, -3.272976934086937, -3.6118196946439927, -3.3422224290640683, -3.8271479556167076, -3.6638552412467087, -3.4073312050220137, -4.056945117769438, -3.8915413258156417, -3.743610977373632, -2.9428318897665346, -3.733662563415902}
};

static const float b2[12] = {-3.4120415321254347, -4.0527147321367885, -3.8159553374521815, -4.495460202469835, -3.368252515046861, -4.066848144919409, -3.508844570219432, -1.8359473630240457, -3.6862651986936057, -3.7118828941818474, -2.9540758917881327, -3.3882801132994156};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
