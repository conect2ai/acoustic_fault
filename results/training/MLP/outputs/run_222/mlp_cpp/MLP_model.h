#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {0.8907905892706082, 0.7090639333996189, 0.8830403776713256, -0.3873708835833497, 0.437239290909605, 0.2155471140194675, 0.012077498560327839, -0.26210195136797565, 0.08058849254627076, 0.8122231705985741, 0.6868218860163745, 0.45957643139202176, 0.013346070537099703, 0.8110514868971339, -0.26290720581792654, 0.1797827197113312, 0.858991739364308, 0.8124243593410626, 0.473714504323308, -0.25044241580000015, -0.173142459095717, 0.08035790962936395, -0.401583703235033, 0.2840363425537312, -0.033007463663389074, -0.20188937411234023, 0.848881233615616, -0.26791473129925153, 0.6498381283582809, -0.20331969216874124, 0.3786930954280817, -0.2194767288163824, -0.23124984688923772, -0.3590268832008675, -0.25026908793803143, -0.2311445228033753, 0.7574395838388984, -0.4336382242573546, -0.06843946360576046, -0.06785487940907198, -0.11462976149202254, -0.4386395611423143, -0.4366713455649072, -0.057492482315874255, 0.03339766001085095, -0.4159859229686123, -0.05452538376702169, 0.8497131149907879, -0.1231515006901109, 0.03174450054316199, 0.8118394196453511, -0.23600342415214498, 0.06340936851366973, 0.5969289406048501, -0.41512387311848603, -0.09449844253348691, 0.7358896156471946, 0.351117750706009, 0.37678357105731547, -0.10591533791616488, 0.37060994298458266, -0.2659820425467358, -0.037815579121719, 0.998679893006828},
    {0.43766581694060713, 0.7222942540598598, 0.7042676137411279, -0.5321705586010429, -0.44407583971182496, 0.02695712942162286, 0.08947746435300069, -0.2637845117313598, -0.1758718213968281, 0.6649642266471231, 0.3857080939731394, 0.8666026993962854, -0.3338028130027406, 0.7464144001821078, -0.19331622789192152, -0.619450495295507, -0.18591294974508898, 0.5121649295171794, -0.44996510980895127, -0.41268756689591835, -0.41079465880769406, -0.2173692662041562, -0.18602607330166232, -0.06474898721807183, -0.283484048684147, -0.5475148209581747, 0.9661710647096012, -0.4424614734712221, 0.33241051948242895, -0.5145567563212039, -0.3073299655823892, -0.536508486081118, -0.718792799808716, -0.41777596401809997, -0.5389338447922869, -0.8196361068508884, 0.7596838650952109, -0.5021296359328679, -0.20704050891454914, -0.26776591684636836, -0.23489486475549803, -0.40046837242355204, -0.6524939319922919, 0.0018291410389952663, -0.20109901589966786, -0.46868642574835395, -0.2513492077158325, 0.5564776382325982, -0.43998021706940643, -0.24508882225981024, 0.5567236368473132, -0.36530631906925903, -0.3543978105521602, 0.4981990163186676, -0.6300648746033922, -0.4373513723498844, 0.731387410276034, 0.32819474522826625, 0.5830884764076282, -0.26598707973979435, 0.5537289889267246, -0.575655554803478, -0.6016721162828791, 0.4629821376112596},
    {0.7301915834164272, 0.8021683979366326, 0.6326196676358584, -0.4974884193385283, -0.23805074014092292, -0.06858075186828921, -0.011246358645304336, -0.48278772174456, -0.4708947242468074, 0.9217985385748515, 0.7038173657869181, 0.8418158292602617, -0.2764629639661041, 0.8549991738173696, -0.4158702018047468, -0.39309131894595295, 0.43706011093332675, 0.956863269306652, -0.46419140670386716, -0.6215940558727348, -0.3694738235415899, -0.40382291393270875, -0.2314133837334298, -0.3641322349328332, -0.30046400373606674, -0.43410769853934333, 0.7156217848656088, -0.26893787308834727, 0.12620895836130805, -0.3312485105792536, -0.06821981991270716, -0.3514054041952217, -0.47512309074403397, -0.3337474602668601, -0.5597640267169212, -0.5683536569467424, 0.4512380979632173, -0.3270819787926875, -0.3693085906602035, -0.1662353369372332, -0.14474932244553823, -0.4969287298813427, -0.6838268833558104, -0.16954527082657408, -0.35882474286286126, -0.8625572578386296, -0.35696716424405245, 0.6395031507807665, -0.3723239082123473, -0.3330286350629263, 0.7136401895607801, -0.6058265353372115, -0.38876731548345167, 0.4979931621767884, -0.25089644674218387, -0.4749918105567008, 0.7844630715489865, 0.5031660716651476, 0.43080614182820104, -0.2328312543403162, 0.4686854697987578, -0.8608108789442288, -0.6193538908449391, 0.5957222102246057},
    {0.6781989805750634, 0.6645790540347594, 0.7822819186191531, -0.8263410880809683, -0.37844396916453005, -0.5197158714323605, -0.3266082300508953, -0.39838004078777317, -0.3772682077776506, 0.8773988614199626, 0.6806248085669679, 0.5305692517471671, -0.5464559632375795, 0.8886816282263295, -0.5377787268623563, -0.5325581210156506, 0.49402236285148887, 0.6738123672188349, -0.48706928314523534, -0.7191247404594402, -0.7209980934123718, -0.52086392786033, -0.513729576998304, -0.40358267587191954, -0.5886850326415114, -0.5095963649718105, 0.6490507497785275, -0.5200312857501821, 0.058552017208512504, -0.6323476535485781, -0.3294674415040836, -0.6601344356848439, -0.6298365421626537, -0.6733526039266672, -0.2650423700073025, -0.7127704749822356, 0.6397846616467111, -0.2916287037654191, -0.2934194867856509, -0.617717739392265, -0.6864080193733924, -0.6827410773640259, -0.44438772740149163, -0.13581966821957542, -0.4913161142790858, -0.7065470101756438, -0.6163374137243391, 0.7396428922514736, -0.5831766923627145, -0.5182705342468757, 0.6576879964114704, -0.6384456636415135, -0.41884759790008635, 0.4052606621260842, -0.6676170991839072, -0.8754447139783511, 0.5275494687446602, -0.02413037615433475, -0.010216316449469725, -0.39285956290048424, 0.4713292184590565, -0.6770035588366214, -0.6466401945417561, 0.3294359379670597},
    {0.8198486792897617, 0.610152041231169, 0.6209138496199281, -0.8501410556506979, -0.6497158404383978, -0.3784001374374041, -0.5790753132807032, -0.5389044360237474, -0.6176006931514344, 0.7499861724304164, 0.40879653621039735, 0.26293293468291706, -0.6241338616972556, 0.9346425638107111, -0.347591515801275, -0.8573240236972864, 0.4870184406451333, 0.6877022248720677, -0.5435777506611134, -0.5566682387314785, -0.7288808881966831, -0.7058434815536301, -0.8630689437911505, -0.7320720641724051, -0.44780085439023465, -0.8336271773761192, 0.4053228777661659, -0.42154938036188216, -0.31657070462384684, -0.8675152641652758, -0.47263044012127015, -0.3887762511507815, -0.5824067282731613, -0.833074848553363, -0.8420680794226151, -0.7580001040187943, 0.5931535055598718, -0.7071292355707305, -0.46307259301426357, -0.5833237778369238, -0.5586529332249369, -0.8485951135766236, -0.6476588610230434, -0.31765731864825913, -0.5551579060019327, -0.6767636600779979, -0.7026778855775483, 0.7412219240627242, -0.4412159807434202, -0.4359754642557865, 0.6014434777515492, -0.5263031630826978, -0.6838542786665812, 0.18687443774636917, -0.5557376213916029, -0.7028396486478838, 0.09598973227766124, -0.2630422178145984, -0.1170906588950911, -0.6088230489758383, 0.5694804042116293, -0.7190762784944404, -0.8858982932353127, 0.21218180421778246},
    {0.5792616545889889, 0.6393234883393318, 0.3812154811655015, -0.761466564117741, -0.5084956635693113, -0.5356761756068716, -0.3185355297783725, -0.2935359737927138, -0.6530099888039786, 0.12583841671633336, 0.0908176520789287, 0.4740338253134598, -0.4890523527777881, 0.7162741651738803, -0.27144705572716404, -0.7412424713565736, 0.33244937169513333, 0.2991407579537386, -0.7648983519168201, -0.8898987962264964, -0.5058210531023403, -0.7682891360510117, -0.6861437822238946, -0.560236378199752, -0.5142637041866085, -0.6001489084399946, 0.23286719151006274, -0.5355826785564394, -0.1943432515928762, -0.7431543993014218, -0.3209217189179298, -0.8483074170389145, -0.6759018349612225, -0.619061119548244, -0.7086989877799449, -0.6662842174487941, -0.16461908115212778, -0.7032038125119332, -0.5828960285866851, -0.6708181918708518, -0.7052071476308447, -0.4971123268435933, -0.7949646729184617, -0.3101782815483928, -0.39981263828281594, -0.9244194160422138, -0.8594108269058893, 0.5319352928145525, -0.558777287643384, -0.5064814920580007, 0.5647933151271007, -0.666961400071631, -0.5585548437062073, 0.0271199585271467, -0.7135204181069188, -0.9389176624175578, 0.18423149113181841, -0.2834380155054373, -0.18581315181906677, -0.5558448205123955, 0.21177007433420206, -0.6542352415297582, -0.7681045391085539, 0.1401277151387247},
    {0.6015014903876326, 0.2695357381122802, 0.1854136396512292, -0.916459155546734, -0.5101537800485992, -0.39662467540767693, -0.37526391259572167, -0.36449063560069356, -0.6546055751458837, 0.16215595021695303, -0.10516495721674071, 0.10175045777601459, -0.7907940350943948, 0.26647742023621324, -0.481653592171122, -0.6273094644746837, 0.27994039455040926, -0.02924505900961687, -0.6811331721988341, -0.7771174457123627, -0.8414106746581053, -0.7749140399127981, -0.5612649586846935, -0.5725794724090706, -0.5403924192525995, -0.579867533538358, 0.0030382820123064057, -0.42535747481564407, -0.17875672974302617, -0.6473943784179274, -0.3052787443622333, -0.819868463105905, -0.5480507882037985, -0.7113484520455313, -0.7271748341003441, -0.6088057912964092, 0.1343661562124667, -0.7612290991381362, -0.33813557224095453, -0.45058728012284527, -0.3845356267228065, -0.7429829616968047, -0.5718097052855803, -0.39726472437019683, -0.5100319536011219, -0.8039503384181682, -0.7967398236876495, 0.6308736667704952, -0.7374614202317342, -0.48650999658876254, 0.44643446310892415, -0.6154869486419824, -0.5645186690656533, 0.19039562025673853, -0.5686208560212843, -0.6234799599008686, -0.22501925793943225, -0.3823717191815513, -0.24690189841387822, -0.6253638848690773, 0.039338928206375155, -0.672832108242494, -0.7466897373433786, 0.19662398520200156},
    {0.42038726330112436, 0.3394749611742635, 0.10884897404866753, -0.7281822104103156, -0.6020137381353077, -0.6040494453704335, -0.2834104268466109, -0.41124254781561975, -0.7134594815203554, 0.18948503535538042, -0.11645272921882442, 0.1887313516527572, -0.6494757711191157, 0.5162221667532131, -0.31073582276273115, -0.9273998004580776, 0.11134625737124865, 0.3267103197752032, -0.5197590661012621, -0.578501992098767, -0.7943558817885532, -0.823388051935325, -0.5469974201638534, -0.5526305342647321, -0.5231484756834273, -0.6737279616699874, 0.0547138435080579, -0.7048423852990177, -0.2976138293787793, -0.7063959300166553, -0.41574916822950514, -0.5171730339693306, -0.6005068131975091, -0.44425626232134807, -0.6408711547403593, -1.0256683455457085, 0.09808487799583734, -0.5149275363180454, -0.5747264871663034, -0.4340517307016309, -0.5564218449727204, -0.6735057343901459, -0.3957954107927126, -0.25781784413059994, -0.6480499255071217, -0.6821776416888377, -0.7519990155590484, 0.43708644331213037, -0.6648561953134019, -0.6658075044927232, 0.3396025849596721, -0.7045957239294999, -0.8385943835558267, 0.1946951269046994, -0.772153303081044, -0.9207630898616374, 0.05201723818323752, -0.45796365857837573, -0.3699880929909812, -0.5988746845901215, 0.23997334693820183, -0.6453612207700888, -0.7362835648531877, 0.26506835772793724},
    {0.3996663185479239, 0.6377376821035263, 0.5025665009929374, -0.7568481273095886, -0.5938250971517361, -0.407526028798711, -0.46225159704784924, -0.3219001285835116, -0.7529960616047052, 0.47679190080411255, 0.33289770048481276, 0.3889918479165113, -0.32553517674065197, 0.5579379095087703, -0.47575049730366825, -0.7592272036421847, 0.48012657937881154, 0.44284419614008547, -0.5117211098655265, -0.6557742849758479, -0.7069373468424399, -0.7249236831405386, -0.4064083101635163, -0.46114804353780386, -0.5645655382179992, -0.6369853520333807, 0.2711103205716796, -0.5795457326668015, -0.25131853820589495, -0.7444952619465275, -0.41272806187999445, -0.6849317402295114, -0.6279979821295508, -0.43529711523852055, -0.8345956607680244, -0.7209932391188745, 0.3005241420477071, -0.49409207408591055, -0.4534357166625714, -0.35865460209408545, -0.4638533230082653, -0.670734501702892, -0.649057805149264, -0.13182103652791277, -0.6513565538810077, -0.8482558433696012, -0.6375818988150574, 0.7895427786593591, -0.6566651641940323, -0.487470473440493, 0.4633390107296787, -0.6939636031683303, -0.8555003479082062, 0.31949890919418916, -0.7089615064030811, -0.8161216558399336, 0.23238338644267148, -0.08333242245169659, -0.36219598325858243, -0.5627671526699913, 0.18914301781427673, -0.6597959425567026, -0.7878111888399437, 0.3222045495672519},
    {0.590222893992851, 0.7229905706342454, 0.8756561602322754, -0.7114886453502504, -0.11132566800350403, -0.6365149487432628, -0.28498351314707554, -0.1878751677762234, -0.6339138951649164, 0.5524002070525017, 0.1696133161436216, 0.6879251369497539, -0.828046540299183, 0.5944998797693383, -0.5354084743314924, -0.6838715144273338, 0.29850707524068887, 0.4707269365197351, -0.46146247190768724, -0.7827703656272793, -0.5450831201700016, -0.608906339580169, -0.7381906687547294, -0.6665124542906018, -0.3817305198126458, -0.5796817118303059, 0.4033034585052297, -0.48822809596584804, -0.2397379023898854, -0.6608962802087078, -0.43286433488781456, -0.9760175569227728, -0.8946665627959492, -1.1987445137626302, -0.8620059417679707, -1.023122735398831, 0.6720708543128664, -0.6099549039379212, -0.5420592416679101, -0.5882580673111406, -0.5377448017537938, -1.001227655836772, -0.6856817587642277, -0.19644804269285548, -0.43402533060161025, -0.7301109348661788, -0.5663947904500708, 0.790955889648648, -0.6621563201827192, -0.41223411010451616, 0.3425178028080002, -0.7495983280695258, -0.5710955161047127, 0.2184170987087531, -0.7099867391517217, -0.590467765109238, 0.4835073112575773, -0.28772637814545826, -0.06504466778767436, -0.5170511855821511, 0.27686791453560977, -0.7388613105494339, -0.7336911511921203, 0.1780181464660733},
    {0.14426581303311606, 0.2975144540560037, 0.38731803944976995, -0.713032558447998, -0.3904461572062589, -0.5690358582251471, -0.27014206835414417, -0.7357578928069325, -0.5019906281474686, 0.3116075582444845, 0.12431566220402475, 0.39213600075371174, -0.5849391975118164, 0.1290563268689477, -0.5690012648821615, -0.7632561687189259, -0.20074426517745625, -0.06776279042944738, -0.6128569780823585, -0.961073326396204, -0.5386644565972599, -0.6749245307438577, -0.6705664412775181, -0.6285457040606496, -0.5853260323445068, -0.8882759917531996, 0.540558802780199, -0.5183651072657806, -0.3165909412560639, -0.5747097191666029, -0.4265903677878839, -0.5418399153292287, -0.46781734329537594, -0.7827632548219979, -0.56649453503995, -0.8309372614176951, 0.3187209824855906, -0.5362378365722539, -0.5762031898340559, -0.6187215687029, -0.5829164645694304, -0.6144655500297382, -0.47680483731041146, -0.2733366196378686, -0.6907465861215061, -0.6858343608664004, -0.7595578020676963, 0.4105969600308503, -0.5660313838393752, -0.6552820356817627, 0.3931648843805388, -0.790366461413863, -0.8223458753713323, -0.23993916835096565, -0.7435216128765456, -0.8189117076442984, 0.26657852719717195, -0.40658284858696353, -0.08417755594857328, -0.6973775834131801, -0.04276631625020478, -0.4859537254472473, -0.5757468682130535, 0.2953413753397538},
    {-0.17580190803656, 0.2202008229396507, 0.3632154333675134, -0.7853577425410427, -0.6141182449729203, -0.4285553026272795, -0.2926299995535062, -0.5589617301791027, -0.49390401661843075, 0.20320614750012028, -0.046041392923951235, 0.28420038736325337, -0.46061144456657305, -0.033515775436567564, -0.5155712656196932, -0.6576596947422096, 0.31449709052464636, -0.17270099021569013, -0.3276868334240632, -0.72679673082656, -0.8145503917514245, -0.7525720114903349, -0.1568812293898964, -0.47162634042026863, -0.5110513843010588, -0.6308424958023334, 0.23277551890324086, -0.8547320605192867, -0.22247330101702575, -0.6844452086739314, -0.4922208373281972, -0.6430714100712156, -0.607962842732916, -0.626671994135576, -0.45708756351749175, -0.661452773042342, 0.1493053311739467, -0.49813756510078244, -0.46426963365130897, -0.6492763264514083, -0.7734224732174555, -0.8774351704064928, -0.6384218514581095, -0.22372556971117816, -0.6070022416962083, -0.8500412419538107, -0.7670999024937807, 0.3737303355779959, -0.6865814304767686, -0.5460715451638676, -0.29352687697117624, -0.7321073864136962, -0.8200248525392629, -0.13832696429506763, -0.6472355114468471, -0.7524532100583977, 0.23187859513971326, -0.24572946440864182, -0.3141673191726371, -0.47613526211152285, -0.16236834617077842, -0.6995276918171842, -0.5992553679137593, 0.11730414580388625},
    {0.3853393745304134, 0.3914999757436779, 0.31365174145355423, -0.7781272854049606, -0.6651566564266296, -0.3618972852556087, -0.5093574418985375, -0.33980456448181634, -0.6157712305610903, 0.3152611664758094, 0.23083819833743816, 0.1952906329659264, -0.651667236413822, 0.4721252162413586, -0.6485043657755741, -0.70063109299779, 0.2425257646404656, -0.0420022804347083, -0.7730388595774366, -0.7527100841923264, -0.5056447229649056, -0.6344321555881686, -0.5147509988557543, -0.4443095562399351, -0.3398171258421183, -0.3611485142071441, 0.22731182997935498, -0.3112669880325015, -0.42940455770907604, -0.630389863556866, -0.5857492465298462, -0.7392647166527901, -0.8000306868651301, -0.8535339035741476, -0.7336193951654516, -0.8511278508018414, 0.4446639565282541, -0.6003351763886228, -0.6435090222955955, -0.4436999764581029, -0.4669710975431676, -0.631469565700942, -0.6629185067831508, -0.3342694824531394, -0.44844361317092185, -0.5182200472626413, -0.6524645268843365, 0.33904139095095687, -0.7548572727449591, -0.38161645890566265, 0.1869792157760055, -0.664768412102269, -0.6079543094752204, 0.04158979528379975, -0.39876214767338797, -0.5568317216086387, 0.3599935285553719, -0.4088449063481713, -0.3313552294469261, -0.4707234426951384, 0.1453041602969962, -0.6066525445260145, -0.7747945932811215, 0.07150218164896703},
    {0.12168565554262334, 0.5828497929795121, 0.6629784643746136, -0.7834775418271102, -0.41235819138354374, -0.3355492763102862, -0.1966984251179151, -0.23612005968088265, -0.5730120769658187, 0.7050838117985304, 0.35287147354871157, 0.42455060761033137, -0.6155989104375891, 0.2717432686303835, -0.34656490136948104, -0.3691425260420715, 0.05035288063513085, 0.2707220001015754, -0.44283920366483703, -0.82658126838113, -0.845668231611064, -0.8728964532925313, -0.5246430624248125, -0.570349285723704, -0.23681273642216552, -0.518211078112331, 0.6568820811571399, -0.5912632228332794, -0.15823493682722842, -0.7083401356285691, -0.4003996012560857, -0.6309885064995218, -0.648272733270472, -0.553643726605585, -0.73445627356222, -0.6627552997373113, 0.27432179109760957, -0.5591685784910277, -0.5836063323854045, -0.41575563672912824, -0.48998922301451275, -0.5934238212593853, -0.48161065978065465, -0.3501544425294796, -0.5957389387399918, -0.7993047500289973, -0.5531704455036582, 0.3623912780114701, -0.47982675377138245, -0.5367208626239373, 0.13431486786462293, -0.8917443886978839, -0.668696318116835, -0.4002336374997517, -0.663078389673094, -0.8308672399314032, 0.5261539152241047, -0.3951227578029599, -0.19387808247284757, -0.6597014742988566, 0.14529276129035668, -0.825140689215162, -0.714537085869691, 0.40326327623552366},
    {0.6087070457207375, 0.6868057321823424, 0.3180756408830073, -0.5322557417748546, -0.7098190008031219, -0.4094158832166954, -0.07124957175841125, -0.4645732886099542, -0.7949818382334876, 0.683783201299995, 0.43739925296955345, 0.49000644000631827, -0.43298985325822664, 0.35526641972319806, -0.3548549347152699, -0.5033778354790294, 0.15088786351130926, 0.3374696020905332, -0.5153197793098132, -0.7101788112645065, -0.5454822204906505, -0.6306342038592427, -0.49663232041194916, -0.5083797472751752, -0.4098173469875022, -0.8056008939435338, 0.596255213808296, -0.4405111193414552, -0.15620204567618376, -0.8554681839613753, -0.21394782742499907, -0.6270037378323331, -0.5259224240948265, -0.626119948883051, -0.6642791409640842, -1.0084586605645622, 0.88289635685755, -0.4994495660077175, -0.7957449501894259, -0.6070736838306862, -0.7439114509507591, -0.5801137521487969, -0.301715973769936, -0.2733492449722672, -0.3008725594468068, -0.7371729434880171, -0.7032588274357159, 0.8621674925452042, -0.6138455763855201, -0.4358223806585852, 0.4810256271476172, -0.6789057103118168, -0.4643437829473916, -0.0017117612308159072, -0.4484948245209318, -0.7518893591625857, 0.6765366875798563, -0.34707559055816467, -0.12096863305878162, -0.5652478022044661, 0.14888580968331794, -0.4867958299178826, -0.5443866630042721, 0.644044637122592},
    {0.8729508975431115, 0.6767079463780146, 0.5014991651842273, -0.5713676274640843, -0.7636228011756813, -0.44473964534437044, 0.006041998291801059, -0.4545827180673481, -0.43012581379018233, 0.8758867405753851, 0.5786625381852796, 0.6199103958409893, -0.6715170578957338, 0.6175844835393223, -0.2764234488786327, -0.4790453878715534, 0.5228544821078175, 0.7372340774705852, -0.5473382620513928, -0.654044295987073, -0.6536726601963848, -0.6876570651880731, -0.5448523919116619, -0.6314660706190468, -0.4512205539376199, -0.48260344221914286, 0.7639120177642852, -0.5627482449209263, -0.11212706999950105, -0.6969960840929972, -0.5243788798700733, -0.6118883001650918, -0.8187631051520265, -0.8753001629019375, -0.532685288011579, -0.6048275614815494, 0.6253077771504832, -0.5332859817602742, -0.5823819523571123, -0.2083610605850978, -0.503907856785039, -0.6090264158793839, -0.8044126393832575, -0.2991147472607979, -0.5604319201899286, -0.6114153450449054, -0.6042521226362265, 0.4541949929101749, -0.5902283785197349, -0.5745588544571218, 0.4895208698176973, -0.6284144076685878, -0.6934618915744667, 0.14857261748581005, -0.4130300972936619, -0.7945961616520669, 0.4428002190155584, -0.30003957581132573, -0.07046770852106886, -0.4886783713140929, 0.4122077738313918, -0.773487247102545, -0.6189305870906135, 0.510964905945068},
    {0.5604271398722156, 0.7325290342893874, 0.7242489639305969, -0.6542572939018174, -0.416000993727557, -0.44509070973222525, -0.3562716156405694, -0.7062229988549016, -0.5802669588357441, 0.7102388138339432, 0.7595109329266881, 0.6940906433703556, -0.38221203813641574, 0.6966965952871066, -0.46233059104783447, -0.6128326415600899, 0.6638196312041832, 0.6093719195758094, -0.4676235373186425, -0.7882596313913828, -0.7002338683379989, -0.7649917562514073, -0.36661610738604294, -0.6348733394160049, -0.41754312915286396, -0.5854371399789244, 0.5911538672585733, -0.7882307716711309, 0.07054181834298859, -0.4629107541986008, -0.3070273254123779, -0.5791543608344941, -0.735504867608302, -0.6396857002169404, -0.5983222584928428, -0.663149696695813, 0.8370691420549283, -0.5384995316530273, -0.2740970750108345, -0.4906975636142075, -0.5382103553689214, -0.7086883170367733, -0.5623420280261195, -0.36381065715479566, -0.7427762887887729, -0.6944874330575839, -0.6209129533538817, 0.9360419884455696, -0.548909229945629, -0.4921293552986628, 0.7746445540654042, -0.8278962317434104, -0.5525598783972323, 0.21378000844482134, -0.6636048656696005, -0.47584125222534396, 0.4818422064495289, 0.05511256329125887, -0.12750765381332374, -0.4121295262087934, 0.3009955912878346, -0.6650071873281032, -0.8743293575448219, 0.5182279416065048},
    {0.7088954957717101, 0.7557549949934537, 0.9223649036798739, -0.5954003859316649, -0.1342305176729234, -0.11510570151511104, -0.17071431312643734, -0.3662189873339309, -0.24313935851816365, 0.7732682076805845, 0.706017176857116, 0.936030467364191, -0.49742102377306324, 0.7562248153353279, -0.5223712869193637, -0.37769093158310885, 0.5777341751416941, 0.5081702874943868, -0.45529202076200376, -0.42973713625019094, -0.42239013270719705, -0.39075935093587727, -0.19052908928848014, -0.2791595132726752, -0.046766363716293384, -0.5946621814427527, 0.6581454106525657, -0.3444251420025158, 0.42417829674850877, -0.6373232493206492, -0.343783320674216, -0.6309960909394632, -0.45048008649426813, -0.4791172599293847, -0.354717043915731, -0.5475234718311468, 0.6156330698174981, -0.624288910221702, -0.24291098143610906, -0.43757561855579913, -0.2772558762569913, -0.7215827398036174, -0.3178760871662042, -0.35760092665585347, -0.2589995640692044, -0.5885192984647221, -0.5175019828207307, 0.8172386678422914, -0.7544086071933884, -0.3865492844222401, 0.7684771181634482, -0.3696289938092658, -0.530573319009886, 0.532490254510483, -0.42036895742972213, -0.33088484546294594, 0.8125316624651083, 0.3071501287515272, -0.10205038891541815, -0.278624182794173, 0.6289528794363825, -0.5849675844860592, -0.7513388744196342, 0.6948090459707423},
    {0.8125117019528344, 1.0062544559350248, 0.48516726118575915, -0.5433461624378569, -0.31367246154727835, -0.3261231668970411, -0.15748152833926415, -0.4714542722293178, -0.36086895009945547, 0.5148457736280522, 0.8797680139236329, 0.7880283168672563, -0.5690972880948791, 0.9209083153317014, -0.5600595278502088, -0.28136666461663945, 0.7474315652751969, 0.5688402033337244, -0.5582402471835723, -0.6382919748241838, -0.3933948761232931, -0.47746323914779737, -0.3105053755209867, -0.41642150108539105, -0.3562800610096513, -0.5973595634593312, 0.6076788205229116, -0.4047983050822546, 0.4725063731675509, -0.35269459357452804, -0.03443911259079465, -0.6203448932055601, -0.5477983468539719, -0.8300781163789315, -0.5136832990888462, -0.6779564601656604, 0.9128716613314728, -0.4411517475677102, -0.42315959724031826, -0.44402129170530386, -0.1318158384086376, -0.6513303145214556, -0.6045348823602064, -0.38160722052322754, -0.4268782870905533, -0.6812504925825189, -0.690703919066258, 0.7589484833201913, -0.3031342744711539, -0.42255745120105015, 0.624743616950786, -0.45842790706497155, -0.5784174210867425, 0.34509174466884907, -0.43806939907007997, -0.5248870255667419, 0.3789097969196141, -0.1350697399755804, -0.28411638650106036, -0.28776460111107083, 0.6584138905292066, -0.4196219114909205, -0.5522230077134704, 0.5316869893465301},
    {0.7062627943040651, 0.813289423605976, 0.7395870562124744, -0.43542001966852395, -0.6935224176951288, -0.5164640344313077, -0.14989774945977052, -0.6043033920091223, -0.5412945376959553, 0.9233664421817978, 0.5669453156005335, 0.6071601830753713, -0.4206257532525372, 0.7085961191975081, -0.8449249117989075, -0.6198151530916579, 0.5874939699430464, 0.48415044902912197, -0.8038185682905478, -0.6748813249789409, -0.708534950761242, -0.5686559142061897, -0.6930923640347754, -0.5087839070055277, -0.3554600030108073, -0.5223759405038175, 0.8028050658576593, -0.8407950503389386, 0.2548488820949463, -0.4822710315065033, -0.335775514527996, -0.6367666775646943, -0.6652996290316131, -0.3982208720638952, -0.6899848825016969, -0.7693678858227482, 0.7896819944347584, -0.537095850244153, -0.7588717933725035, -0.6081488515672004, -0.4347735235620003, -0.7772264087196215, -0.4641265522281612, -0.45321431329805484, -0.4269407846398131, -0.8054790228584177, -0.5550344524876366, 0.769619994323066, -0.510644633558628, -0.47517579910262203, 0.7779246017097862, -0.612735818142174, -0.6235681649289753, 0.0025837331732459726, -0.6487765135964046, -0.47473987503218573, 0.8331774784361298, -0.28848738621507497, 0.19923247568956426, -0.7238406384177403, 0.7176088871199113, -0.8177380167171083, -0.8609097923526031, 0.6573979676210959},
    {0.47513738273946504, 0.6679034062275032, 0.7427223642304985, -0.4635180719414161, -0.6233959627922075, -0.3027619957095366, -0.2501381670730454, -0.42121492676227185, -0.49242969781062007, 0.6826320497368785, 0.49935493712625306, 0.6043043350401558, -0.5882775187735058, 0.8106187898502559, -0.5979594878727756, -0.6302572652004607, 0.44668631083558386, 0.5045691536142641, -0.7096753026105613, -0.7835591658739572, -0.7065607560942164, -0.6438397748155946, -0.3310982112636434, -0.4828514500713882, -0.4041399517328275, -0.4870180335005576, 0.875156903041452, -0.35708611342134844, -0.08898549559167121, -0.755270590319593, -0.16365093571443423, -0.47374819812421703, -0.7129873986978831, -0.6121059547196617, -0.46478863191592074, -0.48045101135280543, 0.5187944585801763, -0.3808813534634338, -0.622769257548273, -0.7429287472598409, -0.4184699345914881, -0.5358378280771148, -0.6117822749297264, -0.1689952210390319, -0.3714199761420186, -0.8124174503919875, -0.4178821625533065, 0.8726882456772334, -0.5341183912324307, -0.37800784992474723, 0.8551316087838067, -0.7347812703348627, -0.7697984984242973, 0.37572915082938574, -0.5997260764747677, -0.602497734464379, 0.5285787043749165, 0.10094239638863134, -0.10665874956994408, -0.5388182715855006, 0.641961702210199, -0.5315501441609711, -0.5113946356200998, 0.6101895834358929},
    {0.6662666312960946, 0.6920414741542532, 0.8388791119662656, -0.5586439846747898, 0.02746053110544474, -0.5102296975172305, 0.06457969516989327, -0.5109144529145905, -0.5996708909454647, 0.8932750332549665, 0.735370648113111, 0.649921388205052, -0.46934478580357497, 0.7212904526519152, -0.6132143877198158, -0.6539437630596447, 0.8071944913226266, 0.7914266027098054, -0.36012936256189443, -0.6722734940850719, -0.18315292584791662, -0.6624420078569099, -0.3158200317413858, 0.0585465673287332, -0.4276677215239223, -0.6881436148504717, 0.938180190773868, -0.3377303280465959, 0.39803557912423976, -0.38282602875313654, -0.2124878820584954, -0.5109981488322561, -0.6762823058234667, -0.5057406291618197, -0.4801322286856978, -0.47329076178560037, 0.5327894022715, -0.5406113735572762, -0.5986536565089327, -0.2832793159669539, -0.44509754977108085, -0.6781611048585312, -0.4865764195745681, -0.10804291428207942, -0.31088507388250275, -0.4551893059769937, -0.43798991088432293, 0.9574421787387439, -0.3100041896700076, -0.10422904087106447, 0.8837331066470603, -0.46249902568351997, -0.45031204846000944, 0.526265575909932, -0.7989333549143084, -0.39966086102326215, 0.6876722779849235, 0.035042767094308036, 0.2852572000229029, -0.09365622210160254, 0.5141049691674259, -0.3947297311488409, -0.4750050861632885, 0.7306699405797061},
    {0.8103945367232412, 0.7012979669938986, 0.7750701879790325, -0.5059494769791101, -0.13786546031647615, -0.1323997694313142, 0.23493673376523772, -0.3210309909554118, -0.2367538053425864, 0.9588040504706254, 0.5446715161666462, 0.8339417656115689, -0.15158777518923935, 0.9587008356852084, -0.30443112567417974, -0.3479108996012982, 0.8548346614928661, 0.6496889263650812, -0.2890903899034596, -0.352647360672851, -0.39202444051629776, -0.36548917914604623, -0.1792109984129664, -0.19130994115584546, -0.089525681369275, -0.24503855597120083, 0.9144551788431258, -0.33603404090970024, 0.5182016463515435, -0.585130482407988, -0.07481561609754911, -0.560945549035399, -0.2956304018104312, -0.5788630544512723, -0.422529834413436, -0.4255897610423439, 0.8885721723372175, -0.33167268199555816, -0.3365458836081109, -0.47249053122868384, -0.25731820096304026, -0.5116751447482193, -0.2881688370920477, -0.23410798932165952, -0.16099184099466687, -0.4282716617145641, -0.4123059205461397, 0.7392864955887544, -0.4253981015426878, 0.03730693698109494, 0.6490197663920969, -0.5664507562254906, -0.5831721580279684, 0.4551940293625132, -0.6429412130016384, -0.3882585659558087, 0.6080901907644095, 0.21036782940180718, 0.20853118527700376, 0.049266806632030265, 0.7636522950523297, -0.42790054996327154, -0.40666386921662884, 0.8257942488394052},
    {0.5430816260638067, 0.9072415423194257, 0.873166985419306, -0.4909870196657226, -0.380650439026277, -0.4856601689622291, 0.0987642917206454, -0.4524794367399073, -0.44497896664566927, 0.881500372646487, 0.676706987536004, 0.9168809271431616, -0.06371854349513068, 0.9052556747564245, -0.4979630006967429, -0.6553225728111375, 0.8035273533527801, 0.7172140071906923, -0.29610643288345817, -0.4346807782663618, -0.6449782178350243, -0.32108238908906145, -0.3096207919391654, -0.30087890770684533, -0.4907496145667866, -0.6338627663420322, 0.6835009212530048, -0.2259154310326446, 0.3563730594570416, -0.45191510150010245, -0.46272177287137256, -0.7703985723295027, -0.6250288516527842, -0.6563583936799576, -0.6175101105777152, -0.5484767596787083, 0.9259195377242869, -0.33552165740750584, -0.5804874709034377, -0.28422394193026973, -0.09561242491842921, -0.5853794757989155, -0.5315318015050393, -0.36083017038806353, -0.41389660077765095, -0.582936953214999, -0.35841294844661753, 1.119417283693752, -0.3588025773301321, -0.2063166597797998, 0.7784021606457976, -0.7028144168733836, -0.5951018378036592, 0.4855718751339194, -0.8297325686473163, -0.34235046249297135, 0.8370928310943296, -0.029217907815221576, 0.10430696922410095, -0.1702282559742761, 0.3975477846426308, -0.7111462426840511, -0.5227086237669017, 0.503500702049998},
    {0.7264192677325533, 0.8545903723460525, 0.767717338100716, -0.6365372528425673, -0.3363238957737616, -0.6181478652019049, 0.08891872570650299, -0.258718848649539, -0.2598835307942933, 0.9349693545636768, 0.6623898149810672, 0.5886874631688747, -0.4595083613391282, 0.866562482696428, -0.3823172311663725, -0.5384233249004411, -0.030149533328885585, 0.5182412629083427, -0.41031897651399185, -0.5084110295404284, -0.6181936930934713, -0.39267902838660157, -0.32639003683150464, -0.5149174201361184, -0.6826622647098308, -0.6829373798965365, 0.9881843791877771, -0.647188397737464, 0.1310269589257031, -0.295531408963182, -0.3874676221567933, -0.7179173780434301, -0.5500150620199122, -0.6923152035347263, -0.3765953366218016, -0.5501724002646756, 0.6569658071355388, -0.46512735209948103, -0.5248549098396047, -0.22701807502226234, -0.3998128246849917, -0.553311401321786, -0.32245066394868477, -0.28575328272133527, -0.5296924064962549, -0.31427094806557804, -0.6404847571876229, 0.6845858067934864, -0.34578005028783787, -0.17990729916314696, 0.7014134714148849, -0.8883778061387284, -0.4851363576520357, 0.09841364144823618, -0.6254230995625265, -0.540676732381181, 0.6961230961038197, 0.23828868548256366, 0.07035325012217056, -0.2590865583613389, 0.17604137869682576, -0.4249456267323182, -0.5680498159900988, 0.7160767107656375},
    {0.7775191636024475, 0.7576768465859607, 0.8868050036255903, -0.3737866747282378, -0.33391266790993285, -0.4942955844973918, 0.03773568228615879, -0.5439545312430476, -0.4855724906399941, 0.8834669159500382, 0.5993642026598288, 0.7075903525670466, -0.4865580024508995, 0.7238814197760131, -0.337494785698727, -0.35293476455982203, 0.6144237520636636, 0.47871272541836984, -0.44919967421378487, -0.6801472792019312, -0.6094978678826019, -0.46507286875234755, -0.014666677597739873, -0.49980645633389637, -0.43138190258158493, -0.4853203134453743, 0.5348577000017257, -0.4042471035414956, 0.10338978181085576, -0.576118734081792, -0.27019791698384904, -0.6567379708431439, -0.5043690416797597, -0.7311430664384911, -0.3546938491387813, -0.46062295059575437, 0.4970345677707044, -0.6900075279238224, -0.4593742404175898, -0.27797452554589347, -0.5052364465097321, -0.5508842772973145, -0.48500490838977084, -0.5310670265900713, -0.5525011475952923, -0.46851155948055684, -0.4259402947733935, 0.6598677808666775, -0.557984582005022, -0.28576255570936704, 0.7817098653508393, -0.619987443410906, -0.5232570333744921, 0.24738238538279644, -0.6103712518201834, -0.44236134514004616, 0.6510216096947138, -0.07516228801817387, 0.13499534568774035, -0.18191047802362037, 0.575302509658718, -0.6645261604387025, -0.6492970270866275, 0.683364155751393},
    {0.8085908556981547, 0.6152517195278621, 0.5541579853557169, -0.45722701541279925, -0.2521115627623776, -0.40802834691912493, 0.28072041909882306, -0.39604584793614145, -0.7664037526645905, 0.6935837145336103, 0.7015863886003662, 0.8649379341191803, -0.40461921110944726, 0.867056268791427, -0.3137246470365965, -0.6999049587055032, 0.5205940719245618, 0.6194880274797431, -0.40000909053066175, -0.5264991308872645, -0.48829995206590654, -0.5261522601829373, -0.0641977337619644, -0.20461597275561483, -0.3267758458929215, -0.5968750387232871, 0.6908490981051328, -0.577988207164601, 0.43114547973353357, -0.40107390204666893, 0.04079017965574786, -0.5191958858475968, -0.5697748146071077, -0.5036721105153463, -0.4430303747593711, -0.6066945954431034, 0.7460546696662598, -0.4176835895218741, -0.3123680885737608, -0.36947749215756875, -0.40010817663449755, -0.40950078521467104, -0.3879182839179202, -0.2244719151095781, -0.47256965920733146, -0.4104478046533194, -0.5611464340415709, 0.49247173656670873, -0.4138703124021653, -0.26754263183868227, 0.665389131076831, -0.38807050995446457, -0.6617089992575864, 0.45694969954334325, -0.45516379277066177, -0.5036321615120589, 0.8565601621209085, -0.046913468916874035, 0.31332033152977107, -0.3610128662475058, 0.44826811036111935, -0.4888568262837612, -0.5454336921605241, 0.6594119027226805},
    {0.5093007375536897, 0.9137127449151314, 0.9474158984804031, -0.6608680052408916, -0.566939024803695, -0.17007062619191465, 0.07755847477621572, -0.4638696447641309, -0.39045621660607266, 0.7619883010179301, 0.8701339375480667, 0.8706248254147044, -0.31784430982463396, 0.674025317439468, -0.2600170375646496, -0.5479084293205808, 0.6189742343069166, 0.7431307818548216, -0.5796453508354243, -0.6784536227503793, -0.4973006655820817, -0.9173153824865807, -0.3330260173597742, -0.41538939701425825, -0.4445773775005938, -0.5867167733807905, 0.7018465281855989, -0.3669394348064196, 0.23244594230863286, -0.7982580251242472, -0.228107284787096, -0.4546555570989784, -0.565849827574366, -0.8261826974385351, -0.482423645239728, -0.7762399512188047, 0.7511414277075029, -0.477213358873864, -0.3940387652766018, -0.5011020840153176, -0.5049943986905384, -0.5091074355719352, -0.32092632747165134, -0.21679230988820683, -0.36808288429315655, -0.5103213433825395, -0.3527030480759951, 0.9554928814053941, -0.7313616631397581, -0.16667267806676073, 0.9141661623120529, -0.4625328375547241, -0.5922877213720719, 0.2768457964537382, -1.0137704769293607, -0.7295637896291972, 1.1727166858054465, -0.05081753901882478, 0.3271232818084226, -0.40249281581472607, 0.6537088033218641, -0.6017963846274755, -0.5361069522260319, 0.7990749407735623},
    {0.5924865013356932, 0.7965881847061044, 0.9056370250064631, -0.6339914342362931, -0.4612204155216348, -0.33876485828441844, -0.16537465461589276, -0.4854563271168347, -0.5015974331425066, 0.9313019029382831, 0.46268297451053614, 0.7583525186832996, -0.48674871248089935, 0.6677188167805059, -0.4084196831471538, -0.5031787205936009, 0.6906363294718633, 0.6339000455101819, -0.37653092922490167, -0.5154782644109459, -0.326098101359578, -0.6269820458993862, -0.3475524138935737, -0.38837148920942993, -0.3630779683989279, -0.7959431561822591, 0.49122102098472087, -0.5423641572871649, 0.2859697000185325, -0.7196389284691915, -0.05796347991737745, -0.5691877343055386, -0.7682514332467842, -0.47798624098752607, -0.6325928281776481, -0.6702905684015239, 0.9333251752095232, -0.2791106023129458, -0.6466910433768907, -0.3008949812788974, -0.5297391344581702, -0.5436159126336143, -0.7323189376798535, -0.11719638936144876, -0.5752653545890163, -0.79989003375309, -0.4951122317517287, 0.6431685467765447, -0.4339065953362494, -0.18117660532299495, 0.7484260415196865, -0.6282085951596201, -0.6922498304713713, 0.48557866349392775, -0.7063601698685387, -0.3654815171687872, 0.8787952465979982, 0.23283955218658856, 0.061860701688733706, -0.20729643100159723, 0.42170748862334256, -0.46466984766970776, -0.5870586321070385, 0.48384410245583015},
    {0.5064297382644269, 0.7624370815178356, 0.6243856294013248, -0.7387869285728087, -0.5583102096065172, -0.3424078733840391, -0.037404978226065956, -0.5607975553913372, -0.11648181008576858, 0.832665163564393, 0.6046979630023733, 0.6085200591285059, -0.18140621109912952, 0.7386153592638762, -0.4848886707592013, -0.45031219835067476, 0.37950392554710066, 0.5348173875177312, -0.26181130014844173, -0.5107353878245164, -0.49679199647107347, -0.5636610771441474, -0.24652162752650442, -0.43770215778160787, -0.5884077300663737, -0.4817037310690232, 0.6510322069158236, -0.13212707411332755, 0.3656330361494079, -0.5918221863445302, -0.25622513108979317, -0.6286498661276143, -0.5329614337614235, -0.6672773437206467, -0.6484763556476406, -0.7241150108988127, 0.9498585582362258, -0.5824317920234335, -0.456494736072071, -0.5043986925896722, -0.3162641683248823, -0.6001710417192437, -0.6202015729926026, -0.13667670699175424, -0.4224634529095267, -0.5093340510492963, -0.5588615962078689, 0.6650796120460336, -0.46372172605103373, -0.39014000979329905, 0.5657872846535452, -0.5752061413741506, -0.6802160281798387, 0.18973239961349833, -0.5530848458410659, -0.5374543557614635, 0.6972455054188216, -0.22658492584595716, -0.15027284607137328, -0.6123740774013188, 0.4211715120659192, -0.8070913728263108, -0.6762823683264184, 0.3644720286212618},
    {-0.22890278121169105, -0.5494450957145955, -0.4625635336938191, -0.00528920199485967, -0.578145735625775, -0.11727995517645505, -0.017904759129893925, -0.34044201610589675, -0.4690481062690579, -0.22155061402644025, -0.2986451952934053, -0.24559251070525262, -0.6728137128163071, -0.41444777450964876, -0.29780675264729883, -0.17242940266424864, -0.34483818576770553, -0.7158614750537319, -0.3707864428636439, -0.5981554493664732, -0.33942003576043434, -0.4310551469037358, -0.6177985920833683, -0.6846620821417072, -0.41133879819497676, -0.10017374954567895, -0.6385468837513146, -0.6919944084249737, -0.2645526331316354, -0.13912005427441362, -0.13140429912655555, -0.4158016313707555, -0.508672399810267, -0.0955098487427661, -0.5987462580097824, -0.5244049003493183, -0.33600247881998135, -0.3427586420070949, -0.3801076758832578, -0.3290835166034934, -0.3895229976481008, -0.18762243530174402, -0.15912493783461637, -0.22446172000822093, -0.4077424598735913, -0.16822619542311085, -0.43570208218393713, -0.36801164499871813, -0.22493556245071744, -0.6106692545753155, -0.37846276654154803, -0.29295761975991835, -0.3086385800039207, -0.13942793910433582, -0.1088204077096964, -0.43395294859401307, -0.16831231318228354, -0.5976579261291215, -0.7159527638595092, -0.5759125475602755, -0.40245074100055134, -0.1639393236707497, -0.3561366139010542, -0.48831828109100495},
    {0.5028401019407412, 0.29495144030578274, 0.613512308349953, -0.3451000749917817, 0.3755344559889651, 0.1629647163803166, 0.17253259802896698, -0.5122571462902095, -0.25038049385468003, 0.36640527832685676, 0.33587501722895013, 0.365338932044368, -0.0997884941561279, 0.5575084433457248, -0.20690881063935962, -0.24223124393536302, 0.30814070904568003, 0.630555761650777, -0.12523409208545888, -0.1847485317801019, -0.0985728736766423, -0.2812251007252573, -0.42243015082006, -0.09085646816374962, -0.3040139795923743, -0.0483666010680164, 0.4597326732197884, 0.009712597940769507, 0.3245588577678826, -0.495376324025374, 0.27024824288628924, -0.38333900255020614, -0.4722199942720843, -0.37866520626529, -0.1645509579204805, -0.334064031867485, 0.28153874113287664, -0.1367978662779981, -0.0889485808298947, -0.29673209344892, -0.26227140476340993, -0.6413560350206483, -0.2722431192612445, -0.08850199680269688, 0.07176446359805516, -0.10966185465948017, -0.361838878498862, 0.17663685416253533, -0.21788611771765487, -0.40800715056073533, 0.4488479040812837, -0.2818170945941155, -0.16206108427094418, 0.23370268955090778, -0.4309026165729397, -0.2463748288864866, 0.49435079690242745, -0.006747787980827056, 0.22691905002570104, -0.15776345784354318, 0.16630599178231678, -0.43516693004031276, -0.2667913884666265, 0.4024638160365425},
    {0.09227713020720901, 0.5127701483639405, -0.43377129268839004, 0.031155625239653036, 0.17880666696885422, -0.408004933838611, -0.2947207778022941, -0.4255031576870414, -0.34105420252398067, 0.09176879443611885, -0.2965655598982571, -0.48269343721579683, -0.28634236042704714, -0.1601836800989795, -0.6980094266176952, -0.371775201219748, 0.5360884077806732, -0.24447009942888145, -0.2041934366763552, -0.07241082509983994, -0.5162170240945152, -0.5370457571261731, -0.31712263598395135, -0.5001426446012043, -0.2589728966184722, -0.3287108180783646, -0.4652769088127592, -0.5779675682286083, -0.36188374505456544, -0.3980423199857743, 0.2550817806717071, -0.5632490062381257, -0.10828008854175368, 0.017769607900423465, -0.33860744096791023, -0.20044340098685967, -0.4496553062002458, -0.6025110205761497, -0.6405399212886453, -0.6705735528099773, -0.3489967831003751, -0.3357115413860435, -0.37178743665829944, -0.30945993687929857, -0.41678516934654464, -0.009679579868025206, -0.2784910500504598, -0.17427360678092546, -0.4549314130147459, -0.7943346603950829, 0.2971788087961257, -0.2949705975637865, -0.2723915420670635, 0.11679327472092796, -0.24376977083043214, -0.44818972438787963, -0.616452426520371, -0.7125696072122973, -0.5425866405798309, -0.5580359573899485, -0.1025935701682194, -0.21471381146295973, -0.31633608634419724, 0.07083786498405036},
    {-0.3334096071199163, -0.2074421100800853, -0.018834281241338686, -0.10833825933405136, -0.22654655690068198, -0.4756794848202728, -0.8071583143486546, -0.3674864142841473, -0.40226752671002713, -0.3767093119077256, -0.11916158893913502, -0.4381653639085296, -0.19030690082881924, -0.20643369864552444, -0.09404739087511413, -0.33988266656307264, 0.29717250162251224, -0.20410804597289167, -0.21550360116256237, 0.011829492231119914, -0.26493907737693223, -0.29765574088568436, 0.18005070582524646, -0.5312953544747735, -0.364990015602395, -0.34261254961404386, -0.34968677327819575, -0.36908248076378913, -0.29263376886594705, -0.47238869291494123, -0.06975366644490641, -0.14674220396508283, -0.3583969974134984, -0.25199202543161126, -0.601382657730397, -0.2767903470578359, -0.3213075571572062, -0.37813193481197654, -0.45260043264665384, 0.1258636081408869, -0.7071441242755774, -0.08356674205022543, -0.21102742091731974, -0.13497580662254344, -0.13562537059655394, 0.029874522318847466, -0.14206110548458636, -0.27749872685810983, -0.1256204019156762, -0.33411839331878795, -0.16274364562171198, 0.04437141026081483, -0.4571855969683419, 0.11915004654910012, -0.24348599616289068, -0.18906900252116113, -0.3461715666561993, -0.2452856530778849, -0.4522069101939612, -0.5146161094597353, -0.429747292352354, 0.025112122136195004, -0.15904481971375867, -0.2224962967282609},
    {0.27932899707314124, 0.07928844330401902, -0.18514775894748092, -0.24763084836571175, -0.2858718901453585, -0.8113777596709315, -0.414397297563706, -0.6736060114294355, -0.4830841550588711, 0.13317715619237405, 0.0013527825753779396, 0.057627819998142836, -0.7409129567390323, -0.043150107465391586, -0.20114080762950967, -0.44387654842665253, 0.05776855226778096, 0.18127080429096687, -0.06892962498939241, -0.2640623670624671, -0.396569976212116, -0.3960989358119893, -0.2388141414179296, -0.28736929813829526, -0.615823320523939, -0.555875763315113, -0.09154645136326973, -0.39141990363276646, -0.3002152577486718, -0.28087244639362474, -0.14216618940782316, -0.44334316933204226, -0.38030241011225, -0.5197992421570833, -0.4289396713518845, -0.6145153912860079, -0.31634079425599754, -0.6229185278564547, -0.46758385208231906, -0.3116692017848161, -0.43385283515192, -0.5592293443335029, -0.5093753832687113, -0.2907590865449432, -0.7350658816715516, -0.5179122739402339, -0.5950609726529006, 0.1141399588047798, -0.5123795971418469, -0.5584371278238384, -0.0835197996435224, -0.47340576389896327, -0.6049664484719438, 0.2403747983609676, -0.6006549743565841, -0.6822015465067888, 0.3330673956248001, -0.5002207335945292, -0.026602453480605106, -0.30457629742382764, 0.009108151314449451, -0.459506775412246, -0.24467625448541144, -0.07219579613841573},
    {0.2939651184117465, -0.08669736307479313, -0.25441143928436316, -0.32207673784078683, 0.03690791021201731, -0.43614445158561205, -0.20397179807685598, -0.4804200355653386, -0.32461550787487736, 0.10404900153037976, -0.14696045599085922, -0.18782535849453527, -0.4996273564687834, 0.2711016731739967, -0.3714844084059463, -0.28965959044224, -0.09510667040899766, -0.00031387549448659037, 0.19578891007566093, -0.0866626304004445, -0.6011153417053688, -0.7252535077166015, -0.6394222804204749, -0.11119622170472411, -0.37032225002852776, -0.35785409177975336, -0.20779433025587818, -0.5332268168114797, -0.1437301915551238, -0.6224803356678175, -0.020432031105576145, -0.22575560541098655, -0.3888117245064249, -0.4988449502768394, -0.19966220609813623, -0.2612379437820716, -0.2939424466025601, -0.48793974399678397, -0.17140025961170302, 0.022265788667005675, -0.36932294738914295, -0.4402836437994226, -0.17694716870461402, -0.1124823654569014, -0.6753825580211568, -0.2064955730947826, -0.16573926054367968, 0.2216774209945088, -0.2528690782683783, -0.49434681069726294, -0.1099423416101304, -0.4230666920016663, -0.2989979479683829, 0.13710356213368857, -0.4526957727300844, -0.19424049158209306, -0.24825409763625222, -0.8147785820570568, -0.22399772189856718, -0.5202741722381957, 0.1845893053748029, -0.2721533473836378, -0.515143180345408, -0.01647357537925306},
    {-0.01727071370065142, -0.17568048522550578, 0.09084046815065602, -0.6653088806237692, -0.06389390137605583, -0.45701394649973753, -0.32983265848543963, -0.29987530408983665, -0.5791739949570731, -0.07102639794856895, -0.17500722088439363, -0.2126101456235024, -0.5618214792765309, -0.10090733133236651, -0.022666920431349675, -0.6349240396360936, -0.018993741187656638, -0.18006398791155315, 0.07898022340594305, -0.6127018205529537, -0.4354169792914027, -0.5749338910876785, -0.4105073148489604, -0.42096590367046566, -0.7503179059874081, -0.6019530570083318, -0.11382759321552086, -0.5736534781686983, -0.4398130386494088, -0.5912734721990912, 0.4153285114763063, -0.3899569074531655, -0.5841079398754919, -0.27262749854419377, -0.2210082856142923, -0.5203376318040235, -0.2867196842910482, -0.619183799232806, -0.5926130635165332, -0.3090763651285675, -0.5283940046899543, -0.6546439477494267, -0.23622384616974829, -0.3620777457721005, -0.539656172741814, -0.4000140331889414, -0.6809137600188336, 0.3497647783193613, -0.666838420741698, -0.47344785791999233, 0.014438550160337578, -0.3807307829872097, -0.36021809146205414, 0.4059368618013111, -0.355908664652454, -0.6129796309762998, -0.08544072357874181, -0.7491939477024205, -0.03139961506554357, -0.5376805207407672, -0.12076160377867283, -0.5431800442579316, -0.4140633054797813, -0.1398319866120247},
    {0.2693796100422864, -0.3502188382006058, -0.023215853396564002, -0.17325932040372552, -0.4233807807770434, -0.41641872913093597, -0.47798221785608536, -0.49808619232078255, -0.3285064911219207, -0.13553203705849293, 0.1628203046219109, -0.06287876289590892, -0.4949005413887691, 0.09926712303479748, -0.21737825563651314, -0.18466042425961288, 0.6022225398266557, 0.11777231180973831, 0.12871280137951147, -0.524350119916355, -0.48497266880785356, -0.502822088268889, -0.33229613294570653, -0.4656918328543172, -0.5776250920967597, -0.45455482819240345, -0.0198918610191749, -0.3744673745055433, -0.1570710844136636, -0.6817459397921338, 0.3111690717567738, -0.4957525235415234, -0.4839334853763128, -0.31001023479400586, -0.28939505083248024, -0.6292293006796772, 0.09277111585242637, -0.6231535874021125, -0.24898770314032292, -0.3691741801149916, -0.3987528702137718, -0.5093631006697357, -0.17499936758852025, -0.028358872461675348, -0.3737332346369427, -0.3389856188635913, -0.4969819283883334, 0.04594064801797153, -0.25162854689768493, -0.7216768051391387, 0.16860290711377388, 0.15485897384255992, -0.28442211306773296, 0.08410420473004958, -0.3073710620819105, -0.5485673577043761, 0.03905708777170358, -0.45954434848967224, -0.35749006624689056, -0.2525185484337301, 0.31558889296492143, -0.4835249600996778, -0.3485712232310822, 0.0012293389859621463},
    {0.11296979985056604, 0.013200690260520726, 0.32231488704143146, -0.5144021113575078, -0.2823097935378026, -0.4629152293353473, -0.5797756528516732, -0.517612681905411, -0.509320052457145, -0.2370126783796879, -0.08728000364370832, -0.2538105789077461, -0.30661806935559893, 0.3422258019226547, -0.027555772734148498, -0.7174808683322978, 0.35521244803255875, 0.29131271220906935, -0.00952992437031587, -0.48780107307012455, -0.6347902609862627, -0.8054934989824208, -0.634236441139651, -0.5170241914498126, -0.3186978943870621, -0.32457903042415764, -0.2988885406716502, -0.5012578007265006, -0.5949658367564467, -0.5015730260727431, 0.03824618058418673, -0.43584433251295596, -0.6180422216834269, -0.17166942494811638, -0.5416770102397566, -0.8119162408623164, 0.3249680336023363, -0.6298003020869241, -0.2155840049937993, -0.8019303982089209, -0.7285854328377752, -0.8352608612187372, -0.35898471336679716, -0.3300603194485417, -0.3305662417952575, -0.2828918331249805, -0.5270282770734263, 0.053465787598390165, -0.7170178192608271, -0.5629649295107905, -0.1314769531777848, -0.5774163730885234, -0.4566535460161632, 0.1692684465646561, -0.40542900051493164, -0.15174078331274413, 0.2649324276932548, -0.7195182817900719, -0.1811529094806214, -0.4055837916257995, -0.26090500457777477, -0.6652025445955994, -0.6462313825237337, -0.20373027939513028},
    {-0.05957857897472746, -0.0758547889242358, -0.0719963943977446, -0.7647164667317692, 0.11352194792127837, -0.32369109008124375, -0.6323057125650612, -0.5956858597174899, -0.48166625855480477, 0.22042057631611534, -0.354098923174228, -0.42803732549425366, -0.6715798625032077, 0.5129119241489561, -0.2717890399959513, -0.551086330567435, 0.0100628831950134, 0.05085748493381985, -0.02099374770143475, -0.6490320576834083, -0.45290111977766023, -0.7521722334086723, -0.8011065331079714, -0.6303756961681937, -0.5100892841509804, -0.5475203329836773, -0.03862363907358335, -0.7210087697636983, -0.4682317811430417, -0.8597607766599381, -0.18399743701309096, -0.5083056838604658, -0.5632435847490872, -0.24187260014006415, -0.6758764800375131, -0.568033272995891, -0.19984910163699757, -0.6850345278067747, -0.30955522220879766, -0.3267678183209263, -0.8624292344001102, -0.4896931052618874, -0.6697179804041368, -0.45114386231975406, -0.47230088036496315, -0.3742426526122368, -0.5933832933467033, 0.27559377631830895, -0.46800051696288475, -0.6715567929562455, 0.2789351032542271, -0.4034198694026903, -0.4550008603713013, 0.1654642176423593, -0.41414471854178114, -0.5807024068972026, 0.023513261548965592, -0.23396190226919472, -0.24444543470954963, -0.4967001879007871, 0.1212466551098875, -0.547867345893101, -0.41644689077951313, -0.01629147971036533},
    {-0.15123744507916612, -0.2142103445105701, -0.42886084216987913, -0.6249120399257835, 0.008505487879643591, -0.6614553922075694, -0.5610148694305848, -0.4257571176659695, -0.66723424995358, -0.020527912894683333, -0.1419206113107952, -0.04322707417447981, -0.46447335468811884, -0.17905536643102046, -0.42815640062316884, -0.21012199903403989, -0.06417880233193306, -0.31173011337927076, -0.3751514686247722, -0.6289590567545008, -0.5528981014910067, -0.5733981503869522, -0.6068553775115354, -0.5959590794236008, -0.7589044862061733, -0.2562895499504223, -0.6171342968180228, -0.5523557095547488, -0.2836396873604059, -0.6153197573842821, 0.1095218093805524, -0.4747923090868619, -0.39695618192592846, -0.40181780643067644, -0.523585759713122, -0.3147090646420695, -0.36839909614856586, -0.5345280819523105, -0.6319271743867972, -0.7081455352543099, -0.5361659550677369, -0.41358850687947696, -0.5357047079662864, -0.17491603444733342, -0.27801913953224816, -0.28043422226821363, -0.7452767843524956, 0.016261648419811668, -0.3864636216971245, -0.21115433674489836, -0.09251903888486819, -0.6693917495614207, -0.5620652083860118, -0.28723904905829095, -0.37298537084709227, -0.5279507768476842, -0.3698599080692318, -0.47403258900056844, -0.7243784841585533, -0.43052543922838415, -0.29634627237325323, -0.2851535904113771, -0.37668414905855613, -0.15581810324863776},
    {-0.18347305155545604, -0.19488759729643007, -0.438994690065452, -0.6013726754556947, -0.00642310466819478, -0.310006939360253, -0.5298310413053868, -0.49467729519459014, -0.44278075132344924, 0.21945974522622658, -0.06878244610515165, -0.6035137144684113, -0.5798885966323563, -0.042123717221205455, -0.6001279109699516, -0.5270172529426083, -0.006323489191599091, 0.03673564332751882, -0.0664694773162151, -0.6608557718709888, -0.6386611962006142, -0.415423991748712, -0.4397406011956916, -0.5258155188821473, -0.42500206480725583, -0.6124842992767117, -0.44165770288518597, -0.5345244257505686, -0.37334158039729776, -0.7173790280907306, -0.08971316342412855, -0.577022649400323, -0.5376311067590801, -0.26075385214544466, -0.6345237001813429, -0.7161025674953793, -0.20818562700093274, -0.8793098254528644, -0.5406351393976703, -0.2899793637989692, -0.6316177314311767, -0.5143494740445964, -0.6068971083006754, -0.352583708781544, -0.34616594081327556, -0.3429253210825135, -0.6272285755043475, -0.06904638778852708, -0.2632153051956511, -0.4700624632171241, 0.158178338219102, -0.5099844451224609, -0.489726641073396, 0.3080665885173795, -0.33280122744010243, -0.7386136955412319, -0.23469457495860702, -0.6427373304757241, -0.41743191563098136, -0.48909717186054363, -0.38081246454084033, -0.32722223808365763, -0.4759842354888334, 0.008776309937864867},
    {0.05283069860209424, -0.2811388060754348, 0.02520759564857611, -0.7134076025288185, -0.5665387081919057, -0.4941907258474452, -0.15246314348851686, -0.3899837749965506, -0.39843798041819517, -0.024677505371578586, -0.41757728294274726, -0.4670738351708636, -0.7340800140615111, 0.03464979567826189, -0.4304598098354119, -0.5659917290422035, -0.24437339366417407, -0.07286703599157274, -0.08669115139438509, -0.45916366629536365, -0.6364083715921804, -0.5348522076484602, -0.5653103948155523, -0.7352596900538094, -0.35387739098645066, -0.5540163977258433, -0.4565146910999429, -0.5999943544372249, -0.4513374140564564, -0.6611785208313811, -0.17663086235289974, -0.6160867541712748, -0.4469888309060371, -0.4224059870441079, -0.35534585548013586, -0.4616441483412866, -0.24925376636079624, -0.4002566265323338, -0.695830580437771, -0.2565261999294962, -0.782228214655781, -0.5194940206195973, -0.5249588235283159, -0.21263412467587872, -0.3900353234633636, -0.6087889442635525, -0.6035788184846929, 0.09745502057685738, -0.5903909407714364, -0.4490440461954649, 0.08017363604840297, -0.24732291926178143, -0.5399465441570171, 0.055185712332592465, -0.5735057319595153, -0.7964582683000476, -0.2784147267460001, -0.6967737167993338, -0.23196376454291134, -0.5749769641741886, -0.03740752598184204, -0.5872459140872537, -0.4229118159230654, -0.057074521276094414},
    {0.12525778664630954, -0.2531314213501226, 0.04560306816187177, -0.5926465244977019, 0.28004568017825, -0.5621991714501439, -0.5069338762052837, -0.4280376898763481, -0.465315687239108, -0.04195015293468315, -0.34140397886773954, -0.480763153265108, -0.37720286384745605, 0.37460269113267936, -0.6902576836560066, -0.6626842816743457, -0.2267821688544188, 0.12894154848310047, -0.09314880719681336, -0.5967833697842176, -0.5544443928142488, -0.6204355549173344, -0.6459572433196515, -0.40379014338533675, -0.7273622809727627, -0.6091179839888987, -0.4168289354710166, -0.5242926549414192, -0.08182406787573002, -0.4845812988253368, -0.13108305577259924, -0.5477954654731729, -0.6437274365367471, -0.12788544116293107, -0.4811746050542101, -0.7639742863814558, -0.059781706232610685, -0.5475303372599788, -0.7141253477748312, -0.4099464985655142, -0.48440829363135607, -0.7998273795195577, -0.5404902002800395, -0.3619519856949036, -0.5881708873291449, -0.43708397503625995, -0.3990301987949005, -0.20900492449028904, -0.6097636313785786, -0.6300829372022273, -0.115033899318355, -0.4171274253135037, -0.36896243630682135, 0.2517151618625019, -0.610706875908486, -0.6718071684203509, -0.15312987685040585, -0.529763126117406, -0.4600149964948518, -0.4001596233798601, -0.0766415185188182, -0.7679610505106292, -0.47370419267712405, -0.32913331118812245},
    {0.2725106819889228, -0.17269514237747033, -0.020106128839738533, -0.6156629271025115, -0.19696057378690157, -0.551676882179225, -0.45489034659374294, -0.5448540788258559, -0.6115114192238275, -0.22276805422648216, -0.5547533405607121, -0.6418853216515686, -0.7971445994537569, 0.21991533297072438, -0.4234000145474134, -0.5344502492003655, 0.10537942090708188, -0.028203521204608152, -0.03416129913667406, -0.6229294179774455, -0.7632052545017598, -0.6289797418257796, -0.4526143787194789, -0.5201384749261562, -0.6233533521778253, -0.45822941900611835, -0.40135252453224485, -0.3784049258500925, -0.43478187079041364, -0.6844266044764437, -0.23970265402498375, -0.542768519790322, -0.42413881904627, 0.02577718024272881, -0.9567050258925935, -0.552474767223494, -0.26839697136895596, -0.7404593842025529, -0.49522566293247156, -0.6847477878365597, -0.6531876696446826, -0.6127266256005987, -0.6930578225579886, -0.5380924923504824, -0.5934461161862632, -0.4792345887940142, -0.6550557522718571, 0.185234957042971, -0.5270897521508812, -0.39586239523948785, 0.02658134418615102, -0.8222070546500979, -0.49809480085482105, 0.08134892809053539, -0.3934922440312201, -0.6656639175952493, -0.44911448762590533, -0.5116936433627972, -0.6397795739554291, -0.747132172483285, -0.33863027256723793, -0.43665179423910855, -0.7678117078715538, -0.11326433767379872},
    {0.6068933900838068, -0.2587713721612411, -0.07214858593064104, -0.7578695631189631, -0.2429942188471229, -0.6261816965324715, -0.5734101186701314, -0.46951346930134097, -0.8427641341820616, -0.24984813237996986, -0.41978923527707307, -0.6110773122789858, -0.8244773693149596, 0.1440259359321181, -0.25191957125539066, -0.4694928525310137, 0.07836740691227037, -0.048281591665427455, 0.0923663020449597, -0.4200430842409912, -0.8601045319864162, -0.47140616356543635, -0.47043504956821786, -0.3851118604980193, -0.5855360139850657, -0.1963144069671703, -0.697007184993254, -0.4605375574123255, -0.24721735906732806, -0.5806119128354398, -0.5513038043022638, -0.4456109125093598, -0.4096748092613655, -0.3336827452091357, -0.42793144667821653, -0.2302303302367299, -0.1814216689500417, -0.7710114306279185, -0.5366134384024882, -0.6721031782542309, -0.5059473586013516, -0.44090588523399327, -0.5866016410637374, -0.4332740092712526, -0.7196021822106625, -0.4015218950544637, -0.7488210186319834, -0.18253610643261578, -0.556591448110396, -0.5802059836770282, 0.19910921210137011, -0.6121196229599181, -0.5401779405191194, 0.15886245798916132, -0.46085907835699186, -0.556216951992229, -0.31678053216593144, -0.5379393175099977, -0.6320788248364629, -0.2857127168767708, -0.3587967269295255, -0.28088069861340204, -0.3939020669679845, -0.2571975568359504},
    {0.1967819211748664, 0.010735461744016038, -0.0038999182824180118, -0.5589355262093127, -0.1737359708408485, -0.3959751222289491, -0.5628218137161757, -0.5078418448309578, -0.42699823580656937, -0.20449652641654953, -0.035028034561631574, -0.5635750186100702, -0.4646987035350792, 0.38948223471928944, -0.235817939905299, -0.5520317103290562, 0.2947094421146646, 0.10659918729687687, -0.06157751594830951, -0.32707557070697296, -0.582894969342909, -0.17948709892413559, -0.4603715488520762, -0.6000821869982133, -0.3308329625724212, -0.18196697829035755, -0.5287090767318676, -0.5927161699217804, -0.33027020360124215, -0.554062734659231, -0.022394245731527, -0.4725914296497509, -0.31955549617132994, -0.21909908655941335, -0.27126134270607244, -0.5987908706514455, -0.132725012047191, -0.3448941876568682, -0.495667536987016, -0.4213500740343339, -0.4595351920434349, -0.5538511065744658, -0.6045751336969446, -0.6442952330443797, -0.40774819162335807, -0.32773742147383994, -0.582828239884814, 0.030037861093359264, -0.37627837320448076, -0.5347930134889949, 0.13461434319333335, -0.42153601157676635, -0.4740647611999339, 0.05661351678251431, -0.6858813394115488, -0.1985479896414244, -0.06015913063452407, -0.5598555396254139, -0.3008582386799984, -0.4226580091597486, -0.2719026000865969, -0.24066162659978077, -0.2395568229429109, 0.19869274669310202},
    {0.3662333297431673, 0.4076742421565111, 0.2791789289494093, -0.20364920459530497, -0.005432114459906487, -0.2784504040818074, -0.21545538514551024, -0.6492436839982947, -0.35962157989529514, 0.3860169753309327, -0.014015151845105357, -0.13375911085923034, -0.06508957286458467, 0.3041366184746215, -0.059790211048661654, -0.4855258475973596, 0.18529676476241416, 0.43904103578972775, -0.06504816780709667, -0.4564987250621145, -0.4611768508894274, -0.23937697512326978, -0.40419584364777755, -0.44914586521167027, -0.1648888442038659, -0.22534100650438993, -0.21172279671817418, -0.4713121073077189, 0.012288815225259066, -0.4528005564376549, -0.013756228756587992, -0.2420545332569239, -0.44058482660163834, -0.20020061002815745, -0.1776823674993029, -0.13510202276789468, 0.16410538367534677, -0.2327009297042688, -0.25443858548084375, -0.23381718614769453, -0.24959805844237457, -0.5716530675345156, -0.43147039009489824, -0.36207303290509557, -0.07434035660618891, -0.24093670872581274, -0.34466423743497415, -0.0744361459474526, -0.5387039950843378, -0.5329255405898954, 0.39605222093342773, -0.31296095709955846, -0.11471124615686129, 0.45742779999217775, -0.3736913067155425, -0.3146319520206087, -0.12821916183765905, -0.4225061573284845, -0.4851876607342823, -0.4020310301881834, 0.19357693439195936, -0.31859071310157605, -0.45913400143242206, 0.28164194117228786},
    {0.10536134435640304, 0.01096475149246899, 0.08779486164999409, -0.42189063933082194, 0.09990560576358558, -0.30573602578925485, -0.46745751761152066, -0.3693147124799266, -0.19779309174777018, -0.161140549497351, -0.3177969796416398, -0.3162075053433121, -0.47267837124681555, 0.1912339809287442, -0.36430199910122535, -0.3501575895566317, -0.16420950194631864, 0.02325200376520045, -0.07218681808696531, -0.3745722025732681, -0.43393566040115644, -0.5525229693903229, -0.5016510376909186, -0.5276557707069498, -0.42221861612362055, -0.34439186153088314, -0.5849590652305373, -0.45843797962767285, -0.5008885782279067, -0.31631474186793984, 0.04590703263984988, -0.32971078299422607, -0.43201073837970455, -0.2538184381446719, -0.251305489415637, -0.4488477763973318, -0.4433501058871133, -0.45086436215181974, -0.5358685573242759, -0.45215444489757295, -0.6419286116682607, -0.46700214906405285, -0.5366257654799163, -0.37395009314693906, -0.39743933160431866, -0.2495518727236948, -0.5736454816848802, 0.03475385834127558, -0.2555327353246833, -0.7319038443929322, -0.061249829312159026, -0.11037243299808384, -0.590584608849782, 0.09113260495598276, -0.44342002509386197, -0.48135082676080726, -0.49010608965055713, -0.6630585833938621, -0.6343366148581883, -0.3243715793027473, -0.14376931816619984, -0.42224976070022396, -0.40464460959750803, -0.14216051097759796},
    {0.20531580286040388, -0.22046661793060587, -0.23360803945889883, -0.35643984923990774, -0.28720075382100724, -0.3917926852572138, -0.7127960236123474, -0.7201882077881242, -0.5413618735435325, -0.23465795484680194, -0.4426613154168911, -0.5362652439770138, -0.520314152525675, -0.04504283699899709, -0.3825944774887365, -0.46109421613629126, 0.004169907794540919, -0.06750219054542073, 0.18063442836089647, -0.6092876918059809, -0.7403493838833571, -0.7974415682262513, -0.548891868967491, -0.577112666311894, -0.6391598653019991, -0.635105907941762, -0.6632316175350125, -0.5940459009029915, -0.5252682654275208, -0.7157187261008143, -0.3211077391438407, -0.4374860235545899, -0.38222948937167506, -0.31204987434142145, -0.4441349464203243, -0.3934340495921177, -0.3961016670892731, -0.6023282391582495, -0.4839395455020519, -0.5986713043544213, -0.8752061462398631, -0.8488328027965578, -0.4971358405410909, -0.3379474054255086, -0.7238190016908368, -0.5132773673215985, -0.48338665120423174, -0.0022538372254196602, -0.39148296115024045, -0.493117458867499, 0.09285004286059861, -0.5867879301956612, -0.5667414114646586, -0.08757986391912324, -0.38569402709100287, -0.4846372610876053, -0.06323485809991755, -0.6613797327834352, -0.12647638770786707, -0.5137302227603981, -0.4800125327774473, -0.5444058540913949, -0.7251645772054425, 0.16198664795746065},
    {0.1067123400742575, -0.2637279310044322, -0.1489595985526178, -0.46777704916484, -0.16043803934817855, -0.40537768232848737, -0.7146694354009501, -0.4419568050753942, -0.8078626235964469, -0.25562870796171777, -0.1286934736292522, -0.3824496276853759, -0.6612063461300233, -0.10927430164499828, -0.5439535403293368, -0.6377378888707295, 0.06613125780731703, -0.20460402709255443, -0.225082281601879, -0.381480747398956, -0.6353925953837122, -0.9989974996187531, -0.6005114611376751, -0.42100643347861755, -0.47323447288808235, -0.48946167094595794, -0.5169282680356058, -0.7067920074716731, -0.7106729103137112, -0.9348062400991267, -0.32206178009858083, -0.6672074149552644, -0.46933330904720516, -0.4545780860083267, -0.8956532716614561, -0.5854374458525103, -0.3448739004880723, -0.5512468470566133, -0.7083360707734514, -0.6180224038579913, -0.6810535154246282, -0.7239490035315651, -0.3690743302363052, -0.36478253566165786, -0.6202746172923145, -0.6343494987278946, -0.6691839493062208, -0.10615463682342181, -0.5485435301682174, -0.7126212584252223, -0.46563010289102763, -0.5706164568367879, -0.5512464053009106, -0.018284337048825074, -0.5869447339122055, -0.6588042249147493, -0.254809186762571, -0.7955774911443578, -0.8073237850909889, -0.5695405559527017, -0.02095604594279447, -0.6131948828276008, -0.7022204302269659, -0.3174903326554852},
    {0.617666818099378, 0.5746905533137574, 0.37057797408530174, -0.4600189812278636, 0.09791350698667149, -0.4727763715313203, -0.7121354023215111, -0.554709312906461, -0.8559568280188488, 0.20612201580982498, -0.23241369682324256, -0.25484214973806707, -0.6929410228982777, 0.6261787788872772, -0.3496325238594196, -0.3950764477428132, 0.5247411135704085, 0.7421462288681732, 0.19285110979112374, -0.4513840070957413, -0.7310732316955195, -0.7264743970428418, -0.7769321418233837, -0.7916807608881419, -0.4702059988425292, -0.4530194918277681, -0.4225633018015747, -0.5479170117692286, -0.17075328397678394, -0.45849700272415533, -0.3008206184955659, -0.44012980664922036, -0.5466265645633098, -0.03643317914714287, -0.579435653220698, -0.49100735448189603, 0.08181088227534045, -0.5250505845517522, -0.5438933474098064, -0.5031858996057081, -0.762017645014189, -0.7304662185172265, -0.8343769900133897, -0.5253074713878942, -0.20311359454487807, -0.5526186429809633, -0.55277270358189, 0.4637927552211551, -0.43880070412156286, -0.377625629988064, 0.5611489125303412, -0.43607074718379657, -0.6605778661084701, 0.38107485950914016, -0.37988082397316514, -0.7850273690189554, -0.054212659468334715, -0.6910409440759564, -0.4078124449476668, -0.4968205106742584, 0.1356157306333206, -0.5032903428976264, -0.6018904364899753, 0.6953204943516862},
    {0.49507839026154477, 0.011237376558624737, 0.20900411781036451, -0.5219355797690992, 0.39979764084936054, -0.29278632409674943, -0.35787609904672396, -0.4126514684612106, -0.6425934758620205, -0.056082621070758266, -0.23521916346130378, -0.49991887838019644, -0.3085879915397877, 0.7648850599601089, -0.12210045710683796, -0.34635198877469936, 0.4015754886913195, 0.5093584305371464, 0.2810789032476988, -0.3885590075952719, -0.44707303996341036, -0.48568484771647996, -0.69009338423273, -0.5381198641697121, -0.45351523972398894, -0.3877374371811727, -0.6490671143509855, -0.33178990327510977, -0.44105110100210504, -0.7881810897538238, 0.2688922305290069, -0.5445880226934285, -0.46330598394082156, -0.21102357445995484, -0.4474828838133351, -0.206596176647226, -0.2069197324089786, -0.4027216603353557, -0.6228740859160502, -0.2903397157685681, -0.6533557599097992, -0.7181314724637452, -0.6019064943577391, -0.2450435552779736, -0.33651411608141324, -0.04595447120007921, -0.5312945328231548, 0.22600752562015272, -0.2270862516745144, -0.5724676840668296, 0.5053933230324537, -0.30876987414557033, -0.642590517910065, 0.5275111511095872, -0.13578684560553228, -0.5599412239460726, -0.18518274168907925, -0.7492882971934081, -0.472251596752426, -0.5169741417802346, 0.20849798694681324, -0.08880654568747659, -0.7980186604383223, 0.502592433203606},
    {0.1592768115827383, -0.24103464860505056, -0.39620754005659575, -0.5602947100034549, 0.19095366385112642, -0.5534803852513924, -0.4219297537696357, -0.6643944528211891, -0.667261038140943, -0.24091067795907825, -0.1836771303720707, -0.7137347688705324, -0.4718581847609302, 0.18050463428267616, -0.24960696101164412, -0.7418490614443419, 0.4895568627677627, -0.20762249687087173, 0.051518024829723987, -0.7622085492738863, -0.784164264903149, -0.46041258423075415, -0.800545250233094, -0.5824172103899312, -0.7158188849089604, -0.5714050366365863, -0.5424377501510139, -0.7101908317990536, -0.6327798272085698, -0.6313354017362391, -0.2452314433432415, -0.5810186185368775, -0.4789025370206781, -0.1687505901056009, -0.13866708636182903, -0.405050393486616, -0.3891548223107249, -0.40610207986803787, -0.5443964200150206, -0.22637035318342474, -0.6402027670521192, -0.6557883823476812, -0.578667946955496, -0.6026238802580468, -0.6211087436822963, -0.13496774446187915, -0.4661330378444428, 0.3580984799336855, -0.5761687468988677, -0.8083522988430771, 0.11743100233910717, -0.6845188648192435, -0.5423257493470944, 0.25045090465477177, -0.3340858837585535, -0.47112645410525705, -0.5924535029459743, -0.6412924933017903, -0.5795890738213629, -0.6067690466377921, 0.029957705826719506, -0.5217907348270439, -0.6423519465250183, 0.07968834529082168},
    {-0.007787134661548201, -0.18451606628291736, -0.13099442117603236, -0.5657740656886849, -0.3240409464878233, -0.4501223856659869, -0.5930298138115581, -0.670058134597326, -0.5787883014193234, -0.05511047851535291, -0.3873599870396571, -0.32835342464062256, -0.25518671104428736, 0.02264914194050708, -0.0736791007437826, -0.7633424818782486, 0.10526311690490647, -0.02770231719309549, -0.024986031815491336, -0.39555174499902157, -0.613434457947492, -0.6728739885516111, -0.7740432662393549, -0.6664576590614272, -0.6814170022519942, -0.6279033265323173, -0.3734630611629884, -0.7418388903181444, -0.5051500945654388, -0.4597937165960344, -0.40225419288992353, -0.40368319665665897, -0.5228249136462242, -0.33360583999396215, -0.4509488273565248, -0.584473042726641, -0.3499804197666976, -0.3962493970330452, -0.5930264815846175, -0.3970281398134918, -0.5605641203860185, -0.6430222030110506, -0.5275275138671516, -0.5844524935238338, -0.4968949500033418, -0.8191737933310307, -0.6147943918419779, -0.041342825375962615, -0.6210002244207525, -0.4695827803994302, 0.1891927696153391, -0.3609841209155306, -0.6540268675414519, 0.183334953813479, -0.5595264484083984, -0.1943671652336816, -0.1625926922329802, -0.6683708840671844, -0.7915861572975729, -0.5007199655180609, -0.43694981342210654, -0.2792471615647162, -0.95524056880372, 0.03421452565202814},
    {0.5274507994838318, -0.27674609663107463, 0.08101546275855029, -0.4549146870722198, 0.06179725450949594, -0.6509292921205143, -0.6281368995026708, -0.6003556806217992, -0.7593525544990019, -0.1871144371274645, -0.3660736131537348, -0.9496552278432387, -0.6463697090955137, 0.3606065430414553, -0.5756548698232147, -0.52183881472083, 0.5643863859272505, 0.1683876834001544, 0.3258639521786695, -0.5140612956401681, -0.7270128870631851, -0.9404631373084331, -0.6290289795737101, -0.5500520522902994, -0.44910205098499073, 0.118260129103669, -0.8659657989442395, -0.6418730702014768, -0.7401780248760701, -0.648267824232878, -0.37134628757641414, -0.10738651229308224, -0.4200351049721249, 0.3576567565045445, -0.5597733260062769, -0.4542884330316711, -0.35983444407497595, -0.7808367923443398, -0.644943009764141, -0.155618562166516, -0.6761076572669416, -0.5775802979635297, -0.6579469592329007, -0.383295977327581, -0.4772607703691621, -0.31971686168545477, -0.5099250736439265, -0.18947468790899114, -0.21831375049639132, -0.7374262223595881, 0.11035101491486508, -0.24300419093980072, -0.49454034871354574, 0.4628780625555365, -0.1643622458109525, -0.3022134062425454, -0.4041201206659245, -0.6301365982647474, -0.5263315741574337, -0.6036713600653525, -0.07325222604863034, -0.09433124429562798, -0.6238762923443406, 0.4020482081976123},
    {0.5714940731252618, -0.19214211023042807, 0.1290576318063529, -0.33272210612908204, -0.0452457438992095, -0.5581330372156467, -0.5544503066883703, -0.5889775694337815, -0.6066560916190138, -0.13359617607733096, -0.2644943619637279, -0.7413720763033393, -0.6932520177712219, 0.5339374905254803, -0.3901678884101421, -0.6205359143366515, 0.5250905783083257, 0.30547613902575554, 0.12085000727263684, -0.6709462761865838, -0.9097177662065721, -0.7780774984666591, -0.8566728150981376, -0.6844669116288612, -0.47508256369156787, -0.5030430732804599, -0.31935241664401476, -0.41832539638433497, -0.31512126506706345, -0.8719581598240079, 0.1761528872487234, -0.4964434845932956, -0.4188659433839796, 0.00880913844253269, -0.520420420443177, -0.4119784200046356, -0.4133844239479831, -0.7972957672517454, -0.7124533208053742, -0.18233098158928937, -0.6162087630040821, -0.6778828700702003, -0.6591972988378613, -0.5584739825504232, -0.479216030734737, -0.1643429545543974, -0.5047177128592868, 0.12167381510878829, -0.32307604815330687, -0.728418738884872, 0.3428255762467007, -0.45808775472189034, -0.6792357659727681, 0.5975394589258091, -0.41546463160116504, -0.5901299678532373, -0.3415383594587668, -0.5934664410370615, -0.4432525183547654, -0.6255712674633624, -0.004065311342418636, -0.3156990685732035, -0.5341503278425601, 0.25383289274426185},
    {0.4788425270124053, -0.438195189451751, 0.05676026643116833, -0.4772213045321762, 0.23748520485868171, -0.6556654576675994, -0.5998121150256684, -0.46636826961380684, -0.5818523187437112, -0.2938303487378283, -0.318711523929015, -0.6605075693443117, -0.6194856069615398, 0.4429150530621946, -0.5412954842771001, -0.7779506563504853, 0.1501203020910601, 0.21513819844659263, 0.07519212304013773, -0.5831978725240431, -0.5120126352772814, -0.6278564867043321, -0.774552221305384, -0.7471117827871755, -0.4766882575646272, -0.5618235221900034, -0.19421889316980168, -0.6140521455377009, -0.36800813082624634, -0.5380745701986193, -0.04711147431007581, -0.5338617013788639, -0.7179066075964577, -0.10842157902741249, -0.22908908582656332, -0.7296896941138834, -0.22745322498011175, -0.45318666508252503, -0.7785882407466169, -0.3376289169580749, -0.6593625035839251, -0.7373111403746079, -0.7811763180560719, -0.4039275795171529, -0.4669961565564125, -0.43563596457900927, -0.6132229149541589, 0.20072016153784897, -0.37784134704052486, -0.5485879166593992, 0.6170003340007972, -0.5548873168765093, -0.40159745708216016, 0.2992173041542511, -0.3736768020682524, -0.4370125874354212, -0.20830090270987575, -0.8912227412803276, -0.40202312285820097, -0.3645073969156189, 0.1812707379126341, -0.4673001501729069, -0.48183555315723114, 0.16835151442420992},
    {0.524358221409801, -0.10367901006772402, 0.05173565731784891, -0.6469516299211638, -0.10140253314810235, -0.3635635242157209, -0.4221636691654563, -0.4853636894875845, -0.5824034131810122, 0.07651337409227875, -0.03172821144155827, -0.7998425262099942, -0.531794855157391, 0.4422821107174944, -0.41521400873779774, -0.590087927769542, 0.3189511695480397, 0.23593850094541396, -0.1273079999042598, -0.47392121323656755, -0.6760810949042801, -0.6635838943469488, -0.828510019035246, -0.7276534655646667, -0.4464269421128965, -0.4301277416672997, -0.3404065877146028, -0.6893002940283276, -0.23171586519209036, -0.8386477214299435, -0.29151488454924185, -0.2647855508388296, -0.5357765134941334, -0.16801711453707147, -0.7038601551481407, -0.44389031932681416, -0.13786864471264174, -0.48191635303021374, -0.3422301155367041, -0.501780430558228, -0.4952474128814439, -0.6121710319951718, -0.6911152601406719, -0.61627045037304, -0.5888656305139625, -0.2400764362197974, -0.8586196067134946, 0.09556104517989461, -0.6151177935200175, -0.6764960393394955, 0.379491772517914, -0.7091043104378808, -0.5693883537216718, 0.1123553055911967, -0.37498049045493126, -0.9239738956884506, -0.33605139092621333, -0.489948849440301, -0.4909364109481836, -0.8341560599544962, -0.20511057180647677, -0.06582230266334871, -0.6296655734773412, 0.19993547900439607},
    {0.5821582188042408, -0.1790527710203562, 0.166093808797498, -0.4713694766035245, 0.046505677706684755, -0.5602847599153592, -0.47121480753431905, -0.6537667714891126, -0.5539860232740406, -0.06799399309130268, -0.6017123614522456, -0.6409453787786463, -0.4930276508267933, 0.6635903105956269, -0.1976317615013302, -0.47856668533003577, 0.43700592492567364, 0.28742158948713414, -0.12933953206308477, -0.636151900205986, -0.6479621911155046, -0.5645100235468015, -0.6797413600670088, -0.4386049280966475, -0.399874423243658, -0.5051998302244313, -0.49401112302702366, -0.8210913878315654, -0.3597096279369759, -0.7293365807658727, -0.35931611118265655, -0.31181174229339403, -0.42330864330478285, -0.10581568639644127, -0.4312569073757746, -0.5622234977788497, -0.27754370471844186, -0.7845816867302087, -0.6358334572765514, -0.222328674033608, -0.3508865126554541, -0.47645390306936497, -0.5734978773135169, -0.22813859208070733, -0.3214662091281219, -0.2665302072274487, -0.4664627414963864, 0.35288747461362363, -0.4155297634591932, -0.7632041828041569, 0.2884213888194977, -0.25870416548539654, -0.6439649121240848, 0.4448714725255517, -0.38658145689509754, -0.6150499767996205, -0.32833502641764645, -0.6432988628581718, -0.4785499760103781, -0.7071686673832198, 0.003580517183361528, -0.27162374468842626, -0.619216133587071, 0.43282393193074625},
    {-0.20317668976568523, 0.36258127072068336, -0.27288899638731995, -0.5294029929417793, -0.4248896699537434, 0.42399242020870387, 0.49616637394802976, 0.11461383839335683, 0.09250025745969374, -0.3374645644668258, 0.14850749278101685, 0.021511471522952016, 0.3388044773546188, -0.2210036143831241, 0.4887404854364794, -0.2040890405828725, -0.6783268490911877, 0.48024137378207626, 0.6722567160371298, 0.353300105204747, 0.6001748110615087, 0.04513778812351878, 0.07512985757007397, -0.5782766215514221, 0.5126670260237122, 0.16373814713065302, -0.08080161328631724, -0.380260812978687, -0.35548462011481036, -0.40308588870771206, -0.15333122581430647, -0.6523322052671138, -0.12082890047184408, -0.032795548217365196, 0.147236736459893, 0.2874102221463536, -0.31896789468972175, 0.1291211478209912, 0.1301805718681915, 0.4156408394105412, 0.2282105147327607, -0.2192491655787528, 0.3402587276539611, 0.270239690486203, 0.15494114161046316, 0.12793541753920687, -0.26410627567697786, -0.20458002899806169, -0.21903324645464387, -0.005393968211048143, -0.47481831948492703, -0.2952277154412047, -0.03336394100019641, 0.8159753160482559, 0.7000445086724395, -0.37773407189386304, -0.22754932776995287, 0.49611279479460435, 0.19580887838082978, -0.22399551558106032, -0.5165747321939357, 0.6567022014370336, -0.35435202655970854, 0.4729686299117471},
    {-0.2939357837737842, 0.08141010996003022, -0.16668928634825556, -0.3912524359442032, -0.43728635838165136, 0.6401752634151461, 0.5030728735032892, 0.3883766391980262, 0.03763528553273994, -0.0055191884981092764, 0.29425876802725653, -0.040678807938741526, 0.14121033499554986, -0.4620959292155493, 0.9224464812912042, -0.31587055917052925, -0.44961472836794975, 0.5273539186418195, 0.6416304862853697, 0.47832003146676766, 0.6342636436388468, 0.133466679743498, 0.16557150525993855, -0.14472521032617633, 0.37554045523341506, 0.5887113054902052, 0.14295155610042362, -0.18890378881570283, -0.48858395984931013, -0.3079873530215482, -0.06806895574997147, -0.3599439347268078, -0.2224906103485011, -0.1257380839016423, 0.017864559700974766, 0.35077730189989564, -0.5528787055749923, -0.2508887680248436, 0.516489547988543, 0.2597699434513404, 0.3461365268083254, -0.2588998739667701, 0.6017387691768197, 0.012756958716682068, 0.5441518252796969, 0.19446582303586957, -0.23765514377823654, 0.24152219834072977, -0.07135496485072633, 0.10666348195359206, -0.31374011855352224, -0.49663370066662643, 0.5137329455391506, 0.48115198006425197, 0.62802008903109, -0.18690396882472995, 0.1404380699505292, 0.4956929064596205, 0.4225242822272749, 0.5605489296891843, -0.32942839895562287, 0.6709641805372489, -0.3477479728090229, 0.4899819482636393},
    {-0.5135243890413913, -0.0035985301965271183, 0.015863304796327436, -0.4848962284191263, -0.49302871936857273, 0.7041852297024452, 0.7829537991872242, 0.7921053909535803, -0.28468093963412133, -0.424019186018876, 0.5889319017804237, -0.1473669730564526, 0.2382452385856622, -0.5098054102417799, 0.5457215574974588, -0.5172423727689748, -0.47793095317185724, 0.35220403931427896, 0.8839891544433036, 0.8690206386914526, 0.118519075148982, 0.14341146793677575, -0.19418948413941797, -0.1822127502784562, 0.40637277584961473, 0.81284298571692, 0.16808108316544246, -0.22978784251921344, -0.383040579268986, -0.21495146636956314, -0.6651503074131935, -0.3809761712921063, -0.4598175868465323, -0.3874257821053226, 0.318780017797104, 0.1125442791595987, -0.5335193307896982, -0.09956200819177932, 0.48980100376098634, 0.5101499838574349, 0.8172967097676122, -0.30270110157278746, 0.4566408344989652, 0.18781539553228085, 0.3525977101751259, 0.3505310522532854, 0.14229697028952587, -0.33317864390260654, -0.26443788281459146, 0.02850605714124744, -0.559879743543991, -0.6694792691474243, 0.2593506709447086, 0.4681312394554082, 0.3537689153952891, -0.7254652239442596, -0.03796298787294285, 0.021060621506028058, 0.35553949021935916, 0.38738158424059055, -0.6370105072344183, 0.7931784181503071, -0.45173209536830455, 0.6288380542149782},
    {-0.6876296786960358, 0.13908856203654021, -0.3416434287711386, -0.24130904650083862, -0.3565590746631741, 0.5227069691709748, 0.489825630130275, 0.600353376950996, -0.09669932354268569, -0.24975008726538528, 0.7376329818579986, -0.38556138756709646, 0.2982385196764304, -0.41284638624492115, 0.4751281796193517, -0.4159558459126332, -0.7965383492512312, 0.3341387832698249, 0.40410800376458794, 0.5360303756412648, 0.5100013302596519, -0.002145898023995465, -0.10741418326165939, -0.16654799488832728, 0.7026647721621383, 0.6166424739874191, 0.41175429044691375, -0.3853784590962388, -0.516239746443951, -0.2050533098870464, -0.5817451468049815, -0.18660483691210905, -0.2898887796287641, -0.32944244947542234, 0.5423319411226095, 0.39730915995934396, -0.35170717752666103, 0.07373358027375751, 0.4382694340433196, 0.35896724290661025, 0.38867528690524805, -0.1875916775061268, 0.35402138493592633, 0.0903078751895911, 0.14977853311767142, 0.6449840016478541, -0.09017203968685505, -0.014307828980328502, -0.2714710960749594, -0.02644325444698399, -0.42558875757597436, -0.5882436667981812, 0.41541284735054035, 0.6906451937532406, 0.449796494056838, -0.29131332886597117, 0.16802640588946727, 0.42392169387997325, 0.41570108327728866, 0.3194478671841299, -0.5928864960630701, 0.6145302457785145, 0.024936312713233762, 0.39791601746956784},
    {-0.6344339738639778, -0.14203281954220562, -0.18319789643756812, -0.4636304935140304, -0.3970415716622717, 0.30315840831355945, 0.36411865863715975, 0.7506323026778494, 0.18980847668289422, -0.15495937907583338, 0.6670974586798968, -0.2682414337343853, 0.06678963646581386, -0.2875402733609321, 0.43752240475943205, -0.3287678495243475, -0.5186021284759752, 0.5237149963985718, 0.5557936760086221, 0.45665675047337695, 0.38399463485673885, 0.2727391421275094, 0.16306033065372416, -0.20879573340720972, 0.7228707559625068, 0.5878393611602037, -0.18113523280697574, -0.45816040052987617, -0.3081115180822866, -0.17616034373183215, -0.3035320269069071, -0.30802642310662787, -0.5574849698633942, -0.5199024575948101, 0.5623106127076273, 0.32969992343255106, -0.034810111025026506, 0.12752598839091167, 0.3472835031677041, 0.15510484801436164, 0.36240344734470303, 0.00928445818843183, 0.3202172001927457, 0.33394260849377766, -0.2897111494164202, 0.429075760302218, -0.39553662345506513, -0.06842697345172524, -0.28604145849833484, 0.0021316820118722863, -0.28039589098331463, -0.4242400213760511, -0.02779227280606818, 0.730684900148528, 0.16635242852543464, -0.06217489487111619, -0.13400538296236206, 0.472313959953523, 0.6442821773538708, 0.4131041266463301, -0.3407284575138872, 0.20334992054832013, -0.15317576796765728, 0.455978829026452},
    {-0.4354549987186156, -0.15449058788881598, 0.1211351199289965, -0.38214413365936883, -0.2823916480985774, 0.5775266283985262, 0.23155914387459034, 0.6862676275846957, 0.25444444698470214, -0.59934763254271, 0.16876728235808436, -0.22659928176454489, -0.06197059073863397, -0.1654672783865281, 0.45474664721203517, -0.8483175164046004, -0.468297311277289, 0.5831364288197852, 0.606046269348302, 0.37289681501553595, 0.10786107916659936, 0.14150509024947683, 0.14198763689919944, -0.26099137300345526, 0.6596429208745601, 0.5633681161548068, 0.1805658523978728, -0.3619785075618622, -0.4142543531646111, -0.1773639842218701, -0.6779546010146069, -0.3480026766856365, -0.37874981263723734, -0.5345499983584905, 0.42952465373377263, 0.46030767693696606, -0.42203144239225554, 0.02874048679661042, 0.3614391614751279, 0.6087163321206911, 0.36935670534784865, -0.06168814294369549, 0.31100061582155153, 0.21824335279969648, 0.14523452768369804, 0.1661851979654176, -0.33546117359465605, -0.3006343050314766, -0.3589942106665022, 0.15149863636377597, -0.7557704754165806, -0.6640049133214202, -0.1380627898324796, 0.573218300473027, -0.07049455401388492, 0.022858748360886305, -0.1261195430110436, 0.1493281200724916, 0.6419454990612617, 0.3368814641964709, -0.32879556725508857, 0.19470430118877313, 0.15662428024888253, 0.7516163700280973},
    {-0.2704027594364007, -0.0713088080040619, -0.056218540747616536, -0.5638570841973847, -0.5716722700420666, 0.40272309198496287, 0.30549075546574567, 0.6163933985051364, -0.09828852898736573, -0.5494621074970545, 0.39322744949509547, -0.15366014206536968, 0.16396191453546602, -0.6594841816369699, 0.48810071628295915, -0.7558656342891434, -0.5742634146767975, 0.6501576881663362, 0.5626141850484595, 0.36629599935944795, 0.05077173364592358, 0.14818950488807603, 0.15039058016163517, -0.11349062932381568, 0.6623076606048224, 0.3069981979158838, 0.07880585887758666, -0.5432992889807153, -0.5310490060167572, -0.3713034064526623, -0.5339651772793604, -0.5120197775706323, -0.4341330275341219, -0.5399350531641821, 0.0804719989831828, 0.5093187032206348, -0.7136564356907821, -0.03003567825717932, 0.5251881809185537, 0.3725370388832126, 0.23682280572612877, -0.08529177255402304, 0.07052092981552278, 0.24228705465747433, -0.11187263068115558, 0.18511144408489996, -0.13120577080149745, -0.14606491838538255, -0.2828709822493271, 0.03970911027732431, -0.6675726075859775, -0.27953944179208906, -0.014276528972443607, 0.6871352164808845, 0.1093442940618535, -0.13504479496725097, -0.050043987956279234, 0.1322138277634492, 0.35509024063849814, 0.250665426015998, -0.18647532545195208, 0.3626419506145911, -0.48166555114299126, 0.4739115400327762},
    {-0.5441147586704732, -0.16653613031358097, -0.5065797019569411, -0.25654664644674957, -0.6831559022494577, 0.4328692733172029, -0.0291308972620499, 0.42761386173340427, 0.04065035977014547, -0.6092884278829738, 0.652851831083121, 0.1314283674184496, 0.21584174888817947, -0.31902607228959307, 0.2832127133431806, -0.5167747429218759, -0.4491426383798789, 0.44375914931728877, 0.4628041367382925, 0.44878796002284643, 0.24448195538935974, 0.5496312690614908, 0.19362711052879303, -0.3661331936283459, 0.5298900218719055, 0.646940151625794, 0.20537339070945695, -0.31593090121923, -0.6151069210795682, -0.1205994278997071, -0.3899171956152812, -0.7143292097383293, -0.22421133498753718, -0.6009693618970235, 0.10288203149691152, 0.8213648709615569, -0.41769975873975146, 0.1668736053408885, 0.212265646148492, 0.25720964214448927, 0.3093918546537632, -0.189394180232307, -0.07396136316867849, 0.3207380201199878, 0.04221178155835588, 0.5221772742401813, -0.5053390545351144, -0.3002199894222795, -0.15248074153837374, 0.12071111224051624, -0.2949631869918302, -0.7588701585337851, 0.1488235135105998, 0.8127451836612012, 0.4752043830503324, -0.4155165361001511, 0.005682354749539266, 0.2524770344778299, 0.6018519547619905, 0.17746903750576723, -0.240147406819601, 0.3155473410039508, -0.2015834490731259, 0.46640865495345485},
    {-0.42753245413622265, -0.01743926200566871, -0.5713018668050684, -0.526125486300911, -0.5055381576661184, 0.5110947217516304, 0.2403531815470963, 0.5193059608926175, 0.0901653629334845, -0.2609516973772503, 0.62808872326702, -0.2211845418859741, 0.5053488160169329, -0.4205950606157671, 0.5639689727129144, -0.4465462995896386, -0.5474746202250407, 0.614799810858643, 0.8763617527636437, 0.5383347889126641, 0.6300694014028442, 0.31711541220052286, 0.03451245289933708, -0.37415263273516114, 0.5568457998629737, 0.5551490591677248, 0.18359951724572918, -0.27234348676157455, -0.7049507926336883, -0.6758829667014352, -0.5863106274726042, -0.21952068762723828, -0.16484663292819177, -0.5223880900134242, -0.14338816514659172, 0.21689971156311733, -0.5374076892008689, -0.06130148869429616, 0.2336690866944253, 0.5684906039358821, 0.6093334926680546, -0.2820730996161713, 0.19333440623972617, 0.3899286998312897, 0.051367989903369306, 0.5479308286733536, -0.23841903457189956, -0.21771825921407345, -0.21487737952292307, -0.050295206952175306, -0.6604043649806709, -0.5571975918681086, 0.25924113199648163, 0.601068969732374, 0.4212216130021653, 0.002039732331048401, 0.1585377825058086, 0.29638824384075335, 0.5493411638586747, 0.31145849456912694, -0.47709641236526207, 0.5931147349671188, -0.23243267603566897, 0.540892300933076},
    {-0.405849091153329, 0.15431258298686226, -0.44565340560500694, -0.5204637147869212, -0.5653997162692567, 0.4524039036870607, 0.4281288389640831, 0.47028130531669393, 0.24184212610851333, -0.5332035689535708, 0.4824446274727217, -0.26329607379886255, 0.22344615565422485, -0.27266264459526124, 0.4234906149620971, -0.5740536563108152, -0.5247940089196096, 0.393307269448971, 0.4929216729696321, 0.6280945302468961, 0.09385386222272661, 0.3848111636249477, 0.03639465596806015, -0.6727550116673937, 0.8039115668626916, 0.4323366956211591, 0.0264967673223768, -0.39568038978483705, -0.821473465577673, -0.759618452764704, -0.3325475493488411, -0.04720312603308214, -0.33950050301267864, -0.6389443932990146, 0.5223158670227782, 0.0933029784097348, -0.4179512373516634, -0.2373893942958234, 0.260788606636966, 0.574755528412937, 0.6161678869781698, -0.4851441015736697, 0.6246667372729058, 0.3896583478477775, -0.022607680065984265, 0.5116586143433174, -0.09462906892984355, -0.022858192037347676, -0.49272134560886205, -0.06334621808863355, -0.4481264268697522, -0.367519678895527, 0.03438220793537678, 0.7074557369247718, 0.5061480721637722, 0.03580606343145472, 0.24348497874717587, 0.5900984073604254, 0.6205171084524309, -0.17168421177605017, -0.5053731937314692, 0.5101441708460751, -0.38912652549460125, 0.4921258593878817},
    {-0.30165576942311617, -0.13963741295004703, -0.5542079109902251, -0.532271960749489, -0.6391940194171422, 0.6788926106901138, 0.5813134299569599, 0.8055520511669417, 0.48488982140571224, -0.4156576356721554, 0.558369908777435, -0.14348166562398768, 0.5069252459211229, -0.47605831341401406, 0.38001304606357916, -0.3312473601874713, -0.2893473910083227, 0.6060516897548058, 0.44923142027757207, 0.6206498224996748, 0.02612340865812586, 0.40805375591929915, 0.14354927095316516, -0.06888992304103321, 0.6230782017338008, 0.5465235284643071, 0.5456146948455718, -0.008763454136111846, -0.7721688437387527, -0.1690820904590592, -0.3862603486808469, -0.22657816994536592, -0.1758146340800269, -0.25606572407068845, 0.25079210621801307, 0.17464663282854623, -0.35861929267224035, 0.1585758911316986, 0.42635951845096254, 0.6003805959736088, 0.4404638753032875, -0.427195757486689, 0.5360091888118935, 0.09008551318107293, 0.28786671192955293, 0.11342930327929732, -0.1323841554259859, -0.42402475306776716, -0.38500623603893297, 0.2018720132019189, -0.2847622961584539, -0.31878083946243946, 0.31605562290957684, 0.8281765018580831, 0.633142091621911, -0.003101106135860567, 0.12649557796832167, 0.2294922470679526, 0.3485258158615258, 0.04202008969482134, -0.7227883372076318, 0.5575001905567436, -0.2861748781326291, 0.570778035355648},
    {-0.33838776795950687, -0.4293881885473119, -0.3610072931137879, -0.4740904950396502, -0.3834356939834999, 0.714731670442591, 0.5323718570056549, 0.7165478037242131, 0.42773659937830816, -0.36879163187216857, 0.6949925745093036, 0.025582118389542843, 0.041843415549718196, -0.44975823394530384, 0.5448082396302308, -0.3582332969639913, -0.6672295036921743, 0.6324867703925442, 0.6600513896318261, 0.9636155887430468, 0.37442442238005424, 0.6091507630530165, 0.08862102346951689, -0.2537619156123992, 0.7796698122634032, 0.3475252346197373, 0.00046411390774744383, -0.5205972684224854, -0.41371162795598404, -0.25589940925765864, -0.8320177760323415, -0.20834490557815616, -0.5869513042156386, -0.5801288561815738, 0.3662857362333429, 0.2275379260107672, -0.3762387704250893, 0.24831843575584017, 0.18146751074751818, 0.7337847367036917, 0.920178194456653, -0.03621642859768859, 0.25382067173957085, -0.1032164819260344, 0.28980107238480113, 0.4803542677408483, -0.09881291949148399, -0.2001369119374258, -0.15166103858635407, 0.28567785242122196, -0.336561877242671, -0.30854782561916116, 0.4810542755786475, 0.44567628985028535, 0.22922964975307725, 0.33443826566838614, -0.06365461815278704, 0.4863350896907176, 0.25173741540861516, 0.175617767173807, -0.5540561798366268, 0.5712980580305415, -0.6512793589912441, 0.6744589499815278},
    {-0.46352366582994026, -0.12191773829732083, -0.22882366356254857, -0.6188753173172926, -0.7643955591659488, 0.7363808552341239, 0.4360809228920208, 0.6194238606493062, 0.08403745246350955, -0.26611255409133666, 0.5196752047472881, -0.03170979341710164, 0.22321052211085168, -0.29480963982131747, 0.6813203256580078, -0.5964612272125438, -0.7878090880429287, 0.3494213382685364, 0.5049113103388886, 0.6542766680395995, 0.5933476158227619, 0.3844455234193721, -0.4435716587594512, -0.3842015383195144, 0.36308905656195145, 0.5275572352157809, -0.04775229379649833, -0.4518165255117557, -0.5063006624976651, -0.312517020188722, -0.47609961773495285, -0.1392562613894867, -0.42096984300670826, -0.668214821089969, 0.4823899162866977, 0.36508171353883945, -0.6964753653222793, 0.22218678290108645, 0.09283732729093044, 0.5853202716752648, 0.5354542614396751, -0.3556292129472249, 0.3915528108830187, -0.1856182168352319, 0.2346100153172389, 0.5093797351102121, -0.1902887258064194, -0.6819993865565565, -0.5014059143376703, 0.27647225358276734, -0.21071184025051284, -0.31565151480208525, 0.22158752522709066, 0.712413273347388, 0.7613276590074881, 0.1462787383351195, -0.058532057239122824, 0.39084442006985637, 0.3919990063488334, 0.3275163125183016, -0.7139025912842996, 0.10824377501996633, -0.3072752142419858, 0.6652073211816765},
    {-0.4681895728491886, -0.09318337763178805, 0.011384519540464528, -0.30540992056409166, -0.6654134155902369, 0.40198929022805185, 0.3930311703990451, 0.6501612432642334, -0.16364511508523366, -0.39224489054190864, 0.4649459039202004, -0.39056082248377116, 0.5783989167312905, -0.5775910763244595, 0.6669608353651587, -0.4404421812839634, -0.5038026790523451, 0.3239393993399409, 0.5642972188586162, 0.5319498606935926, 0.2560598350883671, 0.6620861140651548, -0.21460605621145637, -0.23477827777573562, 0.6143505149017705, 0.571673961566683, -0.12581044352849607, -0.3693363219892316, -0.4599399050070213, -0.053829302421150554, -0.32139149864983285, -0.2594193857233264, -0.16935622010323367, -0.5880987200447749, 0.5175231075347183, 0.19303816220360703, -0.3860921574260208, -0.20290560920807652, 0.2786478655217431, 0.6246393643367455, 0.4754385096495492, -0.14488403964646895, 0.31369436501495773, 0.21803764913115803, 0.34050829250796527, 0.42230765921957397, -0.2821195890988683, -0.5170646152458644, -0.21398660489568547, -0.2749808653448004, -0.4616167915827836, -0.47210444483316216, 0.37467018439793265, 0.6713952757712757, 0.5664898939505554, 0.28999672725401504, 0.018578547291215348, 0.22538665066087982, 0.6222478563108693, 0.19965486892302328, -0.6160145564438284, 0.31497108724093076, -0.5498998403485905, 0.39122789815588876},
    {-0.6113165737990912, -0.07015986476327556, -0.03591863640085174, -0.36963194900965424, -0.6623718589077159, 0.5219973206209081, 0.6293490656036718, 0.5006648507043179, -0.20194888394359856, -0.6101571093728474, 0.5369080035852675, -0.2141295640315424, 0.43034696250763427, -0.6779772207308034, 0.7755283330778757, -0.5181137746377241, -0.32904862159209924, 0.3147267484108977, 0.6219996020981382, 0.3589526741394113, 0.6092525601897819, 0.2987551893327447, 0.26551123195953613, -0.550998606883374, 0.6669828558331407, 0.3937454969559887, 0.21582395554529796, -0.4052083915122866, -0.3373887127049151, -0.2736772148945339, -0.6276526024920374, -0.3605797483641596, -0.25237653820823863, -0.5069572670133716, 0.42100468696406995, 0.26168477257733425, -0.41604993126496886, -0.2695001924027425, 0.12439581682036867, 0.4422554776310179, 0.7991283513449066, -0.018042618299809635, 0.5109232983774326, 0.6235513123126077, 0.054434023143060145, 0.628989084235125, -0.42813354794662384, -0.5898823372416158, -0.42112998243265765, -0.05567068679361483, -0.5127849341716171, -0.36886291267320265, 0.4691640330468112, 0.6840339498704741, 0.5334620448337895, -0.14611701277174188, -0.05251887025013236, 0.31605386046694495, 0.5004902514342796, 0.503797557687358, -0.6676715937942017, 0.47884078840708644, -0.3063274102524251, 0.8087756691204798},
    {-0.5238381656795749, 0.04781659288764645, -0.007684869233875692, -0.45905335356338106, -0.7333149338635788, 0.5967943000804942, 0.6848130813628136, 0.5808108191611596, -0.21771207566799297, -0.6656827727626577, 0.41501371770171885, 0.03707387414506894, 0.0817166987402472, -0.0422123068039571, 0.8739814259924629, -0.8201826589425248, -0.3401214284292062, 0.5610126384422564, 0.8142973093504745, 0.13687972383408645, 0.4017513532809851, 0.3429655613557918, -0.05157379753006798, -0.2866893365615293, 0.6536983118228554, 0.48983773305952527, 0.09326356031402307, -0.2799159476297185, -0.6509942319030958, -0.512738408956847, -0.8393659719600044, -0.2937730394280835, -0.411929071308803, -0.561492237582472, 0.44968257772564535, 0.12628213055813234, -0.43799501930541906, -0.551117548017958, 0.4946318529855678, 0.5151085385536174, 0.18005661666981884, -0.46892602910787956, 0.552605028093363, 0.15607759508132713, 0.10312577501997405, 0.4919327379923633, -0.3895032792826592, -0.6968989366995721, -0.3428534748575934, -0.09988035097634738, -0.3572819589588766, -0.41431573752275347, 0.24796143820485114, 0.8000098340380074, 0.437991450405227, 0.08818496075374013, -0.049170735745792, 0.47288549307830213, 0.5600179442548655, 0.46123095937361486, -0.5891905039111439, 0.4614389613262238, -0.4925175984173524, 0.4873203519195937},
    {-0.06573738167503552, 0.2250979487089138, -0.48871307729561475, -0.31139923997311614, -0.5817963270219741, 0.5826487343561995, 0.4451147123864471, 0.4213880978449855, 0.09709712261106697, -0.3129875832746043, 0.6013265624374949, 0.0743600811729631, 0.3126508904146331, 0.11061153725069245, 0.6379658824143432, -0.5462700909692642, -0.275999044944042, 0.5141353176935758, 0.605649140802369, 0.7192120853555409, 0.01285182956499298, 0.11364380329895339, 0.2067658997990667, -0.22610901721894797, 0.5648114847947375, 0.599621503120006, -0.03347427790058241, -0.30411246660296315, -0.4458566471742117, -0.45041385139135814, -0.8707902190429764, -0.30485217415515387, -0.291945688383684, -0.344288934481524, 0.2770144012053827, 0.43191930010958435, -0.399732963974403, -0.2616297716862985, 0.314328506857453, 0.21594033713654553, 0.6373409401081953, -0.33123938933655633, 0.6469302998885151, 0.386901959005387, -0.00032574178346474734, 0.2124543087617301, -0.6708665709751384, -0.4080535602449168, -0.20179877157766576, 0.226848162108265, -0.4087577148875727, -0.4351717333996143, 0.021853422811199372, 0.7690676460759351, 0.6271790504311827, -0.016515465942665255, 0.16155231290018385, 0.3372757162875583, 0.6112677056620744, 0.10656309630614016, -0.36163693869891905, 0.6711234363179193, -0.4722636422343583, 0.46114550846422625},
    {-0.3669913719074077, 0.16764472435484135, -0.5130574235253172, -0.38245148415592706, -0.8985128711696924, 0.6036175965964446, 0.4061257121444816, 0.8054752133443742, -0.08319868683012686, -0.546765410094793, 0.5032106442025183, -0.3838602897905534, 0.3656459730326657, 0.056870113555556406, 0.6561903635487801, -0.4001270816125529, -0.40775955548892817, 0.659823141984267, 0.3962911912563546, 0.6378874808989698, 0.3681154711030637, 0.07337450436863803, 0.3076377278062343, -0.31984320322220017, 0.7271096545344609, 0.6706572046130742, 0.2231724854044206, -0.2732539341525775, -0.4210583374153607, -0.3069549329893057, -0.6834382405200197, -0.4653365137690562, -0.03776591124525502, -0.629257961339668, 0.18668804423722968, 0.37502147379622885, -0.4268130987570656, -0.22145527247034313, 0.2805157568054144, 0.6736871290350515, 0.8182889482548328, -0.2872973145604697, 0.08402194193783488, 0.43583309246354407, 0.17769992977444588, 0.6117937249914813, -0.35377380209206216, -0.3847848659219231, -0.39006742314753057, 0.13023416949914757, -0.19993525748828772, -0.47705776240680875, 0.06642035717739643, 0.6081175641432195, 0.6292534502121453, 0.1459835325834264, -0.042121778390532265, 0.16741634199738353, 0.5096131636599902, 0.376691812433568, -0.6737577745436224, 0.5121588110967678, -0.4611223780108171, 0.5109327290666239},
    {-0.37519566887219086, 0.21557048894746011, -0.2549754605529259, -0.5902721725602033, -0.6718975075537886, 0.9371359406570103, 0.6381582807199617, 0.5468751161779404, -0.1546950652822639, -0.5300107731183794, 0.7173683501607611, -0.1973437321834486, 0.3499910775251541, -0.18952687485543684, 0.7660993502303045, -0.3941731952907588, -0.5230643282634114, 0.6024692925146861, 0.6796821558520663, 0.9421829042350218, 0.31006615770363255, 0.24353789130970457, 0.3219107864835577, -0.32483650927276614, 0.4650409877883225, 0.6439734858237087, 0.07736105190403043, -0.2692968743405109, -0.24833589386109872, -0.26532054091131024, -0.6146452467014836, -0.4016887594998781, -0.14855074681411903, -0.5114414231774834, 0.48976665426794397, 0.42490629229432747, -0.5291976993154673, -0.28778133592435207, 0.608205718696645, 0.704690891046104, 0.5483030870923763, -0.252494420692205, 0.2890350143346474, 0.5907825827360841, 0.22027764115600554, 0.502282156061129, -0.45453672906001796, -0.45091510497291926, -0.46449503090782845, -0.21648600767296247, -0.2691535201232243, -0.3863407898367987, 0.24452054207923338, 0.542819458804581, 0.4882197415301103, 0.193961419088546, -0.17022530716008827, 0.6781775610862557, 0.48931754248277437, 0.7399479815867029, -0.5064572572656636, 0.5606326312035436, -0.5257554599073514, 0.6131414095176541},
    {-0.5356712968227265, 0.1277556727588725, -0.376953571890532, -0.4875889424125542, -0.7582039586324869, 0.644623066364911, 0.48349445154300713, 0.5088789341811292, 0.2077421553653542, -0.6065304627456928, 0.7888193515941929, -0.07889255774406556, 0.36083457405711905, -0.5108487884651686, 0.7676762148626102, -0.37072364085890325, -0.30485091402183334, 0.5726790309710525, 0.6283285206209841, 0.42718244541436345, 0.3651559268205808, 0.3461158468654336, 0.11594451869035498, -0.2754047532648428, 0.7754836841634573, 0.5626774608434343, 0.04972049990737459, -0.49256431760900815, -0.5115418141445585, -0.14024254989970683, -0.8151542407173243, -0.2906740684319855, -0.19826682605594415, -0.1728669049844464, 0.6798566471851567, 0.4951453645342398, -0.616769533622866, -0.10597696411777398, 0.49486550228981113, 0.5630107557174849, 0.8011701970453933, -0.0704618871503755, 0.5166912259489852, 0.4210302069422629, 0.5005973752360809, 0.5784853321442005, -0.128563800498665, -0.49334706677272444, -0.30300935050321504, 0.11281501475018497, -0.1578626022656068, -0.3691208873126833, 0.07232478465901168, 0.7107161725306222, 0.4624149073594138, 0.1556197878965016, 0.11272447709247153, 0.480836126674219, 0.6469579317774059, 0.4355320420037452, -0.4132464414392278, 0.6607008084637693, -0.6035967607925845, 0.6377066696332758},
    {-0.5034439289736432, 0.17756631751856466, -0.24606218326704343, -0.505547051705495, -0.7761037390525014, 0.605871559915493, 0.4106754229695939, 0.6217896920071799, -0.13624330424034184, -0.439089457708993, 0.31562668470300204, 0.021768938428636787, 0.5560351247251388, -0.20185060591353673, 0.7128445910235026, -0.40997858582974056, -0.2219829350514517, 0.5063041170479015, 0.681115635183477, 0.7333982872264256, 0.42952174542438876, 0.14109461019920924, 0.03262177558981354, -0.2979101349595933, 0.895939020720508, 0.5739541914149342, -0.05071763475432785, -0.43283273422563745, -0.6075617634310583, -0.3555971899181673, -0.5316332360814495, -0.5414904164997185, -0.3611009765907148, -0.32768726963655614, 0.2420783504736353, 0.20846128885757742, -0.48824700618818623, -0.22088588543701837, 0.6644921189491739, 0.5229563419081523, 0.6618409553596768, -0.47308663705662823, 0.37021624541752973, -0.0902567114323037, 0.18492425293976195, 0.4290027453363733, -0.4680448131303652, -0.6485857342158954, -0.4447011680644586, 0.31679148662036755, -0.25417391013684637, -0.6785642829772929, 0.4354263829694628, 0.7910490008005653, 0.560258625000743, 0.32019620352833156, -0.06851018876897524, 0.5184873318882754, 0.4232286397263587, 0.42915748152844135, -0.7178102409815535, 0.7057640778885872, -0.40922809741878974, 0.6475178132946533},
    {-0.34491746975531656, 0.01781017637915239, -0.1919220286171659, -0.5974928135201776, -0.732936644355695, 0.7127542157511395, 0.7035688801883342, 0.6681174997225778, -0.08455623382208827, -0.7164905793772459, 0.46331789529148426, 0.04541223289116051, 0.8181747972608654, -0.17868189022776856, 0.43450763376893886, -0.29548866395206497, -0.44889955619996996, 0.5879485694902051, 0.6220307837824183, 0.2963777779670262, 0.6350617955140581, 0.37497438990360155, 0.1267475327356512, -0.4937252130706022, 0.613439589757117, 0.44613885517510693, 0.3182747171985346, -0.3977452659692694, -0.7459031123416716, -0.4056181214570806, -0.7344995689308556, -0.43912795296749235, -0.23293719040211172, -0.32219648633931297, 0.15616366574311952, 0.3916824548219551, -0.14698686724250556, -0.16735154199343, 0.5646887373064025, 0.9163194152207272, 0.8694471224328695, -0.2867440157130494, 0.3996745071446387, -0.2584609531107614, 0.32499054850319775, 0.47326740906559245, -0.5362584054774896, -0.6172283780452746, -0.49696600292614396, 0.10239360141002068, -0.15020409426031342, -0.6737558436838239, 0.24044651566979577, 0.5825179753309501, 0.7361666629763243, 0.14228814731883277, -0.057234130086085855, 0.38258380043830514, 0.5695436504421908, 0.2561085337984919, -0.6086772637706896, 0.6661326297343154, -0.7783456871972089, 0.767247641250863},
    {-0.6039659164029051, 0.17271649697187402, -0.5568605186241348, -0.8023158268121091, -0.6935310332036473, 0.5888129732031969, 0.33796585594371914, 0.4645480051482284, -0.30502817008855504, -0.7688355297331233, 0.47086438279098203, 0.06952787672381505, 0.6152286423024803, -0.15288322764845366, 0.6656090092620689, -0.309931129528488, -0.47716354065052596, 0.5381278389425698, 0.5712899390996443, 0.45236229614027096, 0.3976421857095264, 0.27665677166356156, 0.10214362660343089, -0.43046991264773343, 0.6856270298279157, 0.5830122343866119, -0.00746524097691431, -0.27378602209344355, -0.5849855237316051, -0.18103261809784765, -0.6282421679591543, -0.6572188985187325, -0.4123666415529207, -0.40265909998199856, 0.09225252433725854, -0.01738947527219346, -0.41307030242954246, 0.06823389297343692, 0.460891372758142, 0.6360619599305429, 0.5421526634056245, -0.2646696161916732, 0.6399910931556737, 0.23940494645109517, 0.2409138747289998, 0.4654745315294656, -0.6956370114191277, -0.6799879187655666, -0.7443597257892723, -0.2253238591663886, -0.14847983050861496, -0.8362987105924702, 0.3308324657457661, 0.6198040723681731, 0.5023163186916961, 0.4192378857737429, -0.25613489370386544, 0.7632802108498429, 0.46772489515456134, 0.8577642062711649, -0.6077847523842119, 0.5647162929478312, -0.15360435322126745, 0.5450685286239855},
    {-0.5882741363677916, 0.10540552929176324, -0.6153043022183652, -0.4809401472347178, -0.6267673826860295, 0.48687756991554226, 0.2785577065238103, 0.5395676477752779, -0.2654807181239676, -0.450484985499684, 0.5981845240781212, -0.06481058846011883, 0.5607196187667152, -0.20963779138604655, 0.6452200745389823, -0.5003169081436245, -0.27356531366733045, 0.6063367489568193, 0.7002290672597548, 0.40151675082936017, 0.35603565125019493, 0.36613869437946533, -0.20028727576273592, -0.30469953738236544, 0.732125762673382, 0.35029787688784886, -0.060854309498906745, -0.8154904229346961, -0.6484058170518305, -0.21296009755646567, -0.5583051591020383, -0.36926477569646754, -0.45472803258275124, -0.8453871737590062, 0.2508469992438593, 0.2025895767317418, -0.5531548999967202, -0.3560240161807514, 0.28530934855153756, 0.829215266465651, 0.5126365714939815, -0.5125342345811035, 0.4672801115908188, 0.09210249484885275, 0.3908543423172861, 0.6026624363587623, -0.6284363495302756, -0.5156315624698796, -0.7491410839223684, -0.08165460009878833, -0.29571651426574014, -0.4433388232090962, 0.18968607447464794, 0.6228691927116773, 0.7679100395152633, 0.1404765693601919, 0.18099415012026884, 0.4187291450207045, 0.7979448773407176, 0.6097945846677021, -0.733272925910025, 0.6006505947905089, -0.2787368416718822, 0.7203664205209861},
    {-0.28315519026898084, 0.11070076491705137, -0.4952969782367138, -0.33828249324040327, -0.9170918959205674, 0.28859079478807204, 0.6139595969017734, 0.5346671204778363, -0.06508603910175738, -0.2755071169640051, 0.6339646663840977, -0.2229258926382484, 0.5474612604738578, -0.24381055570301732, 0.7528939183782176, -0.723833578846229, -0.331977599311564, 0.7510105181545969, 0.4787422080707873, 0.4757748628563601, 0.6000168670618601, 0.3615681320460671, 0.15729088967775112, -0.509211179774294, 0.5250753699593939, 0.7798682620643467, 0.22210547935350555, -0.23419040389103055, -0.3875318416364568, -0.21000014351403418, -0.6946306796073839, -0.4415120614621189, -0.40801990932806437, -0.5390869728031052, 0.03483314615855987, 0.18254754929420924, -0.522606137235352, -0.13003312335861292, 0.20949321586702774, 0.6438659678361266, 0.5522237242331303, -0.5777951693350278, 0.5524789916730528, 0.2908376929526484, 0.6588861886738528, 0.4107452512819594, -0.45563180724432567, -0.6442479134625017, -0.7335270799968722, -0.13336794148982348, -0.4993003198246956, -0.5018051868551305, 0.1766353052100916, 0.6102586653500854, 0.6595915295554872, -0.07608214284783547, 0.2678311685482906, 0.6913939003002468, 0.5135124539314355, 0.4375807977078244, -0.7620280646600114, 0.5431036833183445, -0.38825111164691944, 0.6525626763818676},
    {-0.2705261905757111, 0.04580008902551709, -0.30271961816361864, -0.4038242596054564, -0.7474137764751353, 0.21266093500837574, 0.5682852280978516, 0.6702474585901562, 0.08133113677733013, -0.5697979291842099, 0.4653293873007919, -0.18662879213675804, 0.3807479957600882, -0.273896096826031, 0.965504065852201, -0.7458982535737242, -0.5548760439687226, 0.8336761763258755, 0.7377645251596039, 0.5517638686050287, 0.4858760353323045, 0.24889980485520644, 0.021648239543672985, -0.2545496159581379, 0.8368661843990922, 0.5259272244578084, 0.0784203265809625, -0.6228243134848243, -0.5511644056209316, -0.45719335919297144, -0.6830116794668011, -0.7248267756626185, -0.43924868320307087, -0.443660134159493, 0.1268436962794662, 0.25611901037667534, -0.5445348835565784, -0.521053857649869, 0.567844589518754, 0.4460843145695377, 0.5670998082858981, -0.4631299773004921, 0.4707798879990816, -0.16804303240059174, 0.495829815262354, 0.6229909704064588, -0.4652618399208979, -0.8909739511607289, -0.6316974603278884, -0.211444285396726, -0.42495366523991873, -0.6832962320999172, 0.13806848274161806, 0.7027903142747473, 0.7105733666800153, -0.423481545090208, 0.07418552262046085, 0.4588196498605173, 0.5158363467929552, 0.22631002333735015, -0.44493927836635994, 0.5942776503467265, -0.32737343079587417, 0.7007416518875236},
    {-0.4592638684947807, -0.007385578719678189, -0.686869589764437, -0.7767189953988295, -0.9135093005429659, 0.4381067360240467, 0.2910862288045594, 0.37312064236754267, 0.050076626604699914, -0.5067514987481442, 0.819123752856789, -0.23103323652171515, 0.20664511980631334, -0.3681138195144919, 0.6686157574961984, -0.8027168172189166, -0.5598306438596842, 0.6891634175227563, 0.5870285050127457, 0.6608404995190312, 0.44448973152324917, 0.4089766645923823, -0.07028260005820793, -0.5364750458618333, 0.7099861026098085, 0.6370004183048855, -0.048074255181922064, -0.5119505959666268, -0.6523268819722028, -0.25506741053444903, -0.5286879121123194, -0.2565959133659963, -0.4175299692092366, -0.4142771160528483, 0.36704451691836104, 0.1587492707610483, -0.7108136486494598, -0.2967186203131433, 0.3538091147175761, 0.5295375363319914, 0.6835420233022681, -0.03413432675064424, 0.04871836057665045, 0.1082282569759483, 0.35690396867386626, 0.573654034229978, -0.5405445087928662, -0.7088928468560054, -0.790073090154764, 0.04702982336498768, -0.337051020147418, -0.47136140695510814, 0.08917810588826444, 0.8813568068315818, 0.6512436312666695, -0.1367129797556781, -0.09321034045788837, 0.7769372910362017, 0.579757036818237, 0.3041417972744485, -0.7722444102387207, 0.6901831360649651, -0.7572860879730587, 0.6004997195952544},
    {-0.7045765402603712, 0.2362917200921105, -0.4119324151289492, -0.6683545604840286, -0.8756081590849386, 0.5138533581435655, 0.5870638873698472, 0.593064513371761, -0.23659550343158575, -0.6503045019402641, 0.5598622506372897, -0.277225158600232, 0.4569597069841675, -0.24798767208827682, 1.1562697451202066, -0.3622580637364761, -0.43482288309134354, 0.5976756287272971, 0.8484827031087709, 0.621569142311263, 0.6706766801986779, -0.00220368516052268, -0.1619458082060504, -0.3761840362042236, 0.8271432981659289, 0.8109678205571659, -0.10428410245609822, -0.6255048304618169, -0.6360992450366647, -0.31144878572501683, -0.5964239127655965, -0.3373751579195361, -0.5795250012842166, -0.7203272616039808, 0.48564091119024794, 0.01642468431871231, -0.36038017944321565, -0.07114716997117215, 0.37744106408250794, 0.5313561009998021, 0.6149446980917557, -0.357429767582269, 0.4889620258837691, 0.34359456693642504, 0.060018232284533984, 1.0832296297904993, -0.5924187358995193, -0.6599986424065998, -0.5972551742097346, -0.2174361323191813, -0.42948105114050444, -0.6779311943323242, -0.06320829968854061, 0.7556450459868225, 0.7263820926134327, 0.021719626347681563, -0.1626647326914887, 0.7351703742839927, 0.5066889876355275, 0.543840442410455, -0.5449138333969737, 0.6940377796556799, -0.3370313925772291, 0.5400078977191549},
    {-0.4726630928092985, -0.17493280707746547, -0.3483886765558798, -0.4295780170240701, -0.5517671245671918, 0.6233585725735176, 0.47685056949184135, 0.632596733930281, 0.11813658783822396, -0.656724139996114, 0.3600799245107533, -0.01378323697672382, 0.6214619392985917, -0.10042069751087675, 0.8660895759024012, -0.6618153697643212, -0.5278017905205186, 0.5626017011058224, 0.6616040293229676, 0.45412984716784033, 0.418040603974377, 0.2894706617242719, -0.28345127909872625, -0.7313216421788047, 0.6312346485913335, 0.5829591403300084, 0.08298906430953507, -0.43439008338410984, -0.5950568100974036, -0.4275809775910458, -0.8001548551745186, -0.41741727625089514, -0.5952326759551179, -0.5382192486006374, 0.3040922774970858, 0.4034503652944331, -0.8095762227927616, -0.5627465443859128, 0.6289124027967185, 0.7440605640970849, 0.7438782547598415, -0.46048203931840215, 0.5692088186243269, 0.2689984433967098, 0.3102951001245906, 0.4783260011385534, -0.3689575455293805, -0.5850984176659171, -0.6102281890293648, -0.09314741539041031, -0.3462138744777085, -0.5572516892718817, 0.4249381727195423, 0.7604465224607968, 0.47597209729570467, -0.06294674899966055, -0.15387838369846277, 0.5297720189138939, 0.6252229347847914, 0.41061568948374405, -0.8238927406649882, 0.7398544638330989, -0.4964387942151906, 0.4145093185566519},
    {-0.6265731248037739, 0.08994372124892103, -0.2561787483169871, -0.8056930596019403, -0.8931273207953377, 0.37878305506138427, 0.4400330172474137, 0.7872597435889932, -0.16252085375860104, -0.8193528001076278, 0.5759871023588202, -0.0030991044292116225, 0.6403726308724206, -0.4299249554594942, 0.8141603375020081, -0.9543821054730784, -0.6882346410037435, 0.5415967734932605, 0.7400166045843826, 0.4541753050887033, 0.5631621187556523, 0.327059255395544, 0.017921153985277417, -0.48213631384157474, 0.5448571197405646, 0.7818104260291535, -0.1877689793449716, -0.5324408869093592, -0.4840226807151933, -0.47079672319017574, -0.8899995430460407, -0.36929792333333944, -0.4345906825228841, -0.557939363410273, 0.2615644795739115, 0.06880027389963879, -0.5448416552205817, -0.21038706346665872, 0.5067703629036646, 0.6105441343463894, 0.8220344950064573, -0.3166658304416514, 0.3988583463476646, 0.27699309229806185, 0.4100871109724639, 0.7132845577391628, -0.5762360649856817, -0.7246471345310984, -0.7297088020236147, -0.1884290751801377, -0.2359879371573432, -0.6721518799555579, 0.5769390356940574, 0.5786070385947065, 0.4208019521000691, 0.22619071843288596, 0.038688426935067424, 0.22637559803111165, 0.4537367584288916, 0.5491429061320563, -0.8778146931131411, 0.5941088704111563, -0.6875838855305114, 0.5781332455790761},
    {0.20372032253587563, -0.5045259869701976, -0.5855114126779556, 0.21791921364279343, -0.5506256954720704, -0.2212300975665817, -0.18932597866232403, -0.1521782817934721, -0.3283298248337861, -0.42851761537523597, -0.4273460047788846, -0.5614944812122844, -0.21559169360348196, -0.24980279529206062, -0.3452430447629506, -0.3043529147026873, -0.19468687364131945, -0.6315518251378847, -0.4512243486526665, -0.46076492951257514, -0.3447702861926743, -0.4973784996021271, -0.6426036664162166, -0.5965556475893331, -0.3383414345309388, -0.10742263931984435, -0.3109434263847187, -0.6659678512212784, -0.45233067645730907, -0.3517336446927985, -0.0639465361142701, -0.6338410246663487, -0.08837645395554823, 0.2343274462183191, -0.5771568900673655, -0.12939904768630722, -0.5206011221792386, -0.4350203295250686, -0.2847866907639901, -0.1972264818480849, -0.4936857783243801, -0.19474614786804506, -0.31812740850754484, -0.1793292598341444, -0.12598158079547553, 0.0034796855951403963, -0.26060743638123607, -0.25336993847666617, -0.16184003844891878, -0.286406163818777, -0.09624540304570388, -0.10976511136591766, 0.1363310441970899, -0.22209916514753691, -0.0025742699867654824, -0.3942091430246033, -0.611199683286289, -0.5777028212841242, -0.5717320278846059, -0.4628345284816577, -0.2000375520208181, -0.21547779366167008, -0.24473619625813162, -0.4749399097267769},
    {0.3902181325724688, 0.27603746574738197, 0.0033266948484395858, -0.03962789648889524, 0.3116691971276287, -0.11636825200118794, -0.002697233112161336, -0.3306271328426537, -0.20623918479258072, 0.05005936691392228, 0.13810903439741748, -0.06895120518611483, 0.32833066994408044, 0.23106864499327215, 0.07026325143232329, 0.006447581993712075, 0.1747154466457809, 0.14310622913634125, -0.2587296945001072, 0.037834059137590505, 0.10681317929920103, 0.335848620791009, -0.29150208334776034, -0.07067857530046898, 0.14496747506505497, -0.10037311495963218, -0.16517552704935864, 0.057672756173843036, 0.06492843363037068, 0.019237715281393446, 0.31231868898926535, 0.016547239461478465, -0.17157897997927013, 0.039141562199034655, 0.056000033288729094, -0.04182376557420016, -0.08986447129815035, -0.15451804209952819, -0.30922088336561054, -0.0016014142358831223, -0.17667922765494692, -0.270303442315427, 0.0851179122554386, -0.32083310069305726, 0.05274962735511589, 0.39927655372613946, -0.19093814761773484, -0.018362982796751273, 0.07786394525968358, -0.22770595740021307, 0.22610687963640805, -0.06062417804571423, 0.22716666716758435, 0.2126832457602235, 0.44521149541434457, 0.22077677427419096, -0.11066262544696757, -0.38936434384554625, -0.2384127174130153, -0.1483208943817339, 0.16802935165387517, -0.1271415359987988, 0.03782961805691016, 0.03352116693387444},
    {0.24276345540688124, -0.05345301028938098, -0.41495392576231416, -0.25544068238178524, 0.006873700799701115, -0.4859198537077341, -0.45114091760687963, -0.5758986841965608, -0.4359768151642392, -0.16473772818467206, -0.3491706169025902, -0.1766947800204062, -0.32352507082079546, -0.1545174487193841, -0.7213626302706725, -0.2608135916129413, 0.4940482076410294, -0.2359680074663368, -0.38084802912895394, -0.5080732381132783, -0.458064234556006, -0.5275381433170576, -0.4957908187234359, -0.61263404828196, -0.542780786463793, -0.3949145393287872, -0.40034422978754675, -0.5454665121587537, -0.5033202332839698, -0.28249924200024135, 0.32122669678347743, -0.3226513126873682, 0.002514106272723859, 0.21082824206954062, -0.4320856888437737, -0.48380002729217897, -0.05378041849263627, -0.830160468901059, -0.4164301895563735, -0.6224582664309524, -0.6675917206057993, -0.3750408400512904, -0.7583812500506784, -0.3940397353889371, -0.6539485788214771, -0.3616063998551111, -0.5232561810899109, -0.17622863871853386, -0.4416724325744094, -0.7265930680971955, 0.1722071124898548, -0.39297855371141005, -0.45268050667258636, 0.2636988885812202, -0.39283794586912957, -0.7634854211083639, -0.6252876972071398, -0.7109202270772422, -0.5710843422515209, -0.879781881389463, 0.04266124719995841, -0.11716477843386897, -0.3712407971369297, -0.05176441137180574},
    {-0.23682252666132445, -0.24616782010567528, -0.06426809644969728, 0.11646037413961222, 0.05601360728986784, -0.25050987027254856, -0.4582391586722694, -0.20248044394720838, -0.20270604223578442, -0.49077932609687913, 0.1347704708838141, -0.22182191633539194, -0.35432555682369377, -0.20976748061084347, -0.060704301160577, -0.170149683510803, 0.13402045014567213, -0.08002824595072783, 0.0844368230154102, 0.041370973392945855, -0.40396240471843975, -0.25843247236783917, -0.5082352737764194, -0.641912224643833, -0.40528605174564364, -0.26536089007077557, -0.2977789410891261, -0.246101349345436, -0.23844476001750614, -0.1091181022543635, 0.21124620080434503, 0.007025096241705721, -0.04930474598149912, -0.09759387488983903, -0.12657226887354614, -0.3572640319036876, -0.2512950401207606, -0.6230966616863722, -0.1635678196541356, -0.1857665952809138, -0.4364506327480316, -0.14868537311313865, -0.059166739601233954, -0.20720679663325103, -0.21499605870471958, 0.007168614309220523, -0.6128182830444022, 0.06061466014743455, -0.1708304345386261, -0.27255551867699873, -0.27030110752835973, 0.04223226506641705, -0.3383373723130783, 0.23270082907004397, -0.18618184326376913, -0.3771249187705533, -0.47215486201731094, -0.48490730114774494, -0.43598210682128197, -0.5772385114165538, -0.018160300400256787, -0.0039131280234578, -0.2832933283495002, -0.21911879615159582},
    {0.13582877128331872, 0.09310825198866046, -0.16652607264363437, -0.22443867689414784, -0.11096233156137796, -0.37800504311685407, -0.46823022233321404, -0.4397768393213514, -0.44086650045764586, 0.04505707638040813, -0.0923479821215728, -0.35603154259981185, -0.3598363821134003, -0.006207389115308468, -0.09994086588064337, -0.3604281973095861, 0.26365508972791535, 0.24409764271177103, 0.1664606661934758, -0.3580737910412289, -0.4568103812401925, -0.25859356702026987, -0.45635624654036555, -0.5606373355707561, -0.38802192329607804, -0.5281413511982019, -0.18696196030044973, -0.5302947562969655, -0.264391502071435, -0.4230592151254442, -0.08644771380457882, -0.25191799099068246, -0.32033101268014935, -0.40014975006385745, -0.17179397984004668, -0.03645913210108246, -0.01631551811911208, -0.5262622871637946, -0.5459611037242839, -0.1402941700954141, -0.586811392389909, -0.4538589760011819, -0.18369891430628732, -0.015825459840562682, -0.34069407226361964, -0.2146385312060204, -0.6829939861027553, -0.0004942220575565433, -0.5243306976741827, -0.5233500772783317, -0.21961946913645736, -0.4789503006036743, -0.20862351235616594, 0.30359193271396795, -0.05380124199517551, -0.650537051530589, -0.2224661052394964, -0.21410431256230456, 0.05088904584957627, -0.3315101869522335, 0.23098970113510708, 0.029997431676552607, -0.5405672710146954, 0.3788929975290686},
    {-0.08865508643558227, 0.3360898310725406, 0.1795791421081479, -0.13795080640165905, 0.01608177779507467, -0.37597686203207925, -0.2627890758964607, -0.3475107351038146, -0.004948325755024655, -0.17073460905252388, 0.07329445490995035, 0.03990931884249715, -0.4050676027236094, 0.2587729494305331, 0.12582357405677208, -0.12672631227217396, -0.09918122021484481, 0.43119112883621996, 0.3926908198924166, -0.06542253287980886, -0.17857810122770346, -0.6685492885225084, -0.4881654615728484, -0.3454080351045867, -0.0654629885530208, -0.30050538528932147, -0.20066843535239348, -0.25613080004881716, 0.053368216477271246, -0.3466228866757462, 0.14813252687091435, 0.09904294115936343, -0.4725770479951484, -0.32566176146496856, 0.006256083453237676, -0.18527068308797728, 0.11387873984101039, -0.17372908007210056, -0.21729601894167067, 0.05007599394756048, -0.30357565243974777, -0.4022200878838418, -0.005574134909584493, 0.039386722484953195, -0.2726520443453424, -0.3086627786459625, -0.3256081186741424, 0.28652282711956684, -0.6174211778634554, -0.6589523630931465, -0.03920408238260897, -0.24892548877178797, -0.2533470760846663, 0.32643399335798684, -0.0692291505061318, -0.5846300087518043, 0.15115407652329646, -0.5888596153868683, 0.21766315615727574, -0.37470022872582553, 0.009400087715499834, -0.11847609011413376, -0.43340889919301867, 0.16507825918209745},
    {0.20164775976405805, -0.1483133382384888, -0.13453299940641378, -0.35437873894388394, -0.2507223276522414, -0.676094693522522, -0.2954858825800353, -0.4292982277086233, -0.23905036218089726, -0.21277496500792245, -0.021577908655635386, -0.1695055674995394, -0.7346850959720208, -0.014843213968868047, -0.3347843514637874, -0.3239636884655748, -0.03555761711123629, -0.027569427595144948, -0.08826008913107808, -0.46760209537796743, -0.25712896289979786, -0.5398368621914876, -0.5682461289375028, -0.4110741409529848, -0.5071535066640467, -0.48665767287074113, -0.3277833172148364, -0.5317724969821854, -0.489063337595599, -0.27428721865481515, 0.3400938022783312, -0.17309176930338768, -0.32121069163242516, -0.3320146138802805, -0.1386484377051121, -0.44028997726176283, -0.2032398138542721, -0.5944054601351113, -0.5197373393389969, -0.1689413152149837, -0.9285983224114, -0.6781143265038787, 0.1294493705587687, 0.17516886583909594, -0.2554722430716874, -0.22750956615807832, -0.25938314627829057, -0.19208687399378657, -0.44778721872747657, -0.6269370338883026, -0.23950350864679734, -0.30553612766732097, -0.5286341395906464, 0.015254632147006677, -0.2875978266954216, -0.6242929067108923, -0.27520807799957464, -0.4585375767162773, -0.257904057882844, -0.2940956204338327, 0.10547206601522965, -0.5269521044499639, -0.5517171693698404, -0.07942835319873275},
    {0.2061078262293824, -0.23477652200573448, 0.09139443645502159, -0.29390990051316207, -0.3553428691176854, -0.24114276680611763, -0.41284952356669025, -0.514095252368357, -0.5185039003720099, -0.054543593935455596, 0.25472818443861156, -0.030499903601842796, -0.38133075091180724, 0.16481717811234145, -0.38174789352318167, -0.325095964171874, 0.07040327646437786, 0.2728596875083913, 0.24503861109639458, -0.48495101647092426, -0.501010003560142, -0.0009399995770192503, -0.07395400302839646, -0.4424595688169735, -0.4449753279621842, -0.292717899242818, -0.1665305638251936, -0.5100794282457366, -0.32412920735735334, -0.4978277393537167, 0.09131444129383394, -0.13961688311859577, -0.31007007046834884, -0.5979771127867676, -0.15271812233897414, -0.5986260355123579, 0.10436716575452686, -0.3578036500364793, -0.3257676142976416, -0.11982636212149182, -0.4477237713666852, -0.42265728476996084, -0.12674309231500253, 0.15503691479018394, -0.2504979359052794, -0.47587067162719965, -0.5553628104370357, -0.07074374665981847, -0.6296596530529656, -0.5796962840432902, -0.09210894304689043, -0.03228805581108006, -0.28010586218632744, 0.3413705186509839, -0.2405685839502847, -0.7513984374769145, -0.017253500406215067, -0.3821869866649682, -0.19723045542991682, -0.17744676330615014, -0.011135515861637538, -0.3228460724894885, -0.46148167405415064, -0.06813890181389737},
    {-0.05386947361448655, -0.41321284413577525, 0.1645375530564343, -0.35547893609464254, -0.6081809147504165, -0.5230963743847306, -0.629825038181995, -0.6640681600519882, -0.46614727670996237, -0.23588341721031145, -0.4010056655084789, -0.3625560625660431, -0.3394581366351221, 0.16778301422198527, -0.1616805476183025, -0.42514714016588206, -0.033768995079927075, 0.1341981366493021, 0.23280516333389503, -0.09509078742834112, -0.4874049643385642, -0.36332623647423745, -0.2185716045384476, -0.5727427460752973, -0.4311174402484228, -0.374314142389576, -0.22945966395542516, -0.3471265313697583, -0.44155228407762126, -0.4690032688461329, -0.03425313769196752, -0.3906286952891623, -0.22452355151713604, -0.4391192803682814, -0.8031421059925359, -0.5266115705893644, -0.05657858014528644, -0.5314729338507367, -0.5972336199455913, -0.2702062503455386, -0.40723559037533125, -0.5811954506053782, -0.3435147534152355, -0.18326782705508313, -0.5046451451135527, -0.20033473981117864, -0.4860595530209744, 0.20415662125576853, -0.3862730748987957, -0.6248270750943818, -0.1154396776897045, -0.05276354595476338, -0.3882837773615724, 0.040876385868685056, -0.17579727754783647, -0.5930517720927184, 0.2772068570392765, -0.3547534124138938, -0.14783568120745788, -0.45460093097584436, 0.099927076594764, -0.48517405330651375, -0.35553104459829943, 0.008895876125818374},
    {0.33914284518629423, -0.15546361565310077, 0.5078520703048656, -0.3540499600902658, 0.014453765231412972, -0.42654588950532923, -0.46630967617294644, -0.5403907825034442, -0.27087571966904783, -0.09838814813034305, -0.7065043320753267, -0.29709398753328464, -0.6063138828610133, 0.5183272741801104, -0.516218484191555, -0.6661942097813471, -0.012046329460001913, -0.32444662155346277, -0.24942912306940038, -0.4480443855944202, -0.7212010518489169, -0.37500283707220533, -0.6039162405360994, -0.5616083762923905, -0.43470530234491417, -0.80745369420108, -0.08864644965582519, -0.5103503348409388, -0.5043488805793, -0.35493806906271275, -0.04542862290708444, -0.5404597125025427, -0.3570610998170374, -0.08881493083005076, -0.6633804825805834, -0.6249206069833577, -0.10705519155453816, -0.5675819856815947, -0.6488250034783423, -0.20543885488383806, -0.5508612543998556, -0.7484284439532914, -0.4434724395117758, -0.16628595405398255, -0.4662881846908305, -0.2942545223954292, -0.5960637770731, 0.3594932332410131, -0.4347475489841489, -0.6504371818176836, 0.48032168680853254, -0.3016410327792654, -0.4539289860127907, 0.2081112362794388, -0.2039662414509833, -0.8658016086736419, -0.13458829689307128, -0.43886359667431285, -0.14320316919506404, -0.5917453919814488, -0.15707373996580515, -0.36001733675902614, -0.30572306143470523, -0.21316169662591686},
    {-0.2605024424907778, -0.13850437058626258, -0.49380498792685695, -0.23404305981951534, -0.029925916387140525, -0.5386789108169766, -0.5641242065498955, -0.3693486590679174, -0.6662795681017463, 0.024356929984243145, -0.40997667732661974, -0.09213381317287625, -0.4171811453871651, -0.07593775848542297, -0.3258800195088938, -0.4188824063802784, -0.44811686967631287, -0.27061099195826793, -0.1102159801895432, -0.4361804648334357, -0.4362226111314945, -0.36087695628785993, -0.5299019599312258, -0.5502012051179819, -0.41402602127404803, -0.5885821416032232, -0.48830678110533293, -0.5472999574508624, -0.35874766495844923, -0.3206063158438504, -0.05608009839599254, -0.3575113868353363, -0.22951925964817574, -0.21441163706192023, -0.4003841340373652, -0.5218077457169515, -0.1621894385009547, -0.5123335408732338, -0.37645724503910993, -0.4638438463558137, -0.6893470792283691, -0.3995487173452305, -0.45770882227889864, -0.11927380931831133, -0.379238160363802, -0.18031404605688306, -0.5452805148049019, 0.023685729318508136, -0.33371557226639603, -0.19349700609948212, -0.05265165681777996, -0.2804639722769728, -0.15500394340684603, 0.21607176818623955, -0.43292654848555157, -0.5254427697538818, -0.11224037242015796, -0.5660672219597012, -0.2654988060859721, -0.35364454954583185, 0.1828728401549104, -0.5052645386769842, -0.4223387997909758, 0.07333743270509147},
    {-0.09838615998719541, -0.29403408671936415, -0.1677414725221948, -0.6650157700007958, 0.20921497236583592, -0.3828612521107608, -0.5432102399675074, -0.2719215829537217, -0.429258904869288, 0.09528391075267131, -0.24485112566809572, -0.415903963274437, -0.39889067935569467, 0.12495168273506357, -0.3020018307465183, -0.6024222158060031, -0.12318248997382696, -0.03344553778181773, 0.019079523994018164, -0.4245817397170336, -0.29251115906967273, -0.4894596158101333, -0.38298906737849187, -0.5124392497676795, -0.42714548344676867, -0.22542314856362564, -0.25786612707345036, -0.5330369080388107, -0.2602512496920666, -0.4028563155739885, -0.0686650599173227, -0.49224549272408524, -0.5124765067464866, 0.08615181869608626, -0.4817520762989012, -0.08919408680529631, -0.3554867506110876, -0.33653174390545076, -0.4647435221400507, -0.2188929227541111, -0.578956802152221, -0.217302875957789, -0.4832062301225229, -0.1257871456524916, -0.4071104077776302, -0.18503318871580854, -0.44529711550743073, -0.17109234974647688, -0.1763902886943649, -0.32848053571449387, 0.1654311925947513, -0.1256169010761742, -0.3300335632573824, 0.23589349191921272, -0.4204551342400816, -0.4268673302613862, -0.37277638095619897, -0.5027514549134993, -0.3372944639726738, -0.40838218043838465, 0.006452421170105787, -0.429964758107382, -0.5148941445969932, 0.3347985057056302},
    {0.09043824389598938, -0.3023829429556224, 0.12440672365876485, -0.3016734440668801, -0.1787817003277634, -0.439566503982572, -0.4815366643756849, -0.3943665347645228, -0.1618773432607504, 0.18666934565367096, -0.4481418473097043, -0.6079548308515389, -0.4102715601197527, 0.16760219780003727, -0.17980714647880938, -0.6193692556076368, -0.05445516076569676, -0.03951588352949079, -0.06461568306837762, -0.40780969787478594, -0.44159276848295537, -0.3680343754173991, -0.2691965262638249, -0.46550261834873424, -0.3834377824949211, -0.6330839969326183, -0.2352550907011961, -0.38445200881256575, -0.2576947862177347, -0.4853786950054803, 0.1140984408879047, -0.5359309470899141, -0.28522300166336406, -0.1749018264284869, -0.3561521847259112, -0.3408373051280549, -0.04738492661200983, -0.15299002375582071, -0.4864778293604397, -0.48218194414785165, -0.34973883965740077, -0.797175085163073, -0.42290019936279244, -0.36992701386125026, -0.33988914568427636, -0.4002716582128288, -0.301653441423405, -0.12734440712272926, -0.4848975410268206, -0.7010972000522315, -0.10605681992787426, -0.4441382763116203, -0.30954857541853914, -0.1293299744487846, -0.4345905050321198, -0.6254418673002808, -0.38591069460104244, -0.6476517970688992, -0.2668022568696301, -0.4252202674700373, -0.34368303824643454, -0.8570466982939472, -0.5782364254417911, -0.0372604061236834},
    {-0.20871303104310995, -0.19942981577932534, 0.059743317736289235, -0.3043757854656389, 0.09239350740442973, -0.26875359676359845, -0.6880697625794115, -0.28009167459581774, -0.558308564824885, -0.14071168550922833, -0.41323089304932625, -0.3735305695445525, -0.5355703014099246, 0.24445253309492682, -0.1538983458098224, -0.3931958936849777, -0.011893160259819593, 0.44063218333293425, 0.19557710619158972, -0.4101483368459103, -0.408377201343338, -0.5708067107951491, -0.34938331945110795, -0.3318390174728774, -0.2912627460987127, -0.38979626440218745, -0.23812343642222558, -0.4929764207294738, -0.14125401201054022, -0.525812601961758, 0.27088156121678497, -0.30881605388960615, -0.26584910358478314, -0.3272928451305732, -0.2481139925824662, -0.3720943185966903, -0.17683533961199976, -0.512810569372525, -0.7925510592871234, -0.3168391168152904, -0.48300194444390615, -0.2641917232283753, -0.4157243851260982, -0.23102576203008965, -0.3549391752847579, -0.12857396603861687, -0.6066560324325394, -0.12274217857995359, -0.6090255422551545, -0.5327116205401621, -0.19644034999048623, -0.46658194029706584, -0.31070963886879827, 0.010881658264572693, -0.18976819386791746, -0.5580886725535708, -0.5785692111458831, -0.3093224113104166, -0.4168819963224563, -0.11922656728047785, -0.08169490241035915, -0.38850212261675354, -0.6980202215840471, -0.45135259524620686},
    {0.505409262546933, -0.39139737536299973, 0.10390864455128965, -0.5695278630459036, 0.18956917024115116, -0.30258378937095093, -0.5049530106609595, -0.19073487966749936, -0.6629351688622003, 0.20053682929724037, -0.2821814556864664, -0.5119089336658261, -0.49463570930686535, 0.2576643119676542, -0.22413476497910229, -0.2363470390748525, 0.19878866481027732, 0.13550206994376132, 0.2299527665376707, -0.49264918245495776, -0.5073181057522836, -0.25019201104747635, -0.568692804239326, -0.7394944284833231, -0.43911292930011386, -0.2601750732089707, -0.26239610698362037, -0.6062962531646987, -0.2617898364341278, -0.31038239488351493, 0.02210572559194212, -0.7566952631686173, -0.342769411137426, 0.24029550938256175, -0.5160141427727202, -0.260309023636195, -0.23514938244668118, -0.6309458244152616, -0.7612137295067087, -0.10883169480381447, -0.6459876442755103, -0.5048346624774956, -0.43943807762016485, -0.28603495265336615, -0.4165631218783836, -0.1306383383411062, -0.49821303104309006, 0.07376248375684692, -0.34290197030302727, -0.49710742933473245, 0.36605405801191837, -0.20597067277711548, -0.6346787688306417, 0.414996717460385, -0.29093323589671205, -0.6783585771442836, -0.6256690102383542, -0.5461050406902835, -0.5603926078842615, -0.3344622803571693, -0.18536931618410465, -0.1977693035855324, -0.38220613864971814, -0.1274691932574557},
    {0.42089819618269503, -0.16440681239197488, 0.13166213136070992, -0.615328088667887, 0.03334707208610852, -0.3329689012470444, -0.17941204205358408, -0.5065003763176168, -0.5506002598222268, -0.1754020258037643, -0.37483068625048066, -0.5912795757401935, -0.2655335181850913, 0.0672159289702249, -0.6258625152410017, -0.6373682757903336, 0.34739196656688115, -0.2265514382084462, 0.48857314025722565, -0.10022868542832664, -0.5026505240355655, -0.32066153283344645, -0.5295553268109949, -0.5426014779889486, -0.2894017549333096, -0.08249985423207554, -0.5102285481291237, -0.34921613429184073, -0.21506395857512167, -0.5369959443649502, -0.27110793663085714, -0.37466743545797593, -0.5750760047736699, -0.052391217005991274, -0.35650914201470874, -0.06821003393122578, -0.17943294312882863, -0.5506963770912991, -0.3716502261495331, -0.27005040093193244, -0.42069332717841373, -0.2377827341286738, -0.41993128528801277, -0.11585930045609966, -0.4660766112037561, 0.12743168649923797, -0.6028310940351442, -0.022068386924701335, -0.43785297380191934, -0.43156093857328764, 0.1336990677534397, -0.3536583715731657, -0.6003015126624961, 0.4076781757848853, -0.3711865451136691, -0.4139430589066577, -0.5877073602033405, -0.35920608311424634, -0.150278385625856, -0.3223931947947761, -0.2923944746986543, -0.3110026763036947, -0.36628485236927855, -0.15362745354387886},
    {0.18725887004263952, -0.4278544657327869, -0.11378615536755006, -0.36772260157526926, 0.06288414479668378, -0.49457774253968684, -0.5765944426283016, -0.32767628554414063, -0.6130644613567651, -0.309176606946181, -0.41574963665185777, -0.4834643555974717, -0.34335732759465354, 0.1734717156775886, -0.2555479351122124, -0.5987948029045279, 0.20421277735945711, -0.31590498102338094, 0.2620129694738905, -0.16382896090669435, -0.3605556763124389, -0.08132751069622844, -0.6330105194988501, -0.5456790394662614, -0.3868190644778444, 0.07329677884340677, -0.586687316197645, -0.4865832928128533, -0.24232200025837095, -0.3512913787901828, 0.05746896878676808, -0.3603789735765621, -0.4423373319767161, 0.051607256648577106, -0.3974281930588592, -0.4275460230088677, -0.5025459719992772, -0.3609799946580372, -0.5353824198108764, -0.24735735905143816, -0.11421824483530676, -0.3954477038733188, -0.43471507673244814, -0.31114400616272325, -0.5304306969135409, -0.2608528330697124, -0.7103430339024426, -0.1379295536575095, -0.4305005585612517, -0.4724875539809309, 0.16633937765515427, -0.2225972802634188, -0.6041851743030545, 0.3970893935792459, -0.5451111724097646, -0.43584651523688345, -0.39863030913605746, -0.8424411079023038, -0.6108475953606893, -0.5455643227489115, -0.1259201904332263, -0.21572213724177164, -0.571419240537322, 0.06052104877234894},
    {0.31579789653199136, 0.010191186964839154, 0.21810816586032122, -0.13453730484143903, 0.03717267174333108, -0.23333654283417357, -0.2840987985424634, -0.5925723892880621, -0.17197650273146886, -0.05658972404722888, -0.07784105989067516, -0.8140535931892633, -0.6002786651912436, 0.05602461657574213, -0.19383999744538608, -0.5209725584218828, 0.4007033835134064, 0.19229034119932406, 0.26738881019719674, -0.3889469119520656, -0.6253017415014327, -0.4219795068753349, -0.6780510263559091, -0.533298786481528, -0.24002533011003824, -0.22327251786470406, -0.389724393376394, -0.5645021560691111, -0.41551447684959747, -0.5031593553229163, 0.10036265592592092, 0.03795717421845305, -0.6578505737729272, 0.30750201975462543, -0.20609811112898052, -0.24793710621657813, -0.5276968896522293, -0.4246311319726182, -0.4428847492233016, -0.23684603130716067, -0.6152233488365245, -0.6509021461781619, -0.23116209513600133, -0.25784570293123227, -0.601860466141698, 0.017242128412527237, -0.737446745564671, 0.2975923710394742, -0.6879656722740722, -0.5905393346481097, 0.15664857979753297, -0.0501738343112797, -0.4040526954937786, 0.672585223798243, -0.18028311300755423, -0.2625112077441179, -0.4667543202213604, -0.5675355750974796, -0.5950622881367376, -0.5704960185100187, 0.30616437740215796, -0.0894961799108986, -0.5620320305771042, 0.13106439701867234},
    {0.19176133354417124, -0.26172341537709787, -0.21525760952727113, -0.36505323130399925, 0.2844283435393116, -0.4508963630126048, -0.27641156787408916, -0.500516158705501, -0.46258604540515347, -0.2812451531357054, -0.2800901130470554, -0.6913376526288006, -0.32441332199806944, 0.2724030395305095, -0.013794549035645337, -0.34582842874224684, 0.28206552266193036, -0.061194430320933586, 0.32723899291403785, -0.5423601143390372, -0.7515942530611328, -0.5729069259058791, -0.5358151765117709, -0.635412876824167, -0.097674788069038, 0.020318616807498538, -0.3685441416868891, -0.31644853247719934, -0.0776870941664982, -0.5017545219195237, 0.2008116153784545, -0.22792568296543525, -0.18382604768267657, -0.07578956734547211, -0.24366839096980225, -0.11460523633246088, -0.4645402254692992, -0.5427401256866912, -0.3938384026925066, -0.2902086730901988, -0.20966068018747216, -0.6902305994237565, -0.3786475327310392, -0.3746242320141273, -0.3335754532184135, 0.014332517054000344, -0.5395017484782262, 0.1669613815412148, -0.3143418968924901, -0.7406800012631805, 0.16136771854016055, -0.14452060797864705, -0.3892975236821382, 0.5158344962698979, -0.13877131064257134, 0.012777777167936991, -0.4493023829686503, -0.6932133987952159, -0.42560265467706543, -0.4703684155123498, 0.07017697551652823, -0.16605179950649843, -0.2884253246407619, 0.2350626899880666},
    {0.21682602852997196, -0.2248750508097089, -0.31709351505688715, -0.36217368055653676, 0.017404922800631883, 0.02054770508329803, -0.42510549237426054, -0.35078974754124437, -0.2502945963820843, -0.2679414717042112, -0.7650228488189961, -0.2312529212479727, -0.4334549798298468, 0.04586571602827389, -0.31314402673634073, -0.30396518775167164, 0.26718061506199875, 0.23542432744169633, 0.028133685124628955, -0.12578951586955345, -0.5592463757447005, -0.6954581899978804, -0.6761848967327614, -0.598309450900083, -0.4533671462675613, -0.2938197162678705, -0.41297324594614326, -0.4145608910820637, -0.27572933048520254, -0.5614467583469661, -0.036889024640935686, -0.30013004470898014, -0.2392335736282801, -0.15498969296605306, -0.29955504897499174, -0.3885042256170683, -0.4282504672133738, -0.4836327629460924, -0.4995917921127643, -0.4704064390611966, -0.713868524545163, -0.3237669864795616, -0.37015987284600615, -0.5114157122995568, -0.3563063986577487, -0.22589482718149015, -0.6640362247784304, 0.19755011349215504, -0.5380201736898805, -0.7253453578033924, 0.12393221008680098, -0.18023829887570955, -0.45629538900825206, 0.5554395326362528, -0.028119550755180155, -0.40469512005224617, -0.5789546424017813, -0.5537242562000113, -0.17712960993892687, -0.3839165511715619, -0.3605502828297953, -0.23865800300694898, -0.7074598670914044, -0.14849708578919965},
    {0.15510289528167767, -0.31222537266284783, -0.43380915832898814, -0.330132051072488, 0.017345467505390125, -0.30867911495192896, -0.5615442859844267, -0.16519452407996377, -0.46909556130484126, -0.49473074040725007, -0.38649874986839106, -0.5373239902041707, -0.6890841516007841, 0.370234510843937, -0.1202353738543877, -0.590039695345396, 0.08276583889108419, 0.08609904855339721, 0.20335118998820484, -0.3125945728700847, -0.8344662227489569, -0.4667870842647962, -0.8321638068262486, -0.5811712201856148, -0.5599093134087818, -0.23905339781831642, -0.5540271335312155, -0.4712131731559086, -0.5929959631428385, -0.6774197646154441, -0.2939167567501423, -0.6215636480655652, -0.40205886694865794, -0.15065287424599313, -0.6595727719395651, -0.3776948802212825, -0.46355795203243555, -0.6994198321084155, -0.41479219849295645, -0.19839380858065592, -0.3434936929093122, -0.5648144115157465, -0.5242818009703213, -0.3507633057484169, -0.4210857482360805, -0.37148023724003726, -0.5109897159168711, -0.08533251135765585, -0.5182628201773344, -0.5619174372837086, -0.25252952212105484, -0.46955141699130665, -0.38849298364500157, 0.29050040828147883, -0.26603095531164844, -0.4623543604910034, -0.7776214822803172, -0.6326235983994627, -0.6641021918880732, -0.39487188782853166, -0.1294201633361136, -0.2760750490921763, -0.6428250724043274, 0.2278800995723799},
    {0.6063023377573598, -0.29808893345725307, 0.12602001854293435, -0.3168908627131192, 0.5127783675467611, -0.357688048432061, -0.6342674028336658, -0.18719631984709023, -0.5827681372292274, -0.32244753090938255, -0.2909155267115748, -0.6496137120147084, -0.5453291230416133, 0.6857694603323914, -0.4888692226621527, 0.006571359084464503, 0.49602627437369706, 0.2737680012415761, 0.27838713193759806, -0.40318798582005255, -0.6331971817728765, -0.3625587099355686, -0.9948131248202028, -0.5323975960680183, -0.18613829941733157, -0.31314139589096535, -0.6698524556903439, -0.5774812440607683, -0.7707542662852634, -0.7878274229662027, 0.13386566931973487, -0.4664287227002207, -0.5111114509115547, 0.1193096130308703, -0.4284047988892952, -0.2983099892443295, -0.47197992635997327, -0.4320069512345063, -0.4760367855058404, -0.2041544827745965, -0.42843702630527597, -0.36732245490497767, -0.5149169729657987, -0.2799560680158188, -0.5893233130297661, -0.28627400777606, -0.5948233798359203, 0.519142525618294, -0.1856800419115594, -0.5068991196376046, 0.4886862789159398, -0.11575084924121408, -0.42573105753396934, 0.3525190684405132, -0.19287883941339273, -0.3986392222578857, -0.7399814075433025, -0.7669187159681258, -0.5240011916756255, -0.3600756535204881, 0.19319407520731507, -0.10336169518136985, -0.6460940769643343, -0.08154979561992663},
    {0.403553789185843, -0.5948698639063764, -0.23310458242347298, -0.2779090063824278, 0.6418622449284033, -0.3785130834042393, -0.6113902568793527, -0.22162120990917478, -0.48610946142559547, -0.2720372650494207, -0.5826132673858554, -0.9271041967866999, -0.5565602483282924, 0.6694302402420366, 0.0151686309693698, -0.41606898245142726, 0.5008786273152561, 0.4020059220453393, 0.2486846298608252, -0.23211431233211122, -0.6402745347588852, -0.6083223275669458, -0.6718986054061344, -0.6043900309892125, -0.16926724535984822, -0.026562800922132403, -0.8316913707136744, -0.685691219441398, -0.3022961976088835, -0.5250783804978054, -0.037463998189309955, -0.4205431081453662, -0.06870060502908043, 0.2688064891742375, -0.24726075534998437, 0.1456809413429675, -0.42108503188146706, -0.511685805962663, -0.4052802639448006, -0.04533599167721315, -0.3939496384182431, -0.519457107466541, -0.4499611281230765, -0.447793761575966, -0.5571763226328027, 0.277444897496591, -0.7388285041831539, 0.29553934900555046, -0.4117150645218921, -0.7692710555339141, 0.38942046739101155, -0.3232928627782596, -0.5578194672589186, 0.6933061609076389, 0.1842423552997103, -0.17295490867258037, -0.8350684310960307, -0.8837531454617586, -0.6363128611461609, -0.47730113495159077, 0.28247064597673244, -0.12534786942479514, -0.3647694591057266, 0.42992306048668844},
    {0.31146580489132913, -0.32058737469481474, -0.5836868070753786, -0.67556887632735, 0.07434008861012673, -0.4515270668773528, -0.4561917834782484, -0.39072710949782585, -0.8340418202828191, -0.7118845199646993, -0.6094647962057778, -0.7242094154620577, -0.2784717707023554, 0.2692762111421393, -0.09009074531650053, -0.494006293723847, 0.5652695716478057, -0.06427649059515089, 0.10085884970794148, -0.3870164877445275, -0.5163090634596371, -0.4111054018983573, -0.6732901028601498, -0.7320264158307048, -0.44056137461250666, -0.21244649080886194, -0.848509227597276, -0.32342522588183137, -0.632897746727458, -0.36987894310950814, -0.02263528530898596, -0.3600898976707076, -0.13616915211236472, 0.46885711651400275, -0.5741463405744234, -0.11701814528001317, -0.594319622912796, -0.5349468329967957, -0.6466954484164346, -0.3705137829272447, -0.7198820806502714, -0.2792297626634976, -0.4218625914118263, -0.5091144625975437, -0.4265429314645286, -0.08043372352448154, -0.3757465406063131, -0.03894160823874277, -0.3672088456667793, -0.6611594992655082, 0.41673529378372526, -0.3890218792755652, -0.7832055339500578, 0.5745132590959413, -0.17259526560308414, -0.4476960241642919, -0.6566897952738919, -0.5938849009774785, -0.7765400557278599, -0.6126262398863298, 0.31100992349705897, -0.29007586129034474, -0.4190748409408085, -0.04006368993786368},
    {0.14584356608820132, -0.2715565482130283, -0.5689010353335306, -0.23397886355305725, 0.16901636014891788, -0.4392776749316909, -0.5400411873819414, -0.6511642316839286, -0.4962604287418036, -0.4769782015685299, -0.46239541292971426, -0.48753123159114525, -0.489037472320486, 0.07408277894644213, -0.3377895313969011, -0.5130422682342526, 0.27374691307065685, -0.040984544657504965, 0.07879196675258572, -0.3210615279139506, -0.30250242940082667, -0.7216816379141382, -0.46834264441070816, -0.5934399590715941, -0.5088026511874747, -0.5241813200809833, -0.5603415400621707, -0.5826458359599458, -0.35014350872668204, -0.7747510575837618, -0.1186029476543286, -0.11240288492518567, -0.3277615195991346, 0.24711218247800937, -0.6107699799722663, -0.25144403651537534, -0.44385929109012207, -0.5559207427735594, -0.5335322373504479, -0.2260403855770982, -0.42088539626110333, -0.6436980564854349, -0.5533165495513042, -0.6371336253481333, -0.6081158105900162, -0.1452720538623896, -0.8867118571759216, -0.349214026889759, -0.3401979985071129, -0.6373169181578706, 0.1813339371483639, -0.4295102141943149, -0.2872537421331917, 0.38992325536136424, -0.1154704895657444, -0.43901189680803887, -0.6068726780782098, -0.5887218553090418, -0.5420077658834519, -0.7303985952063622, -0.12709006398003436, -0.09954760208789538, -0.39367758783104484, -0.016369257377010733},
    {0.6183162571310162, -0.46260197337631853, -0.3925130042922633, -0.3505437928010377, 0.42410925663735616, -0.5488116810177619, -0.5407036662287443, -0.3957812718074314, -0.7243609400844625, -0.5513489011291045, -0.7690357307642245, -0.5629253778396516, -0.4668487251994257, 0.20654326793841835, -0.20948376425805815, -0.16470179327629977, 0.49984321833435824, -0.08262628663157193, 0.2667093311637648, -0.35003910296420193, -0.45616742463960713, -0.6214704954180489, -0.879902489530811, -0.39222357608739467, -0.17040010830769423, -0.14167605698056837, -0.528604570566181, -0.6099208223841242, -0.38515904842439447, -0.5866128312900293, 0.21304976036743456, -0.3855069187700594, 0.011399347743727495, 0.312363052461285, -0.34097352362073013, -0.28374830604195006, -0.39422803877720025, -0.8731684820824859, -0.7445839212094388, -0.09112427392669659, -0.47354273423530796, -0.4462968876028648, -0.6437126327000874, -0.35474391746028106, -0.3565720316521254, -0.07742842384321155, -0.4957797983530668, 0.09019182858018951, -0.39940501109706605, -0.5261323011469815, 0.1291321891663749, -0.3805915021847146, -0.41033453769677564, 0.6195780739506566, -0.06519790498405979, -0.2612812337178853, -0.5818298318313222, -0.44725915133827365, -0.8432122928205154, -0.6895122114194366, -0.04640645247279221, -0.024160843325942472, -0.5030251851417565, 0.306011583557984},
    {0.3290116047619042, -0.6154023891229862, -0.47868983991733394, -0.6233987806925335, 0.3103800566431508, -0.5328818289940067, -0.6154240743564673, -0.32288788393380474, -0.7757646689672518, -0.3486199944998966, -0.6032444576816249, -0.6746876957462804, -0.6691734027954787, 0.428082048805521, -0.35661713195816336, -0.5071922145721957, 0.23475257551468467, -0.06341623492797134, 0.11344711424777805, -0.3040528205439478, -0.6776943961162287, -0.48099386808874706, -0.6100374248010542, -0.7774354019987949, -0.247553384989151, -0.014758887346221088, -0.6440209549486542, -0.8024491776278909, -0.447921408790037, -0.49580364809068445, 0.24362759623496497, -0.4444133454456057, -0.1848140007833453, 0.3424327780125358, -0.38049090619670384, 0.043105922387973686, -0.6644739126151848, -0.6003729268899546, -0.5064762858506993, -0.33114830973234854, -0.6762770365583746, -0.5247639502878078, -0.7277730314751955, -0.26623701191254606, -0.44453342543911517, -0.10935708576803176, -0.4978835103911031, -0.10752972268978818, -0.48088152113583993, -0.6772754428907323, 0.48225155259330876, -0.34305978991627634, -0.5842261118028195, 0.5644634277604083, 0.11619900202451436, -0.2843171008840847, -0.5005281065137532, -0.8275136575238066, -0.5416909468780066, -0.7636774751536584, 0.19077689708359938, -0.31863469394212407, -0.40659977447439744, 0.022331183956547825},
    {0.6038338716818153, -0.3473063811709174, -0.40399848547547024, -0.5837411394194976, 0.16848381811493474, -0.47550091580929005, -0.24854131671776897, -0.5487574367071211, -0.4362629290917452, -0.3364973819749274, -0.3976750232052738, -0.9421987026193117, -0.5004422597452252, 0.524076034853018, -0.4133490846704928, -0.4561916855470643, 0.5853605814125341, 0.15967708865614658, 0.043121585362458296, -0.36415399786852526, -0.7158311132176147, -0.548897268545072, -0.5885108347851764, -0.5016077110913099, -0.4653469018468023, -0.2069468257607498, -0.504127053347594, -0.7910702641948503, -0.3394870491991208, -0.5943696949906903, 0.188105009363816, -0.4570226642787682, -0.5154795137401708, 0.13591106371284767, -0.13389002768587024, -0.24185302336392847, -0.535044812622132, -0.5076109369405499, -0.6234339496857323, -0.2104916332919756, -0.7010173717108592, -0.44349784021254507, -0.4628810618277299, -0.6088496690873373, -0.6991971336701853, -0.10082951509960467, -0.5829470947141877, -0.004137400634024855, -0.47312764124633117, -0.7716285878403054, 0.1330365836761531, -0.25102234042336835, -0.6079105644512032, 0.4064725506724497, -0.06742578022628763, -0.43245342845926044, -0.5996864422457897, -0.6688028441478153, -0.5106621536316636, -0.41816376021471413, -0.05968402506991817, -0.06621160426219719, -0.694056066898902, 0.06197956617333752},
    {0.47788245802702284, -0.7798962997199604, -0.29393746879634125, -0.21866156158243055, 0.30576646168841093, -0.5709212155532909, -0.46261601550801296, -0.2489473410216926, -0.7272764869177484, -0.2797918616947439, -0.5416889373786684, -0.7220302707904227, -0.2880806489407615, 0.5954210141728897, -0.23306899504973613, -0.4774910441407528, 0.6815429452748242, -0.06417128002731845, 0.2485459837248724, -0.2314647710529744, -0.8893050245667926, -0.6606980802183111, -0.7257270797810839, -0.8424000955558463, -0.21996787481631405, -0.190326283795357, -0.5154309086286017, -0.6482031504589988, -0.6111193011307609, -0.3259859876112113, 0.15561654020422122, -0.2938607474048464, -0.41350026104428445, -0.023648155540873253, -0.5356312699168975, -0.2527161169008779, -0.49842934083497925, -0.7144991882965381, -0.6749985310735173, -0.1301734743172253, -0.4866716607914346, -0.5364876187407903, -0.5409445581981979, -0.3765751957044044, -0.3568874418183125, 0.15512364511691912, -0.6023711033383695, 0.05161680969142108, -0.32928357707020883, -0.8582793928855806, 0.38159648967690757, -0.18507869574348088, -0.5646307941486667, 0.5893917542504019, 0.2545191722379462, -0.7506759444942074, -0.6187292073047256, -0.8944400720572472, -0.6691326839093232, -0.6765442575487495, -0.06774974828301192, -0.20762682955544737, -0.39563768942325017, 0.2075744743174961},
    {0.3109101203858379, -0.8055948690029208, -0.3252868765147574, -0.38878686695066317, 0.23005523426011176, -0.46929115900553603, -0.4985695429581658, -0.30010480924355354, -0.6428424812184825, -0.3897625517277735, -0.568384430193016, -1.12035715337977, -0.448811431762402, 0.3275766551579384, -0.20355088960980539, -0.24947672749078997, 0.47152811473458345, 0.23715449804319097, 0.20613972346800744, -0.31355097939059084, -0.5855429974955775, -0.4824971047233627, -0.8805111282411993, -0.7029526420313866, 0.029776789320360025, -0.09453981676054742, -0.838043402876387, -0.4977625353212096, -0.4909453512212848, -0.7590768621700382, -0.00527124473254243, -0.5042032096845825, -0.13815323060094972, 0.27102165842682613, -0.358441953203988, -0.22295009088650158, -0.40253524216055003, -0.9110440942988408, -0.31507626855786414, -0.14135865409274478, -0.3278250965362186, -0.6192466733875244, -0.39322710751169737, -0.27199745231756495, -0.515205027072509, -0.12777096579781555, -0.47850159127326525, -0.17907364514914137, -0.5465185092825007, -0.8287148017488325, 0.3003778201236943, -0.14955604253578664, -0.6344821104816187, 0.33136722442141753, -0.32235782107762023, -0.7229712619811848, -0.6114998215601524, -0.6340096127589905, -0.7795864373988375, -0.7641042388120013, 0.059798056330496334, -0.4111914724432737, -0.5910552512134736, 0.4445915331985867}
};

static const float b1[64] = {0.92947721728367, 0.8705571027225772, 0.850834938249868, 0.8148460035033894, 0.8486988084203247, 0.752253440441108, 0.7519298108558112, 0.7934484905935403, 0.7403509630149276, 0.8771873643986505, 0.83122820324904, 0.8527962143085378, 0.7644816974879954, 0.9211635142296007, 0.848415423095012, 0.7670961720939432, 0.902930936802859, 0.7982881592163401, 0.8238686951367509, 0.8369103843489569, 0.8156034656117134, 0.8119051350808154, 0.7572966299508125, 0.7633645821657916, 0.7847302637647946, 0.7731090323429748, 0.7416144771216313, 0.7522712073244765, 0.7551084118494297, 0.794131119879323, 0.7992217672264125, 0.8071947472234322, 0.7566512217163651, 0.8317336800918297, 0.7581192197979573, 0.7658911816337761, 0.7948017973894809, 0.7583660818463722, 0.7616455171292884, 0.676921544486812, 0.8268567672682761, 0.8217428640917245, 0.794610853335072, 0.5099715731773986, 0.5902381706472677, 0.791623777108112, 0.8155972045927878, 0.8959222624132256, 0.7569767766008322, 0.7584879988360979, 0.7872943431564622, 0.7765438131951612, 0.7450622814187046, 0.8441254989991459, 0.8081548739695475, 0.7843867968426748, 0.7873421871292928, 0.8204752713023478, 0.7755643715663332, 0.7179057048481997, 0.7841022541785808, 0.8401685869025789, 0.8048258090353618, 0.7759176021168348};

static const float w2[64][32] = {
    {0.956359685779488, 0.4698427968971496, -0.25153343408750717, 0.4663163909155453, 0.8935780120843874, 0.7980538056318528, 0.9146902026709924, 0.589893399820349, 0.7612082152490445, 0.7300780571655808, 1.0632963101697221, 0.8253585239413095, -0.40593881016146466, 0.09328155638348265, 0.9423830124925244, -0.06042691615112405, 0.9082348541662583, -0.21579388890930085, 0.8076468221466115, 0.35324716754319907, -0.0494976257535409, -0.17535255037163294, 0.593667433678984, 0.5961384015026076, 0.5232223528646588, 0.8958335925039486, 0.9699849549596636, 1.1523905450637344, 0.8048398183035829, 1.033525560664767, 0.9606037441132367, 0.6595074610149109},
    {0.8343703671143418, 0.933532177284353, -0.258266123797158, 0.8085641936788724, 0.5707316743014044, 0.8898164900214983, 0.9938568667394461, 0.5054062986743976, 0.7480304966731305, 0.7040244287933701, 0.892380792003155, 0.8195109936859467, 0.24050917992289175, 0.3298885528324218, 0.6877267908985937, -0.1802084272304624, 0.8567221910383216, -0.22910626392997213, 0.6406698790919491, 0.7202465836099903, -0.003510319085767412, -0.06010931076362381, 0.6481113569651481, 0.08555133536318126, 1.0381754042922526, 1.065387159463485, 0.8974828301357222, 0.8921026775032875, 0.6916303881550846, 0.8470932474813908, 0.966881278113441, 0.7422049968959046},
    {0.7617118223769279, 0.6782454654113965, 0.015922835112979143, 0.7819107772575034, 0.7593615724009251, 0.9630458031238457, 0.46649291695817807, 0.5285565095151025, 0.6544041431528692, 1.1124651903076614, 0.9604288863680778, 0.9267794172897803, -0.22397252191637082, 0.2578128219801996, 0.6646909699910838, -0.1499981593474409, 0.5846086185929023, 0.0765984937211347, 0.6718530079910127, 1.063163918716656, -0.0599349303904521, -0.17666885577589256, 0.768902832285009, 0.5368147368728287, 0.8687129232159548, 1.0217343530631438, 0.7541893622554874, 0.8173828260001637, 0.7883952358413643, 0.9399276456487747, 0.6491527007102373, 0.752670259289214},
    {0.5886793443188011, 0.6270161293781285, -0.0807020517433158, 0.8591888457864287, 0.7566054952984276, 0.724107984352159, 0.9583105704901328, 0.09822570672352914, 0.5682243603741126, 0.9460500118212644, 0.957609264905137, 0.6870985795419012, -0.21081160277043173, 0.16549803870703897, 0.8035579823625337, 0.16016890305806186, 1.004998731900832, 0.0039618930409071945, 0.5744270844932721, 0.7814703604382337, 0.015637287178003913, -0.08676931504498646, 0.6803397669901016, 0.24290024607586727, 0.41394039635160995, 0.848980185131564, 0.6968235559475631, 0.5377117317207467, 0.7367080360526306, 0.8874383214648872, 0.5677218907620982, 0.6066570715058622},
    {0.9455842904756917, 0.5980639437774721, -0.058478821175948756, 0.4541684106566474, 0.9745242972293688, 0.8179802866115986, 0.6159883142726713, 0.6080960685592013, 0.7306060784975206, 1.057184135499455, 1.0702778831003141, 0.7034497070151176, -0.22862442648871642, 0.376759909007449, 0.6929604672955446, 0.028383656656857287, 0.38764719133044134, -0.06700445293729623, 0.5553217778426365, 0.7891473890166613, -0.05545419551933497, -0.0004730379973784966, 0.7575733514888672, 0.34127343467282245, 0.642182441969894, 0.6022363266093144, 0.7163656534309834, 0.8670334424443642, 0.5205624641722679, 0.7983423933205405, 0.5900436428173349, 0.9387154928279181},
    {0.8391169554293976, 0.48644951353844396, -0.23114850414180999, 0.5675458524445444, 0.5409475443177775, 0.8653800624366667, 0.6190717233249378, 0.5334424801359099, 0.7590085364974315, 0.6663577407750548, 0.5845877102694269, 1.028525569093893, -0.25362990478137515, 0.12553479081393965, 0.6451382266068348, -0.039381477806415925, 0.6572530117961027, 0.26184813695309855, 0.685354105592632, 0.9164341600477599, -0.2109767854960312, -0.03669313195392041, 0.7743270838871901, 0.08591009559602389, 0.8211225492135898, 0.957012722390204, 0.7575092893898073, 0.6863361750055043, 0.9692667403258044, 0.4648912307209506, 0.9793053035882759, 0.6569381290743628},
    {0.49028160655451114, 1.0400671815986462, 0.10530429960351448, 0.6733295373275402, 1.0090436427169818, 0.8665282428039982, 0.5915947509374198, 0.5962991403736777, 0.8019450269960844, 0.701863827771886, 0.7695017049536123, 0.7523381431390124, -0.024573292562190895, 0.2132264226877513, 0.7924538686775746, 0.14457956012932419, 0.6407539877007473, -0.06856702344149909, 0.6171116533177966, 0.9069346673977163, -0.10751848187653575, 0.11858236616210044, 0.3921983750130619, 0.39517051660614594, 1.1395058972381986, 0.7998225042571373, 0.3697858116933624, 0.68512885811657, 0.676653480924674, 0.48907767567596944, 0.9730450346988396, 0.7068851040759128},
    {0.36963499034364666, 0.7481188324779812, -0.23921119985077594, 0.9047617523802964, 0.7996273700348938, 0.4879777916061716, 0.9036530842989435, 0.696372121734638, 0.4551706014709799, 0.4088443214345319, 1.1048577515368847, 0.7221782212382518, -0.33607037574849397, 0.09293402448196468, 0.6347637376725614, -0.007200158315785016, 0.7060154847172347, 0.10333775433769508, 0.6350150768075554, 0.8182524913690904, 0.3614536913208814, 0.07107917954150827, 0.5776900971842648, -0.165251224317459, 0.8338287582992304, 0.6355642321718082, 0.6395459451604096, 0.9263720656517699, 0.5849756072769238, 0.5758861335649929, 0.7979265813431785, 0.8775466686491963},
    {0.8408961777754824, 0.9029366787314972, -0.07563995602340977, 0.8157795346503539, 0.7300797735618095, 1.0779553938725406, 0.8222040784428691, 0.4011510712757438, 0.9227142047447793, 1.0903874314550543, 0.4935854573110817, 0.7940356135218422, -0.19126308936414105, 0.40545095006563514, 0.5282340767780878, -0.03774831081891115, 0.1926955112521017, -0.16482122488979706, 0.6523181124158492, 0.9516986617483556, 0.16353116158093828, 0.07520904842259016, 1.0755442523977876, -0.07169862038884675, 0.8361119382365637, 0.5703791874028128, 0.7260272897259875, 0.4445930155693796, 0.46666170854830696, 0.43518436178475617, 0.898509056273319, 0.6928797035240674},
    {0.7062928176190916, 0.7444026720395279, -0.10954349208542044, 0.8371374145365678, 0.7875042514657635, 0.7175293804783356, 0.6725618210634674, 0.5697492841767887, 0.545675985915595, 0.7928794414348037, 1.0435220369458134, 0.8618447214622581, -0.029960197937408922, 0.5534241461345301, 0.7195088945610058, -0.14789589034595366, 0.8329031204520734, 0.016295488086030704, 0.5098231962545474, 0.6910413545801676, -0.20944118210589888, -0.12169775792457946, 0.7426349435467797, 0.19159532878302266, 0.6023659448631421, 0.7980444489051175, 0.7208162726903896, 0.7193631457608091, 0.5872256565081724, 0.8874088465662336, 1.1699226007529675, 0.7194875146745382},
    {0.7360760280688481, 1.1297606782975815, 0.1791467968704338, 0.8112400231386052, 0.6500190819016053, 0.8983345841953713, 0.702179788177285, 0.5323985665934932, 0.8045181666095925, 0.9009405623495518, 0.7277337644200655, 0.9967867165982857, -0.34761609355939055, 0.22416851018102243, 1.0308106205546128, -0.05212281951461959, 0.8218788045499371, -0.22238267928837382, 0.6492596129023711, 0.6248756144492286, -0.06639086188225837, 0.03206496401664426, 0.6627460117266829, 0.26445071845499313, 0.9653488201136232, 0.9297101086502952, 1.2529929471502028, 1.0844932351541532, 0.6863545356733666, 0.9740734744171009, 0.8128416744634032, 0.701996691709899},
    {0.5799180130634456, 0.777619822606874, -0.0026105991869777496, 1.0007285086978106, 0.7490232628977396, 0.17536192236566248, 0.675044433703035, 0.2053251463506583, 0.7513328900635748, 0.6834105628073703, 0.9774538916189797, 0.4898763897411521, -0.007918046210201342, 0.6840039459994194, 0.643645649332003, -0.04352700392232406, 0.9184314562922571, -0.2239874231357017, 0.6174855971770277, 0.888029083433843, -0.3480620560525335, 0.15738712533492283, 0.6520586005702836, 0.07811570609695213, 0.908786171012889, 0.7080843864043896, 0.6984976450118284, 0.4757831108626099, 0.37395922757729494, 0.9675899144662209, 0.906689936820643, 0.8532307913215489},
    {0.6841762332728524, 0.9951993253529318, 0.18084223826167248, 0.5378847279826923, 0.6070501120439259, 0.7997526115517156, 0.6308681413501253, 0.5326570507298383, 0.9073356300095158, 0.7796219797552832, 0.720752461737412, 0.6153940814295147, -0.36958730820309676, 0.2840285596717802, 0.37563500078321704, 0.058573532254672156, 0.7233450884533901, -0.04599937559688276, 0.3773993339601444, 0.7450988116548797, -0.21242548452273485, -0.030686524900221494, 0.33045839306166436, 0.3922830743387754, 0.7071684441183047, 0.6668672348936284, 0.556458881557602, 0.5369491364656334, 0.7285597215214002, 0.887645601883017, 0.6682110566101471, 0.6165525945622637},
    {0.9914841200156843, 0.959536183934396, 0.11702929369446287, 0.5875127976503667, 0.6213599549379651, 0.8296705482161906, 0.7451939974910642, 0.7050418994722354, 0.6778130068654817, 0.8553128701634746, 0.9176401538300785, 0.5964891527388475, -0.30772776580399847, 0.26418677214075775, 0.7257262041661467, -0.3979729626530863, 0.6734696042593806, -0.03697667783379824, 0.8197621216588408, 0.501386230022567, -0.007583485055156793, -0.009760155928857386, 0.7008606105555565, 0.2891962348047182, 0.8561041415510834, 0.6338815676603874, 0.6384951160282551, 0.8814536300927494, 0.504490618249961, 0.6577872187181402, 0.8939073025369809, 0.6132954362671683},
    {0.5578553058416935, 0.3762332001431436, -0.5068157629622393, 0.8189857020102022, 0.5281627229859006, 0.9321368697269468, 0.7028018815032514, 0.3069418488656805, 0.6131472275130989, 0.4059120954308974, 0.8631000395773089, 0.8092738933401192, -0.29247418217223214, 0.33694640550535093, 0.693841611721839, 0.0486192004373533, 0.5531926573224188, -0.026653183124220953, 0.5911094191494699, 0.7027939946633189, -0.08713065236371814, 0.037055595191636835, 0.723310954000935, 0.37141334541378906, 0.6442933762928422, 0.624751089596899, 0.737474339168985, 0.8163848143946434, 0.964958408453161, 1.3464906258899776, 0.9241234303370827, 0.8579561565271531},
    {1.0502793629991194, 0.6667250303801058, 0.04862742704197359, 0.9733521924355562, 0.7778615411699007, 0.48297810346903763, 0.8708042462902292, 0.588502177168856, 0.8672670787724492, 0.8937784290708198, 1.1866407566543804, 0.8105186861797594, 0.08158767544323557, 0.5788617705104284, 0.7643241326930519, -0.28875762071027905, 0.7838514152298003, -0.01046889074333007, 0.6384241143341433, 0.5800802205074281, 0.08089639304436612, -0.016686271955415714, 0.31975255830692734, 0.3672696690680548, 0.8381165434153518, 0.5026095070150453, 0.557388266154623, 0.7477560471905393, 0.7745173956113891, 0.6354266691359032, 0.47437310255768345, 0.8244167508506292},
    {0.7467257332491221, 0.9018565226680799, -0.25225638028304065, 0.6294651715583334, 1.0031560109357296, 0.705290371678597, 0.9104383205033785, 0.48738435235328686, 0.5598759212554812, 0.9142968005272069, 0.9840046519258738, 0.5054071634677633, -0.003907087329917021, 0.1947354989143075, 0.510024664389021, -0.2348927571887868, 0.7487055423485802, -0.080107708057612, 0.4798797311871871, 0.8286778012890629, -0.19241708817084846, 0.25856966703273865, 0.6689451022686215, 0.15269160012518898, 0.9225287553726887, 0.46822077053311734, 0.7672868035097177, 0.6249752722291041, 0.7093116289842696, 1.3130447395992144, 0.7927064360134194, 1.0328579229108847},
    {0.7172597280200482, 0.7519648860707386, -0.14696357294898518, 0.61394973384164, 0.8550972486531544, 1.0789987864958057, 0.9085489766238138, 0.47440968301687786, 0.8912625035417479, 0.528540177028194, 0.8580659426908867, 0.8937085032918232, 0.17557615020150905, 0.5875510418649585, 0.596190860622714, -0.1097973150986759, 0.9624117800724146, 0.22519253476547058, 0.9727563618085663, 0.7501708519051211, -0.3211943658190602, -0.029647056563611753, 1.0884343325472239, 0.550612128309183, 0.74253375098405, 1.164128018856844, 0.679771759747944, 0.9531508254472941, 0.9954274867267943, 0.8542647068321877, 0.9227245883846849, 0.7444555623914898},
    {0.89857704592965, 0.7504032847238454, 0.01988308403782151, 0.9666147653088147, 0.738029277534731, 0.596615600945265, 0.7517615886015521, 0.7937221604227633, 0.7888663703086535, 0.8634390703792949, 0.8482880068505178, 0.6680048832702549, -0.1157211515238093, 0.4014271445653833, 0.8079438092685073, -0.11321493282724553, 0.5188737197935399, -0.05512171046760509, 0.5358253099669172, 0.8542933063203383, -0.3981823703289788, -0.2551792822635271, 0.7509814673066346, 0.1771955505181134, 0.8576640128983253, 0.6864995930631655, 0.6723978624709488, 0.8919334657700079, 0.5864781431663233, 0.40344366738660986, 0.9446253261023735, 0.8742281773778129},
    {0.730305886750393, 0.4897058348489007, -0.4243240571439202, 0.8182777570721236, 0.5686938393430931, 0.7515101522111421, 1.2295172572312876, 0.6994623483084851, 0.4809667907983967, 0.9616639014122353, 0.4525367391352037, 0.5151055903332298, 0.03492461975033225, 0.24148763867899684, 0.4061795444465202, -0.062111390878317164, 0.963739109337021, 0.06749611280035052, 0.5517689553196187, 0.5577622152789314, -0.24192350166609494, -0.01283254971037663, 0.730435702591558, 0.2153904054034785, 0.601438165949164, 0.31158660705038904, 0.4957422358334692, 0.6618288547055278, 0.6809858233258933, 0.6251023173773995, 0.8177085516117363, 0.5755967504557639},
    {0.7025205025510957, 0.7250889986038704, 0.0572599732847888, 0.9921260007119771, 0.6191447475057592, 0.13625623726267155, 0.8011941912884238, 0.6511875944751877, 0.7378999053972015, 0.6920829593010767, 0.5774465636157443, 0.48850086165145973, -0.3336594767062039, 0.0799675802058911, 0.4629465243807291, -0.09461293045496054, 0.7509546312255917, 0.09427542030621339, 0.46551596032904824, 0.5611547177434972, -0.19615844343860725, -0.20104805150284355, 0.5908586056100541, 0.006911756095015727, 0.6960343793283561, 0.5600621707904018, 1.0248093536492435, 0.906003321135158, 0.538246931928821, 0.7926295742521301, 0.7744429571035713, 0.4901421467960295},
    {0.7400493704010283, 0.5762959713575783, -0.017020080854499773, 0.8931222167938763, 0.7844713399696582, 0.5414025561232091, 0.8223482679976942, 0.01353644931675398, 0.3307517035843879, 0.9752857105886865, 0.5144855997533644, 0.7495401333171466, 0.004150801765272936, 0.29391782239008996, 0.6064067425711454, 0.0021165459069261284, 0.7902650715991025, 0.07799590749078321, 0.3534009971443401, 0.8422723033053677, 0.28570501828822215, -0.016772470012259347, 0.7841340554098101, 0.35709281456500497, 0.7269187734444852, 0.6498911712781201, 0.5013880744525893, 0.5978008786988714, 0.6107276107829267, 0.6557833641955617, 0.6129114217779218, 0.5454326910206969},
    {0.7517966194191896, 1.0261277078402808, -0.10481110900773477, 0.7978740656107436, 0.7320267682391208, 0.6730849643415369, 0.6135842065686372, 0.4692648406213568, 0.6933266766750646, 0.8036534800078294, 0.8359019252767241, 0.7149859562835232, -0.14457389759204828, 0.1341889212880891, 0.6431252505359711, -0.05692733304621495, 0.8061049629028344, -0.0199912985461914, 0.7493894828221356, 0.7367864981324433, -0.1142341495295662, 0.14531126603314867, 0.8198531071814263, 0.56569951111494, 0.8704359244346865, 0.6990518979866727, 0.4134631277841222, 0.8832149834981776, 0.3172769377143277, 0.6550276143579822, 1.071422208830315, 0.6077215780878089},
    {0.6865532026535388, 0.7464529899213237, 0.13338495563616048, 0.5639065656252814, 0.8618247438622341, 0.379673500855252, 0.773684106511274, 0.13299094092165206, 0.8023644610543014, 0.8320181158732263, 0.8321173847466683, 0.753231242037429, 0.08838716543110625, 0.14000948113047548, 0.6093920483444863, -0.03455672734309368, 0.6994279896865103, -0.07649824954053219, 0.30731202544105807, 0.8265723594537743, 0.1269790736510104, -0.21502908046497543, 0.9592085715412397, 0.12140125627186997, 0.8066025810793274, 0.6239840198629842, 0.6034009597073015, 0.3150757415038435, 0.8598795467046302, 0.42398821493009836, 0.6601853674771931, 0.5295195578384011},
    {0.6441507025202617, 0.7771315390570469, -0.21147233280154393, 0.848302298369406, 0.9867944620636008, 0.6901073757335149, 0.7396884678303959, 0.2637462252798794, 0.7697401735548364, 0.5965843445361915, 0.5520301467927967, 0.6834061866259747, 0.05818966787371461, 0.22717686515674365, 0.5824776868696966, 0.11576643439186138, 0.44721958167849535, 0.06139039959502548, 0.2883308262325731, 0.774774732610243, -0.16553491536439255, -0.24462550718155818, 0.7654217421784993, 0.451184366260705, 0.9441629492274285, 0.8261769370212158, 0.8213557819127868, 0.7599749737058366, 0.6253718074943001, 0.7407135303738073, 0.7854431651349162, 0.7850048053824417},
    {0.6060744882580833, 0.5140192864683657, 0.01132597512808283, 1.0838189218100662, 0.6420978495602306, 0.8407988043712683, 0.6994590329278618, 0.4479965506518158, 0.3803987629899111, 0.41630019056910333, 0.6253926981240342, 0.801674256545937, 0.15579945298228615, 0.44701997217104433, 0.999593788463741, 0.07481059173270294, 0.7564024401602156, -0.1980387662877762, 0.699041197534927, 0.9686366448902913, 0.08693928908891764, 0.0226377726710273, 0.8411712492023613, 0.16855290833238715, 0.8248527936037781, 0.7022575025222358, 0.5901294075512298, 0.7146768278942361, 0.6085758934226506, 0.7616074078306725, 0.510128272018151, 0.6808565710795007},
    {0.8124979833554885, 0.8010638520437431, -0.03715531078635547, 1.0558594420144056, 0.7004871908655242, 0.8787575748779847, 0.9726109237915807, 0.6038376156401637, 0.6023843813271154, 0.8845712974808898, 0.9271733963562113, 0.792914662865205, 0.17197017269134435, 0.5837206499452461, 0.6250789975361168, -0.21670951427478904, 0.7589836424364457, 0.005406342886414532, 0.6544157035289407, 0.8576490075869931, -0.02865197783927056, -0.21233564398438748, 1.0732026173368283, 0.6860949368469068, 0.7507619083708249, 0.815821935785131, 1.0217449361105297, 0.6834479104658789, 0.8166238985746413, 0.5260869840506197, 0.7957286895155276, 0.7252720756838379},
    {0.7785904941355003, 0.7918813729418306, 0.3342253979916701, 0.9131785137446524, 0.7671283670033728, 0.6800135961861188, 0.5263990532440141, 0.3308000162507315, 0.6383503808889722, 0.6452509158394296, 0.7606302661680738, 0.8256043753396151, -0.18937436916297073, 0.315608464966209, 0.40871445683504, -0.2071518080410586, 0.5705137256642402, -0.004301780153031431, 0.549880653585539, 0.9821037672748653, 0.07743381237833244, -0.037574627585443644, 0.8300926092224646, 0.6105041182965064, 0.721445738987826, 0.6888541264051771, 0.7071684715049195, 0.6485764763222736, 0.9591021335097912, 0.8255675284617708, 0.715642123368187, 0.5932246715883016},
    {0.6698217005875571, 0.5825700240312035, -0.006538802913663907, 0.8618911876265635, 0.671301030040874, 0.7618672340577323, 0.9960211234915953, 0.48118460183212547, 0.7437259196660411, 0.9725834577125732, 0.5852825403602102, 0.8364083794594229, -0.03764692886369593, 0.3857453689419875, 0.25743207748057956, 0.048908266382427054, 0.7218549761271582, -0.06225372625814144, 0.6309556152865983, 0.8875539307012945, -0.14697837896249094, 0.2953488936013585, 0.7169568705757104, 0.29904763294760356, 0.9855179115724871, 0.41427081682363925, 0.7820009796983002, 0.7545479079799662, 0.7032481427081183, 0.6024607810398445, 0.6559938814919367, 0.7597073539899546},
    {0.3945508666623441, 0.6824904007763992, -0.13672386001161324, 0.6038490200968175, 0.8346640950076745, 0.5674706911837951, 0.9521236866598877, 0.25213281233115165, 0.5522262478886377, 1.1331334383869303, 0.826594460693802, 0.7852959954415896, -0.00018271484853116533, 0.31891710400949047, 0.7636114231078207, 0.02216117261333449, 0.48905160563938244, 0.2925779176074482, 0.5925774336031487, 0.779428180616959, -0.10138978189893029, -0.05177182409260554, 0.5242210939584154, 0.3360294688191628, 1.009618975157578, 0.4661706999202645, 0.7315184468853739, 0.6048339840738062, 0.5421527547885614, 0.6808869901714623, 0.7674638485898087, 0.6130791749880213},
    {0.6295301375160847, 1.0527333614161654, -0.11199180266891477, 1.1465884104508137, 0.763596238348812, 0.629302275966966, 0.910018831245055, 0.5654688760767735, 0.9053768735280797, 0.9246146961526206, 0.7689733268261093, 0.3395341458531577, 0.14953081879102387, 0.15714632260028066, 1.0902751251954406, -0.14533745140769358, 0.8939744446024961, 0.14920324479223082, 1.0088415923298926, 0.6362576291527815, -0.019694927330911858, -0.18371148033359924, 0.7021568477021041, 0.6688145712209446, 0.8840991286542651, 0.6272886024924064, 0.5186101997626448, 0.937285370656248, 0.7566128992875472, 0.877500145320505, 0.7624371461734497, 0.8089627801606286},
    {0.5945314099265596, 0.5760122405197544, -0.3770313329140046, 0.46427268914011877, 0.8453811564836581, 0.3025556373607374, 0.6347883697279624, 0.5289920961433684, 0.7617917195493596, 0.6089352346796358, 0.46292575919688345, 1.0512662991082915, -0.1103255154514107, 0.19813393873029628, 0.41373834262675396, -0.12143682627580207, 0.7420680843800253, -0.24895725173117805, 0.4828093763619118, 0.6771220755714846, -0.048248146516429884, 0.14156600549117213, 0.9085806052701813, 0.24415042045525, 0.7725446811505418, 0.5348435328891996, 0.7766361279485436, 0.6686842441215276, 0.542729194437687, 0.9603866896200883, 0.7038281166180628, 0.4453745895672089},
    {0.8159028077219307, 0.6021355353580937, -0.12145448609100819, 0.9708020929001884, 0.681885851314251, 0.658287638370606, 0.762823000799277, 0.23375746325722152, 0.8176162884631157, 0.6743695505102685, 0.7405366770185158, 0.48565684598733994, -0.0417780740284491, -0.040786178067057546, 0.7543574142601226, 0.08513391144981644, 0.6324137310114629, 0.24529983877433886, 0.5224057551333157, 0.6481805092640115, 0.02300949640070936, 0.08221681080665928, 0.6168151333963517, 0.32020592995367453, 0.6961539596916938, 0.7534702893860549, 0.7190370281602669, 0.5294788813032086, 0.4637418796463673, 0.9040460109641872, 0.6957370130612545, 0.28094022862822043},
    {0.6707851048039191, 0.6959857685577026, 0.11540102082648916, 0.9385083391129213, 0.8956852299475171, 0.6119980532187018, 0.7032468056834904, 0.4837687032551748, 0.6746097380905788, 1.134783827778791, 0.5791520036698932, 1.009694884653716, 0.03314828687298905, 0.09251466320700452, 0.6651892292822529, -0.015900822432054325, 0.8516920377238645, 0.054719846258775975, 0.7338136311586593, 0.6708008488980706, -0.159512305285623, -0.07278933505482921, 0.5172630121758455, 0.4240416597541288, 0.9628021013686552, 0.660212391149231, 0.7527278332011111, 0.5088035888968936, 0.4920879551756502, 1.0721750445693317, 1.042814700466413, 0.7226374624106419},
    {0.9980244327730945, 1.0313138345191266, 0.365163493021758, 0.733265856990026, 0.8599312388790711, 0.4466659413861502, 0.7357043207614173, 0.4706193730300008, 0.62420420516552, 0.41673454895220885, 0.8870128738905185, 0.7026721432306268, 0.07074427155192008, 0.12148251292998401, 0.186375483388767, -0.2730704379513826, 0.7879759751861753, 0.13784047115580378, 0.7226814908502227, 0.9777495906086012, 0.14111023749241178, -0.019415969691678796, 0.5884209923363295, 0.45378255303163306, 0.559173573305567, 0.5476802275258353, 0.918561564787021, 0.927787330932213, 0.4913857604403231, 0.6738862061643942, 0.7568842406375822, 0.8261544506447298},
    {0.8083150224582853, 0.965944529966254, -0.002578515431870554, 0.9186635161047567, 0.9075269881714951, 0.9921905560191562, 0.8360953773339359, 0.6952445265063266, 0.571758100184511, 0.7350026224221313, 0.5779479333378538, 0.6319107497394126, -0.0058116750330894276, 0.18284080342036557, 0.645546926418592, 0.21945642545691207, 0.7499180680455196, 0.005387225356247451, 0.6163143168400499, 0.6640045997994538, -0.08644178066628626, 0.08951855675289794, 0.7256791352680093, 0.21212299335500232, 0.6052599552228163, 0.66143161305126, 0.5021056534751985, 0.7112233528947216, 0.6286000143989404, 0.6994710098732079, 0.6033913069014688, 0.680836498254457},
    {0.6588390597805422, 0.929636045921835, -0.23949422853498112, 1.0310422885414086, 0.7859009834466174, 0.5939902005493272, 0.6473378202556476, 0.866687343610152, 0.6278312218583585, 0.8519019320513292, 0.7662164133846548, 0.8870996462178489, 0.01996020730848658, 0.25562901850159303, 0.651771912689923, 0.11128465304967233, 1.1391884450559835, 0.10993387978361344, 0.4927815098399032, 0.8301720294902729, -0.09097612922815078, -0.19698475430748708, 1.1072328231736468, 0.06510826578024699, 0.9312229572251888, 0.8406752630682591, 0.5161995257029098, 0.7059609460166165, 0.9670609953655837, 0.8189549071765272, 0.5835345479679064, 0.46951009887854406},
    {0.7017353182462736, 0.4954103429855976, -0.1237793180665984, 0.5086123024205468, 0.5333379548129739, 0.7483647995696232, 0.5970773157179682, 0.45329025406928064, 0.7520484369842687, 0.59960502731608, 0.6582112788096632, 0.905659664732054, -0.02011189992117561, 0.25411877530407423, 0.4886940719176693, -0.14704074758405764, 0.5742674608156533, -0.1768293575778751, 0.3627853823326497, 0.7569688411128535, 0.06453728548890143, 0.07154524586395329, 0.7674245574085051, 0.3791394172539026, 0.8400972174238519, 0.5018845671744544, 0.8257844889529745, 0.4170155164399938, 0.7094859856397333, 0.8362361812552339, 0.8399884611081193, 0.8721928958910254},
    {0.5460022820338791, 0.8165261758905161, -0.013011928111782901, 0.8914774650214536, 0.8137749637621531, 0.7026176087215528, 0.751900716430563, 0.4773547657093941, 0.5209243980087347, 0.593520765230526, 0.8730943107309345, 0.351517632305935, 0.1385843841014124, 0.04230692181130754, 0.665017169189304, 0.2314818268119957, 0.659199528172601, -0.007985914502396543, 0.44546872670185134, 0.747060687895126, 0.08773412069901931, 0.07267889434391286, 0.24105081621670774, 0.06192336298601674, 0.5068082728119611, 0.5989469233569196, 0.7992810484445743, 0.41014842337750446, 0.5365814204114974, 0.8681116221012759, 0.5681249282185064, 0.4789495894265087},
    {0.7979722892450364, 0.8459879230090742, 0.24305794039484216, 0.7838434536437816, 0.8364022552447743, 0.9569175846080543, 0.9086918253228048, 0.5190248734429956, 0.7092790748956278, 0.30956326088088293, 0.49229450826025295, 0.7309579688477837, -0.11129516055705671, 0.09734206512899292, 0.7648729910512087, -0.041141965960939914, 1.0869445187726392, -0.25086794253179356, 0.7335537197121237, 0.7915478256841032, 0.06793344015349914, -0.3669484839820235, 0.9043065810040388, 0.13359783890339552, 0.7009306464195711, 0.8574615407049443, 0.31178273322499617, 0.5907785027197363, 0.7667297569752681, 0.2350369687406734, 0.6907873351865119, 0.533973399057907},
    {0.7211147533181527, 0.636014142798863, -0.02579120991433062, 0.6701688107355132, 0.45107424902678955, 0.7392032626111437, 1.0109682288795765, 0.33713488188398827, 0.6573737420626815, 0.5930651283412669, 0.8013866380207261, 0.6066984548920867, 0.07072454078068634, 0.26152883366876734, 0.569363590922911, -0.44714301626833086, 0.7233362144189371, -0.15564501976000614, 0.8398505849028965, 0.7724240771959467, 0.05084601838622273, -0.010883627887953976, 0.9623792197067258, 0.12605446231517362, 0.7867746009910762, 0.7266453404289719, 0.6781875076228686, 0.7082608635883136, 0.6080679482104255, 0.7228774853693061, 0.7191102554044646, 0.7844784274234414},
    {0.48399024853206946, 0.46866443773555094, 0.04970326821403134, 0.8365983826281401, 1.1858378564076455, 0.6389148647910912, 0.8503495049109219, 0.3580806390988385, 0.42758521201359057, 0.7662650667547557, 0.511809693486138, 0.7833244310372501, -0.051863605073851904, 0.3380088977438663, 0.28222198699168666, 0.04144282685191561, 0.7219088698239557, 0.08471308668112472, 0.4750940288121518, 0.7222979118022267, -0.2256529340474482, -0.07526634700445112, 0.42323531668423847, 0.2920012694020033, 0.8001613453839594, 0.5774297007969857, 0.6088486737010838, 0.5753581233696773, 0.41173569130198595, 0.6588101341931526, 0.6660480987484908, 0.6793054871360708},
    {0.9183185781496471, 0.5881669333658126, -0.020044139375376455, 0.49186548490548115, 1.0553586067720608, 0.5585405648599178, 0.4387086516771812, 0.33650706962411975, 0.4817788122707907, 0.6115867697314423, 0.7059395223137306, 0.3855014313124005, -0.33547867139806975, 0.7678324493212173, 0.7580701409321555, -0.19135274516580555, 0.8383924868998457, 0.1330949356963171, 0.4382076051830488, 0.9143711386518909, -0.2992602840282739, 0.166594978967946, 0.6095104162185824, 0.04217194361492765, 0.8090585583219592, 0.8061580052390908, 0.727672070261395, 0.9855488283479079, 0.4742929515343243, 1.0640057993569487, 0.7727041628029601, 0.32356844247062766},
    {0.9216475856525708, 1.00287855340235, -0.21364410355237587, 0.4116111906117731, 0.4306493204898464, 0.45513052998349735, 0.35405759392055386, 0.7111320520754881, 0.7679445059128273, 0.7267847241251976, 0.4670275155701841, 0.5611163688670195, -0.23224389067486378, 0.24361052352410564, 0.892875677410514, -0.30453930973984666, 0.5228907643658869, -0.1774842830762337, 0.5254474111710786, 0.5682991260026247, -0.010399613241842222, -0.14593608090810847, 0.41238730461881523, 0.37384646773416597, 0.6158665751790978, 0.45753391468459137, 0.6525583282509496, 0.6157425280520752, 0.6376658536669971, 0.4302844044903192, 0.654168424277608, 0.6822873029309166},
    {0.5206255483883808, 0.6254480158672361, 0.006603337083459193, 0.510267485976668, 0.5668970292045736, 0.8288540609065838, 0.8834448061805042, 0.5593762903331939, 0.8035320052023904, 0.5806407417932472, 0.8967931389978295, 0.6242508069319298, -0.09325364388205998, 0.1492717588006788, 0.383672201375467, -0.18179240243266787, 1.1704796483304476, -0.38076195245321753, 0.6484848295255712, 0.4342034700075974, 0.06815904753386999, -0.09596347223497925, 0.7084627311682523, 0.1479806007322651, 0.6174686716873979, 0.5290848244870274, 0.9407644851172936, 0.5944105424670671, 0.7280626060795387, 0.5680094350756275, 0.5815555683407064, 0.5681245849262049},
    {0.5399732765186301, 0.6455049485422286, -0.012984538280372607, 0.9537148832394334, 0.6583521473743648, 0.5475317075440983, 1.0498975448699588, 0.7857403874027221, 0.7136561625997041, 1.0030846953372834, 0.6282706617600422, 0.657454422282373, 0.33071068426576383, 0.08401652243250529, 0.8798630696391171, -0.07612726536876505, 0.5805300757474855, 0.01797436043076394, 0.7543123446849626, 0.8380830937129581, 0.06065336747204519, -0.09573889103579365, 0.7171543990036134, 0.4961935883866659, 0.6788477640262788, 0.6474958077848729, 0.659817688119698, 0.5451313863288588, 0.40637531829351214, 0.6689503174020983, 0.8474808206198847, 0.7514889769097923},
    {0.5521663340989963, 0.6061240959818285, 0.18154223577559037, 0.6750324865157273, 0.8074998526760154, 0.6047272857698113, 0.7871528892723264, 0.4223295820453409, 0.41765388854498, 0.5552978142496112, 0.6917645479489916, 0.6693424358633532, -0.25294280812550674, 0.20691948315210335, 0.7406300269443823, -0.14121152957647368, 0.9263428993206907, -0.10481078890659204, 0.4270989057473754, 0.7288178726065321, -0.00463148565999677, 0.07843666849674456, 0.6627707278893816, 0.6253831997576591, 0.6991138017516622, 0.4866867754891692, 0.5131535115385408, 0.9163233671390121, 0.9764008288790365, 0.8683469690036362, 0.9281601776129864, 0.6380845505172271},
    {0.7529001821960769, 0.7181751931592786, -0.1738582185518526, 0.8676648514703433, 0.8644648354565115, 1.1589469468027072, 0.8862828641535883, 0.5486469012812285, 0.6494306853832323, 0.6446543069572522, 0.8919538400950513, 0.7385577172403482, -0.12431111019480146, 0.2022461028807146, 0.6545817304363399, -0.16052265053479814, 1.050176098904931, -0.24551845677741926, 0.9402477375350244, 0.5508714723354426, -0.29970199751702287, -0.44681797075629076, 0.8566003647914854, 0.554710156872131, 0.7114580527143998, 0.6235281885614801, 0.7829131174439853, 0.6979864280574342, 0.5775549085587908, 0.9556657733180148, 0.7388442679054888, 0.66561031670463},
    {0.9350186454904444, 0.43924524790364355, -0.3166961918962919, 0.4346964264974966, 0.8403928735084336, 0.9776150071587799, 0.934006718925292, 0.25893044288224326, 0.7782612455741761, 0.7419664343251279, 0.7371172245131568, 0.4233129602525896, 0.1778026270529241, 0.192698408684741, 0.5942416800277655, 0.2817452181624908, 0.7009675220624252, -0.23697365518296812, 0.32010250317258054, 0.6964859903338296, 0.13268431795934998, 0.11364445972599949, 0.7158383952808848, 0.409780388612849, 0.3575795159341743, 0.43896235013757123, 0.537924687141041, 0.7049811193636933, 0.5286813584771967, 0.674645957267457, 0.5689430960843562, 0.6833250194378173},
    {0.7274467020085547, 0.9776994630694466, -0.32399439751408743, 0.7803558483282977, 0.6379291952539381, 0.813929530963086, 0.7668277037348155, 0.3394287189770804, 0.7777195284443499, 0.9428093355045156, 0.8617841428995539, 0.515311762558536, -0.024772465424743408, 0.45201855019807874, 0.48849131230126586, -0.15517415315462305, 0.21002748898311682, -0.007906582614705575, 0.6748554921261708, 0.731141427724301, -0.07511480405461828, 0.05181572224597448, 0.3984485997935344, 0.09284921561596204, 0.8255075828539762, 0.7812997559848849, 0.6505493605554578, 0.19439469180648675, 0.6204198827692105, 0.6992141090431904, 0.7695288427591633, 0.6168773328841481},
    {0.739721802857117, 0.671267055630138, -0.3536921182987056, 0.98656446111775, 0.8463061212529456, 1.1655315751763307, 0.7670910961328217, 0.7522569809829799, 1.01662402901813, 0.892444211293989, 0.8611442991055105, 0.4978968233056956, 0.15202224979711068, 0.579515677522015, 1.1802877065652841, 0.1433016527531009, 0.7400436417743174, 0.1893634773616371, 0.7502292099894947, 0.9483619916259344, -0.18776541490662452, -0.011893088206635719, 0.5754993748580819, 0.4154119609073397, 0.7565468884343939, 0.6726627056895162, 0.9216294791582617, 1.111543862420645, 0.8838062984537757, 0.960637395779455, 0.623118403804878, 0.6589774884771812},
    {0.5112111603080427, 1.074793119871134, -0.024657308588398732, 0.6879856057003486, 0.8097487455259496, 0.5092923454177337, 0.4557761150927662, 0.47460141598592737, 0.7043575508857047, 0.8301760748259852, 0.6519761826759337, 0.9190381334956701, -0.0948030048178242, -0.05638789001640985, 0.6932748241858613, 0.26775990510636744, 0.8769382068364335, -0.32621206577272055, 0.5817784929192169, 0.6740326102778994, 0.007644972414960885, 0.12501321051113054, 0.6051085094550134, 0.3809104316504645, 0.6910309271814812, 0.7478459033998303, 0.5577060859718704, 0.5982375725429315, 0.7353114119144047, 0.9109503489257932, 0.5548623239859003, 0.8175662311047438},
    {0.9185433353396509, 0.9703563851003139, -0.07643447936574092, 0.4388885681905943, 0.7618309284123969, 0.5714125283941912, 0.8303750036971149, 0.2614169183556872, 0.8902059645340025, 0.7306294659424349, 0.5681486351038981, 1.0244156305368275, -0.18351128821338938, 0.3448067257427594, 0.6497816334956507, -0.13103855160807665, 0.628589502598682, -0.23296361356908624, 0.4041015865258546, 1.1052147259594762, -0.17155848356487777, 0.18073847964324122, 0.6731913044629232, 0.1048068358069393, 0.46649299210838074, 0.9470099729740614, 0.7990827443091862, 0.8510184989576655, 0.47764091935797065, 0.8794011577678141, 0.5311979769340096, 0.4315613041787693},
    {0.7375251845154114, 0.4865225380979429, -0.1743530659715809, 1.0785533466110675, 0.6286752629326158, 0.8476204265482036, 0.9427613103519059, 0.7439066191906208, 0.7247476879247599, 1.0079731476737583, 0.43528131258593233, 0.500515300355098, -0.10343911328862446, 0.4202319221363175, 0.6906091569864204, 0.14291060300111263, 0.8941769699446045, -0.14575509285604218, 0.8793306438945852, 0.9545315339513127, -0.20277593170242034, -0.339348688538738, 0.9383500153206619, 0.31363636079778917, 0.6439841470922759, 0.9919527707275455, 0.9400119452240109, 0.8241206125940139, 1.3306228739708805, 0.7554576360624108, 0.7393236569945397, 0.9481891054779591},
    {0.6633755546642229, 0.533258062483421, -0.3933010122322723, 0.3867856728252765, 0.8027524799416472, 0.8542162474383164, 1.0569185498793021, 0.44082370443130536, 0.744321462188718, 0.5968961408196679, 0.7434448670362958, 0.6076700360511038, -0.11972744167598608, -0.03636999600430778, 0.6805508059585346, -0.07754029583933025, 0.48225370732492245, -0.3111265043486821, 0.40386723529930074, 1.1797137868187368, -0.18154849066160555, 0.07975872783724691, 0.5672557369378027, 0.5442349481872155, 0.590933023777363, 0.8863780589414813, 0.8386666771653877, 0.5111576182995206, 0.35681256478088524, 0.8298246665366543, 0.6625454859888794, 0.4786093847654389},
    {0.7715294787198032, 0.6601409670771625, -0.06839839899345215, 0.45749560231359115, 0.9259398755124512, 0.8309075166345993, 0.6721044617397546, 0.23270733304217647, 0.4082564925454393, 0.7213295682850067, 0.8128196987804341, 0.4884947578228383, 0.024459101003682572, 0.22799148370714778, 0.6985033969370835, 0.09039174094277204, 0.8412826697476172, -0.40466917291530224, 0.5999685012463306, 0.385466082940848, 0.06433143342893517, -0.07564468851694002, 0.7607243836452567, 0.10783395899619559, 0.8164037907457234, 0.7600244066588381, 0.784768444471887, 0.26690657846004096, 0.7851579947218633, 0.8861143430513725, 0.7774264209537877, 0.9840304458929452},
    {0.9767813136221497, 0.9837210768950132, 0.1239587444259147, 0.7654929288015533, 0.9071390570865344, 0.5672955612771896, 0.8325655034652575, 0.8048541332386433, 0.8930397100809082, 1.0819467997703944, 0.7239660687939431, 0.6531098523939332, -0.1304485049598256, 0.44461379760481917, 0.6711472304419416, -0.1324605400152404, 0.653290899422661, 0.18742620711434368, 0.6983209136615347, 1.2085646023657968, -0.026167223288647092, -0.1258763591445795, 0.7962036967583908, 0.2883940407530775, 1.0042270987103232, 0.620198093655445, 1.0672464154109895, 1.243758235722314, 0.8128904128622535, 0.6585950355709268, 0.8393033115788533, 0.5942465658895418},
    {0.7190544108346498, 0.8055899545358425, 0.13842927252041975, 1.0335087649984862, 0.6720297888185626, 0.8258390770851687, 0.485599868853841, 0.4620257481947528, 0.3754832501538024, 0.8079533686476397, 0.9665154742525891, 0.704073706801454, 0.1015036283934854, 0.1290527856754125, 0.5307319169308228, 0.14889001987523895, 0.7513714497990013, -0.02025390866103696, 0.597083792988857, 0.819934503483996, -0.10573823562604008, -0.19407370520915979, 0.5923816517360144, 0.3171861906169728, 0.7315023675177367, 0.7516893074095921, 0.47728891787395816, 0.6500502271371498, 0.6364497670722675, 0.9070040233155109, 0.8560689395141277, 0.6561332354732675},
    {0.7609717596058047, 0.798699052382666, 0.010445154819535127, 0.5077291661445354, 0.6680756469203678, 0.41017509979137495, 0.7200322729740738, 0.3980753332727725, 0.6117596385780579, 0.9327922047326537, 0.7111722336718242, 0.5278015544909478, -0.2022135570922622, 0.48206696643574504, 0.8931063648664519, -0.28856819068202744, 1.0007649283884865, -0.34303095892921626, 0.6856953674662225, 0.605115350005358, -0.10499817096940918, 0.1265254706698445, 0.9868807025470117, 0.42995452208019347, 0.7513862012414648, 1.073836593048013, 0.6384220325472748, 0.836651007919481, 0.9786104528594671, 0.5960424232040731, 0.7457169377271816, 0.9330831131337184},
    {0.641204996681298, 0.7201099993280655, -0.09692009519032962, 0.596162467242041, 0.6362678560824772, 0.5997462507951897, 0.6676284501947798, 0.695511827497682, 0.6838838156432827, 0.6758480337850102, 1.073572583501502, 0.28973226796958185, -0.06801327649539826, 0.27113811812757993, 0.47325706914325744, -0.025365764962723136, 1.0066520176265228, -0.2739581262934015, 0.6950755248115386, 0.71961926799596, -0.10492525452558235, -0.16830503799872454, 0.4004495075677037, 0.06947569520554542, 0.5456211213030931, 0.8566893337827067, 0.9304426281769713, 0.5966826619847126, 0.9677735364376909, 0.6474967228038401, 0.5749524088933942, 0.6131952962757504},
    {0.5896269575432632, 0.7022670234379292, -0.031905838729970784, 0.7304566583417733, 1.0526432213299257, 0.6473377958051604, 0.4852227972952655, 0.28780436375985746, 0.8554061242673692, 0.8922195488047571, 0.8953785069305253, 1.037064257382126, -0.07784344328019771, 0.2668128992683129, 0.7123683711766041, 0.024152769294472253, 0.7376855153174637, -0.07233978356593103, 0.8127689329916801, 0.683784460454628, 0.2702283190470453, -0.004254628563707202, 0.7661852949243665, 0.30328576636065174, 0.9929910498638262, 0.7704650256625807, 0.6569224400472661, 0.42319271226287924, 0.8639839787323135, 0.8166668020035613, 0.7624165409832783, 0.6962452224503055},
    {0.6677119609810981, 0.84096622738747, -0.11959155877585724, 0.846112777475923, 0.7089041690997413, 0.41835959646399895, 0.6681212574256453, 0.4448255185058234, 0.4584662085698439, 0.7975727257798149, 0.6545957090213863, 0.7376659423693092, -0.050546759587936925, 0.3402714612425711, 0.3967897668836008, -0.06888640433183511, 0.606262583112151, -0.119033403707193, 0.45873901377597454, 0.8425025981246541, -0.028105889968798762, -0.24743951260374902, 0.8713937578075518, 0.417530753962318, 0.5011592691541973, 0.5994340192321213, 0.6922979923101805, 0.6055813005785542, 0.5568073663924085, 0.9820363180872813, 0.8190420666145078, 0.7655107502238412},
    {0.5430361047256291, 0.6989674976216785, -0.16221065715737462, 1.0524906025823646, 0.5069356627943838, 0.3069073888375978, 0.9722929818421251, 0.608340145366602, 0.7831999860881003, 0.8319598263302396, 0.6478190231188553, 0.7382105623773492, 0.12984626130546487, 0.2966356340921889, 0.5840003678591486, -0.035190141269604645, 0.8034011278366728, -0.24650284201474962, 0.4315238858231128, 0.7597173639496346, -0.07656143005657345, -0.4161436644671078, 0.4733011387736179, 0.1269762884614926, 0.7622003295275542, 0.5839296142494905, 0.8664236369877499, 0.268418556543774, 0.34486845872549454, 0.6639227695975269, 0.7080120384173003, 0.5512552240053356},
    {0.7890777023904811, 0.970558576306145, 0.29303725327519975, 0.9603577254283061, 0.9528079059102789, 0.9829384503618518, 0.8623816085593803, 0.6343929809981446, 0.8579078539785112, 0.6720795841383976, 0.7266895865261572, 0.8792779351568444, 0.0966232920118613, 0.4524256985872227, 0.7304314390056329, -0.09158488823519446, 1.0372677007635926, 0.08534940972010338, 0.6236006901555777, 0.692133450714133, -0.13133473422527575, 0.10602652912515724, 0.6009189378233425, 0.38207001926657697, 0.9220939377255293, 0.8190286965598813, 0.883606173661561, 1.075302866644636, 0.973052775606485, 0.7143635587268111, 0.6514993519647183, 1.056073114478367}
};

static const float b2[32] = {0.7180779835631309, 0.6929657572743164, -0.057645426017989464, 0.6927929845791799, 0.7365743135290752, 0.6762895056827235, 0.7144733292415026, 0.5522117816979444, 0.6054677001450616, 0.7132539850839539, 0.7253399756548271, 0.7604189956147089, -0.08002251005241735, 0.3631402637338038, 0.685533689625426, -0.06336863893405217, 0.7532721675458434, -0.07767814310346385, 0.6371836200749703, 0.6850706795814716, -0.015492003421657189, -0.06047331337912073, 0.7291549730314848, 0.3592205853393857, 0.7393142346786931, 0.7397144670838145, 0.6611708040686594, 0.7144621232764742, 0.6762894236525296, 0.6811782748906395, 0.7043897948975317, 0.7406187381701634};

static const float w3[32][16] = {
    {0.4965694361775101, -0.549104179284789, -0.09517451499874369, 1.2848206906384485, 0.015956892916473772, 0.2808744732878772, 0.7601666079039212, 0.8264830457399108, 0.9112645251468684, 0.044132550069642895, 0.9868136444912228, 1.0202401155223015, 1.4888057341157548, 0.9052920020125991, -0.2764941498327081, -0.11956058234275617},
    {0.5861971984011808, 0.05405041525248582, 0.05729192158724255, 1.0027501434072599, 0.4270491585133575, 0.25737722176006805, 0.7827141452511348, 0.7441882465564398, 0.31764621012419303, 0.2891697138881808, 0.8201383734407931, 0.9659837350651801, 0.6512290283851523, 0.9847108635812221, 0.3120140410117157, 0.15868967549650675},
    {-0.022452103964291682, -0.153481486898785, 0.09660880773387256, -0.5926799420078213, 0.019764229440822526, -0.04055461857468259, 0.019606665280597416, -0.11005868495168371, 0.41362542241085964, 0.10753011789876368, -0.5389219073157232, -0.1554312494654339, 0.2581494798341115, 0.03371064781847529, 0.005255424315764027, 0.419159430583034},
    {1.1114250315535026, 0.037292248490839855, -0.36036791342882074, 0.6400716968967447, 0.12765777757334149, -0.34566538422307325, 1.1804642056118015, 1.1359583652324732, 0.7513182056453237, -0.1591552893960436, 0.6193938698520588, 1.054567690986178, 0.7647911590192183, 0.5744890841927798, -0.17477737242822483, 0.045542946874262975},
    {0.8675315519963049, -0.1625612104107079, -0.3520719543017755, 0.7006632739869739, 0.7650061880584668, 0.324126485950927, 0.6120355626980585, 0.8158417739421568, 0.7213692212002102, -0.15218412679742055, 0.8831666135138428, 1.1516603735642186, 0.7993264326588732, 0.5583681241550753, -0.1173070444929693, -0.3527787069640171},
    {1.1557457149389914, 0.1246127116433669, 0.07437374973287791, 0.6808216092929981, 0.6186796409646211, 0.17957142036811496, 0.7010579590892617, 0.8090011137680504, 0.36126417122039733, -0.03971637322991884, 0.9824145526093978, 0.7615927530897673, 0.7136443226429716, 0.6999792992338483, 0.3338267470534853, 0.3152583938980956},
    {0.8435387632344068, -0.022564265677532162, -0.1700238642032842, 0.8554309802249985, 0.45238087416290873, 0.04182531861696819, 0.4217477499746851, 0.79749971674231, 0.9745153209605402, -0.3770933597694888, 0.8414081062066969, 0.5525401869665036, 1.1414214276268078, 1.0211871384570854, -0.06135195394714692, -0.3722260662805477},
    {0.5552567514159621, -0.1956812253641949, 0.05770578945590705, 0.48617196263353274, 0.9969007958005128, 0.12650903213591438, 0.8836827750965826, 0.7547346723674078, 0.3073589283398629, -0.5676963575948185, 0.6251826502859855, 0.6694797600816459, 0.3725937468400671, 0.7313943186729194, 0.04869929629377753, -0.019462729486507246},
    {0.5072968918135646, 0.4094686286272844, -0.37787891650948113, 0.7292367714535322, 0.6822526872615206, 0.2801057455391577, 1.1560986524739432, 0.7039963471280287, 0.538592040232178, 0.31524173239874415, 0.9089403702122313, 0.5411635945375173, 0.9676826584887824, 0.6889670112437711, 0.20370773822990806, 0.00804055728062062},
    {0.57251333179828, 0.13393527274425868, -0.40540432409630067, 0.7941955271538429, 0.6772389480683165, -0.12042410618229249, 0.5385352407635567, 0.9662078996327004, 0.9927151575919907, -0.20538832259813428, 0.5329760560638922, 1.2910938986052733, 0.84226767784485, 0.6062756323416268, 0.09876443113160546, -0.29707828079301224},
    {0.3476460730344943, -0.060737169269885684, 0.23541090544915522, 0.763144395504872, 0.5089909405353179, -0.40156106409085274, 0.4133679227003859, 0.8031974972176847, 0.3392378602980115, -0.30424553307391833, 0.7807573906975122, 1.0705816259521173, 0.5556988917001461, 0.7834635901973849, -0.29645223381426744, 0.09060513353221458},
    {0.6288762780773735, 0.0034382042955454026, 0.07964281163902619, 0.4203366143463782, 0.6021463240727343, -0.09584478475870753, 0.7019784585068551, 0.9327486486635083, 0.4211188077016679, -0.2634273863789207, 0.7955603729621037, 0.6002950922764101, 1.061570153410059, 0.9070859653740367, 0.11658141378674104, 0.3633916551035525},
    {0.1742990490536889, -0.22024133099643267, 0.11660784315005791, 0.406247103121698, 0.060675987932586876, -0.3803356767179042, -0.154173280682939, -0.3274764248296313, -0.053219083391075825, -0.1970691261082046, -0.13574596308356288, 0.06573562023850675, -0.42865072215457467, -0.014789798871625608, -0.5237920863877307, 0.10793015706078349},
    {0.5828052416779059, -0.1577105192796058, -0.05304434714199291, 0.2455487115771549, 0.6647945742202611, 0.5179132536080879, 0.5729832729044695, 0.3766435856798745, 0.3423312168173398, 0.2064688324090976, 0.051950818441312205, 0.7806040113248126, 0.42379613109853376, 0.7193329085122739, 0.3415007679941357, 0.49459541932592177},
    {0.6342276470130965, -0.15878821856701003, 0.26418349708228656, 0.33616891477139627, 0.6059354554506978, 0.23138183874490623, 1.1812330302376557, 0.7902562632850337, 0.7032794903936342, 0.4884792107004328, 0.79070002414308, 0.9716850281454531, 0.9304172682101677, 1.009434267161907, 0.3698931075877113, -0.1138103658178112},
    {0.3598687142605828, -0.5055291155912095, 0.10876761162964955, -0.3392080221939088, -0.2930630331636668, 0.1425501148571447, 0.139939955135499, -0.22544308599593754, 0.45309883979017124, 0.17045880893292883, -0.03972248644536521, -0.26483254517830357, 0.4803837890010085, -0.25216059830550147, -0.0006129518792695911, -0.26540033679667807},
    {0.700895464831429, -0.028436821861904722, -0.16174790504193048, 0.7183616194221588, 0.8320474484284512, -0.00947256989589132, 0.26412007627742595, 0.9717976292020579, 0.501250110278306, 0.11051415718494763, 0.8802269118682642, 0.5157395359040288, 0.7043132784783357, 0.7931447273413951, -0.14150569342892885, -0.07210120048915994},
    {0.062236630350886245, 0.19367928585103775, 0.18926249634973488, -0.07472072873021897, 0.40759974186391623, 0.31005684989433285, 0.15217060493971732, -0.16832809345469255, -0.40903449980274403, -0.06930071307787684, -0.3029278189070821, -0.10019040055361982, -0.4336789946785563, 0.23375450469783465, 0.1537133763381926, -0.06311429528621837},
    {1.0275360092157215, 0.2235355717015713, -0.7722968606004973, 0.8107207779282691, 0.3598544667171611, 0.07861599449533482, 1.0014824082404716, 0.8317351673209159, 0.9952636249824697, -0.27725091143333147, 0.7453536983937006, 1.0571605699960633, 0.6911173037517371, 0.2994011720926239, 0.2858671870897824, -0.2090256051519904},
    {0.7262757277399979, 0.15714717710730197, 0.05894884665848114, 0.7413289270038019, 0.6478639087114952, -0.023206704398358004, 0.8156415374604545, 1.1237949657455926, 0.9926238799822037, 0.09758635851032195, 0.7072902435443741, 0.9409457713714018, 0.8037758329568411, 0.6067324789609283, 0.2031440829291403, 0.112915127687622},
    {0.0012105740387487584, 0.10753908156163348, -0.48592924410941946, -0.44605001859167653, -0.000748213128111109, 0.09819495980966648, -0.15029940831088767, -0.06530257706312333, 0.48206046895519605, -0.40813670836102056, 0.02485645148683189, -0.005124610015935836, 0.1889479383988886, -0.1521098719251317, 0.18237192949955078, -0.1223501786822779},
    {0.13799354349880455, -0.10290744063357976, 0.21644570341395025, -0.21165643632393846, -0.09820976962516063, -0.33165633756755225, 0.11399985413649802, -0.17191631908956173, 0.04508827173730295, 0.010014780954525656, -0.012843283347308379, 0.15475654923794346, 0.009290961419321613, -0.3529400964015657, 0.5998387666368121, 0.32731460655552946},
    {0.398220388685597, -0.27691629309892773, 0.2309551970411256, 0.7499984276161024, 0.33763275979535035, 0.22541806545837575, 0.6357797446076121, 0.6320216839302323, 0.31557427948977124, -0.622518039361219, 1.0322871530918738, 0.8706759364863319, 0.763189029500143, 0.8248051213987591, 0.24597447727361013, 0.24462926343319127},
    {0.45790691883362433, -0.2925738260267448, -0.3004699044718925, 0.3735986734205586, 0.3631444204875635, 0.47463194174803897, 0.8504613420828416, 0.2056234890213804, 0.49805698398428855, 0.2756435782520028, 0.5586002374925105, 0.4104840727834803, 0.4819920799683082, 0.3677026484241461, 0.16260943603806316, -0.04399000135011907},
    {0.5637097570347024, -0.20317150635496725, 0.29522025284778064, 0.9344212295951321, 0.49165450468109106, 0.09836045084672547, 0.9339346277024994, 0.7653701566079274, 0.5904342733681971, -0.4119210364992829, 0.4904965259321375, 0.8312212444074317, 1.0244176080836254, 1.0187297176434031, -0.4983240358981195, -0.18242527231727645},
    {0.8534819808744736, -0.3618651255144744, 0.28286556995262474, 0.6375935276710948, 0.8408242476395491, 0.06149696726836108, 0.8251374131991539, 0.8521639785471434, 0.7888561876420565, -0.3430368058036721, 1.2970012815219074, 0.6623371670637769, 1.0267183592616065, 1.1402904899265982, -0.17992451926911102, -0.05908514789596974},
    {0.47281869686422023, 0.0811369506546218, -0.011896721572480654, 0.967515650686694, 0.5558669709106129, -0.013188587308415226, 0.755744044036626, 0.6937747676764029, 0.5195137400108957, -0.01126750619551487, 0.8829314210799194, 0.6343693287583188, 0.6246565307330743, 0.6414626854684065, -0.27023649887400913, 0.6229907146966814},
    {0.8429849406046926, 0.05450188248893065, -0.2824730304777592, 0.9467518441174382, 0.5194172963516778, 0.09835314996064502, 0.48068000901130714, 0.9625142700801945, 0.981489962414206, -0.5197824748817542, 0.5978430704631145, 0.5864622248303741, 0.9885120403117115, 0.5015848107362961, 0.06687139724824444, -0.31593584371320493},
    {0.7559890782556795, -0.4875997550838761, -0.047759812432962186, 0.9669293203625958, 0.23662310460599556, -0.575731381616186, 0.6350333343996721, 0.3764958637713592, 1.137501584617093, -0.16416674565426673, 0.9412509505983174, 0.5339301057838047, 1.0847314055008457, 0.6650834334837071, 0.09595948285372707, -0.1146358262916173},
    {0.462725946907876, -0.1355095028188366, 0.19701297483556116, 0.9018916471543105, 0.8501049755535628, -0.02976356496198938, 0.6465365626874525, 0.9737799132849025, 0.06493247244462788, -0.14636822539616273, 1.3382915406153923, 0.5279713310551598, 0.9857556873088466, 1.0029028730990788, -0.44866769772908827, -0.38143161728565406},
    {0.7824125569255955, -0.04370441409940704, -0.4077379128929645, 0.6153674157503646, 0.5935567706166391, -0.0024018149161559106, 0.7131752604891178, 1.0419318496784349, 0.5187727994455146, 0.5342866988966969, 0.8226982508724093, 0.877113617948049, 1.0077310006706737, 1.1027384569101912, 0.10774266480902565, 0.08138718012776573},
    {0.880300020823197, 0.3999274295703226, -0.3763557570456417, 0.5742595410720779, 0.41082267268786454, -0.04906172993505112, 0.3582606947499456, 1.0190938492677253, 0.6080078325853331, 0.033457413691776274, 0.5915334036635986, 0.8894473179396277, 0.683923500460923, 1.109699123938918, -0.4385140613124754, 0.050188832439284826}
};

static const float b3[16] = {0.5999333962647648, -0.01978356700732491, 0.046244911074389695, 0.5336366538165997, 0.47570483515643747, -0.02191101350167316, 0.41303176090030336, 0.46681544758674226, 0.4795383871926889, -0.03484048556475551, 0.4497368888883187, 0.5892330378743657, 0.5162740936777102, 0.4932658229280157, -0.01014511883350129, -0.008748649880476805};

static const float w4[16][12] = {
    {-0.06253831355851959, -0.46727406757668916, -0.6843148560238368, -0.7331838541933322, -0.756321723729404, -0.46062603160135074, -0.7829560961101314, -0.807699558928637, -0.7345592003157667, -0.5800371281079479, -0.5203857482145021, -0.8556751227276552},
    {0.1225389701809022, 0.7154766329427474, 0.2561821114685954, 0.517758907277719, 0.4848163734369192, 0.3562349617978945, -0.49121059679345336, 0.05809876339350701, -0.2580609979932721, 0.24242112228488516, 0.11966678971449297, -0.19845426894815524},
    {-0.15611711442774334, 0.35532471180163755, -0.4878525460153767, -1.0426482571626168, -0.5083734179352393, -0.12844870080786613, -0.7260131368665814, -0.13038437013227458, -0.20784934884765263, -0.22350417972056313, 0.17651028896156853, -0.04253168094605756},
    {0.0613751343578714, -0.5103173497327353, -0.7691646692853009, -0.7817009415688357, -0.4267768373414528, -0.6751973332722755, -0.6153045097351333, -0.8935748915892191, -0.6112921681380633, 0.05728549251672008, -1.4054280282097114, -0.46677675968208215},
    {-0.5060615100888645, -0.13936396721141336, -0.780842784983965, -0.49287916714109803, -0.9285546622959159, -0.44854638099802235, -1.4577116078217653, -0.7009620567948824, -0.5719322839898635, -1.1681966349538462, 0.1858319739302281, -0.8059599662032513},
    {0.38418622264889385, 0.034473661857230886, -0.5019299405878453, -0.803560158001735, -0.04256657087599689, 0.1250668083937843, 0.3124703280593456, -0.3024553958906354, -0.3168058512042453, -0.007816748459695488, 0.19029080741165086, -0.17638924289822402},
    {-0.48547924078835647, -0.8142108485218417, -0.8637010841407046, -0.7612557094690018, -0.19662628682210553, -0.8964394375164544, -0.42712129602369986, -0.39846803562845423, -0.794670627051229, -0.3618433378671442, -0.027495620045318716, -0.5547503502369701},
    {-1.0732156113189555, -0.6362947687566464, -0.5051562546329111, -0.3380420732792825, -0.7439590411185544, -0.5726366010971099, -0.6179090139528858, -0.7758091265523093, -0.8095757484231679, -0.7693123178147006, -0.9341582191007071, -0.8516040357135254},
    {-0.7012103099429493, -0.2694907280527897, 0.008242443546961492, -0.2723930632540772, -0.6236700585667337, -0.6314712054550751, -0.2911689275195693, -0.9407636818094307, -0.35702600537949664, -0.7605541649683862, -0.599595140493414, -0.5767535647933822},
    {0.1822719322574909, -0.01219607486087498, 0.10585159851947837, -0.5676397534304378, 0.3139232379833028, 0.4008869505317192, 0.17056645747977411, -0.14668504940469076, -0.12087135008722211, 0.47708580126265226, 0.5907656137437691, -0.11538705453066406},
    {-0.9283855066137362, -0.29359975191170584, -0.3554448790943481, -1.1056913710170175, 0.14481966208697594, -0.9648923181122346, -0.14430832306802158, -0.5124411248040628, -0.24549577043231993, -1.291041590688619, -0.8615780510261707, -0.5926567512804581},
    {-0.48879178214209257, -0.8318636804911714, -0.7759953106962061, -0.9451544793195227, -0.7797246679245017, -0.5755077516651793, -0.381549486876299, -0.5351788230054585, -0.6661618251305815, -0.5240628727455294, -0.7907845226046362, -0.6731248029309063},
    {-1.2398224366766182, -1.0983532124155293, -0.35479846300246615, -0.24401520732816798, -0.7006411008770913, -0.5306570549009049, -0.8199353659464117, -0.9766419514972613, -0.866273669366886, -0.593734701798835, -0.49015457490769176, -0.6311149922852916},
    {-0.7543422306806761, -1.076613043948421, -1.2453728919712312, -0.5823615544892815, -1.2882001353885588, -0.5914697898266755, -1.1761708576354142, 0.0037248751392009185, -0.7025065257551544, -0.627455461302313, -0.6501777630106411, -0.44835656831798104},
    {-0.21072594027864325, -0.11450490565531911, -0.1143496845824623, 0.2167557353624998, 0.3558696279025037, -0.008181261116495378, 0.23799572594132684, -0.5095639695946066, 0.2520364668431803, -0.5601179033182937, 0.2321972657750962, 0.0601967293501724},
    {0.12312163014797532, -0.13651255347437735, -0.08112540943339745, -0.7121516883223153, 0.10242366074241001, -0.4482131224977354, -0.02994450533805107, -0.26013207458087795, -0.06027136100216639, 0.4214030046126814, 0.15683700685190574, 0.0963022178789895}
};

static const float b4[12] = {-0.1298454071085005, -0.34948311209601374, -0.22688636546711757, -0.16631455363092884, -0.09986585510249842, -0.20643521028605027, -0.22891569051597377, -0.265687936796245, -0.26682692953615295, -0.23125910706926636, -0.32526893149570163, -0.2604207003369095};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
