#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][16] = {
    {-0.0906510135357423, 1.4798759911329793, 0.8362482279206778, -0.8844596937302258, -0.8181825003283975, -0.5919231304525633, -1.1139677510326216, -1.1138469113264187, 0.2907989283760235, 0.05536828155517864, 0.5056118215375648, -2.182305664271776, 0.49848808499782893, -0.9526798472169571, -1.2262735813053738, 1.3423826292380565},
    {-0.3173743367397182, -0.4380237415592421, -1.2650323322014325, 0.2991372396346642, 0.33617582946808977, 0.5812839729952634, 1.8816666007692289, 1.7270154677444896, 0.34518043110921526, 0.5333387594385769, -0.9021435956758345, 0.21783324215449507, 0.055687694424365, 0.7582445078832478, 1.3950657848090307, -0.04638088138641932},
    {-0.7794602569077039, -0.5087864175513322, -1.1702096527845327, 0.5771144568085164, 0.6163775489640253, -0.4639490898798303, 0.5037604470880576, 1.1235905371789918, 0.6987186438302279, 1.5195738984161424, 1.0502843907841934, 1.1189671260828506, -1.5445147637184196, 0.03926579180125817, 1.3548479783635257, -1.0253336968847984},
    {-0.18181721293005484, -0.7754103568960762, -0.6114116583527615, -0.8867895525561588, -0.13158546247850383, -2.3323830639694636, -0.04334959918277847, -0.4443359737145965, 0.7059382194843078, 0.14179811539365123, 0.6890155877094238, -0.4081477728547938, -2.001276223591177, 0.3399863687766176, -1.0606705857359668, -0.43467387964820153},
    {0.2258058642976628, -1.8616980169092796, -1.4484429199821434, 0.701752985199984, 0.717028037044623, -1.5171141557009888, -0.17502825444806494, 0.021120680019431286, -1.6738822008671634, 0.02035077724735363, 1.3611843712077927, 0.6119273885564731, -1.3606755585267298, 0.475067186355213, 0.5098589865896246, -2.1524875081830137},
    {1.915577222776313, 0.5878029199188102, -0.598201704467432, -0.5686862998675798, 1.4687415230984289, 0.3491318812690365, 1.365417519364656, 0.80613112055817, -0.8924728493560119, 1.4240245273091918, 1.471264683731568, 1.7330243927953037, -0.21160203427482205, 1.3020920684242385, 0.944689755949091, -0.2437070273904549},
    {0.8151472694583711, 0.7139881683393201, -2.018193403050372, -0.9988969997333936, 0.9592289476851286, -0.5293252207519421, 0.9677828369456949, 0.7817464693826239, 0.26030353048219146, 0.9364869468808267, 1.3046636548923987, 1.8037504054247935, -0.9952235161649597, 1.3000412735581444, 0.12458945646153677, -0.353921613095019},
    {-0.30477752182129914, -0.7559165576416286, -0.7780691388768832, 0.3041019082065055, 0.8734411966272961, -0.7056723501073755, -0.08748032781276499, 0.8255129363729589, -0.705773642470756, -0.10999196576492087, 1.2505137597477916, -0.08151915459963503, -0.41960791787806334, 0.8989731745134535, 0.7651267019511848, -0.29642909870010986},
    {-0.9583237838835559, -0.3990874219647479, -0.4911493773383624, 0.040506687506147006, 1.5386818399667155, -0.6822448242883595, 0.21999407202590804, 1.6488804049390808, -0.24351617329938663, 0.23864547377446418, 1.6277056670728605, 0.5052785032163872, -0.9599460092459319, 1.1795991002940334, 0.24427901217537934, 0.367752276348461},
    {-0.05895297352602575, 0.060401091399158176, -0.24432600206917268, -0.17712021824153423, 0.9335319324206234, 0.9060955403763075, 0.3250639122018576, 1.401140085244513, 0.5359466380729653, 0.5594810696261687, -1.4960054240123726, 0.3781195100544219, 2.2047511982193044, 1.2384457702782827, 0.15789406538002895, 1.2311344287869257},
    {-0.3739479714749867, -0.6031655067295034, -1.1150099042679846, -0.8127569070359103, 0.25819293179769437, -0.39078738173274297, -0.6562467773906675, -0.550666905456609, -0.13760181526258203, -1.079977356036977, -0.5089156194743552, 0.16183661543565675, 0.45310762659044246, 0.2870935091384425, -0.8220167065727257, -0.025452206620481012},
    {0.4141299418986439, 0.3834889424789847, -0.2338141722447353, -0.12221623525303339, 0.08316922685695376, -0.003939113087542695, 0.5732241863834425, 0.8509644111874405, 0.8340275892028655, 1.4689822706097178, -0.39845242816847853, -0.652897312810973, -1.0173314021315107, -0.10312491554758535, -0.36665179015792915, 0.6066212980750049},
    {-0.826952750788957, 0.35440504799595124, -0.855898312214141, 0.851890437553553, 0.05994498887276243, 1.6013005632859594, 0.74434012949054, 0.15854939132577073, 0.2985972782945603, 0.07859563029247456, -0.48761313270699547, 1.4303430835008186, 0.08759360990755805, -0.13410338622325735, 0.7268669250444495, -0.16901771654715328},
    {1.1441712032330305, 1.022229215075428, 0.7744624540542787, -1.2667311637364536, -0.04574232938223283, 0.2777985998026284, 0.4601197276836582, 0.23640222555333076, 1.1085194378889947, -0.31229576168274964, -0.017015160335531222, 0.5500217328515323, -0.7278157837085032, 1.7650263821871641, -0.6579721158914936, 1.5850422740629841},
    {1.2747406581511278, 1.2510865335919255, 1.7522238224665345, -1.6979137640635735, 0.5900179188528352, 0.8480380619982675, 0.9706829543155492, -1.0966116817651743, 0.6063641477679831, 0.25267243124385824, 1.505587860381083, 0.4201290293510081, -1.1525191054438948, 0.037162945376534265, -1.1282185070615947, 0.9076861640747066},
    {-0.24154597793668656, 1.3936735286050967, 1.8125527157329533, 0.5023083096075301, -0.06584260981441878, 1.8127903063354323, 1.1648069731973547, 0.20478777468668813, 0.9391793196021858, -0.1048001513382413, 0.2968790109621472, 1.210642104887329, -0.1949535341464283, 0.7369549236523472, -0.5863726886589813, 1.6499992896327529},
    {1.0594225634384238, 0.579543617015094, 0.34575663709319415, -1.486020403106251, 0.7554506655959948, -0.20780248842912483, 0.6643822962786178, 0.3873944395910142, 0.2249297408046977, -0.0900784287684896, 1.0687359790680095, 0.890327415941813, -0.6768133156826052, 1.5387567146953876, -0.7055490866768561, 0.8287476741829106},
    {0.09093284536665258, 0.623804565356367, 0.308054955688554, -1.1188798519198528, -0.06635074797790481, -0.24040233960348106, 0.19039257912631785, -0.3590163117470141, -0.19798548218039738, -0.39584194374562415, -0.152883139436813, 0.2988666864976021, -0.23408635261220215, 0.530567855742344, -1.0098258782193803, 0.7262480485431492},
    {-0.21792941535795032, -0.14415009902407563, 0.28004069540550475, 0.374950693008011, -0.8428499264857153, -0.44013799287168326, 0.23898761785702954, -0.4893522024316511, -0.5924179340893895, -1.1804446186697453, 0.7047038689014627, -0.1984931651185574, -1.3102440256945191, -0.4348350078460383, 0.22158911794326616, -0.025753215667278364},
    {1.5606415722626272, 0.22372673601719822, 0.2829396253516006, -0.25622977942258346, 0.25443604347040905, -0.4520224790268719, 0.6950153244187232, 0.1262070083732017, 0.26940420091375905, -0.3571744948858257, 0.30354080647365506, -0.5119855271188626, 0.6835655799442674, -0.027559580081139116, -0.526225229126002, 0.7552198720180245},
    {0.5691567667692501, -0.6367286135015761, 0.4025112025978532, -0.27616742574591235, -0.31666234238179763, -0.6698038120582358, 0.429900898232075, -0.8254886393765618, 0.37846385884145883, -0.9535609238329017, 0.4834246960441561, -0.6744035947018676, -0.4795760137298412, -0.28819799837535975, -0.36657899498082824, 0.08475429948758922},
    {1.4333758151115947, -0.8951252178283978, 0.6236688035983984, -1.4249001355969937, -0.16232195425147658, -0.6215118189520484, 0.3505137412331835, -0.6697221127808622, -0.48564980083723924, -1.6290580698801065, -0.3721971725633814, -0.48512540368577056, 0.29830513606811576, -0.10394133238059858, -1.3157801822465474, 0.378916295804648},
    {1.1336281834382105, 0.6482932399597819, 2.119170643059088, 0.3985099556594763, -1.0007235425991237, 0.5353084692116014, 0.46212676352509496, -0.46756340004527525, 1.6062773955323983, -0.8181035596130076, 0.16417154625611932, 0.6236654550920172, 0.2925546583426985, -0.7899555981527617, -0.04005035048012172, 1.273483523393685},
    {1.176513574641787, -0.251841231399966, 0.8539595310029049, 0.7347041735786789, -0.28851453409297234, -0.2969419361797362, 0.41230923946965614, 0.29623231717932735, -0.45239665396434736, -0.7442709801147769, -0.8460803545511842, -0.5686093250721851, 1.2399262701213685, -0.510968445465107, 0.3269838410808901, -0.051577612856341847},
    {0.5990659700915671, 0.5492858054141199, 0.6953307478166177, -0.45406082745131954, -0.6005656323779817, -1.1435844063851894, -0.2416158290206339, -0.18042130400431847, 0.34415910851786097, -0.5514265244938473, -0.0010203795366381225, -0.5333924127099593, 1.1040142359799423, -0.5857033028926494, 0.061346546063099486, 0.8049209322741826},
    {-0.3402201384009729, 0.003053040850125688, 0.8647378280690629, 0.20788301304082268, -0.8800138216182074, -1.1066191420049964, -0.5894390472097563, -0.09127388240979376, 0.4519739971003825, -0.976468321344578, -0.450254889820183, -1.4794476179557228, 1.0336331884730314, -1.5241505858844528, 0.12965564422479992, 0.3813306226553643},
    {0.16434164074043156, -1.0548463794029233, -0.11107223242631543, -0.9666413655934633, -0.9836327541256337, -0.5659213965417063, -0.3798488429499183, -1.579361983976229, -0.09950510635210362, -1.2668995487751589, -1.3805671989698556, -0.7670101623923968, 0.6323496285241053, -1.3049950896263645, -1.7918760688397235, -0.7064088779384982},
    {-0.059471006688080745, 0.44810513224494897, -0.2794019402828919, 1.3875899920930668, -0.8792606680942955, -0.7127505473827693, 0.3150863743595153, -0.4597850155120355, 0.031951155172727355, -1.02481744025673, -0.2839903370981939, -0.12641254743910552, 0.6088706069625676, -1.3791635646069171, 0.36328596515401923, -1.019892587492081},
    {1.1728542306421517, -0.615180138275448, -0.5794833965542053, -1.3499264794078245, -0.3592557629960527, -1.2783909591252938, -0.3502305079832941, -0.5813274291451394, -0.15447829092577017, -0.4918269163791498, -1.2158699164252993, -0.7229737299658702, -0.3131215744855483, -0.48190475679213374, -0.6882141173002781, -0.34381400369950005},
    {0.22578013388857027, 0.052005262181483776, -0.5850596069829154, -0.04454758826996752, -0.02073406504491664, -0.808047255351716, -0.5381706873774655, -0.11713631472415062, -0.8322384760009472, -0.4722281128921369, -0.14028617737147847, 0.04839102993899239, -1.27591797348941, -0.573259085529124, -0.14194115286468395, -0.8282678062036246},
    {0.10313333342707923, 1.7504321312079494, 1.7076339498854496, -0.49459611257520486, -1.5533844367273044, -0.5299163494892652, -1.0571721629835797, -1.2084671400869977, 0.48026029193296593, -1.9579721758301718, -0.06449058740077203, -1.6050519535500998, 1.5710806776027357, -1.3985892019284303, -0.41911090210900465, 1.6262288672716085},
    {-0.8265178161073112, 1.6198650810311037, 1.685013094213657, 0.1819712640062742, -0.5509650575626839, -0.92590680674862, -0.8979587507431558, -0.09188650475140876, 1.2006295540919731, -1.4854658254904634, -0.11939579319238178, -1.3299415237707561, 1.3853369059148453, -1.0680487864008186, -0.3544140960630712, 1.945116195180285},
    {-0.3624443589057273, 2.082368117321499, 1.6843728692858835, 0.08524414418143395, -0.3534699777525263, 0.7487077138737257, -0.7416258978433754, 0.01870324262025804, 1.2352696466053261, -0.056898806351098674, -0.06388688257544532, -0.33916748683092485, 1.8771772055286542, -0.17713750873744524, 0.5649339684095165, 1.7642954056389617},
    {-0.4808169786642488, 1.816973644017475, 1.694654210904253, 0.027446729941299503, -0.2463536824196133, 0.20953573560137645, -0.5207690229960757, 0.16923226549386547, 0.76196607415523, -0.03566160366374664, -0.05517301021726845, -0.676423446683354, 1.5569945854317608, -0.44051291106397944, 1.1312334472033452, 1.53550754068115},
    {-0.36307131104997803, 1.0606155881987989, 1.3834348053629595, -0.736832893118186, -0.25979255531161943, -0.12059536498967394, -0.4279982594553466, 0.050264592412081796, 0.5844169446816643, -0.1760938751121674, -0.07464875599496724, -0.4906982474237609, 1.348472908099598, -0.4360093603499102, 0.5118223460244946, 1.1313999679649278},
    {0.021865100029156398, 1.1631622554706753, 1.1214658917914944, -0.3682402842830244, -0.1261826657582255, 0.19587164281578665, -0.36110994889006215, 0.44045573153807754, 0.3925637619862871, 0.318216402659451, 0.19237802633533724, -0.14269547568892427, 1.4489733708259274, 0.0014791743551335042, 0.39087205820330384, 1.2661343334690278},
    {-0.40456286060065005, 1.482552554641418, 1.2934071730743872, 0.26023637883932965, -0.6492376326636345, 0.3982805927167342, -0.34612173616487174, -0.21900196180611559, 0.6099908276760946, 0.10796804939234213, -0.1733376435232104, -0.27014322156700765, 0.9494523502273723, -0.2662122205707129, -0.610859459142958, 0.9563372238680424},
    {0.37885725417211763, 0.4795638137845129, 0.6343755493348586, -0.03210942993786578, -0.6431901017765126, -0.10364157658191488, -0.06873776052382294, -0.5448596168682608, 0.5499860132353837, -0.8051054998151429, -0.010935483930532912, 0.229844452417659, -0.6604112965543947, -0.8728784558970963, -0.519756477410256, 0.40377685182874745},
    {-0.1501171311050509, 0.5101932212593236, 0.1932752072865154, -0.35307748253792476, -0.3209534054880078, -0.7126092848385772, -0.5592188353397711, -0.05114614770585369, 0.20695819295800155, -0.9831466740678129, 0.1701415099904078, -0.7094388544369608, 0.14090510142541873, -1.232294086066485, -0.4826911981090742, 0.4946677880366781},
    {0.04164142432244648, 0.33558460656275013, -0.43912178569732463, -0.5202245449969739, -0.01632345125931936, -0.13236186559435312, -0.29834764408670156, 0.5490481587256424, 0.03177384970176373, -0.30958888728704953, -0.08324394474759313, -0.6394676613715118, 0.15651338499157133, -0.7345022613813734, -0.07632831871660484, 0.19766959856465338},
    {0.05305758002708004, 0.8242533488562175, 0.09554503814100937, 0.18760894614804996, 0.16377955890875512, 0.3120697208552278, 0.15446936402331982, 0.35894479736557, 0.2843925075381223, 0.626842909637163, -0.3380885421841568, -0.04152691119143775, 0.31899886765532076, 0.5712862330195303, -0.028717445923442473, 0.7083482859486486},
    {0.40875667668677146, 0.7088773884844551, 1.03514520668779, -0.014184796734733681, 0.18379735394003452, 0.7279538299111916, 0.3389621084200196, 0.34411549099185645, 0.6282018874978021, 0.47583179021689403, 0.22130100848834025, -0.24603144133704846, 0.404186825278409, -0.10036779577567667, 0.36266588161409435, 0.5770074979519684},
    {0.292753041497028, 0.07221070961435418, 0.3255896933210213, -0.6915589406498263, 0.7068293241256454, 0.17177567408193165, -0.10391949764506025, 1.0902424832773576, 0.04680140397936556, 0.2898219845921808, 0.060229839968090296, -0.34678893116526566, -0.1922150004077411, 0.48457974030892326, 0.17411923632825665, 0.336996344797687},
    {-0.23203529201370454, 0.5942468707167019, 0.39157720044300637, 0.4860660853267624, -0.2774724379118334, 0.18914899413153863, -0.06517841581263183, 0.4403102019356237, 0.1703693666204442, -0.5593831869532226, -0.055057033512108354, -0.3128605884010783, 0.25538901482455, -0.5882351724091783, -0.2473860404725372, 0.06872217348089246},
    {-0.3410976270684716, 0.6208648051089306, 0.8085226856382886, 0.21687320328395712, 0.6451223124152026, 0.01966393495684571, -0.20495751026768483, 0.5044014627379804, 0.1849554306788155, 0.22146530060832673, 0.1323428919215075, 0.1281553746934863, 1.0388822581178596, 0.10668499575512483, 0.22658178236225668, 0.32376388855067245},
    {0.4033853171182719, -0.5641365666458094, -0.2242687904463457, -0.13303890662978757, 0.6677436272494709, -0.0542660130840026, 0.29316673581218944, 0.5707248500156921, 0.397929103090825, 0.6183422684925276, -0.07811626996376135, 0.34471544114948066, 0.2804004785942113, -0.11434422444893551, 0.39344299057789917, 0.20779197986098458},
    {0.06113803793444187, -0.5188661231364566, 0.23406791070652685, 0.15323592692841823, 0.08523578569558672, -0.18729693583265875, 0.2110671596818969, -0.02019168897504974, 0.20230781126387037, 0.08116889387246931, 0.44167987557282234, 0.30326822378487284, -0.3065721126438688, 0.19084961327151564, 0.6728346472685853, 0.23803218412967383},
    {-0.19377023569480567, -0.8318857288312689, -0.7473398362301238, 0.14155647011576036, -0.32445531527683885, 0.31218610916438505, -0.1997901681234197, 0.18179080839989714, -0.13042465515418938, 0.14378902716816228, -0.030638376264775533, 0.16915648496644742, 0.005706483246417582, 0.2813831490623058, 0.5765435830718841, -0.9475388112533669},
    {-0.26000606368639506, 0.5632398130214776, 0.47309960985254096, -0.08356127625420953, 0.14985991513783922, 0.15877697290665632, 0.10906254859087096, 0.08900395816822756, 0.5116932460369066, 0.6986854912550123, 0.33895370160669774, -0.11449727746454492, 0.5413855945940442, 0.3073191875800531, 0.8358188525439185, 0.7569308218231856},
    {-0.17053872851764879, 0.1403834809240236, 0.2521868341911528, 0.2888280273782038, 0.2730535515791714, 0.13908419753277373, -0.09125275525891689, -0.13060551815700314, 0.3537373507653169, 0.635380044831791, 0.2773895366985042, 0.2131332344652528, -0.20096925160538634, 0.24009203103482907, 0.5073721783354569, 0.04673068435164755},
    {0.10534668875526315, 0.3301853754758082, 0.2639725910513304, 0.31968328505278, 0.3779652180744959, 0.843530901888761, 0.08838451411793075, 0.962481176943936, 0.6607545289474092, 0.7421265877847611, 0.355812712832343, 0.4169232959148884, 0.6793045480657741, 0.6295507404240673, 0.6352599294952959, 0.1064274887387577},
    {-0.08994271829004004, 0.5977447270204265, 0.3302627129357472, 0.5130188652544925, 0.01205110731483438, 0.2514097855418132, -0.0199084605208682, 0.3787224543225977, 0.7382560015097699, 0.33585707453956476, 0.5049368059129348, 0.05377925487554772, -0.034011518408862164, 0.5693522627731674, 0.7738955644326232, 0.4976543306885744},
    {0.07048177988723425, 1.1323723293573629, 1.0275687085806375, -0.14584726997083738, 0.5386184054337879, 0.13578758856095902, -0.4197299176334749, 0.2740821375375167, 0.36677115152215006, 0.5572101711096777, 0.20616209219576667, 0.36181296509389965, 0.8594988180911497, 0.501385758846076, 0.5805548128093643, 1.0111445592073125},
    {-0.21056780385301127, 0.541147228592561, 0.7524779583169656, 0.012886944433558612, -1.120012728451399, 0.015363602314700062, -0.12255682170170067, -0.44764482155616814, 0.2342236651540115, -0.16057274509659228, -0.020023996353387547, -0.12996469043912123, 0.11935799794839486, -0.20048598151498728, -0.19339238087224814, 0.8366120618224836},
    {-0.29468669061020836, 0.2049630784118887, 0.33486555559111664, 0.25017358309890064, -0.25317566304535316, -0.0697290228895209, -0.18104674316782912, -0.07930149836448958, 0.4522170481102427, -0.15755889857882305, -0.03849320315572864, -0.3025675415988471, 0.038656651018472224, -0.25133937279439866, -0.47316672593940906, 0.4259439647427529},
    {0.07989800486883467, -0.3520788687897788, -0.4346481975252663, 0.3404046158956272, 0.0843303671354411, 0.09911443501251976, 0.07648088311010853, 0.16967596786956518, -0.2901097560069616, -0.10763022352847808, 0.2536595395182689, 0.23805544628547692, -0.36070334662557924, 0.6589681234485353, 0.11408019359269887, -0.08793614168816259},
    {-0.0142931266132365, 0.34899241270760906, 0.26364836139354303, -0.1600126690492497, -0.039415799020256624, 0.025794477265300465, 0.09724325392862256, -0.0632480766590376, 0.3452011474874116, 0.008379706579593258, -0.24186740369732937, -0.12444611108117828, -0.17321192363292048, -0.33721036650631825, -0.43986022466891916, 0.36041786391058284},
    {-0.23419290837994805, 0.06119055057776201, -0.03013223914426915, -0.12027878977338292, -0.736211319008785, -0.044678618301491564, -0.08585307514377227, -0.5115628180462521, 0.326846288631295, -0.1075037282504726, 0.011272098316105409, -0.5759242412586466, -0.19492048070063678, -0.27923034368940775, -0.654678436469904, -0.20305503527435873},
    {0.13258685986576252, 1.277535062151491, 0.9994163223640472, 0.5082274828994623, 0.6407361813140079, 0.09909566296922766, -0.03142762962836944, 0.7389398871845564, 0.16334921393165702, 0.7389078120760444, 0.23866495729008544, 0.39367579336398517, 0.8379389767853401, 0.5005398161494242, -0.0057844483720553355, 1.0105735985082656},
    {0.1989369099911827, 0.13592035584306172, 0.49040008108616295, 0.031199465378373557, 0.7407396703070538, 0.1912193364243808, 0.30097494271354114, 0.2162010666416823, -0.010186784089534984, 0.42526107329772705, 0.15319972206642296, 0.3370118099468797, 0.26499424359725415, 0.6329955808079277, 0.7855012800488264, 0.14663019466326266},
    {-0.12413631458636133, 0.04392427299932829, 0.056382721671072174, 0.29141117431842056, 0.1748743746991365, -0.003791692142809293, 0.013342535429666213, 0.05542265585707594, 0.24671265879412171, 0.43122063575610775, 0.21096705059454562, 0.008841215285533995, 0.0975602819654237, 0.21884912991375144, -0.41294489811036306, -0.30799335018164337},
    {-0.5777637725074979, -0.8029333830321748, -0.9354878072940148, 0.011279112954168198, -0.47424989327698325, -0.6783923227628186, -0.22747914038093758, -0.21028826268260653, -0.6776065303721966, -0.5043320801623431, 0.14566343587371894, -0.19229294630934743, -1.281979986617169, -0.5842454026069648, -0.9192750513972028, -0.7891233537567327},
    {0.2472497216045035, 0.1082253045909172, -0.12457955084464153, 0.3072439633371304, 0.062380821340351694, -0.3166013397398653, 0.14798058675649142, -0.0693679656552853, 0.10578739024608025, 0.43191769242777645, -0.2913413136646182, 0.5076747924516515, 0.09971957886685566, 0.2624551447417257, -0.10443838125396585, 0.18128833895148516},
    {0.3017231697389666, 0.03466970017886911, -0.13238825577854343, -0.047408581209770415, 0.49540233595497707, 0.15992056667525067, -0.17378320617657755, 0.33140413870720864, -0.26479771961564647, 0.36513757533739544, -0.20949367042021794, 0.49678984444086816, -0.5017511503968692, 0.05393996133297026, 0.7392714114170186, -0.20931826096890024},
    {-0.1231578549851395, -0.029566906505573073, 0.09879290559315576, -0.21451160782379206, 0.24294355986469107, 0.42409924862686804, 0.04223105273693644, 0.4883035541780458, 0.2798638262627622, 0.28513020850062226, 0.31341618841461233, 0.10956789671625287, 0.40896070252703565, 0.2108462953045281, 0.3352725237850216, -0.0058257791388338555},
    {-0.40720894963798193, 0.6887100390790317, 0.4241077356999596, -0.21922657798719797, -0.2708370172878343, 0.1462543544916684, -0.3224988979786348, 0.043938437971441424, -0.07140654464787259, -0.4049671498730379, 0.04929764164117123, -0.1791531257025494, 0.1802085527496667, -0.15266323754836306, 0.6671682537917246, 0.1187287069499808},
    {-0.1542007670807474, 0.5709596516735511, 0.44745565986326774, -0.10825113622422772, 0.7615966700259311, -0.08220990290726686, 0.08177465585000412, 0.5395813457795074, 0.08072711628803543, 0.16806909637858414, -0.2062550545789945, 0.4717999035211883, 0.08897212932388307, 0.2874989946313369, 0.8665675786143402, 0.02239668605469828},
    {0.06360410719656934, -0.24141691154408457, -0.2908673577148626, -0.5108639042389753, 0.16137620555398813, 0.18213513815022078, -0.23094469480398913, 0.05161562250609921, 0.03704505830040451, -0.41661360952987553, -0.45780431474550554, -0.2819600548792721, -0.3907897753461375, -0.8624258700030508, -0.1587930387374522, -0.3171124277416192},
    {-0.02146455398187784, -0.6630742595409226, -0.40830279909295253, -0.6672323544497114, 0.23887592397311297, -0.41566116541203996, 0.21320040809736213, 0.09055819940854705, -0.0014340616420356602, -0.22020189486047326, 0.19528831444386063, 0.238349134028688, -0.17516332327522147, -0.3599460458600917, -0.3586764620742426, -0.5557058935109128},
    {0.13959248250835826, 0.3318817320769124, 0.35449202851513156, 0.528755306737285, 0.005182287702149272, 0.4075443548054511, 0.30743706139994864, -0.4112867622071179, 0.10414780782714511, 0.07677258813621239, 0.15364975831482994, 0.3099626013425506, 0.4360501899525873, 0.4136475411101651, -0.34455757541364584, 0.7099475670466253},
    {0.07984181357887064, 0.8502499756366362, 0.5199986136722878, 0.30890252801646884, -0.28591757039685184, 0.3725334177147402, -0.20077445520475123, 0.13881184471914254, 0.45796482313877307, 0.12105604709747907, 0.21362490447013965, -0.18808822377695078, 0.2523947408383666, 0.03022299815711391, 0.0058987756735720525, 0.6779535448423334},
    {-0.230802396077515, 0.29700835928162855, 0.7055831108877605, 0.5321688873662835, -0.4479912893149286, 0.08805254031901517, -0.17685529965816252, 0.0556103256355401, 0.2820866898587008, -0.022631194108806714, -0.20907291392408148, -0.16162854115194691, 0.3660335240232555, 0.3555495204128663, 0.04827550707703248, 0.1708544708810982},
    {0.05894616678727533, 0.19167877562888774, 0.2169906060234349, 0.3903091164516185, -0.5613136234294546, -0.14131717587256082, -0.2871808813973036, 0.3770458322160843, -0.07679520329991255, -0.0016825708823122979, 0.12796188521845384, 0.01367189349558539, -0.1615468245057658, 0.3479557672573019, 0.2981153898663567, -0.010205239270165858},
    {-0.3286650819265146, 0.2472978141570935, 0.2690122915894401, 0.029213842294390578, -0.10854381230634505, 0.12138293152870887, -0.030218623538485503, -0.10638003150610881, 0.07955925080671858, -0.2559230497128024, -0.16333466630004087, -0.09245416249595839, 0.35473858310249246, 0.17513725982592615, -0.5390967027274389, -0.05328888877940888},
    {-0.6007758595641065, -0.6677687604582996, -0.3591632019881647, -0.7752009154852877, -0.2059795942784675, -0.698438578824787, 0.060854766719150744, -0.48943163800364714, -0.36018333887912507, -0.0998421720175317, -0.4436407261578134, 0.0008329392090594753, -0.7866086106423712, -0.0062913904384693095, -0.3760943412453033, -0.5495232151779522},
    {-0.15684324422008153, 0.6038911655362909, 0.4706531547813944, -0.45262295779611655, 0.27382792394361005, 0.7361352153000359, -0.15668271630821387, 0.3975593452223851, 0.5195312873787749, 0.04493943456981882, 0.1663444871131045, -0.11744273872175125, 0.7055842539586218, -0.08094108952337764, 0.4035581842130911, 0.7894798320351893},
    {0.05724657470444447, 0.20932157866868434, 0.19381667718779272, 0.1521461904542573, -0.2569860181321443, 0.42500277584416213, -0.05222207805587589, -0.12420773762928898, 0.12259179577751894, -0.05422052960760911, 0.1963035007458777, 0.009539788615234501, 0.7248971888447667, -0.1651094886370466, 0.08669616639375494, -0.14246950432649105},
    {-0.32167520442684205, 0.034486159121330205, 0.3983649258330386, -0.4342717692528069, -0.8524526288523283, -0.5790487547651494, 0.009286675002938321, -0.31165537302318813, 0.07252587609059982, -0.8179573851067159, -0.192536220119506, -0.7120866837338422, -0.026603001447588495, -0.577168240592623, -0.247894717097144, -0.17638758725631729},
    {0.013699592607846341, 0.24465400403018317, 0.10445316603422201, 0.0726157669251404, -0.621533384983636, 0.2949819247611401, -0.05795557391028354, -0.23736118575436094, 0.10603511808557314, -0.2755120452531085, 0.17822039051755575, -0.19797080020560892, 0.06876696906702359, 0.2649814167748535, -0.08767755782687796, 0.13404156863406072},
    {0.5717957950688431, 0.26097421202987586, 0.9370329196329875, 0.7797363904043602, 0.07509598088827352, 0.5542778255935211, 0.35161246114958566, 0.17182917391549435, 0.5124294959303362, 0.2242113928825733, 0.18886186786256448, 0.41024493929067263, 0.8171804013426721, 0.26656998900508405, -0.11942130734691626, 1.0125178363191414},
    {-0.31682952302102285, 0.21976562591924398, 0.0909379023768121, 0.1291671439530407, -0.23591763436117927, -0.04044301783074596, 0.16622318257234886, -0.36829207036049266, 0.3931494433697871, -0.23128833541487098, 0.009300776873802815, -0.4331104213762933, -0.2508550723593277, -0.3109254775529927, -0.07560192487104044, 0.17774106099982664},
    {-0.26415561825383094, -0.5143132139632349, -0.37731870855406385, -0.4563879191599572, 0.2391945950352888, -0.051817729499233, 0.006645909130023509, -0.3911208560102187, -0.4632944996866281, 0.039496625397012444, -0.10386426475845793, 0.11882200472537685, -0.22755032373881923, 0.11495841256464305, 0.08190710005658658, -0.678113516293476},
    {0.07663040992321324, -0.10290531489468581, 0.25502053883642806, -0.033223148298903875, 0.10385253272469724, -0.0011866661891636802, 0.027613486974271417, 0.2576924103165044, 0.20616593250070395, 0.015893837844637514, 0.024275536946985518, -0.10974715482654801, 0.5016305676623782, -0.03471508367784048, 0.1276768883314602, 0.047108714129652646},
    {-0.1652622089407673, -0.00018368807316773643, 0.20313089097719572, 0.18237011090134547, 0.13626128287172698, -0.19107201270430274, -0.2620874914854899, 0.13514676643617052, 0.11368086768884707, 0.23129050988666294, -0.09025382527053522, -0.07994572917341396, -0.028924494922938426, 0.13609011931893944, -0.6622756229478262, -0.2666626565477083},
    {-0.0783799955702765, 0.16346994242680044, 0.5418018974065205, -0.300601613582669, -0.11396060297404452, -0.01365494878799736, -0.19152259407091043, 0.06928855225078871, 0.14633791220009335, 0.03076626594076477, -0.09216147541729423, 0.08040179987689795, 0.15743111432559745, -0.23639090516344685, 0.33160250006113573, 0.4014306981942653},
    {-0.007759444329616693, 0.10205696943123696, 0.21378755825638274, -0.07384936630547086, 0.263916035562606, -0.0445245356743412, -0.08371760781810113, -0.11866557185884553, -0.026056013582941587, 0.10972488648892585, 0.037651181204394424, 0.24670505549867255, 0.5930134174348871, -0.16954609951754163, -0.1333699848659571, -0.17950220094602892},
    {0.07460768971334203, 0.3806812194825952, 0.7435412873344833, 0.6296692967487733, -0.16447713613596066, -0.09784212512007832, -0.06865967723215839, 0.06519093760774526, 0.4985304766212796, -0.09652887421074219, -0.264170693731089, -0.3182874881064231, 0.40049370324151334, 0.1978916998379142, 0.15188266391647698, 0.49331057130233397},
    {-0.0687730303142297, 0.9646248189501543, 0.46267904993422887, 0.08678005022815997, -0.00919413327572197, 0.1588729293350642, -0.20730981821144356, 0.26550067518351095, 0.1711468787578835, 0.006259950818411293, -0.0984598261265779, 0.11171406498431541, 0.5094244644528012, -0.17715416777195198, 0.1049627172370546, 0.7811741271560664},
    {0.37678123934985547, -0.5214438755744241, -0.38970073757590185, 0.6774573645904974, -0.024839492956123126, 0.11194576979487499, 0.10984000099835495, -0.30321738605489845, 0.20814337157002857, -0.21036646988054486, 0.12710977706345006, 0.2901073302822889, -0.10348975208159394, 0.014694622483095526, -0.3934213394186608, 0.018606225492477917},
    {-0.16220339708564352, -0.20610992945324896, -0.6207080754207889, -0.17191408666935934, -0.45072291349126914, -0.10406667630546808, -0.22365802006467214, -0.4078443991590783, -0.5311861777788843, -0.06553736739674533, -0.1356158610272606, -0.17768829798872998, -0.34820631821973197, -0.22893472432975862, -0.5813015204075366, -0.6539688471047312},
    {0.10509056036490583, 1.3842760402558807, 1.3269866659772798, -0.7442465195080545, -0.9568832454463465, -0.9084897883415813, 1.0075158870278802, -1.7168325590326146, -0.11057147713142752, -0.7580005181079856, -0.9182192586157898, -1.6734080386944392, 1.841502382424459, -0.9444190789318482, -1.274510908040093, 1.5166737780328756},
    {-0.4882563625634052, 1.6611075546313854, 1.3777783060899436, -0.4326197744004872, -0.9461949295034069, -1.5282153225745143, 1.1121918778624764, -0.4770422292810643, 0.6052781470740196, -0.9328523065846185, -0.8468035699100395, -1.9088683328925435, 1.8162440686178092, -1.1074431112298058, -1.14880925174941, 1.6569952567835617},
    {-0.20691199626426582, 1.592447375498941, 1.842187235917514, -0.014546637940894634, -0.33341660455471267, 0.5906207268765751, -0.2685045451017241, -0.4931735524432633, 0.8627839534884383, -0.6743024236168207, -0.06493346852528555, -0.4013266801340745, 1.765648870090084, -0.12102945684066875, 0.39289539332110535, 1.7467533537990256},
    {-0.2588525648091656, 1.370619484338373, 1.3383194929093343, -0.11992488054321322, -0.2353691753989988, 0.3705264264806359, -0.39379088020084146, -0.0765368216024096, 0.47873893212703, 0.046242407870539445, -0.03334541943296515, -0.42409426348462986, 1.494421050549389, -0.22699767169467164, 0.7305451992800155, 1.1714634175526561},
    {-0.38158447192112044, 0.8187294486391495, 1.1504996745359448, -0.7537907050886287, -0.0969401840959276, 0.23816711951617048, 0.21200536533518585, -0.24551805237106644, 0.30123913318999757, -0.2287677998920433, -0.0066513747264781665, -0.36408385979396013, 0.8070642078649627, -0.16423351684902918, 0.3608777567088075, 0.6872985655403087},
    {-0.05785919849858483, 1.6398920865573117, 1.6660705181458895, -0.22723882963084602, 0.5644073891836879, 0.8039043212041347, -0.07274945183181906, 0.052693870040455705, 0.6721955760107547, 0.04321737913503139, -0.1008048647218282, -0.2457543864999814, 2.0699053869718047, 0.21243509404192915, 0.10188680087956763, 1.5106207814035035},
    {-0.12302216716955511, 0.6169980854002316, 1.1625273944452834, -0.19289060407236727, -0.21655181791076986, 0.07132408732978404, -0.06821632099287885, 0.16404766199126358, 0.26637502985378486, -0.3256568506028684, -0.24288644380047597, -0.2367133107768002, 0.16426735856886748, -0.13448105175385708, -0.5657226314964492, 0.9502508336520349},
    {0.1754235751688978, 0.13644130541570793, 0.6409036711573236, -0.11117566592412723, -0.32051373646809905, -0.3584878685186997, -0.10371909634000215, 0.01910750181966129, -0.15799275777665117, -0.23251840511969216, 0.07208522861641455, -0.4420196886394324, -0.11105788301310231, -0.6739148593379048, -0.5557958619259211, 0.4414148275860489},
    {0.18947817181900822, 0.15988055907899815, 0.27753638553865206, -0.05913866717600163, -0.28833330866107426, -0.08614684862687833, 0.6070327578119993, -0.23281612679460734, 0.06020660859456444, -0.7828733457847955, 0.1994227841319287, -0.3775544298898055, 0.3143280253199812, -0.9949257531229135, -0.5595475056399912, 0.5088184214567737},
    {-0.011106343104026617, 0.520234475226316, 0.5038535590050852, 0.07073271586581215, 0.5423320589408486, 0.1479686360982921, 0.11907900359991772, 0.7177375064539991, 0.26019664357331845, 0.3440432205491285, 0.16439443349118144, -0.4358505709680039, 0.6096337912120328, 0.04714562932820653, -0.54044759742176, 0.4575339013462904},
    {-0.30040508271729366, -0.19821769312699783, -0.40857126117346865, -0.3102335321186757, 0.009323507274452265, -0.4485265531349311, -0.42816509225144556, -0.11826481775781247, -0.3929902054577777, -0.127534789377828, -0.05154425716884696, -0.26905969338332164, 0.4754271120234074, -0.0646023280312434, -0.5490545239213271, -0.24881397666082194},
    {0.0593524152467292, 0.5924594800853102, 0.525418735008682, -0.07386184077095438, -0.22208237064422967, -0.20197701127973583, -0.14010453975858536, 0.1779198448929719, 0.4095043362811097, -0.15359001039227005, -0.12501098910531472, -0.1041088337137141, 0.7442905873800958, -0.45297739168296686, 0.23487623217383952, 0.3679020135504425},
    {0.2807341165953568, 0.5753390348070311, 0.28459432992798184, -0.37635661832449024, 0.6724148843397488, 0.1187389573622006, 0.12425074756983302, 0.32798575809411123, 0.26786403709412687, 0.4093155495967801, -0.21497351619824337, 0.023871792279105793, 0.7177396663079431, -0.013867915096794642, 0.2882260744200856, 0.9065849355873163},
    {-0.1628205456359358, 0.11431123122563366, 0.09853057660873195, -0.19095632213103228, -0.5306199366269648, 0.029415938020793706, -0.18313022775070611, -0.17687936663053697, -0.03503541865487248, -0.618066666042416, -0.02505356149726539, -0.46140462791632353, -0.2800549127532596, -0.35440627068287756, -0.6771281417428434, -0.13268092396740733},
    {0.0023464208901370744, -0.11392697559116212, 0.24575074748939812, -0.7878429060928065, 0.4818550652595545, 0.38392896045635233, 0.03194871383542965, 0.5621458905875135, 0.11980622643245163, 0.1426647157446927, -0.4580914502019661, 0.013119587308097952, 0.5128634723702769, -0.15238964675037142, -0.34719439697572413, -0.16335691858692727},
    {0.1831629474277656, 0.09915755580099428, 0.164667955642999, -0.12689824819720436, 0.8816200379517146, 0.038242119508515256, 0.43458254359785287, 0.13547369425757194, 0.5310605075994964, 0.15264983028204637, 0.11163169506294311, 0.043837569885697286, 0.5261559975921878, 0.4314998480642083, -0.2588563143293727, 0.44605134697610377},
    {0.19541839453081952, -0.9055486384481503, -0.21913499330209266, -0.7077094632640563, 0.02740889176795136, -0.655169077705852, 0.4113521549713845, -0.0588867101424062, 0.026418126965608444, -0.2358128200730965, -0.05560610876321387, -0.05721406436349725, -0.09985383732775503, -0.2379269448763307, -0.1664749387793792, -0.23808909486749147},
    {-0.2395555439095086, -0.8359855179748193, -1.2619725576422154, -0.4051170383273533, -0.48344391815018223, -0.5745846772640837, -0.0776973139906351, -0.39303970854931386, -0.8417857429828883, -0.17216629938123926, -0.17261918333701182, -0.4958793467185183, -0.4268406698569279, -0.1869418430020199, -0.4090046300298391, -1.2206900292894505},
    {-0.2161403817951132, 0.7442570456555052, 0.9054943017997069, 0.07298809499298169, -0.12133026618426529, 0.13581849827584958, -0.03565945928281173, 0.28014383514500385, 0.011823808425973723, 0.159443751826598, 0.15316053908204763, -0.10626242684082272, 1.0190359256026245, 0.8223763460942883, 0.4996080566243776, 0.483163280683851},
    {0.06016227682845621, -0.6819039400170092, -0.43299163400939855, -0.020162677149955528, 0.13789349585094912, -0.23815905972597332, 0.11016683180336577, -0.36477964299434046, -0.06102414245363488, 0.40277031706377997, -0.0602475406305424, -0.38431479543410435, -0.11455132489779495, 0.4658205591686272, 0.23163344936345254, -0.9662502522775578},
    {0.5386619578601841, 0.20740762950932648, 0.10770225371700069, 0.5316790092581093, 0.3673240679959573, 0.26694052174404953, 0.08360833392358871, 0.8879339678043265, 0.31726947571806663, 0.6347419459047419, 0.0559509659427387, 0.07879838901762733, 0.6337076179140346, 0.19990437246741818, 0.4402932800940357, 0.3763818310228146},
    {0.04711703695786274, -0.11638743447807962, 0.026438410776121798, -0.07562651581760736, -0.4037643548935693, 0.14826769328508693, -0.008350984371913334, -0.08678128088380169, 0.06498574263815332, -0.05963689048392529, -0.08675868955646869, -0.1943607308700853, 0.08311191776987194, 0.09212168892491619, 0.028508908735509753, -0.1933355355448384},
    {0.08392463288040969, 0.40678171949594005, 0.8305338719034638, -0.19618899899960668, 0.36890503283982706, 0.2592883716313014, 0.025023343179037382, -0.14231419312577887, 0.24301847675537322, 0.3111174838407012, 0.10065692046599359, 0.3612693529303877, 0.3924582654477306, 0.09849625733357244, 0.31694710663665865, 0.5547650216547991},
    {0.1519625452021624, 0.7764673485346525, 1.0079023429241516, 0.24458716816564613, -0.178577881878854, 0.13147054089456536, -0.16032404948476697, -0.33759207104649874, 0.5931675630935814, -0.03374006913428442, -0.05251638565894917, -0.0534096504656772, 0.7060850368537699, -0.19680459855095217, -0.06373006160355563, 1.204428192804331},
    {-0.4388102106510816, 0.6190480275940166, 0.7553822501572569, 0.05585505852214341, -0.3001681038695692, -0.1911579769978634, -0.45957137643488294, -0.008484433725077421, 0.34437078767135015, -0.46199967626560445, -0.2655994172282969, -0.4457541126584858, 0.4329173313172526, -0.28208468011762144, -0.42711502836596327, 0.7350593471908898},
    {-0.0733275236749563, -0.33929204754019954, -0.2371588789140224, -0.2129666698999321, -0.23313598372149028, -0.42989857358221456, 0.06839480222842367, -0.5594365947564255, -0.024862537646429095, -0.2219434683747214, -0.13351208969024633, 0.03240362156494359, -0.19074043823128115, 0.08792324347773166, -0.19108951162044116, -0.32103509579164985},
    {0.04948122408776445, 0.8814132707693448, 0.9647695608537101, -0.21489375547459644, -0.30959006243984416, 0.289838636753876, -0.09489987950378834, -0.26910518473375267, 0.377508091866628, -0.04672560903173407, 0.17785052050719816, -0.504214269473116, 1.1186639768377082, -0.2114582220842705, -0.2331899475804206, 0.8972613566448386},
    {-0.2158113252429992, -0.09394723984207183, -0.20666256129570135, 0.3355206100160985, -0.6379962098293652, -0.2547695446349296, -0.37932010235701663, 0.013703121200725355, 0.09122685589315867, -0.3241267242914743, -0.2534656845465541, -0.530608810046377, -0.266874110118327, -0.672153384147958, -0.5967036198821143, -0.43553585728511324},
    {0.020310630199254463, 0.5574892584457717, 0.8918189276382524, -0.031057101731061597, -0.20459073079905574, -0.21895611663725983, -0.15082678681133116, 0.7502469338848126, 0.3775552237143887, -0.017248418219587117, -0.05822446303626607, -0.2582852560629215, 0.6620310876556937, 0.023304937775993313, -0.2016845905519508, 0.48440894666351375},
    {-0.2020221638659494, -0.19594811389711028, 0.07280574355193949, -0.00015142147267480408, -0.2748238017713462, 0.32918930248017675, 0.20266203112741366, -0.05644981454523103, -0.05042976659342868, 0.42694809582602605, -0.06593991082722077, 0.03081904561316107, -0.1850663937732704, 0.3145499159798935, 0.36558915901397804, 0.04159250689188985}
};

static const float b1[16] = {1.9833175936436849, 2.8463481665571386, 2.930451157148282, 2.0426986861687255, 1.661179270015917, 2.59968168772897, 1.9825246526122835, 1.9761170410334605, 2.614244631344801, 2.0563479782172225, 1.7500741588172901, 2.0199957379790807, 2.9295807779089817, 1.8513682631426984, 1.8369522505940425, 3.019478353511064};

static const float w2[16][12] = {
    {-1.5330831281463786, -0.524253558487614, 0.15210921442984143, -2.3027399722550466, -1.188254017257724, -2.051916876595933, -1.3422484642640649, -1.851828393045049, -0.5849810921688194, -1.0360315400405098, -1.0501315505986828, -1.0968841507755058},
    {-1.8302965193787664, -1.5358033037660108, -1.666566578513888, -1.8737125484014572, -1.6674814959147983, -0.9437546396957753, -1.7994350165879467, -2.0860468311513998, -2.1580125620413857, -0.7418114499052023, -2.0515107931775107, -1.4448522431405337},
    {-1.937772884013788, -1.6505076787404651, -0.9002609722481547, -2.012067083200059, -1.2737404742543543, -1.8698195688023187, -1.531186279305762, -0.9487769807172708, -1.491521744856704, -1.7614102994470044, -1.975020925720823, -2.203629715606225},
    {-2.057781173416923, -2.193085581788965, -1.9612602808491038, -0.38331060599225547, -0.9658536439022211, -2.0298798565520797, -1.1966039143192055, -0.64497543685817, -1.3536439515022276, -1.501609549347408, -0.7645641745561238, -1.1181172480754675},
    {-1.673296819247337, -1.0193194896194946, -1.2278051857890209, -1.1620924631357974, -1.5164582178138384, -1.510009497974736, -1.090754192103102, -0.7906671188962134, -1.846111115363078, -1.7195047125288259, -1.3106483742849222, -1.960557517440505},
    {-0.9447303479257452, -1.3110685679400111, -1.463929233738308, -1.1554387552197578, -1.0963750664819794, -1.3430517328313007, -1.9898123034647415, -0.2403828236185256, -2.2796458968435083, -1.2581234838021997, -2.024397513642258, -2.3085113438327083},
    {-1.0456461472343437, -1.0109758553208488, -2.5327412207688274, -0.8727763058365474, -0.6093117697944639, 0.35513638503143785, -2.2881874796797006, -1.4261907349278127, -0.8635720850664756, -1.6068444813867258, -1.267021033405411, -1.1290828185212523},
    {-0.9857045395325182, -1.523538780028876, -1.8789116349754267, -0.708749198357363, -1.0169575731813265, -0.9205443140659817, -1.3381808305222063, -1.6919259224610135, -1.315714445651085, -1.8256020311825103, -1.4774449790178783, -0.7285078187459869},
    {-1.095084541577752, -2.6864401315692144, -1.907813639145874, -1.8581599226693946, -1.8187621531287657, -2.233299223849212, -1.2831574567705204, -2.593193168909468, -0.16349792050762615, -0.38635461671105165, -2.267539943023801, -0.6807814435223549},
    {-1.9518701515429835, -1.925020168838152, -1.2434556952173181, -2.146968472084537, -1.4073562517912601, -0.9809454518930149, -1.9078526469401287, -1.1335782339005673, -1.8580150146553842, -0.7343596969513797, -1.0089665841079778, -0.40020354263425445},
    {-1.6404782559735271, -0.9550354541326286, -0.7547681238823343, -3.1125654853006406, -0.9448864786862841, -0.6156467893471089, 0.3560797599380498, -1.270548049468765, -1.7393599419412444, -0.3061547507249109, -1.3507220882816486, -1.44198794602169},
    {-0.5419522049945816, -1.9274568025059169, -1.8868446980469198, -1.2594963635754985, -0.9616856439336162, -1.5571441194362832, -1.252791627679729, -1.7790470977420771, -1.8980170864034265, -0.47727454113764095, -1.409584183487293, -1.753957113988101},
    {-1.7972544327129618, -1.4527652726187643, -1.9414636774151508, -1.1256436119517776, -1.5399946960770532, -1.9729522240686899, -1.6843519704314491, -1.8223833803585059, -1.700049459417452, -1.6699597185811805, -0.20463753645696517, -1.7024375272402317},
    {-0.673705310016676, -0.4071536747882515, -1.0373186621327979, -1.381890476330811, -1.621752648603433, -1.2795871152340776, -1.036903835751577, -1.8162707288425233, -0.9678403253653554, -1.9035642004183462, -1.7325650778639012, -1.4273121000697984},
    {-1.4479954525819476, -1.6734989179102584, -1.4598958146050214, -0.6794026808936856, -0.8842531500946246, -1.5510170839817001, -1.0983860069973275, -1.3113828464266306, -1.1298893333923465, -1.8313084895928349, -1.080891879127592, -0.8722498515108318},
    {-1.387157727786517, -1.1877613288447366, -2.1762003115609443, -1.7359347255016024, -2.0398565839458405, -1.3121315642223228, -1.605628314708868, -1.6433491137418847, -1.773498191827172, -3.0382678632189055, -2.0656922817484378, -1.5095568941080417}
};

static const float b2[12] = {-1.0260578753576177, -1.1782537292230078, -0.9983674886065167, -1.1234232588748336, -1.4956676903457402, -0.9726096489825053, -0.9954530975643392, -0.8491291991782094, -1.1156814542391118, -0.6816932301224603, -0.48217784750556764, -0.8238933167460706};

    // Input Layer 
    float z1[16];
    for (int i = 0; i < 16; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Output Layer
    float z2[12];
    for (int k = 0; k < 12; k++)
    {
        z2[k] = b2[k];
        for (int j = 0; j < 16; j++)
        {
            z2[k] += z1[j] * w2[j][k];
        }
    }
    softmax(z2, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
