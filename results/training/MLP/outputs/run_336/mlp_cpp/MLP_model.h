#include <cmath>
#include <stdint.h>

namespace Conect2AI {
namespace TensorFlores {
class MultilayerPerceptron {
public: 

float* predict(float *x) {
    float* y_pred = new float[12];
static const float w1[120][64] = {
    {-0.027357805704327554, -0.47719427609112686, 1.2373464921580972, -0.08766538092435464, 0.4619958859457011, -0.2311648292545086, 0.9294492740711642, 0.08974437177653213, -1.0922738973919242, -0.5215922195139777, -0.6403383154441094, 0.08384857533786967, 1.930182208926021, 1.5010906830446216, 0.9119441235900212, -0.6001982385868676, 0.4914205528626274, -0.4364822531120759, 0.27027869760421336, 0.20534873929876654, 0.13353509995463192, -0.24569644933060225, 0.6976500482150004, 0.6803976473329115, 1.4465433823361964, 1.030374675113882, 1.2160447475712117, 1.089811466210928, -0.7818335198704148, -0.34235419261501343, -0.8900602149258374, -0.9091949185598727, -0.4738500345859302, -0.42352607284945926, 1.395672936927439, -0.4779085538965759, -0.32531591967329765, 0.4690979966373807, 1.5769442585407836, 1.102485412924639, 1.6341165175278842, 0.7462730016922938, -0.09998167692944897, 0.45080717975921436, 0.6582013723305795, 0.5986809977821388, -0.537315221390326, 1.5608616130992214, 0.566296439383766, -0.28334142776998833, -0.03983370364175689, -0.4061681741656246, 0.6484152358895743, 0.9975500353457049, -0.237586510620564, 0.441957133649663, -0.4250431408900788, 0.973783259389872, -0.050453487380076996, 0.7379514655922109, 0.8573116943219316, 0.7005183035189165, 1.1246241982269687, -0.7346943623654952},
    {-1.1452338670779811, 0.47794610238708674, 0.8142949861229052, 0.05371980256675633, 0.40168528825171007, -0.8336800115342103, 0.2977076780609084, 0.43006492657483536, -1.2425398356213324, -1.5177773635539726, 0.013767876761388811, 0.583416956282858, 0.8882250688099419, -0.2100943078646787, 1.4263991243788996, 0.5892654067247864, -0.5465299648717241, -0.41670141719772263, 0.1539215229496825, 0.24334833252371896, 0.37248334280851303, 0.30691388435437544, -0.49443127029458656, -0.5994470923975302, 0.30738284098204555, 0.2472082730738526, 0.5130128194997173, 0.23086728165207462, -1.2323633542433075, -0.1041396699398902, -0.3750245215121471, -0.7293800365222898, 0.2212627635168238, -1.6047254584029682, -0.3515532821067735, 1.0302247618672455, 0.37811768956335406, -0.05205767806176341, 0.5336412823838744, 0.11737012594572144, 1.6183083483421368, 1.3975292832970128, -0.7160530219902856, 1.4215648042378444, 0.921386079581306, -0.5200975138879927, -0.994523840925666, 0.24137845685240697, -1.048350922173646, -0.6672653227275711, -1.1667924354164678, -0.6930417008950309, -0.30429098035865876, 1.1648957544354097, -0.14348765025541224, 0.6862803620466013, 0.060101672128537176, -0.6740143451791605, 0.4496387405719736, 1.1564590100557872, 0.5968508053124797, -0.08202601141228087, 0.8356120114404086, -1.2048792046104069},
    {-0.6843000615809904, -0.9725543246226216, 1.4876134345607763, -0.8023455941216118, -0.11389608166574465, -0.7671709436180031, 0.8672138685787223, -1.1612353761541778, -0.6882768514148537, -0.03435272312964805, -0.05562100411203163, 0.9887599031028469, -0.38131864783326497, -0.20729513139128208, 1.552157706626453, -0.2530010854056194, 0.06289827964027452, -0.6306073108044394, -1.2983908018179562, 0.18739278888936237, 1.391847079947929, 0.32256483201658026, -0.32265094937113953, 0.9538416281943449, 1.164742494966755, 0.8674374693065382, 0.09791310173932388, 0.060470586330229385, -0.7795684905873319, 1.622603244032427, 0.7256809586694708, -0.20866367619401355, 0.7366016055869424, 0.507938832335704, 0.7814099061952987, 1.3416970886915167, 1.081430536015467, -0.9043338677252003, 0.9481211726446651, -0.02865129565258057, -0.05650188821469537, 0.7515615841272124, -0.03333443079778175, 0.8134228889135775, 0.8129312774153361, 1.0695521219149138, -0.8950522077217491, 0.009737598247691366, -1.459415517845488, 0.048521675081675764, 0.2920265468275074, -0.36979898641855524, -1.2704216700295454, 0.6524710351326787, -1.6185593411215087, 1.0542102170171734, -0.7052286993161385, -0.5605257448828289, 1.9210013685670535, -0.49018628415069715, -0.1443686517299111, 1.2668832303403483, 0.17431096820353306, -0.9005792853800019},
    {-0.6951510565958566, 0.15674350158116837, 0.18505484557830204, -1.508292550466749, 0.4746236276972918, -1.7181950653825986, -0.7612079635048756, -0.28537891283707106, -0.42362932582211216, -1.0244161708169714, -0.10812447663775304, 0.9743643619365766, 1.0107635209867178, -0.7653103441280438, 0.713412529308895, -0.06013666330220819, -0.5359103607745934, 0.848996726031487, 0.10922483863325, -0.9186800451342507, 0.006342075043455931, 1.0843131560632104, 1.1182066422452577, -0.010949151259512591, 1.2876635967121461, 0.3926958291415383, 0.6358986225208437, 0.01595739574173784, -0.018147166118937574, 0.26149018935887514, -0.6647468463532425, -0.02321899063627746, -1.2017512579990663, -0.5718846305939725, -0.609244463643193, -0.33168800966157763, 1.387739600701205, -1.5627675930797549, 0.3859410954210076, -0.03855973338448645, -0.1953541469017025, -0.3045956577529976, -0.4238999218451163, 0.44771969402466044, -0.8295540639110668, 0.7208425023208352, -1.370957122706727, 0.9890976172242207, 0.11494162686061653, -0.36029453063861067, 0.1289125654556514, 0.9098952246332689, -1.0536018478019042, -1.186794185365072, -0.12110545476190669, -0.9928529896692533, -1.4518507926939233, -0.34314153426271954, 1.2848466554011815, -0.16388638824890564, 0.7796715957374718, 1.0282859879151458, -0.35870880962295165, 0.9095972644036928},
    {-1.3211663710133912, 0.21869467616074847, 0.5115650317362505, -1.574523992174267, 1.0629529854526105, -0.800606868442876, -1.3501941379554794, -0.9342241972074342, 0.05504044174332092, 0.11939238948070822, -0.3877683899322994, 0.5727579432787198, -0.3987858553618658, -0.24658300899319838, -0.577299004824706, -1.0312199541272826, -0.2723036234275501, -0.34770881498806333, -0.3527472197964234, 0.0953532160026833, 1.0831129243557753, 0.6389478815006595, 0.8281917055277405, -0.9547342768161656, 1.0692772805755018, 0.855335022456751, 0.7677842999226993, 0.07244077310429654, -0.42708584071609845, 0.8372736407267347, -0.6277917912181986, 0.41033230925836556, -0.5550118732263702, -0.3508085469663424, 0.4132066933602523, -0.11312671846060925, -0.02093685336905747, -0.47008069386237006, 0.9084641122217304, 0.006707687843667843, 0.4297633732012827, 0.9815625640115822, 0.1343287744610481, 0.8373297979060463, -0.6878434949337934, 0.6020968149126228, -1.5750006004872925, 0.4557899190265419, -1.0693724552092878, -0.5570183402148547, -0.3959107600236697, 1.3308822672495375, -0.48193427639342873, -1.6801031167186185, -1.3820187473650842, 0.6458682475217028, -0.06110014618377023, 1.1450884311081435, 0.33566026573220487, 0.37310238185987815, -0.4537419320524566, -0.7472208420458236, -0.17935623962489503, 0.04789637797704131},
    {-1.6950177818477414, -0.9836713800392656, 0.5114646801622964, -1.3768404229237696, 0.4714964782653569, -0.17475945736469267, 0.28852204490715416, -1.1638317740661364, -1.5691063611181988, -1.267886014507657, -1.363537513486588, 0.6711231397420574, 0.7187788270603449, -0.9646790871706049, 0.0655791863525396, -0.687614878804702, -0.3292394605647622, -0.716482188497819, -1.204465251843548, -0.4583538129263909, 0.1819803312097939, -0.3718083575719639, -0.08022078857359885, -1.397424095718978, -0.19437080308867227, -0.5983291483668651, 0.769267814092393, 0.0053100403953402885, 0.4242658093320345, 1.0648221278141636, -0.24842512560366992, -0.5535165125704772, -0.36871662219929024, 0.3068899152423032, -0.05050658743841838, 0.49394606934819874, -0.9073892960568074, -1.5852377355005218, 0.5618991640625292, 0.7946798238448662, 0.6132328360116039, 0.6730841282486086, -1.1795179564037725, -0.3118487266494932, 0.7326310941187429, 0.39116334842089223, -0.9238864730442395, -0.8968493975570966, -1.596507814643555, -1.7489322186817076, 0.02665780745752774, 0.7019034158225403, -1.9610041045919893, -1.66927675845983, -1.6011702470620337, -0.05851459449109167, -0.3446372292072851, 1.073917109719645, 1.1598947717564478, -0.6458131762750862, 0.4461709983905988, -0.8104681996013259, -0.3174270481328171, 0.6042351047663626},
    {0.14990866295764987, -1.0390786216163428, -0.2706812654410662, -1.2398289831896478, 0.01749380669219392, -1.2505021487635208, -0.9792499013942869, -0.7943530853328737, -0.17372315085777038, -0.35800215338944064, -0.9971292884933853, 1.1079924196589885, 0.6848764881100458, -1.633787558305428, 0.12758490223877825, -0.10785668541548532, -0.38169123680356437, 1.223884558279022, -0.6623932171567517, -0.6828609011850884, 0.09709419687269934, 0.11544888744553092, -0.03219084415336179, -1.433371137898647, -0.9895964939592975, 0.0031893395494766424, -0.09568050157058465, -1.0796553974751542, 0.2018608208366224, -0.10211148314087953, 0.0276223736473677, -1.0727700047559818, -0.8208043865424134, -0.2085808597565319, -0.8552587360841669, -0.41732037211503287, 0.7987307892645267, -0.8796805269476818, -1.3098713392474217, -0.6205767857830977, 1.0035451906194492, 0.20056077940775985, -1.2533179292968386, 0.8443468168301612, -0.08452829875122007, -0.05745234202051573, -0.43252474841814886, -0.017250909256074837, -1.8360676006374619, -1.5861645324618352, -0.21774275893529826, 1.0089679246526273, -1.0230464155095318, 0.2028254528586775, -1.1549930314060362, -0.8416876260160595, -0.3531675182691034, -0.00451265262110549, 1.0856361455364678, -0.24096038169697012, 0.6558580595878082, -0.015846585058359244, -1.6082774387309313, 0.5882030579359961},
    {0.22622453090287079, -1.7181768526803944, -1.084897363474987, -1.2342343650943306, 1.1092304755842843, -1.6965074539477065, -0.7774491903219196, -0.717289235814494, -0.9411846884913682, 0.3646146719312313, -1.0629649932722862, 1.1964050482551087, -1.0974455393612499, -0.261419920770902, -0.517852519846514, -1.4026284636837691, -0.64314277880977, 0.8618633517023375, -0.5239055073550619, 0.6572987062879296, 0.7801704078825102, -0.8768877528366764, -0.3372089568956312, -0.7070523036300868, -0.0257716731344623, -0.7110832813385523, 0.8162573813732057, -0.06222246085801408, -0.8173755906812374, 0.5723245150372617, -0.20336737580133268, -1.6566269969261844, 0.45114902638720333, -1.0129763520860318, -0.19012810246566333, 0.633254212792218, 0.5275114963307675, -1.417066007359899, -0.25981683183423104, -0.9367462017964754, 0.07908138215497071, 0.8994970050231299, -0.6577098734245845, 0.12767955262463468, -0.8761114468812721, -0.16966507198994252, -0.01942916723036534, 0.20836698255107314, -0.3613855656815298, -0.3397442308107659, -1.1738264756437151, 0.7462501028663796, -1.4067882371413194, -1.067442181381722, -0.02853940355026906, -0.05570408517055831, -0.5292645568226483, 1.298758317679446, 0.8524107842939338, 0.42333003037866596, 0.605546986672579, -0.043440358972033674, -1.5935568574741965, 0.39232839055874985},
    {-0.9770401933274795, -0.7538289313568414, 0.7786375771749394, -0.7929365271790519, -0.08134210853124176, -0.8096632126224974, -1.0020373902148396, -1.4724048750706225, -1.4331201119651926, -0.8234320705661597, -1.718349238849783, 1.0424574118589525, 0.5690559283575807, -1.0296792830292922, 0.7941118510469998, -1.04620409656708, 0.30109898573140587, 0.37747246817073227, -1.885549930869823, 0.2642588767013398, 0.8824346726775129, -1.2189701146608816, -0.17638843677900173, -1.1854807959673137, -0.19927814248100204, -0.5867447163638712, -0.4634640908489332, 0.6309101155410959, -0.37364227980916226, -0.5020575029910388, 0.07696844806424526, -0.3811571154889719, -1.0422237784006536, -0.007938413780602121, -0.6761200053700799, -0.29983964023638265, 0.31675584505050247, -1.8983910752931166, 0.553481044410042, -0.579929990878849, 0.02337960912187198, -0.6032960334763453, -1.8339758194882083, -0.32625203117545715, -0.9155536078588625, 0.9294535516730137, -1.120724777560788, -0.3383767639232083, -0.5993672450454183, 0.014671572073822732, -1.831953615299981, -0.6997708629137137, -1.8466906553289597, 0.22865053332661137, -0.7042692927540132, -1.2122541619817484, -1.6685314774579059, -0.34118728650627184, -0.11540026541198428, -0.6360526419225454, 0.6056492080634306, -0.0829459504616388, -0.24438093500067948, 1.0023056868729272},
    {-1.0773409727471797, -1.5935917344483557, 0.10872506071036632, -1.993146999374024, -0.41131051454416157, -1.2969069050371564, -0.41852951078533324, -0.325788918534343, 0.11491697740903929, -1.1216751263899627, -1.9476712861102579, -0.09648397583261299, -0.7276303882642208, -0.5857553390108019, 0.24877806885524276, -1.4225448306389008, -0.427889949909113, -0.4254149611497263, -0.5699203610550461, 0.28967028411345713, 0.7472344558381768, -0.8498395718748734, 0.2082237502440565, -1.22227256143271, 0.9542287688907231, 0.08050086205090885, 0.0615344055565261, -0.4662662454025128, -0.051001247911746005, 0.2528369522202429, -1.3185439933169554, -0.5924206215207587, 0.20114628787122485, -0.481083281767773, -0.8833495561472113, 0.7709059074447341, -0.30881722248023885, -1.6214917069791746, -0.7277709722524861, -0.9151784029022896, 0.9268058615602676, 0.8766751760765511, -0.3273942279222536, 0.8732654275475091, -0.6416749654206643, 0.789612481461776, -1.033613225894374, 0.2518861225855698, -1.5796619225644601, -1.8333306933692906, -1.5061705456402932, 0.8957765536239877, -1.9959639643321976, -0.4312812867310083, -1.7590353300829857, 0.2105173956453185, -0.8135698114899728, 0.3224574471755322, 1.342479700962656, 0.3055404215717566, -0.8305102259424395, -0.026586774719854822, -0.05180462449659927, 0.49990517750572067},
    {-1.0174751797481887, 0.1918789627570703, 0.5558203894347792, -1.9345890175370986, 0.9382151531547402, -0.3664432260274508, 0.06673490581384278, -1.1108293565816403, -0.3488642990891184, -1.4746123045069406, -1.3737543315630398, -0.016829381988852844, -0.9294027566945855, 0.13252844516353415, -0.6040951023696461, -1.738685630268736, -1.1760506897876242, 0.06078973762173462, -1.2627830267069096, 0.40990791272291965, -0.8343931891015296, -0.6759375996426559, 0.6204856082200656, -1.0350997267183677, -0.43444282116476224, 0.6447420317606678, -0.9532700523259101, -0.906111502338963, -1.2750802844174849, 0.9476477372563443, -1.2676995438119654, -1.4653722649845613, -1.1452392923721137, -0.5168475931905014, -0.9735059913791875, 0.1777691051164944, 1.0457634716961237, -1.0909346418595278, -1.3408814700846199, -0.9407355150444011, -0.6690682497721055, -0.6920468873535107, -1.280328815148382, 0.41696173088213034, -0.8929650929485164, 0.8200302960473426, -1.1768481221102685, -1.1225039301250088, -0.199106409382035, -0.57555171161024, -1.5385297821268984, 0.26439657790669036, -0.005469997590608641, -0.11410804838128988, -0.3426786063286779, -0.008191889678791135, -1.3937235442641072, 0.11251035040876738, 0.40791255078802413, 0.9809515502452014, -0.495610831454019, -0.25280481678857414, -1.3181135206685617, -0.71535794417123},
    {-1.297736059814174, -1.5826512839498292, -0.2908106345460693, -0.3330331287733387, -0.24111073129604968, -1.0968477300885509, -1.369650059366807, -0.12360024166961561, -1.5618465660021386, 0.16651281249981015, -1.5445276060128459, 0.05896696820455581, -0.47252933870729485, -0.5752763280527637, -0.14443561494022564, -0.8878523011163714, -1.0916247623225808, -0.06068136721408998, -1.663735152210528, 0.12009705155000724, 0.603718959427079, -0.9761575414655038, 0.04035206075352848, -0.5895720297016572, 0.32385691148772167, 0.3005667499713643, 0.7634702745647517, -0.32571709309638996, -1.7141173576265156, 0.4250138937460783, -1.1044925501841039, -0.11257435101757172, 0.15805789343489896, -1.6300836158481633, 0.3369690103040179, -1.3882243738107236, 1.0341606362468576, -1.0979740680616905, -1.138605779304287, 0.07444094774711182, 0.8943479213486604, 0.2923432434584493, -1.449420460679383, -0.42297417225207945, -0.49883988699656856, 0.3182000598486045, -0.0817785590145616, -1.295980053375312, -0.913765234015325, -1.2328147044833788, -1.397475096970546, 0.679517619157485, -1.498362675486542, 0.3573707553600561, -1.075836714848992, -1.5974915993784709, -0.5918131272134419, -0.08159283521447883, -0.5698012216681475, 0.9739109501237304, 0.4418260425976013, -0.8056035604104607, -1.2229579886576702, -0.4321717879215462},
    {-1.3132050121976124, 0.34829732846602734, -0.6698195187873046, -0.12447137868513741, 0.19613199925882735, -1.391478020897405, -0.5369318204376368, -1.7969265397466527, -1.6176375756460948, 0.31610720589165503, -1.1889872960268575, 0.767559103451751, 0.7604098094791139, -0.4786562706953831, -0.9658599750265623, -1.498113266477984, -0.04175630130258013, 0.1787024851599275, -0.7618316784949288, -0.14161475568416024, -0.1599793919171632, 0.14541552790306192, -0.14799727557444095, -1.313017845192854, -0.264328618509494, 0.8297120014352001, 0.8862173124829633, 0.10342826881044503, -0.8600024785840341, 0.5360293753430959, -1.3263400190588988, 0.25485459146609574, -0.9393827538404287, 0.3167098410675599, 0.7801332254379628, 0.3868477634275133, 1.050951311556384, -0.39484827300683767, 0.5434869396092942, -0.22878955912451898, 0.28026220025936727, 0.5559218762502319, -0.9581369265881662, 0.18741442512052436, -0.36376406889320917, -0.3136072159938896, -1.5656988771489242, -1.3285232336989357, -0.2991048881688145, -0.4081463467474973, -1.4221749190781043, 0.8170010631785088, -0.9116515078541507, -0.5364031753384344, -1.4998374629300146, -0.8623114706828028, -0.9583246967301476, 0.8159717170611325, 0.7336194738261623, 0.26074720369072124, -0.6643570810940215, 0.24639066165932472, 0.3249955322271528, -0.7164889182181123},
    {0.3983526120330414, -0.5899809281381068, -1.223391402163574, -0.23523212517773864, -0.49423564164016087, -1.2545769159727997, -1.5017981380881813, -1.358151841266086, -0.7591210877168117, 0.17830131715044847, -1.6019450876309937, 1.1583527291591476, -1.0312781402962088, -1.119848527144819, -0.33010576449881346, -0.013922760179028734, -1.3185357169961316, 0.12403877147943239, -0.41955754195900025, -1.2669882800931378, -0.3755381883416336, 0.39504574650872853, 0.14405577205296885, 0.3317248672404772, -1.0541687784852565, 0.5065284151402821, -0.3132675274451877, -0.07277909391571084, -0.1742237514312931, 1.2222995610386862, -0.872575479298416, -0.4289588108127316, -0.5928166764834775, -0.8066897755361698, 0.6221621638279644, 0.25290465482544316, 0.6180184838548287, -0.19375759103620568, -0.5228529095912151, 0.682403883917053, 1.023406537294252, 0.16406370013040517, -1.1476742685479475, 0.9157537210539406, -1.3842393624904925, -0.6915440103531131, 0.2974200725802071, -1.4206523125223922, -1.5353402585890847, -1.9217376439373395, -1.4770617967938773, -0.6051533473339756, -1.150844493896615, -0.8844854657265355, -1.6913172561854888, -0.4605908894775533, -0.7265154835596591, 0.5478815545578997, 1.1984415610565158, 0.27038023119543314, -0.3099969573234792, -0.6281851226327253, -0.21066482979054324, 0.5974376238641458},
    {-0.6948714418427475, -0.7881167575647755, -0.8761028484369756, 0.1874488989152702, 0.976147807356304, 0.026494050510464075, -0.6196205725756877, -1.7782563446064827, -1.0792428636407, -0.22108874806360487, -0.31541919767284726, 1.4726755151951725, -0.7447427622346652, -1.4169693436266755, 0.9017386528311004, -0.8909654382227448, -1.4909028998080234, -0.3063427910506024, 0.11743718877797572, 0.5419913846363801, -0.5637795652756964, 0.14642353295357807, 0.6672807919431315, -0.6031101079338343, -0.976787719523039, -0.7673346512602566, 0.7746208468349696, -0.9477426124918178, -0.124033852847958, 0.3613933166115079, 0.41490810156755614, 0.2965160256480514, -0.7215401911890192, 0.47769754820649113, -1.0924450251074431, -0.9822799843295823, 0.42464525336846654, -0.11321435804369231, -0.18231579869236442, -0.19612697225886533, 0.4512873526644533, -0.5234438297133713, -1.7122809962679486, 0.9321862688730305, 0.40232419239647954, -0.6896598551600333, 0.04177085144629869, -1.345120139252038, -1.1905414904609586, -1.0532220263476733, -1.3115736172466503, 0.8217891648003288, -1.7454932244864267, 0.32268894943660886, -1.2822277194775127, -0.896125638971464, -0.9245356370410306, 1.1340311101500402, 0.5886251122210902, 0.27374737956462375, -0.5361905555899886, 0.2790126020800707, -1.2656520742357373, -0.4937975721973984},
    {0.4381309856930642, 0.2402908742278449, -0.30973751072808203, -0.5383981584802683, 0.04641944211902189, -1.1912182707809926, -1.5316589564522014, -0.3080102399092247, 0.21382526033016516, -1.0225184855070233, -1.4972782414721684, 0.42664848481977147, 0.7567817164433767, -0.15050119862383815, 0.9415565013321346, -0.18108525180404633, -1.1440465758289815, -0.7042642096204192, -1.551173560172018, 0.030847236214435286, 0.7130997407001807, 0.4076877403540397, 0.5996334119621256, -0.17280263916397104, 0.8414250323519277, 0.718346192567824, -0.17851747366262005, 0.5121771218314262, -1.5937709881386828, 0.7924922114828004, -1.0623125987329396, -0.007493784232554682, 0.843368209625096, -0.12081595198652381, -0.36884843631890335, -1.1002311368233557, -0.3127997174172411, -1.433632421833925, -0.04221944688037538, -0.6305925497213463, 1.4290723360810282, -0.33453740505020463, -1.8025332428506387, -0.4909212419633334, 0.7086355027208184, 0.5321917063452414, 0.10085276863362916, -0.6477341003587177, -0.05017044426438651, -1.1804224105031713, -0.9299120681701541, -0.6401202125140201, -0.7027958993595333, -0.6717884303561222, -1.5147896191824815, -0.8408191943894373, -0.9909305188474034, 0.4005459602156198, 0.4179458200976316, 1.0125720125532036, -0.9905152434463329, 0.14930629599651515, 0.12443466132841573, 0.24016685848267558},
    {-1.27093021414714, -0.7188877964594211, 1.0695984326329224, -0.07330214576211366, -0.21699511331490323, -0.38558665557207805, -1.3311487821448136, -0.4666808180255552, -0.9409344053261803, 0.4112664326640582, -0.7956006101072977, 0.4057189371075902, 0.773450669066905, -1.0569760092014544, 0.7827440442526382, -0.6541494766641196, 0.4318561927925268, 0.033799103375199736, -0.4500395882438975, -0.0682339481591004, -0.17206266752674335, 0.4211319424957599, 0.5161500643494378, -0.033053935420185206, 0.9494717520174605, 1.432958840829174, 1.2004321497511306, 0.5214571102481017, 0.4824325996871627, 1.5815328847045005, 0.7379439098166609, -1.090995882870471, 0.835739137092375, -0.9114880954437294, -0.23271887708128938, 0.9938390996817159, -0.43221928247758334, -1.0354744870492185, 0.07762382956785159, -0.08978072367935472, 0.2443974528813882, -0.1366294832250397, -1.5080070705218462, 0.4422497112990765, 0.9560632469597782, -0.524675487493538, -1.1912557408057098, -0.9329641177412578, 0.04963560635430941, -1.324438002282397, -0.9596394951064064, 0.134575321480737, -1.566397737983523, -0.2742228765270649, -0.050611646186612735, -1.0821353072407482, -0.41287169064167617, -0.01721131575835995, 1.440606048902569, 1.0174242661826636, 0.4729619830198171, -0.6577121906584008, -0.4406830027095649, 0.595089778148977},
    {-0.10628446983539568, -0.5681154847108859, 0.3386932540119463, -0.3093581022251566, 1.1824899289668656, -1.5453267736906242, -0.981523796709632, -0.3987641950179256, -0.19732964331639044, -0.876480376924097, -0.24073308586262218, 1.5072740693930622, 0.4436197319983325, -0.2948838042957602, 0.525788376411688, -0.5003121227856966, -0.7602303854484097, 0.3826503218873362, -0.5155587504733412, 0.41947351968507723, 1.2870133201750302, -0.41320224845828357, 0.20683291451347155, -0.10460901683867861, 0.8767627767236801, 0.9122389826174255, 0.9746073124108381, 0.6885286566663301, 0.2662503414384697, 0.7153762376264737, 0.024758334380129362, -0.9411090185522116, -0.5949952660247956, -0.9490480955804947, 1.143351751538191, 0.9675067933473666, 0.8238027575591588, -1.3533022638503784, 1.5367424260056413, 0.9946826161027462, 0.7537073997922047, 1.543405271276655, -0.9002861167466123, 0.0022477428142549057, 0.09928270406058017, -0.8270778207524591, -0.9564263819264907, 0.05172749416214605, 0.2975565886921006, 0.04528926079514987, -0.6127522270602186, 1.3585616473907511, -1.1227009050229086, -0.07842028484681329, -0.9293378956384253, -0.4690899223892245, -1.2488695250663437, 0.9252313413635223, 1.4408433629561175, 1.465087323382082, -0.837349828006587, 0.8696735982224271, 0.3334784851326201, 0.11800913189305841},
    {-0.21784897265372125, 0.20332256992392697, 0.7062769354044501, 0.10728139969794706, 0.49495855109066417, -1.4876133850223765, 0.17818085081076543, -0.8592165127895807, -1.144815827239473, 0.895849421676214, 0.5612800737653542, 1.0989217423492794, 1.381248512892733, 0.0251142389542349, 0.8453172503202077, -1.051939118074751, -0.25653345049328924, 0.3340067158675291, -0.9741087742286004, -0.8905467298475922, 0.5559148222532393, -0.016828010229406696, 1.1913841824075204, 0.6988709658390343, 0.9655482598074255, 1.3252303249799589, 1.1071820592709145, 0.30589411070243894, 0.33877050799939706, 1.8587639179160873, 0.6146966773598977, -1.073402015583413, -0.35864835056154254, -1.0395731005714142, 1.0173084067718594, 0.6453791041188649, 0.8153530216306255, -0.5920620244604394, 0.8469723707791976, -0.6479432434682572, 1.033382479742313, 1.5999894627414153, -1.1499920452920398, 0.2509516189711113, 0.2194710096792358, 0.515926953084855, 0.7426582003974825, -0.6433933556466851, -0.2695869232661329, -0.7871458829891373, -1.50368007057915, 1.3198994004535658, -1.507382609968349, -0.428495863274211, -1.7709995683980246, -0.11824647771602505, -0.007634312035402249, 0.8252639674828407, 1.1630131835718678, 1.2536547544872152, -0.6331385840477992, 0.5595853285458934, -0.7145008363953785, 0.584941205189672},
    {0.07432785586068323, -1.1803650518467308, 0.2886828736007582, -0.939255485657847, -0.18580704276788562, -1.3467558147070573, 0.20942746753053335, -1.0014017040591545, -1.0827972016941503, 0.679523856782597, -1.0866424855337926, -0.24691352329630356, -0.03210554558779552, 0.253181816694931, -0.09106832097357626, -1.111782275721593, -0.6885032510744398, 0.07970250923092809, 0.0455117101364538, 0.707217247289162, 0.7410110460739203, 0.5291535131956225, 1.5860078146038221, -0.4293702004034813, 0.06928151399759871, 0.7314506477584969, -0.13805100770632603, 0.46243010026732534, -1.0788886764673211, 1.7141605689036643, 0.5848989594663478, -0.8826373001335029, -0.354614006851108, -0.5279757320090964, 0.8407286258120692, 0.8511767873699233, 1.384905818845927, -0.3897559515585711, 0.8264056257142627, 0.02424411231207522, 0.8034809473100893, 0.0313654110646916, -0.355341804444506, -0.44814635753294696, -0.5689708405464663, -0.3644769027101674, -0.16426466729141448, 0.5736611946159248, -1.046521823845941, -1.8364247941530285, -1.5808646371647288, 0.124813840832238, -0.983096607148571, -0.19421936337058532, -1.5288315697511343, -0.8175320750533652, -0.1224232697216714, -0.05118486759683413, 0.5596550708635971, 0.23045394716763506, -1.131284186440297, 0.9772954107375, -0.2580724267879457, -0.22203435701822505},
    {0.32406565794821574, 0.314415022467121, -0.12227808577841585, -1.7911949722211538, 1.4152194378184517, -1.661786417278945, 0.03432292454668369, -0.6331103389991887, -0.6294995677766204, -0.8932132764176939, 0.05681478193474147, 0.8677170319006235, -0.16761479543334756, -0.14098238611417144, 0.35876338935365853, -0.5640562904223405, -0.7664930862567487, 1.1571568483172734, -0.06727825267650459, 0.7190712994914781, 1.3937410004699946, 0.9430178578938887, 0.6413860912301509, -0.8130450895283452, -0.14737690284351124, 0.23509292554177122, -0.5601570583542922, 0.014241963137211466, -1.2979228103516682, 1.4642598147574488, 0.6727730689306501, -0.8067745845891431, 0.1056341692129081, -0.7530529639366518, -0.07846645281085307, 0.20779480252979504, -0.39525907897490925, -0.9291463380775642, -0.768519789990224, 0.20482515951146102, 1.3628975813760382, 0.4902984954779228, -0.8754564849373203, 0.4791795199539213, 0.9722216245829457, -0.03626838954280295, -1.3630431479364213, -0.3865330007447505, -0.024841302619981593, -0.412148730693566, -0.40618674697540597, -0.23990521281592503, -1.6880158127305658, -0.4385461522843641, -1.0640360491031373, -0.6491934482893915, -1.448209815042393, -0.4208155692298999, 1.1141224582548448, -0.1234226817002995, -0.8470591369956696, 0.3650099321921335, -1.2246948169068443, -0.6964025508825368},
    {0.34742206969271383, -0.34989133312027393, -0.24933385461433882, -0.8178804430855526, 1.1157395518214321, -0.9538633356970706, -1.0194755618098013, -1.0023111955166304, -1.1760111951174894, -1.0288572243672551, -0.284464951850217, 2.034109273301248, 1.6667907768842862, -0.5158243716432235, 1.0834276673664094, -0.3300427509922761, -1.026970917941386, 0.7170166515100972, -1.3056051526060046, -0.18165333715420778, 0.649228367453487, -0.5130195457672152, 1.178147812340391, 0.06900055142479182, 0.037774216307296334, 0.8129003117160251, 0.07275554196101604, 0.9155920227822173, -1.0510888459191794, 0.8409194467243427, 0.3813603651277325, -0.004813317906533459, 0.3433886941490849, 0.28541138032847785, 0.5942095602323703, -0.3996706008251433, 0.9230189471110021, -0.05527133289551518, -0.3399027407680188, 0.08003261701046523, 1.525125805666548, 0.507662752599642, 0.011181922384465243, 0.4567307186187058, -0.30953744426154395, -0.28205121996184046, 0.4073309175870804, -0.302737618785152, 0.5481123655742324, -0.28950225416624803, -0.7702161763088418, 1.4447895090140865, -1.2813633977560561, -0.1126931852340298, -1.0317852977239428, -0.421137706617406, -0.8571132851764589, -0.5026903419323318, 2.107476409284542, 1.36230746432172, 0.010728811187249075, -0.4932233496313471, -1.1118377856733828, 0.3148068517983797},
    {-0.37819795363785663, -0.4657454036033386, 0.21400364426625626, -0.40744741151955466, 0.27603856656110004, -1.156140300391424, -0.8566883975298885, -1.1525788753465727, -1.1271961856219492, -0.8942694471207592, -0.17058232762121212, 1.2421735732918129, 0.8073160640198283, 0.7785076664454327, 0.2921275407146536, -0.6279173150500518, -0.6481895502189793, 0.5559460736699668, 0.47055386482373707, -0.12556037352296248, -0.16823387848634697, 1.065036150515421, -0.12432415060758105, 1.2102231454908325, -0.018764201698910427, 1.4188778902797288, 0.4382388779203352, -0.10621135073288443, -1.2152221842207807, 0.5982158996975754, -0.25389600983445043, -0.5134477780257233, 0.5292901703395408, 0.4783091070545273, 0.6161577790934958, 0.10045995097338434, 1.387674711081346, -0.43909253722290614, 0.7743256445341911, 0.3040605103152482, 1.5764196993971935, 0.3500789894620784, -0.09512608892025558, 0.18121741781552114, 0.5859071912317574, -0.4537301465103624, 0.04211476271721232, 0.732226513159371, -0.3178097909619129, -1.1754238694244477, 0.5586358610280169, 0.6785212667769217, -0.6405438788077711, 0.8228774491130705, -1.4030832097758474, -0.6363393724341759, -1.0089294767813024, -0.278807009602924, 2.2129841680798363, 1.566560573617983, 0.025545381249663636, 0.48589206758631037, 0.08646000176125768, -0.6031327796280573},
    {-0.8500228710361455, -1.1111448868190954, 1.2842328988432525, -1.4459724179848272, 0.13867513396207198, -1.2736235953070105, 0.7351544136783276, -0.6020799654514621, -1.1005469893195556, -0.3329786744549027, -0.7277897293001107, 0.0009605311975744487, 1.6690211609604553, 0.8057205657887739, 0.576769147321015, -0.7410485180159788, -1.1687618184620132, 0.4788864073640557, -1.4477522110012881, -0.7481381138358829, 1.4245211505810889, 0.008641375869643553, 1.2530814170607905, 0.2576599127376627, -0.057460079959009466, -0.3016461800686623, 1.5079510239269658, -0.3138325644033288, -0.5639752932475465, 0.37856574840530566, -0.936090543304407, -1.0157350422875484, 0.025478929322650855, -1.0200444036898195, 0.5147916758411887, 0.5885724742788506, 0.6003281607188624, -1.3007009042022568, 1.5863138449364438, 0.3963856506067257, 1.8263773533851664, 1.2944597841418755, -1.0165858261149952, -0.4129057489120216, -0.11701853645817716, -0.2017625842224923, 0.5396123868105664, 0.7253996284411102, -1.0073295699274463, -1.2424853544741614, -0.6342295949777719, 0.2841714288273304, -1.3886313867140168, -0.04466900567920578, -1.727552330462506, 0.018135788295859642, -1.487571818004401, 0.07477142461554072, 1.3450077312343816, 1.3293982889342668, -0.5834637101565188, -0.5692925312799129, -0.05865763674941479, 0.25437035885691917},
    {-1.2760183097963584, 0.3108479588407471, 0.0008658749517753117, -1.4235031737136072, -0.3931774058711123, -0.08897458882882647, 0.21465607130095513, 0.09291415234351055, -0.2144398919025515, -1.0969212344161379, -1.3305640357382083, 1.5450048937949634, -0.6560728728586877, -0.4771953824833422, 0.9118717451950253, 0.5856492048898865, 0.6521057711953046, 0.9148210642814073, -1.482786591088189, 0.986875723160246, -0.4472604955907311, 0.5429412554221319, 0.9200650773436658, -0.553553746090643, 1.3973344366161657, 1.012585891656252, -0.00375408641841568, 0.49160132985448446, -1.4643105129488199, 1.7053246889085367, -0.5667432235259043, -1.0160336927839888, 0.2706204927062102, -0.21600284909967324, 0.26606358184216006, -0.7676360665772332, 0.16608275123449995, -1.511854279161426, 0.4065686644485852, -0.49681790615924837, 1.1250800829884269, 1.38077624952763, -1.185922463042529, 0.7959197160327677, -0.08947917841416794, 0.3421583846153565, -0.09055461617391947, 0.6378924542948017, -0.06750953986673562, 0.09157739473225994, -1.2311461907522245, 0.21817554232705094, 0.11874463555432083, -0.26702353980406074, -1.2218982735200055, 0.8973033126615745, -0.08628699419965935, 0.6459415202310166, 1.3380672763196253, 1.1222370011532712, 0.28119078534541714, 0.40611840684190076, -1.2104438307395078, -0.6001734733652598},
    {0.4882807035461106, -0.26476838055355906, -0.20868024444000785, -0.3807874192628693, 0.5252815784915581, -1.6281804747459316, -0.4313990784122146, 0.2044594231336048, -1.3914682663673297, 0.46691986832867816, -0.11751227174010878, -0.19492682473881673, 1.3175789164732428, -0.07222499880343317, 0.23204142780596343, -0.9363935069836716, -0.9348896327328536, 0.8336165985401001, -0.21406618866575103, -0.005642791497394938, 0.3888826232225478, 0.05710327740392397, 1.1553034874754489, -1.0218365684452362, 1.2199036668170455, 1.3110485788376387, 0.9036975337531109, 0.1899008286581332, -0.9271131899187018, 1.2434849068865967, 0.1006461821750424, -0.524541264615569, 0.42676034080066816, -0.05486226118600906, 0.7823563056736874, 0.8609266980119399, 1.3167963934985938, -1.5765107785645052, 1.0824809934218291, -0.425611362187964, -0.14247397856966643, 1.6959616167783023, -1.1250150076336645, 1.2657100586553243, -0.36485274887358327, -0.8346548040224636, -0.20448693500746465, -0.8658688662819699, -0.47165820406484504, 0.3310100103856888, -1.4536714811922837, -0.41364723760255845, -1.0307600699181396, -0.7588140930716256, -1.0313871139090496, -0.03306385951570763, -0.6740936204232018, 0.05604620800177719, 1.1916079119484264, 1.440657124660933, -0.665029858381629, -0.739091580366141, -1.1662593224936864, 0.07239909171024143},
    {-0.5705976195770253, -0.567706568445422, 1.2885215703680626, -1.5768324246876524, 0.5834873901663156, -0.27611810355520544, -1.0663181056411615, -0.6849622067555675, 0.3945782392960079, -0.09529151864088622, 0.051713746380040025, 1.7097251870956525, 0.208466938950427, 0.23808510686486364, -0.135438955526901, 0.2181630986627033, 0.33503932433452616, 0.23086804476997794, -1.5580683182450061, -0.4521369209137619, 0.5964310262726721, 1.107353564834612, 1.1197740374745968, 0.8551719666364569, 0.8437578984205228, 0.11934228954042386, -0.4057588045810892, -0.6657664842145293, -0.13615652028459171, 1.6777958321208786, 0.30567374873185366, -0.09780423466263079, -0.169870346367934, -0.11452746093301511, 0.0434198802846933, -0.07774043775040884, 0.8578768260794867, -0.3337599081849668, 0.9056565387956617, 0.5452709938948889, 0.5708478981470911, 1.0813535580486309, -0.29135565088901216, 1.300342631054054, -0.17899134655578874, -0.3353948411210996, -0.20597726060564078, 0.7787175535947446, -1.4493040626095257, -1.154501406414335, -1.503845534650398, 0.6754220983450765, -1.7069268184221085, 0.22821239931696888, 0.1685221034390786, 0.9126880745017345, -1.5330064118673712, -0.045507647353078766, 1.104324306224424, -0.26709153735694163, 0.6505464789644682, 0.6476419601895032, -0.21166933635901916, 0.8427484749435421},
    {0.6919656195069868, 0.5260821624998231, 0.46019875635261476, -0.5699102713421965, -0.41858865411742374, -0.4172856270451307, -0.3873297086092875, -0.31562847314742165, -0.42528410824796, -0.0860507138321486, -0.027184599353974444, 1.4485418133165489, 0.7964948893962602, -0.19720779083951567, 1.4483197371308787, -0.920801659223813, -0.4962154043301374, 0.8135461007873197, -0.498488558779429, 0.21140016789004035, -0.14388598007916767, 1.225108147264184, 1.6271919316566028, 0.6845590917579985, 1.165949550409925, 0.3479870430602786, 0.2009878854057928, 0.26911522816906364, -1.4550648922077025, 1.3737091646512771, -0.22899525215246902, -0.7459966643331036, 0.0428330254798403, -1.354339198257523, -0.05888578752666091, -0.704864675250664, 1.1662143926127568, -0.3332302361625413, -0.33020995832504907, -0.7637874445974425, 1.709030390623926, 1.182983158633104, -0.505562689200677, 1.2874644578703194, -0.49767770230493386, 0.21562455573666953, 0.6318678809496449, 0.18919183793789818, -1.1617506311008248, 0.07112453999905226, -1.2912840606713412, 1.225836478857445, -0.5652488678046912, -0.8529773696024467, -0.7550901842033013, -0.7651436969739825, -0.09499854453605062, 0.0913686729836407, 1.5290846934662263, 1.0762729765153933, 0.21839419014916195, 1.0941728603454437, -0.9512136793574224, 0.6240726038508216},
    {0.623780854522032, -0.6217875882589944, -0.008741024023890435, -1.5919695030830046, 0.7245421029504013, -0.5369946313808136, -0.3419558883145104, -0.5722098399591591, -0.6552628805160122, -1.3635643109700937, -1.2168331333838391, 0.6822668549455533, -0.40319686596276627, -0.8645571056471905, 0.22373139799200356, -0.2031381811298496, -0.547056352670711, 0.20260821505340174, -1.2577782692428325, -0.15915579451306064, 0.0694739394938173, -0.04384431506854551, -0.35365006470767707, 0.09164064421617447, 0.7199775223184043, 1.242776622309696, 1.0606374110008023, 0.991897714501679, -0.38700370182461896, 0.41928318146683535, -0.3115276761036396, -0.26694628146852406, -0.5025609749253381, -0.5023444887502403, 0.08687307436009993, 0.8270765718846864, 0.0550421144378772, -0.8397936119164291, -0.5739403398365867, 0.43019828815025, -0.008155599595234096, 0.03793649426184226, -0.22809957300478995, 0.5024895488542185, 0.6747028527523968, -0.8211269170975168, 0.22082611595001478, 0.8869877481078885, -0.6111521514172595, -1.0006905875304288, -0.8276534140753677, 1.421972023734826, -0.5801186320566254, -0.4558171767991788, -0.4512693918642232, -0.7555669990997625, -0.5282874773816378, -0.7549059269807186, 0.42207172172304275, -0.47492237092424666, 0.6502520225522077, 0.8849301191423588, -0.3778247395007912, -0.17574892881666984},
    {0.3673698678996696, -0.06656155487640487, 1.3741672027425118, -0.8160724244068156, 0.9458900476965518, -1.3974970794775556, -0.35271342341928735, 0.1937347982509656, -1.346914617234899, -1.1300131460199063, -0.9217405254971869, 0.14826477793393994, 0.9493432898508828, -0.7402885803979161, 0.7317626252459183, 0.5337169891221105, -0.8562675117112133, 0.43593155842355047, -0.7986612300875657, 1.1262256957462773, 0.000594911368134123, 0.2186949831179275, 1.2022170528221559, -0.9287997809636714, -0.13449630122062733, 1.6083037926444685, 1.2782096398023157, 0.8320479882940371, -0.3800995825705649, 0.3111944189444757, 0.32342824738964643, -0.7664799867673222, -0.6791203576875351, -1.5001968519181172, 0.3227518332419229, 0.6823233113144014, -0.006477651090512215, -1.145666090340234, 1.514858695346963, 0.7328653287877245, 1.5138883170465924, 0.7797375461087228, -0.24333080972737944, 0.4035045095708576, 0.5260757811865886, 0.4499320101625219, -0.8803086251602467, 0.8803228455666222, -0.15383134693555642, -1.3375790151256985, -0.9724845204515323, 0.4270875120087928, 0.13641680759007455, -0.49966564200936736, -1.4370183382779178, -0.8633996501388712, -1.2125537155555683, -0.14774508925873778, 0.7187324522368892, -0.3078075162313493, -0.28799086440735894, -0.09514262081319416, 0.6528207335552811, -0.002157136731514752},
    {0.11927763450650611, 0.7224253635150156, -1.1484640389338694, 0.5906347385534338, -0.3823718648692992, -0.02935713314095492, -0.37603199285941274, -0.45696517429909533, -0.9548003069237674, -0.6850125938049709, -1.065334604344643, 0.14745311292342592, -1.6073096842393246, 0.8739822294574334, -0.6231528911989002, -0.2583884584082336, -0.0598518576809465, 0.8521975535154761, -1.0898247781959647, -0.9349296503601257, -0.3619480245013138, 0.15909394230255933, 0.13553761710854814, -1.3156239831879395, 0.01677103328841907, 0.6699321468847681, 0.21107465573336187, 0.4984205351939573, 0.744426796370924, 0.5939410092992516, -0.45316311387936886, -0.6895706699658163, 0.6328017513677962, 0.8237204314720944, 0.037025239059111585, 0.6469017367357435, -0.5757240219788309, -0.851728828629752, -0.8080100788774385, 0.7385518354152361, -0.6981276565530486, -1.4434169471723721, -0.6062338186379479, 0.7173379047485122, -1.2953629392017156, -0.8448490885314379, -0.015208804158974078, 0.16558997330552855, 0.4029125231123769, -0.6162151277272726, -0.10784312380300388, 0.11975076454643371, 0.8715055251788801, -0.5456818724437498, -0.8183346653342309, -1.3358792600007892, -0.6618572012435828, -1.1220286194262106, -1.4107937002200883, -1.4510029580641646, -0.10538214396114794, 0.5823640471912329, 0.590664103375646, 0.7347042234072768},
    {-0.7692656979182424, -0.7409245259984542, -0.021479991941623335, 0.3052863460363885, -0.11006026397740706, -1.3281939064824344, -0.4324830150942433, -0.9901260521270179, -1.125041835119671, 0.6904291885212013, 1.1032028192225376, 0.23562954223757543, -0.06615443547663927, -0.5512045361736363, 0.017159879103395382, -0.5018991135075592, -0.18585570261805096, -0.6104857934590793, -0.27362794850574557, -0.31576907675046983, 0.08312152847292698, -0.4989680665208652, 0.9310801301636049, -0.5795696800023321, 0.8333924643921158, 0.766585740296455, -0.0030965571861116424, -0.10678180536354734, -0.27664627010560877, 0.9694302996088681, -0.004271513648083862, 0.4385432029568868, 0.13127105363669525, -1.0593484855328237, 0.3065704637978985, 0.4684328342411184, -0.3168211588938365, -0.3093380008325024, 0.5401883995493222, -0.46194078780544884, 0.6692903587938986, 1.324353587564863, -0.08778893451026938, -0.04332094311336805, 1.2559521851994933, -1.0600653911834592, 0.7956513353009728, 0.43131507314964673, -1.1054100967304092, 0.2823066189021409, 0.6662348116001175, 1.2116494323795115, -0.7183673994727743, -1.0800879393660492, 0.01594809709364272, -0.20714008581106264, -0.6882908189177854, 1.0846358596357921, 0.3107122991740471, -0.5442333296036752, 0.00803045857574078, 1.1354820832960089, 0.777479115307421, -0.09107562551361434},
    {0.30227513729473526, -0.7115698790258858, -1.2073706798873018, -1.190895311746878, 0.0899382570389396, 0.3541531013001463, -0.6320226299765233, 0.6360193828534144, -0.5554791226394837, 0.5110385584086051, 0.5073790671085874, -0.43557989847207057, 0.7299041481931229, -0.09571463105927287, -1.1312962761282044, -0.4798976690617236, 0.5010568545655896, 0.3928988004619625, -0.8499857114288125, 0.34127625084936847, -0.4876624577750233, -0.7810416575969853, 0.8257994236493242, -0.16531572299789954, -0.3963195167047611, 0.1918912092145598, -1.0869622007044486, -0.27084893871001187, 0.5126161083753085, -0.7664098915951105, -1.0283988924464982, 0.0025708674087749303, -0.8145314921360675, 1.098540765841903, 0.8996880146802724, -1.3377463807384038, -1.28037026121839, -0.49696448508081686, -0.43948230286288276, 1.1723072056113253, -0.5978451064253312, 0.8079588925118367, -0.9163529599930835, 0.2833400638044613, 0.037313510725970715, -1.5586573566749133, 0.46424352710827343, -1.1877102786794715, -0.6437572268731065, 0.055097509780413605, -0.9408691620142128, -0.9779861406987337, -0.3342084885846757, -1.4549454294408362, -0.11997399119559404, -0.378139627605462, -1.337266869553466, -0.42355071223634005, -1.1244602373622634, -0.08323960907945153, 0.68897696194033, -0.12677705902939154, -0.23648322537122857, 0.6211113811083487},
    {-1.389589121139844, -1.1409161038933393, -1.0012805627952486, -0.2067217577073179, -0.15743584418018117, -0.38821301466787095, -0.4805634965692197, 0.7293008388441548, -0.06025768732715346, 1.0021770923735438, 0.591528528440502, -0.16064074183285557, 0.8795436571993485, 0.39425466234383777, -1.5270543294058287, 0.27235415352823067, -0.7437253055235502, 0.48009354868958354, -1.1051052615513552, -0.1378305943825026, 0.11810434709960567, -0.7708494721472031, -0.10368770156283175, -1.3736868759076768, -0.5082478198447904, 0.3267701931511859, 0.17149952381016445, -0.42216468086055087, 0.22752698442451724, -0.4661026079604989, 0.38496796743269796, 0.2899260568137744, 0.5071541552957833, 0.9926591082144081, 0.8657141561801381, -0.5408133010404039, -0.3366662453505391, 0.7330419467711733, 0.08264512308473523, -0.8072525287371809, 0.1572694604521147, -0.46826832442399147, -0.7492818552561744, -1.0363613220053864, -0.19170057560944304, -0.6436026875945915, 0.6936979409885482, 0.6660078368102278, 0.5653200952838003, 0.7469785777144936, -0.2569052740699387, -1.1522718706558013, 0.831327086783889, 0.16356158551692834, 0.8316377514911077, -1.0426591074229146, 0.8992169307927596, 1.0070483748297616, 0.28945144268940187, -0.2985908453212554, 0.044547218288750814, 0.6346573804946964, 0.3852300585835479, 0.7810811452288191},
    {-1.4614589627774675, -1.208316626319147, -0.9490757755135831, -0.9151073967909136, -1.015435747251831, -0.07298114993071744, 0.3666571981212651, -1.250187502194774, -0.2862293226817709, 0.3209363104581455, 0.3018452172305854, -0.4367870155396178, 0.28761050534751653, -0.7815347420368309, 0.14725816595353144, -1.3325236530962294, 0.5685438812232788, -0.260500434304649, -1.7014598873610116, -0.7075732898491222, -1.1808534673069448, -0.5555862703529182, -0.49639753328941183, -0.28004177750044046, 0.39057362765716286, -0.9197073864205179, 0.6114907572587227, -1.1202651009987294, 0.31931878823149795, -0.588330139507758, 0.19745705784141326, -0.44937495341436745, -0.35915682847368435, 0.5070087949842059, 0.36268334192308255, -1.003312220609274, -0.3671323021465476, -0.8621037479748328, -0.11838858998402628, 0.9215143586604693, 0.07762782325628785, 0.881899122140572, 0.40256311159757374, -1.1326973026578293, -0.5699132235011504, -0.8221722441392266, -0.06988179868582017, -0.7326184177366366, -0.6162788073870743, 0.23154579723987684, -1.6354725329177513, -1.355033933911806, 0.29590005475263836, -0.18179220097844526, -0.0077264226672533395, 0.6073234301710867, 0.41968985781578916, 0.17673869460094666, -0.3904529599406968, -0.8863757403282917, 0.03617755285596496, -0.6415546424085555, -1.373338580182309, 0.12090183308975581},
    {-0.6126356693250871, 0.4074163010569758, -0.5730348818116433, -1.2980094840363876, -0.7236215615487258, 0.11202493148222771, -0.539893329984121, -0.7224387173735474, 0.0075493099866648615, -0.2721868821068314, -1.427452041723594, -0.4973222882180377, -0.0844231374302613, 0.7301179747362393, 0.26259192032666523, -1.0922388732362631, -0.5823613819945845, 0.25409729296324507, 0.20547132744998672, -1.2659701981499045, -0.5647392174429838, 0.7162045939038758, -1.133709814027581, -1.3701295259686903, 0.2128496905430355, -0.4195425656910425, 0.44536621931752857, -0.1787759347823315, -0.7947039000879693, 0.8272170722861687, -0.9768798414623563, -0.029118077669745408, -0.3234118434138347, 0.6820817630989443, 0.6523015168566094, -0.7744584381723554, 0.4424527017987239, 0.49173554449049445, -1.135983182236943, -0.13491490160033262, -0.2136625894781054, 0.9257588472729965, -1.0440568344811558, -1.1997038229406316, -0.07259700271979035, 0.28623928863367115, 0.2229526395823898, 0.17683333731263948, -0.06549998828550707, 0.37675975303062204, 0.6746783242320762, 0.6621938673784459, -1.119885525269171, -0.5672207000958227, -0.8227399288922959, 0.36032287652829376, -1.453919051898377, -0.5816783130192954, -0.9336510104848135, -0.35682786376015957, -0.9233787416557873, 0.3902875126599747, -1.415230711851458, -0.47876137585840367},
    {-1.4267147731384748, -0.07822186615664585, -0.6118723453704171, -1.0554183495315008, -0.281444662681039, -0.5356059246276683, 0.4475158475810891, -0.56352691743784, 0.05408299384974644, -0.5183159736869141, -1.6110196547896893, 0.8712371486427156, 0.5152708510073863, 0.07269622292624692, -0.14270715396174283, -0.6691742263560664, -0.62262590675257, -0.8441580785248708, -1.2556159635608564, -1.0429438379236922, -0.9355992275492997, -0.505509220981745, 0.605582410864602, -0.22420277576719583, -0.42567960632790197, -0.2434971696035463, -0.8930621006405964, -1.716928598936934, 0.0877595314105331, 0.6310231557983959, -0.8540137796466936, -0.2805165671874271, -0.7662859852521541, -0.17044899300456673, 0.8174412035091624, 0.3977679220971902, -0.5991616906232589, -0.9483647736363529, -0.24399392240887322, 0.20722409621369456, -1.3242703350707519, 0.6643418912590497, 0.40749809284113153, -1.2150571079326504, 0.1521995407572171, 0.5478109830326965, -1.5180721459578057, -0.00731042480185892, -1.3663193529078077, -0.729518619377944, 0.465730064255699, -1.1021509005431176, -1.6029585464492158, 0.3569298608791677, -0.17588412789064914, -1.375172104173539, -1.5168507790080183, -0.7043954623548753, 0.19875763796339266, -0.047879549795349266, -0.8495552084884805, 0.0050741565302510165, -1.54434011009516, 0.006080775951860804},
    {0.3046164108361164, 0.5313508225690409, 0.3343762946471325, 0.619436530461032, -0.5239871419892238, -0.2987037834438243, -1.1341053213460608, -1.0897026404058958, -0.0028074938018725483, 0.7191483693270849, -0.9163068375483976, 0.26614137286549205, -0.6385362018058788, 0.0011997335717819889, -0.47458189227710607, -0.8649716640590299, -0.7484647524342742, 0.04591290968792857, -0.8172327832452574, -1.169195537108593, 0.19421625437053555, 0.4868144601161906, -0.9970655928762487, 0.42289668226901056, -0.7060600334739585, -1.2438466400641768, -0.6956376026195128, -0.6805666827622321, -1.0874922560021345, -0.017294857959769323, -0.7576488713602033, -0.8258668534908978, -1.2129385785395002, -0.8840071325835381, -0.034195966013498315, -1.2669739786754302, 0.5573282637175015, -0.8585367558659941, -0.7163227610263243, 0.6340535947474717, -0.09476058149470803, 0.8279098141567376, -0.5168853699330234, -0.3151191778648631, -0.7210936634626408, -0.5464779832338597, -1.1025844367613025, -0.8413791164226032, 0.11923998968338506, -0.98321032845083, -0.32835798966304275, 0.5668012450435985, -1.2313477006427735, -0.5044977828937803, -0.8866123488627203, -0.9694332491954102, -0.8821569382993264, -0.6270061567096196, -0.3488582910980356, 0.35904785836517994, -1.2616304200638202, 0.7182909331394529, -1.411277421483678, -0.6330291000097559},
    {0.30668629400636616, -0.718828008505119, -0.052037239422686336, -1.3251268517875308, -0.07226131684047332, -0.5230534932419489, 0.008307419492002033, 0.2921861332776672, 0.8258756831886175, 0.531022935349011, -0.7375135250945957, 0.7982411710056717, -0.5474020352423555, 0.8087774974379427, -0.9565449662962526, -1.2778868073069745, 0.19199375565697546, 0.12236911253447925, -1.1989305944590938, -1.075476610844257, -0.21974908894365863, -0.2841764328717417, -0.2702161574163978, -0.7656282838475139, -0.6193200194399808, -1.0143444031822222, -0.4617240366108078, -1.0033170233396007, -0.6163185156038948, -0.8239481253794272, 0.0015862329877559, -0.8379880402085798, -0.8201450093341233, -0.8470219191779277, -0.6238969945173936, 0.20029786214313317, -0.4466256459087486, -0.8122241623501636, 0.763116095209122, -0.6068569456103898, 0.3905323108633684, 1.0124269989867565, -0.9626277788400268, 0.13060721683932627, -0.9822447974999414, -1.0646039810633767, -0.6175241752557072, -0.9365055318022711, -0.9303000592702477, -0.1145456576611472, 0.515699364113336, -0.8946371357716056, -0.6523963051239089, 0.17658983671697337, -1.2226439516153527, -0.16766999812409533, 0.19004739075901697, -0.6392906552925015, -0.8774606030857108, 1.030066237261193, 0.0739111189897748, -0.5187645488264485, -0.6348194654598017, 0.226130582300359},
    {-1.4007328939084056, 0.30311524138416707, 0.21494701954419498, 0.2635292159310407, 0.28546821869307965, 0.4881226697783039, -0.17286540006192133, -0.5652354217190345, 0.3426691418940392, -0.6464171405962198, -0.5765808121158559, 0.005505273242526957, -0.8595193865718467, -0.7335124543546621, -0.7666922189003781, 0.44663120908155857, 0.5090732317768593, 0.05889611028047348, 0.20137735440910948, -0.9471295631060725, -0.14614716110119483, -0.922449825556225, 0.8064005344415524, -0.5264164590664843, -0.07246538529854556, -0.8101269990961287, 0.9457075184597966, -1.178869658543699, -1.3075676057541823, 0.5118927239801645, -1.0449066316641062, -0.7958242267748789, -1.1386593656680948, -0.9058365237446553, 0.5725315506982679, 0.5480513393410578, 0.4278850805624732, 0.633880100059037, -0.6077566305694911, 0.38725461277173345, 0.33143549802635797, 0.17585407264217717, -0.05759395655278584, -0.7550864174710632, -0.3423379416294606, 0.44735742604428075, 0.34200296366097854, -0.41069580465106, 0.006170312284044487, -0.964320775746667, -1.3569402065113223, -0.39111393560214136, 0.16556078846196695, -0.5082315848851106, 0.2225122215574371, 0.22052251167469122, 0.26412425881296075, -0.688104670699523, 0.695995176733604, -0.5508842952503189, 0.4019452692052991, 0.32717001264202095, -0.6694649451114297, -0.40852469410773046},
    {0.1939848772384391, 0.244021802685234, -1.3634520262405068, -1.024291466488087, -0.9366032465266558, -0.7003718024274705, -0.8580441143539833, -0.7568959284148418, -1.1321686244894071, 0.016636125716940328, -1.1587836917581824, 0.7056587917173903, 0.28180398529859224, -1.0574453405451754, -0.29467827425670373, -0.598723256086865, 0.6908390126910254, 0.7349267053780643, -0.15361297260190931, 0.6131858577303063, -0.3807584823542061, -0.18556974206166696, -0.8679670876768317, 0.2742141295373719, 0.08027263077079834, -0.5699735417771176, 0.942146184340664, -0.46910634933675355, -0.16409071144201967, -1.0342052415180052, -0.0035504316683074542, 0.3646866887285384, -0.2600126279211068, 0.4929097478903406, -0.5578395763188452, -1.351796308932275, -0.3737347709267424, -0.482201618288747, -1.1085370467048048, 0.1058597527797011, -1.261102520467609, -0.8164079004820803, -0.5912763071939111, -1.2151774990777613, 0.8617188073172918, 0.3601030794128559, -0.33519404631129296, -0.447594323851563, -1.4627008265644827, -0.9760556777793029, -0.4928899869614619, 0.6272278209355704, -0.46059635126993115, -0.37278725836962107, 0.592055394066921, 0.20573337007187, 0.4179176922045361, -0.2495759734309861, 0.42207576456048196, -0.9899788492895417, -1.335849702374135, -1.1391772870625614, -1.022837401018052, -0.9101754092422846},
    {-0.4085881874138667, -1.1585418181335612, 0.4785698779987701, -0.40521896232566834, 0.5977421004129794, 0.47247946971798416, 0.5872030271075454, 0.5701671152612274, -0.1683974794164187, -0.3116644609774822, -0.838146675126827, 0.3047426537542386, 0.07565863054543324, 0.17819634419378722, 0.6397800239316337, -1.2667229125230457, -0.7670921633983723, -0.5621965958104189, -1.5561153032183233, -0.7991672210220616, 0.09460872037754724, -0.6596107094655177, -0.48489328652502206, -0.2146757164102479, -0.5187811247476426, -1.2715581362904944, 0.36466762924324003, -1.1088433529391473, -1.2201074723304979, -0.8199655703707451, 0.5916958429461752, -1.0872047706757555, -0.9652464025143843, -0.25795595978741565, -0.2815199866583132, 0.37092779743997917, 0.7292811955709976, -0.3460914608611436, -0.36180347978075544, -0.4917654984240661, 0.478101751471213, -0.724534226713587, 0.5845468924945003, 0.14574378617170825, -1.1291763267782546, -1.024649796227789, -0.8004670386571919, -0.6927561002029866, -0.32178384529548176, 0.10389056821098347, -0.24954051531260624, 0.3403942424364003, -0.03957589546639444, -1.2715222593336655, -0.47981130244686887, 0.5924047413969111, -0.590218844918597, 0.6122821946336956, -0.653304686584207, 0.624302906371207, -1.0793623246491093, -1.0550254335582447, 0.4827161703315171, 0.6863828487163702},
    {-0.3266612671876011, -0.6540549736396958, -0.9020960320279421, -0.9485133368349196, 0.0161926954556793, -0.5565337455956061, 0.41290772067604675, -0.13594349072644504, -1.0037980726665758, -0.4515539277318365, -0.15388070882407406, 1.0294647624884645, 0.36064641497453903, 0.1292667342747096, -1.1928547859307435, -0.7066578312899343, -0.5125325770860261, -0.9817402740912844, -0.8271404900269895, -0.9153183281224799, -0.8777114095783574, -0.7002435046494587, -0.5727335578659677, -0.37095613020300394, -0.780757470042533, -0.5350576812105465, 0.6494642742674931, -0.31363341179813825, 0.4633716628157039, -1.127662525388481, -0.8825899197343389, 0.20139564236278792, 0.23941799449600562, 0.6562824575540303, 0.18465216526286318, -0.4251550158166901, -1.0781434516557007, -1.209450973452964, -1.335787137125602, 0.29299711137395484, -0.9717036710570557, -0.49319813504479526, 0.1004094477592624, 0.5338760640556204, -0.9686968993665606, 0.629892192467512, -0.34026627158124734, 0.018683649044803744, -1.5267402186755776, -0.32789902413133765, -1.3289203379483159, -1.2420721497969542, -1.0999029577256951, -0.7894825437503208, -1.5254416909368331, -1.1925426446942347, -1.1735131252700441, 0.316778472569296, -0.32188123852043954, -0.6301360477364679, 0.30298609582113906, -0.13771674597769054, -1.4326300356332557, 0.0544850193896349},
    {0.232158577048759, -0.8674921919991647, -0.018772596575575475, -0.8899697982366357, 0.38530343794635274, 0.0050340979370756865, -0.5088415873388655, -1.3703621734312077, -0.5466851903753598, 0.48862912067969105, -0.3122554904675796, 0.2601646553374025, -1.0424432261140735, 0.5227956283696952, -0.6790909338197783, -0.9625115717648542, -1.4833820467099847, -0.7604045333615925, -0.46063287775145834, 0.16934265881190555, -0.925021250967525, -0.47720533633751994, 0.5285540743805381, -0.45128843039511674, 0.5002106036159657, 0.6015410230930563, -0.4740973938207679, -1.469491329539905, 0.5558892206920693, 0.5896244146728384, 0.13650031952234207, -0.04650644854068036, -0.4503557874903878, -0.15224845233350998, -0.8812593652294314, -0.5436303971600887, -0.0996393406559295, -0.33037750327082904, -1.21441096131762, 0.30798888120658197, -0.48511229305088144, -0.23603500741196407, -0.5759420657723673, -1.4032111634472295, 0.16658938869677611, 0.5500082297386034, -0.6286791060861688, 0.11467791926140529, -1.10111047387113, -0.33545588060274734, -0.4490901285433071, -0.4552548216364575, -0.42624991277271257, 0.13513103554187014, -0.7122455956125355, -0.7744334350064987, -0.22814939541428828, 0.8253327274346801, 0.26420152612759196, -0.26311267365926116, -1.080075745544899, 0.04495975844910275, -0.006735174285183096, -0.31451950039539045},
    {-1.0191763220296917, 0.7209390519316169, -0.2374990593366992, -0.5127207202980555, -0.5120007043352723, 0.18702883935891843, -1.1564606762300897, -0.6218842579603572, 0.1424014351247849, 0.5075779310911955, 0.20954361701575605, 0.6247851061979643, -0.3228169173944019, -0.5791919828601102, -1.2742636979064301, -0.17970949927523922, 0.230806454925179, -0.6265093405261513, -1.264926848451541, -1.3069197706952758, -0.6959584071472676, -0.43516182556340294, 0.7666590792558562, 0.32934295223863264, -1.2384530982643978, 0.08045275131406215, 0.4802835600367205, -0.8399525344806885, -0.33706150765525805, 0.03110017081978858, 0.44302569636448835, -1.0003786558549097, -0.1454297418239834, 0.36612884567198534, -0.5021630917998455, -1.114554437377788, -1.2732056740954178, -1.169370174401748, 0.37620689091090725, 0.16519848569675544, -0.19770508312198462, -0.07241802933393772, -0.1196577290830318, -0.4170988407758576, -0.34626081031149264, 0.12456181367502746, 0.2230607008048007, -1.5197645811741196, -0.9885050204033584, -0.6975080096774924, -1.038344816435135, -1.3927699813616863, -1.214661728867553, -0.6424395888942692, -0.7356711328307647, 0.41174102573287674, -0.7505117687096532, 1.0877476683980205, 0.8697008927584748, -0.5383623179707174, -0.9462804715427314, 0.2809267626307541, -0.19210044698008535, -0.21908932902409176},
    {-1.4543285772573427, -1.3210397849952749, 0.6560875555561022, -0.06027548249739169, 0.4543155153072204, -0.8615952356870235, -0.8170181522922453, -0.5936610633648867, -0.8277556753827787, 0.2574841569305826, 0.20268164274209272, 0.7325665224335473, -1.2153208260191868, -0.5976587839794719, 0.05731713931243184, 0.16614151948993722, -1.5281614811843418, 0.9969309030053514, 0.27042728686452056, -1.654935742179006, -1.0369100146699817, -0.16325151768631943, 0.4760910506716067, -1.6720852981521035, -1.418392507482328, -0.10637695478734109, 0.5962384507982478, -0.9802257648808899, 0.6169536412517034, 0.6345275733075489, 0.20033458885279454, -0.5023105661269648, -0.006159507351391516, -0.9086512679431293, -0.8807922615932936, -1.5908482111649929, 0.41313591246970927, -0.628625861905596, -0.9303672115359605, 0.04378313028681699, -1.554006202414671, 0.43044561271660153, 0.6543454768074272, 0.27160091216429977, -0.9324970918454326, -0.44653285396956827, 0.05157032378361655, -0.15403523008125847, -0.3443447719374619, -1.0978861625021152, -1.152286835160958, -1.2486494174810043, 0.12470758101312708, 0.23104679460452057, -0.0008109065601756303, -0.30304202981501094, -0.40270149163856495, 0.8319761089263824, 0.38705513296150434, -1.0503202727866034, 0.006660661905657777, -0.6725491998906913, -0.6486620484284986, -0.7805747086043143},
    {-0.5126189581969315, -0.9442457127449518, 0.4027798175595182, -0.9888213658178536, -0.703992019291038, 0.011233487417948931, -1.1173907559052603, 0.41347414194874665, -1.1977789658787645, 1.0057978643184229, 0.6883897344786352, 0.10474268716295485, -1.0091949853826623, 0.8858951967498107, -0.7089207271160727, 0.25731806042275385, -1.449562749556459, 0.2309582152655357, -0.11116455983169625, -0.14724394454754713, -0.5133804961663709, 0.20076707307729796, -0.7641950866188802, 0.5512911726916742, -0.7864849220361282, -0.8181892001610367, 0.18874098561197422, -1.202465754127967, -1.0135343550810667, -0.8933503953326575, 0.45682640662683427, -0.27379520671727714, -0.5905431703248314, 0.33580664067815336, 0.851512506276121, -0.9643461325722164, -0.6730340426702766, -0.7292665308865447, 0.20105706708976984, 0.08275630339146384, -0.43679788187322405, -0.5938139677140843, 0.41303640703479205, 0.9446465327946137, 0.33300387437043594, -0.9776686084256956, 0.6548205836447273, 0.12721886662556195, 0.38536881146633706, 0.08930843289267229, -1.2471902603062868, 0.3465510760430983, -0.4914892665244559, 0.2769596459337841, 0.1823505105497877, -1.4413285803851454, -1.2074719595659673, 0.9769499959930955, 0.5707257329568998, -0.49886389155212196, -0.6356735042787296, -1.2913174098846012, -1.0522824134883477, -0.24938949173664487},
    {0.6115709889746326, 0.1793093409080174, 0.1966997659422753, -0.7861023798669462, 0.01527920592334327, -0.5149298850318677, -0.254232923315778, -0.16456507841606025, 0.13589879251559628, 0.5031619552412288, 0.5380419378346382, -0.145232476730088, 1.1259252485051239, -0.7692566603336318, -0.03427156038485831, 0.626393297309692, -1.0763137521079391, 1.1087692121943307, -0.20312034683412014, -0.41042805018466544, 0.43841144186632053, 0.6921853131853822, -0.39719272205364503, -0.9003023838726018, -0.5346821993234508, -0.3592379936317646, -0.5999223936680947, -0.4701641898836462, 0.08510059308930507, 0.5131059650468272, 0.6748480796388031, -0.14620634260927598, -0.4930556228858471, 0.3013136466086033, -0.44494186350605897, -1.3903495573295919, -0.9258676396105916, -1.281196752638436, -0.34091390094606483, 0.7833187187718631, 0.3450401626494727, -0.5062280597135861, -0.09117517385954664, 0.28288806881570605, 0.7944645380598978, 0.4046354402893173, 0.7000988466509391, -0.44130084273681, 0.5991578349203134, 0.5241804046615054, 0.1579976630997894, 0.32910495855395067, 0.34530937182219773, -0.6010263018251403, -1.1891680145416308, 0.12367753715702745, 0.6924052609552019, 0.4834897516157382, -0.36982466674112047, -0.2833874023035208, 0.49450215780371226, 0.08382587973534733, -1.185749120460752, -0.3790391024701871},
    {-0.283193718371, 0.6594597970190987, 0.5421483919246747, -0.4503123924402397, -0.3697781337001156, 0.1491220148323, -0.5533903187524327, -1.0149583958204849, 0.17334260395818168, 0.6206272472308446, -1.0767878782643352, -0.7557948099315744, 0.8807430123986377, 0.08234729160548244, 0.6294586093046352, 0.49332664717861996, -1.2669235063701307, 0.4816456317894289, -0.7663492489714065, -0.0052757655542598455, -1.183724138555554, 0.7128189319282358, 0.3029883459785347, 0.2455752746926019, -0.3208423056412572, -1.105339897254959, -0.6637049228967016, -0.860207139152292, -0.38937832392734045, -1.1348611194563332, 0.5419031259864544, -0.4240090649489957, 0.37631512116235116, 0.9369445894288569, 0.4106069267518964, -1.0711805083224608, -0.08587309568657471, 0.6842629677138752, -0.2847421035942101, -0.4152991881033742, 0.2694704768225637, 0.4974833654748914, -0.6100911761112972, -0.05885067047498008, -0.579204474009361, 0.14754777697005417, -0.7813161804579816, -0.027334361649469528, -0.746954798542026, -0.6800884783811949, -0.6460585410063001, 0.47898073417621284, 0.7014911918497087, -0.2154592875404827, -0.3578025555201713, 0.16530246108526994, 0.7207404261631978, -0.07282369503699462, 0.418405582039043, 0.043744515543973836, -0.29598925921721825, 0.11502695811380471, -0.16214398740462843, 0.8093988840221068},
    {-0.20388759065494153, -1.2974486198863353, 0.5513921176671971, -0.27299450932328834, -1.1553126820022688, -0.3808402783485395, -1.3943858373616407, -0.06960968215601386, -0.2719783781171794, 0.40139903176523034, -1.2573477131018935, 0.07924091544055074, 0.39175257159707483, -0.9933429958062041, -0.18341552303138467, -1.7709891209066952, 0.35888408338185424, -0.5200633664327953, -0.0950119772034037, -1.3873417133954367, -0.7054086241120607, 0.640483858038104, -0.9882416085910896, -1.3050513376657449, -1.0519924989674345, -1.2248403482415444, 0.15684014104337948, -1.6408954852991586, -1.4382896772587883, 0.07487654660136668, -0.10760559885776194, -0.9442516305862327, 0.4125983098112571, 0.036699715833638284, 0.49508464393345997, -1.0547607235144127, 0.26575639066708057, 0.33233174796919923, -1.4329276922543208, -0.7006780584760327, -0.2991732572974078, 0.020156990506464377, -0.8454482475738827, -0.5278841889376945, -0.16882140990196676, -1.242023038409303, -0.5978529828965741, 0.3599016732354964, -0.07754893287897971, -0.5592400007613062, -0.9744273057829905, -1.5374604317838207, -0.18291757402072695, -1.095650966115473, -1.1853521602269061, -1.4291217905856282, 0.20548097958973915, 0.8454108693073537, -0.47254124107246365, -0.8062971596900314, 0.4219144884624232, 0.2923241765715718, 0.47034059492044106, 0.32915449498869015},
    {0.08562300120137153, -0.45660999823884935, 0.3887617801715859, -0.6918836779631768, -0.6361633379920638, -0.2519553743439932, -0.7697422047154925, -0.2294001068541668, 0.02484777782018331, 0.9932570751853168, -1.2396980957665134, 0.7691632469823143, 0.19559165177660773, 0.19985859972499762, 0.014235716154429291, -1.6643298023704838, 0.23111847162316093, 0.6092643454230933, 0.18247046571317072, -1.224824711807572, -0.44643057424659527, -0.6607479940703179, 0.7168768141496406, -1.738688248269212, 0.11102239145542814, 0.05336290694390834, -0.99895285392817, -0.9950889634194573, -0.8436134160120625, -0.9372027730339882, -0.33687271299491717, -0.2349416303022192, 0.5817649036886812, -0.9424278774794833, -0.892966006948033, -0.5186243799328459, -0.9371993999309631, 0.3621297565922209, -1.6207675147135752, -0.9024442820489251, -1.1594418796723687, -0.6249351787044936, 0.5326977650038976, -1.3023510390470077, -0.514015159768097, -0.8038397921933818, 0.05915952083771732, -0.0046040228745908105, -0.4374968213426013, 0.38404445544536164, -0.8491805582511317, -0.6023314666343176, -0.9762123386080478, -1.6340828326944468, -0.5068845053692865, -0.7952079882645147, 0.11857983223105598, 0.037952551854274506, 0.34232468240843666, -0.4857755795741389, 0.45502889035830196, 0.5212607747586964, -1.0671693526974333, -0.5474920929852037},
    {0.24665660412182208, -0.350168471714443, -0.592565499951833, -1.1816834030386207, 0.6958575659128836, -0.8655930468272076, -0.09700874674914063, -1.3676270024602024, -1.25361583891916, 0.4961910928982013, 0.15873126593811135, 1.3187175654908998, 0.8217913286970912, -0.07118202394787768, -0.9398775442724807, -1.0045335502572768, -0.8733166038364892, 0.26895105129634284, -1.1268904829920203, -0.47187600465893603, -0.7895447570342133, 0.5641263718230536, 0.4121215028138098, -0.5787955781060423, -0.2875367670484634, -0.4318452928978673, 0.16565712063475604, -1.1739778625613035, -1.3602503477053574, -0.06615853521196395, -0.7705331182348938, -0.4166391243379325, -0.5082965936720287, -0.5584724286067814, -0.3871899854693954, -0.6014125415931173, -0.4374016576494114, -0.186742283114963, -0.3018180313973188, 0.750469534200949, -0.07273772620715888, 0.7649931404345014, -0.801512733609406, 0.11090275119464586, 0.6982528218468679, -0.2726445035710809, -0.8687448571862262, -1.3563748059988636, -1.1812561291340709, -1.0297814201022837, -0.15582755583457977, 0.12187278218983778, -1.0197475442851862, 0.08411305149518333, -0.3019604560694047, 0.44056373708392155, -0.9269522720875948, 0.2961942042912997, 0.9915085410898916, -0.8013785315065092, 0.6678173769072258, -0.4447600983088041, -1.3164446036069402, 0.11183200110443901},
    {-1.2648717449484692, -1.078380116069548, 0.6460020909682656, -0.7362261267282305, 0.9676461346284959, 0.36861774977190015, 0.37168877200073464, -0.09959647616415275, 0.7539806603418387, 1.0085663726635794, 0.09709669048579639, 0.5597538212071356, 0.9755654194034478, 1.094958857629403, -0.023578439310958214, -0.9182337658661889, -0.6510025956560319, 0.4107466936456647, -0.810541556686397, -1.1551601672056115, 0.7718647278453821, 1.1483450010064062, -0.04512658367999084, -1.2016574911367535, -0.46736456823166134, -0.04013063294145862, -0.5833109933900585, -0.6337442306655878, -0.09477002084851653, -0.21614088657047745, 0.38559696306052155, -1.0522412000036865, -0.11494327650908054, 1.1553566727211797, 0.5685955457350979, -1.1603692186500318, -0.6804148053442345, -0.23885549014015928, -0.938551041917576, 0.03260502967466772, 0.1800163804671964, -0.722304626645468, 0.27641958492875196, 0.264201695010833, -0.40390262892883355, -0.13948730793884725, -1.248288420189982, -1.3512596450798835, -0.8207337843641818, 0.7137137640730088, 1.1256529503851302, -0.6092738430979191, -0.8252397350906892, 0.19091649961327908, 0.17178921393716032, 0.08740889779519413, 0.6716707793237868, 0.878115405489772, -0.76446794677532, 0.3555675974898632, -0.9569114634562704, 0.6155182925444285, -1.2822549458856942, 0.2955360259682936},
    {-0.40261603720135575, -0.8775919765622961, -1.2279151945621065, -0.7400197436840648, -0.3185834348026503, -0.2568774264734492, -0.5699349298569624, -0.5216193130222911, -0.30467084516476045, -0.02097668259849855, -1.3807449861889853, 0.4368022991114087, 0.41529779685858936, -0.42863238037906903, 0.08186487269043637, 0.12749592545947117, -0.44330077142925245, 0.7360081508268678, 0.3760638675104658, -1.7234245357757398, -0.4918706088519278, 0.022493788087705264, 0.055212665642603964, -0.11327760321382696, -0.43127051230266755, 0.6114042606083084, -1.0801781145895029, -1.3741819556067516, -0.2841682416168666, -0.9507765603633606, -1.0274549780469366, 0.16700005985835975, -1.0885754229887938, 0.6051388149788856, 0.27526564951919985, -0.20409261506743603, -0.027520898337667646, -0.07451216845080702, -0.5289094750150833, -0.4766021015980065, -0.5733059295611813, 0.7152239533850456, -0.1779061993286397, 0.3860336862475565, 0.4581930693805348, -0.9083940620657596, -1.342411076237487, -1.2580654225851977, -1.0391455491412331, -1.2161599742750602, -0.037434517562781155, -0.86152238784245, -0.2590479728250107, -1.7891727813492104, 0.20056708406372592, -0.3185413953601163, -1.4119905805964195, 0.6823206362894128, 0.6322383622909022, -0.3791442528396996, -0.6189126476104095, -1.587191824712224, 0.17686149574811244, -0.17591768037324262},
    {-0.6192630981809585, -0.7869386912002707, -0.5120302170788276, -0.14677781871178874, -0.8074678259980654, -0.3326543418920942, -0.12341253392557598, -0.6724104838434766, 0.5320417812620181, -0.9701742610737261, 0.3937128921182701, 0.5910335193968528, -0.155451156788295, -1.2619715900063904, -0.24769948148927629, -1.011832241653645, -0.7615917098702238, 0.01115589310487354, -1.1157740917775634, -0.9902597285371271, -0.7871640512814172, 0.8049260072059913, 0.3331829356241691, -1.0264591624505581, -0.1827844687775932, -0.36443323994893045, -0.7455988503941767, 0.08288119407005379, -0.3186446132901767, -0.6163573219147649, -0.07520532148342131, -1.2870432569528554, 0.15661949971877887, -1.0135465043922767, 0.08637340610271407, -1.3136630223757608, -0.43023488722670866, -1.4856625544827435, -1.4751540546321869, -0.8329565720302227, -1.4536552013779938, 0.7356400093503593, 0.5362946607919886, 0.13041150718384778, -0.2000574727395854, -1.0385621224606627, 0.09349120947697927, -0.6851217325612308, -1.3203927652339449, -1.5690876637708449, -0.37014034528146494, -0.6887010237302197, -0.03230873740052435, -1.4145737054399212, -0.9812388432813961, -0.5016668308808796, -0.6319949559762666, 0.03505472824910162, -0.24210986024222436, -0.5813152518423256, -1.365620688920418, -0.9929596287618596, -1.2764177624981046, -0.3060715803488625},
    {-1.3167400501908515, -0.0488695295883704, 0.5149749156147909, 0.1894307915019613, -0.7656016698265682, -0.32613817091304115, -1.4614245598271633, -0.61443187205718, -0.7365641721764167, 1.1408310952956298, -0.4275919888873251, -0.6365061872030989, 0.5404777190748398, 0.15220161277261943, -1.0509089600209107, -1.1546775458314682, -0.6800370819374981, 1.0622190762829375, 0.6536013958032256, -0.9226266214638924, 0.5935513520829298, 0.8159469741376735, -0.12187121902567623, 0.032999270063120076, -0.10665054097871565, 0.4590155124596311, 0.29763385473825366, -0.8795299219945062, 0.22471545323991882, -0.3232018325195454, 0.24044367771589478, -1.1686253501673358, -0.15539908477226883, -0.3471442739039498, -0.3092164593044545, -0.011761593201687895, -0.936615614412644, 0.5754118953442722, 0.14514269401383934, 1.1702342393669114, -1.6944610842459211, 0.583929950788617, 0.8115489580436652, 0.6975651065289051, -0.5862860303521099, -0.4210174131188408, -1.0179056470488277, -1.0724125759118464, 0.809634613123038, 0.14098316967578078, -0.4301339702568789, -1.4895661610282365, -1.1319909795527143, -0.38213586250961556, -0.8632757685110104, -0.21100028960976586, -0.8776952504273688, 0.6889047113858507, 0.05674406184984115, 0.7881904843901651, -0.008867096512402415, 0.1759714656163612, -1.281478459333648, -0.513770035759109},
    {-0.6474823631294854, -0.42344195663128437, -0.2111500223238298, -0.4469545538417874, -0.5253079013942057, 0.26435372463497964, -0.8063641719607882, -0.6915897608507305, -1.4061569079818896, 0.7875930716359515, 0.24654031786165706, 0.7728090249315128, 0.17740482433832605, -0.38548101619135994, -0.562465890979966, -1.47231644551116, -0.4708167179042987, 1.1682652552495503, -0.8760610042064048, -0.5735011106228064, -1.023603272436271, -0.8582216665710818, 0.29429318375312696, -0.7457314976099054, -0.8205587671397359, -0.07806000802831906, 0.24090166181651038, 0.3857355699363657, 0.13735556690218273, 0.7992825377472791, -1.0678732374100273, -0.6878308996532645, -0.37189206044533035, 0.24452858798922522, 0.8005061321788619, -0.5451403627795425, 0.666786692545715, -0.8894421143337037, -0.36591812015285974, -0.14854261280337067, -1.2939716919784372, 0.09114492825303758, 0.8568400427325266, 0.6696431664274362, -0.35490665687048795, -0.20259871169265778, -1.4555361288139135, -0.8385449816612743, -0.2627560270550861, -1.43430298749425, -0.9590516709403767, -1.1220092869962097, -1.0508437252111298, -1.0984020834873853, 0.4350557493261655, -1.390193211575659, -1.36014696800407, 0.7863527192025295, 0.320094447767519, -0.8732692101784689, -1.241701249646291, -0.8627097383473391, -0.6140183808368146, 0.9363443354543758},
    {-0.19561945832849667, -0.8413856874178841, -0.15087502466122873, -1.5369033263258722, -0.8302393702732905, -0.21723911290367254, -0.6866110504688494, -0.7287489760791797, -1.1426904528564468, 0.8380785718774314, -0.46264866132026633, 0.3864801782565966, -0.08179221441502428, 0.5000123774720967, 0.4876517887953986, -0.5547826463286107, -0.4327981336820567, -0.666422446594718, -0.7967408348406748, -0.653826604197825, -0.3123587743431737, -0.7672367835099916, 0.2078706917393991, 0.23834437989748686, -0.06857806018965108, 0.06607612459602104, -0.9131236473455625, -1.0442085169946873, -1.233234778722107, -1.0375579848574197, -0.875667164385955, -0.4252908127310068, -0.5736441934526278, -0.11872989369212948, -0.34061609985279084, -1.5312501832217145, 0.17129469135945763, -1.4299112549602597, -0.0520378501105676, -0.5734692850158516, -0.22368727744863526, 0.5942250984007226, 0.5526376543978191, 0.821942036838839, -1.3883631080566545, -0.32694420872639707, -1.5414030168218302, -0.7593467085530764, -0.08173975324225834, 0.08619497803229123, -1.082201688982775, -1.2559781302033801, 0.24377028582816854, -0.5075892597485194, -0.541811814511735, -0.8760372882692448, -0.21584873955892217, 0.8218685468024133, -0.5999982165627756, -0.76497097066039, -1.0697896748342666, -1.035832729555649, -1.2040978424339859, 1.1416063645814472},
    {-0.2975723777395083, 0.09536741026646221, 0.08941358095837239, -1.4167041224855992, -0.7604979029824191, -0.6714682699916169, -0.08050852342665404, 0.011904534238131578, 0.25823202233680276, 1.0865182838393552, 0.27941985447122336, 0.5227551291324439, 0.7332549241239134, 0.09471508700093965, -0.698746605552471, -0.3744198752784796, -1.2330692327179065, -0.6447087724709888, -0.011773548696085627, 0.05477240924891429, 0.5997022405635501, 0.7067548817138302, 0.8030118205903813, -1.3686720717913397, -1.291059504548226, 0.44191248194530103, 0.5723188549390203, -0.907988310926827, 0.7150294422106623, 0.7957069540499211, 0.5652158744666086, 0.368917835667301, -0.06719607022137059, 0.10650589697580172, 0.11536031402529417, 0.1895940578140021, -1.339270980677885, -1.456144773951049, -0.7476608065141482, -0.7313438935683572, -0.5396175461555132, -0.2615867874590394, -0.5028597624509674, -0.7164865486645275, -0.427453510976643, -0.482871924526783, -1.407595223875127, -1.5573063745801219, -0.24752485367297553, 0.21970159506418568, -0.41007335492452274, -1.5029723835985376, -0.9559688147527013, -1.3698410270454633, -0.9939494897962563, -0.35423008611577844, -0.14291619496043748, 0.3769424618735976, 0.8325450306869007, 0.7253564009652413, -0.5108791053655215, 0.2807860303900314, -0.9728152395942984, 1.0506825408444425},
    {-1.5078620853801936, 0.37056172484479843, -0.043618865709986084, -0.07874798016704694, -0.4957300264926041, -0.9779019008389401, 0.017697827479007066, -0.0032717075781290394, -0.5385478502479033, 0.7334570023830974, -0.5041082080961726, 0.4469310482398703, 0.15775728555710322, 0.6424849556944344, 0.0666630422033165, -0.3936017294982185, 0.2277185987675612, 0.9915889412522874, -0.02322516714427501, -1.6067416173267275, -0.5924952517428274, 0.9511072938635406, -0.7341871962110796, -1.4168862384392307, -1.4518392842263852, 0.24709888560909635, -1.1712011994920628, -1.3630737429028028, -0.9162995270948284, -0.8186516967977382, -0.7461808536391069, -1.4316558780552973, -0.8891765821600053, -0.758396439137228, 0.29131016273055294, -1.0020023464991261, 0.22362482635860148, -0.6852246555023669, 0.09755799740140195, 1.1950637139461004, -1.3287377347410723, -1.1683325499361197, 0.22539154641731302, 0.6084710544745918, 0.20886680148781342, 0.0057300006169015575, -0.6649311364933871, 0.201066187031197, -0.15120556494430795, -0.051101574591280806, -0.2196963992331849, -1.3843166187082887, 0.2869900274887655, -0.5663450603509891, 0.6284045230061589, -1.1332092394645943, -0.7549326560839945, -0.4990407990472759, -0.4967548479042095, 0.6124821598781768, -0.35675446348537576, -0.6638960435258747, -0.31582304591569543, 0.41256019129309435},
    {-0.3862928701028851, -0.8384032788319743, 0.8551180550134618, -0.9347645153806688, 0.7459608524077874, 0.9119061848939041, -0.3029897063726769, -0.6468076543955481, -0.17188582559074989, -0.060699107908132245, 0.5211304616542025, -0.169023178847455, -1.0689431178952344, 0.90902457019466, -0.27072239357827993, -0.21413369341107938, 0.18788716234021058, 1.1939338123148315, -0.42843037848957616, -0.6151952440529365, 0.1355357176090001, 0.0750049956356284, 0.6913320603173496, 0.3709685740736792, 0.3031000687726258, -0.1584169291457194, -0.6503566213702591, -1.2270113264991351, -0.9492846579692974, 1.2766523567825943, -0.9271084896864233, 0.44904565550511416, -0.34120480980822504, -0.8689461551430132, -0.7547461740209425, 0.8038168552697055, 0.1382962635715928, -0.9575231571776569, 0.30309764595932287, 0.8480506760721847, -0.21315379845710652, 1.0516069065634748, -0.3951673328911853, 0.9493646456381317, 1.052126452440191, 0.934179408553248, 0.4368396365848578, 0.14058834698647787, 0.06669359206667361, -0.6434403285455371, 0.9388742938932655, -1.4315881409974558, 0.6520378824926437, -0.3058186612557295, -1.01228493273309, -1.1236834791124386, -0.08239408006297218, 0.26112999714001645, -0.34331610558866443, -0.6691025552059091, -0.18494819535001394, 0.2648801506287857, 0.6208998807210598, 0.48641578010364656},
    {0.7324694485890639, -0.893312128890342, 0.8532664192336432, -0.5776181219406848, 0.12280907235215294, 0.8891457444929791, 0.16578562984990888, 0.2567268651900405, -1.2324385606253663, 0.8147699348065768, -0.6966354642977027, -0.25356207235133427, 0.40856468264152723, 0.2937997898573356, -1.1548131731914915, -0.2852850811036802, 0.910821847252235, 0.017968957064516247, 0.6974077398663119, -0.19546593174663515, -1.1279646365254765, 0.6273394337298243, 0.3161613819686022, 1.1222104934187929, 1.134724358487645, 0.1371961430150127, 0.16120260528037847, -0.361207816467166, 0.6574335173534616, -0.5759794725813385, 0.5314246441710336, 0.2254759811917851, -0.696746295315449, 0.37811462056314415, 0.06755274673239801, -0.14259853719158536, -0.029302044442419316, -0.5631204946898896, 0.7683361647276921, 1.1524405585578341, -0.5324977276173619, -0.7329471747320861, 1.364493425343, -0.1447104901511625, 0.6644364421287636, -0.6026402524541045, 0.8566646872336943, 0.022787532334081373, -0.49504318404124176, 1.3800984061589017, 0.6148459704471558, -0.04638733599525505, 0.8416032510428945, 0.22790509669996833, 0.24673944632584718, -1.1407160155177705, -0.38614423930911124, -0.49853544560494695, -0.73549748783741, -0.6541095348987871, -0.07174827709534103, -1.079609508756425, 0.044865306484234584, -0.2695768940617557},
    {1.4355302287010667, -0.8127832963567587, -0.9483487563884869, -0.14492876487770795, -0.016335939208126888, 0.8084802071942853, -0.5683973211694237, 1.3255580421025588, -1.2945558246930826, 0.3868316740436293, -0.30770983443021965, -0.8304369748972786, 0.5392820372900816, 0.47494538929543295, 0.37550651105076294, 0.4899295832756062, -0.6128680500825557, 0.1695062611117012, 0.45447855196509795, 0.701734431757186, -0.8540375080360358, 0.03727762589866506, 0.7508275195748941, -0.5747781488137143, -0.06402381403538854, -0.713149037062731, 0.6684521183924943, -0.42132783652997785, 0.8257415130523053, -0.022394576114240627, -0.9588393702464533, 1.4552811149500389, 0.7251571522162115, -0.39695078663529054, 0.4703371666805815, -1.5152128169569306, -0.7061275092012003, 0.03437809779665246, 1.0901654157944736, -0.12310633460970402, 1.0787978452567015, -0.2192718490171618, 1.4728169619524605, 1.4392331376158374, -0.5972582752990979, -0.34463605269306885, 0.30165203998633316, -0.5014738511110091, 0.2968044126557331, -0.10713758243115604, -0.2296563064688509, -0.5988982228670103, 0.6089950167328106, -0.6560446661356313, -0.8983419667087423, -0.7749866198769119, 0.36653167676175147, 0.30010796591049577, 0.6714263171386261, -0.0719945110564071, 0.4194515662782763, -0.8364555051762365, -0.19779875563022173, 1.3086730830236346},
    {1.2323188446871658, -0.8206275270175338, -0.5981520406677995, 1.0823568948794677, -0.6684432213716525, 0.7054629491853337, 0.6168769023309807, 1.0022319937250324, -0.1196407047828169, 0.130796640277709, -0.508557204573001, 0.7848308350660365, 0.8239629165960108, 1.1755366330968768, -0.6326366587290334, 0.25723926683658505, -0.764815710659303, 1.1071841944051715, -0.5215847743098658, -0.9743420953040404, -0.7802576664291175, -0.34830967916671174, -0.14715058206202733, 1.4287677469397262, -0.3534039712238104, 0.34609323142019943, -0.7292487230657922, -0.7342150256697911, 0.8055480123273286, 0.8588272396874972, -0.4517649731589359, 1.0643434674855508, -0.29156192880735343, -0.5550058865909313, 1.619514035232644, -1.3689760555422887, -1.1840054795235566, 1.0052385944440054, 1.4003174715744409, 0.7654999033622529, 0.18947484044358123, -0.34976084344527125, 1.1776105409981452, -0.030279496114695388, 0.5173368453312736, -0.08004709590423328, 0.44295235986652454, -0.3146379650527603, 0.44579985328035276, 0.05929696023422909, -0.8928323935933674, 0.7676854568600636, -1.0326808545864696, 0.6806551488764715, -0.24768522594411782, -0.40747650021894266, 1.053837676312483, -0.3463662649179312, 0.9068107521004919, -0.6370751300903656, 0.16692967692799165, -0.8883275782055096, 0.7320042035313593, 1.160073014046193},
    {1.2726568428865928, 0.25307695464203606, 0.5051599847491391, 0.8945973402859037, 0.10437598208760109, 1.2673638313282074, 0.40140294166423707, -0.7374348998566898, -1.2753746122312113, 0.10645277983061818, 0.5926299833781148, -0.2346837616106161, 0.792876223735468, 1.0177107313287648, 0.4005223192400964, 1.2340252267485392, -0.6588510737445307, 0.3714680132746226, 1.0504810375662923, -0.4523922585105788, -0.41888571373285627, 0.14399155356497798, -1.1598518420644284, 1.0896639135796347, 0.04437667248168118, 0.7554561794836367, 0.9049747893803722, -0.3079186566698942, 0.05001118190885041, 0.8279095289585306, 0.1298369247338803, -0.7757879050316532, -0.9273884948139532, 0.05182956510572077, 0.42728072261533484, -0.38715759224455826, 0.4205826152829613, 0.8080254998790479, 0.11236652673971534, 1.3046418627466259, 0.255162454741679, -0.6926849436599213, -0.5705844490791685, -0.732562282012274, -0.9713875445258473, -0.3997310894446553, 0.452832375207525, 0.3754788449169665, -0.5828620706680196, 0.28923640904043857, -0.6053969332939787, -0.6475960203976361, -0.5229723091370929, 1.0218744207461496, -1.157348771353779, -1.3572601610227322, -0.3354925345312515, -0.917867867934859, -0.8220258985630761, -0.1916197819168529, 0.41390927028705266, -0.14904080794199667, 1.118407078288606, -0.006026247339052981},
    {-0.36875881935600047, -1.421778608189788, -0.9149385605503202, 0.07014708852241701, 0.2629939035378039, 0.5543427085158075, 0.6573597129991772, -0.4186089984092352, -0.8085939485232675, -0.34275698218363104, 0.0965672100843888, 0.12915155299532352, -0.30003761170946563, 1.2905981956084074, 0.6183231427090603, 0.4559788564367565, -0.9931190448026119, 1.1069613992944562, -0.10470823678277073, -0.36471396615362595, 0.34609424124172444, 0.07345256009186531, 0.3457796413140917, -0.4536306498481695, -0.08268043319031686, -0.37459054386664226, -0.9701321237882152, -0.3472651022570925, 0.35976507613767017, -0.2500605025266567, -0.7125258707485603, 0.2600292970639015, -0.4471083225239836, 0.09649283253191566, -0.5994718641374037, -0.6644114304620692, -0.8947935246967565, -0.46861513765488333, 0.6140659019773826, -0.03132236006584106, -0.36962361696758317, 0.8285514859168724, -0.6513479079325208, 0.9532487296194079, 0.7954239343086734, -0.4419601273876047, 1.447150007688031, -0.39063143727419475, -0.9194393204854588, -0.06122262652448502, 0.8877551322693445, -0.4020242798759408, -0.775900982791916, 1.1830288088192868, -0.4533096983437726, -0.9175041689648383, 0.06206400244795565, -0.9143785353977514, -0.47927338720421836, -1.0726293645753033, -0.5827822971853167, 0.16599741347662172, 0.3170881845441321, 0.8903866694908098},
    {0.23955427674376134, 0.006391521143724071, 0.44069696628567684, 0.10072836047593019, 0.16628609064999328, 0.22151589469918673, 0.4103507962438998, 1.116679086194757, -0.36571080560426206, 0.12613283046758658, -1.1236088392643115, -0.6256596249507796, 0.8059576121030653, 0.23183125582516356, 0.4287095826630581, -0.37216426567329053, -1.2960069302876167, -0.21645266893227869, 0.43995591164574516, -0.3919802735221682, 0.7731801056362184, -1.6715589273721299, -0.5100865101393834, 0.5584050840082206, -4.1091611197949575e-05, -1.0324057990381454, -0.21023952439518231, 0.10556356468252794, -0.7181247658017886, 0.5571787749595231, -0.3836512856354094, 0.5116378221781916, 1.2095856126216016, 0.7803851842873745, -0.1277570078862967, -1.3522917581130334, -1.2128823077794721, 0.745677376791941, 0.8527066120181342, -0.0929836883858182, 0.7037465190998354, -1.2710860210523784, 0.03881232392170841, -0.6750769277205912, 0.3047373131263235, -0.23174231134215553, -0.5589229795514561, -0.142787603028147, 0.5490758732833513, 0.06453012284019746, 1.3435053326914024, -1.0593762024026205, -1.0154324982503378, 1.049904514936979, 0.7019735406620141, -1.3356747162531803, 0.6826281784625035, 0.8925857606620778, 0.48660697835736355, -1.3646903344616228, 0.1323181020545773, 0.20598622935275085, -0.3746315941646196, -0.7591920820001483},
    {0.4794542652745491, 0.4629297739381313, -0.026935567031122223, 1.013312486524732, 0.3507278192125961, 0.3945396236026188, 0.18898555792528304, 0.6560627463267104, 0.599302092529951, -0.17229754193444127, -0.21762576626285213, -0.47486216910683643, -0.9457848535341304, -0.37498202718252127, -1.2987006450526108, -0.2905233853050106, -0.8067854625546368, 1.0624289357139305, -0.7267726853085708, 0.5710864834314929, 0.08395865973527611, -1.446728591249886, 0.500640994509145, -0.46853607789208424, 1.1280475356002047, -0.9859547875609799, -1.3857756714172442, -0.670918737513694, 0.6572384901694265, 1.092568839354474, -0.7262624175916049, 0.6744367600539973, 1.4502477318606555, -0.8280590250811916, 1.0764082372898705, -0.6739721991880585, -1.3344180854077345, 0.720113680284463, 0.7037487194902966, 1.2538564891114636, 0.10301744616882863, -1.1360908400698744, -0.7781856460524882, -0.3168529545120938, -0.3895070062900269, -0.20881603821301084, -0.025718000278474297, -0.938565015476035, -1.2070753143651114, 0.25514188381140823, 0.3819700089650055, -0.6368971149521392, -0.4431880451549087, 0.5577812269763873, 0.18522302842451943, -0.6197961809654733, 0.7639927327411339, 0.37729701150690936, -0.660391673234984, -0.35904089930830313, -0.7084146818810826, -1.3309365141407452, 0.9124981088509514, 0.7667442576048485},
    {0.698969124317674, 0.1982848859357731, -0.1404061028953637, -0.018955547803046893, 0.08470692098340525, -0.18978910092852855, 1.1908972381275167, 1.2733431475846517, 0.1258588004500833, 0.22490456047824148, 0.8612145107590157, -0.5879564804776137, -0.1252054616078499, 1.513205753070205, -1.364431713103753, 0.04426003942740992, -0.8382656544675309, 0.9859660839641439, -1.1156283159709384, -1.2354235451414541, -1.2500493589489852, -1.6780436806686185, -1.1942903666990783, -0.023237513951465998, -0.7246647108977595, -0.5267780082630975, -1.3161025471849142, -1.218446472657513, 0.15814295649961896, 0.7808559697421492, -0.5592978224263238, -0.6263343846939828, 1.1316699875447094, 0.708453450739095, -0.20049805496856318, -0.5618261557634987, -0.9061091025438825, -1.301138413473765, -0.04615970575892488, 0.10401280384083982, -0.31630295644873446, -0.394555136343536, 0.8740933417164075, 0.9426380215567396, -0.604132028618837, 0.6328504145987499, 0.22505739516660148, 0.654433756623046, -0.9389736611093596, -0.909463933843737, 0.5617050570423588, 0.7144501049980512, -0.18371497292264252, -0.8329909122496245, -0.9897850759562598, 0.14251400326639724, -1.0997308018349976, -0.6523998146759347, -0.9706540456925429, -0.5336187900587865, 1.182258079355224, -0.15545644740587597, -0.4957180592176862, -0.7670990709259446},
    {1.3710363476019, -1.3281900985842385, 0.647561984982737, 0.9654123571527765, 0.3995712750330415, 0.8559570440943898, 0.2342158525213479, 1.386457664496068, -1.2797844286504316, 0.3507857611623506, 0.14045290268756852, 0.7717965114264655, 0.6720176152680976, 0.15680502985104552, -0.009357395436273563, 0.23353446366457659, 0.17532903337141653, 0.9527820739292724, -0.933984120950212, -1.1041067709989838, 0.06509272840481199, -0.5781700141947599, -0.32981641138580353, 0.41115957393480973, -0.4145561141205208, -0.7767983530310476, -1.4029000231398432, -0.3391417639338605, -0.5658794119124857, 1.185319634449983, -0.8121246381731287, 0.7354550088754862, 0.7053721408912004, 0.2284177180581385, -0.4992413005848669, -1.2305187467889571, -0.14925013239066648, -1.2675854593090454, 0.618187673625142, 1.3862203164315836, 0.6964907043149225, 0.624656271691421, 1.3159003391445676, 0.4093998601835606, 0.6057912296972898, -0.6545169083603822, 1.1564875722927699, -0.27728754050052923, -1.0828430167559027, 0.8059469415915756, 0.6958011559539256, 0.3139883803099764, -0.6602886217718728, -0.9516323658985361, -0.10979210719891506, -0.36823271022991, -0.5493377750116333, -0.4322517435537585, 0.295347799150665, -1.1451924150944068, -0.19472083922602068, -0.15752767255701763, -0.3150296031246848, -0.7727527984903669},
    {0.881404659064864, -1.5259937972874191, -0.8020317728394444, 0.9476216468639913, -0.8188626239790808, 0.4722600400402849, 0.14399891229479395, 1.0906717630293543, -1.3276828951003279, -0.47838039086606293, 0.6740105313450094, 0.7193772528706706, 0.8740877580850438, 0.3309243200138736, -0.7438510485113123, 0.43584250111850276, -0.06780550893638125, -0.3343044939047653, -0.46499621891930626, -0.24965912632876522, -1.0508997738897579, -0.04773379087156568, 0.7457633221973553, 1.174095358056472, 0.8788642821989013, 0.6047101137439205, -0.0008711854914527761, -0.04469785268416045, 0.5328440928337954, 0.6735948779250778, -0.3935923272089642, 0.6377697474421643, 0.9797775385556001, 1.1343642800642189, 0.5201798330541753, -1.318256191294851, -0.8334718186719257, -0.4537898675877448, 1.0346783991221602, 1.1654278342183448, 0.3144758725145364, -0.5255275350135385, 0.13291046388784386, -0.051061456379084755, 1.0166979100112277, 0.6285149493281019, 1.1417057547594667, -0.22121358789299098, -1.4422624992768227, 0.5083918881701948, -0.5872168306934263, -1.0070457037310923, -0.05395284012242191, -0.25570055186538476, -0.8510158287103816, -1.2813725398601552, 0.14910024738584576, -0.41552600137794765, -0.608349173117574, -1.201180034540202, -0.4503771299874171, -0.2876101065765488, 0.7402250387475653, 0.25786709317716844},
    {-0.2564863131693171, 0.257768134409197, -0.24604535818169068, 0.7788782700510587, -0.17395200234787225, 0.8308259208558351, 0.15164033923553588, 1.1614753312153197, -0.4821906594349841, 0.1428170295701944, 0.21260683968779107, 0.9760567633723382, 0.8856534834786862, 0.3825292656347977, 0.15884146093725948, -0.5361994118231072, 0.11626008111302459, 1.2390256628277063, 1.1228973108988733, -0.885935558944093, -0.823222361048218, -0.7897249659142298, 0.15774045781751345, 0.042780256000319906, 0.3118002233541639, -1.010741596707558, 0.19608553219733804, 0.4900937371179142, 1.2492866359583814, -0.5776972293731417, 0.2606911343697146, 0.8066955715904492, 0.5091923465071234, 1.0471346123622793, 1.5538381339087233, 0.2746639942393159, 0.5917504346996563, -0.8055977219651552, 1.3756834837740546, -0.509720599811526, 0.5288277702281955, -0.5495153505254895, -0.6475670376168843, 0.32362718342080365, 0.42433867222576366, -0.38040286564553205, 1.6471971900917395, -0.610578846676441, -0.44974121810140777, 0.1919771341738353, 1.3288948954091715, -1.0557170714643678, -1.1601155959879494, 0.6321572140855989, -1.0447170309157916, -1.3134589430458778, -0.6138112293873065, 0.664752053407798, 0.9314402254894721, -1.2889831081329897, 0.878549955541091, -1.4893689399040029, -0.3633462940104937, -0.9545930355313073},
    {0.6447945139168019, -1.1242259148855853, -0.1300338667879559, -0.8558469256367147, -0.7711863761608826, 0.208597160725278, 1.5641870517528935, 1.0247694896455328, -1.0019852646954814, 1.0482758948734892, -0.0377598479878055, 0.6113222749141447, -0.08737307769372603, 0.5731796262740181, -0.01557340965378267, 0.9983589865869157, -0.3341001330377843, -0.32204038521178435, 0.36991185407239086, 0.14335189056385403, -0.22557859788954382, -0.6114578818054319, 0.3180573344726872, 1.1025906742195921, 0.6267874197952049, 0.9356943511954121, -0.9831602197299129, 0.6062119314532906, 1.0136464303166355, 0.9684867330072104, -0.91012678185722, -0.0920175678134063, 0.35953866567431036, -0.6280583064770892, 0.7485169935699801, 0.5544847624673526, -0.8435367688696699, -1.2514323715274507, -0.37513852688246185, 1.1808452632966755, -0.3065424551070752, -0.08745991325415652, -0.4619646759806706, 0.9099378297114237, 0.05281692196594523, -0.35629930102449264, 1.4633564325862072, -1.338444313568926, -0.9735837735330298, 0.28447361250191794, 1.2306196965346703, -0.3956598523346732, -0.0909610203819555, 0.9686326228529946, -0.7298071180249535, 0.15969542356305794, -1.0267367071562272, 0.8616123624851405, -0.055200913355133434, -1.046745148208336, 0.318857755902408, -1.1404755870432575, 0.19464600689776101, -0.16342998662994446},
    {1.3845372531262041, 0.3946673187869512, -0.9979923104185058, -0.08396781580197003, -0.008763272675941692, 0.3143679036134241, 0.4804655316959216, -0.04567349059612941, 0.262345229189399, 0.3998982128220315, 0.4724558346578355, -1.1535418087997067, -1.0695768738796914, -0.06170052401407777, -0.8629192582755817, 0.8187466942470729, -0.3400416327589702, 0.7937654827068812, -0.8329220383228767, 0.19653986895686662, -0.8865936918672055, -1.6906503949060203, -0.3212773299253623, -0.9384044759230571, 0.9327990383557687, -1.0214482472450161, -0.05955548141152864, 0.7429362377213241, 0.4015771723096054, -0.668284255167167, -0.7108373965125496, 0.8173245748835869, 0.7222196393229744, 0.21979612284573377, 1.3921876467915415, -1.382303606967481, 0.19494799066497873, -0.22535185136888575, -0.5152816764409568, -0.5626849422092252, -0.4661035678998316, -0.8263800887978849, 1.082639892764228, 0.5410672989577934, -0.1432142892850508, 0.007792445065958276, 0.6354851844991725, -1.0738034800130873, -0.7024709303764073, 0.8317781635872221, 1.1983936172130853, -0.3918236025710862, -1.056998239934258, 0.22701317026770085, -1.1904684424293792, -0.5731274111125505, 0.6322153217859536, -0.07336379652732224, -0.19465917729359491, -0.12839803631310356, 0.1798970393230018, -0.1456738364513725, -0.7207800336117189, -0.7803098899462099},
    {1.3900419546346978, 0.1833782464367017, 0.6734586313000845, -0.7669000803998819, -0.9692610873877302, 1.082156830848801, 1.4778197147753358, 1.0069191599161005, -0.7730029155724898, -0.21659069217997703, 0.38116830764851584, -0.1985512967148943, 0.7164244815895353, 0.4136509674213669, -1.2193461863784232, 0.6024246127250603, -0.7691539738972444, -0.005812185582015028, -0.57972007894406, -0.05498689404684133, -0.41936347617542724, -0.9557254278413901, -0.3640257180105804, -0.6904531732159443, 1.3211174791798455, 1.0811289863873061, 0.5917124219876193, -0.7885282609299574, 0.3974307442947988, 0.6880504419521828, 0.6692238379524573, -0.03635295177166164, -0.0397965481057684, 0.008971363225537226, 0.4237464189755094, 0.5933095592329429, -1.3479819026775106, -0.6699997402247404, 0.41894371259513413, -0.5075175823136621, 1.1132803582782547, -0.6986319605478011, 0.8277621987495013, 0.37333178126606764, 0.9673819090179016, 1.0059587717440825, -0.33807706321614694, -1.2715731252507905, -0.7475016378736139, 0.44811057325412235, -0.6417453658020922, -0.8681781565798297, -0.031822264814652494, 1.2394825929928592, 0.605693664552143, -1.318004758419029, -0.08069314499781982, 0.5074837297014565, -0.3047087701152376, -1.4402377506442423, -0.15989943441861643, -0.6438930694489986, 0.6534779897684465, -0.8383733687875216},
    {0.5920004630574895, -0.7443365094023356, 1.1238785725231286, 0.9084296839344744, 0.4817892917100663, 0.19716430345488942, 1.0881266202538324, 0.9412113543794273, -0.3111229180224139, -0.14029407533536656, 0.9864924057074476, 0.08032852492821524, 0.15155630262882958, 1.6563332487648854, 0.7576751130990194, 0.129601642522942, -1.0808430733394747, 0.005366862863856773, -0.10500538767118488, 0.7909247822188079, -0.5477096587856765, -0.28083759035161104, -0.01627651466529094, -0.8554284541874162, -0.23934196080979084, 0.4968988822261343, 0.28107932592535617, 0.44771495767875247, -0.18335800243319747, -0.18746738299311544, -1.2329770284403379, 0.4314950186115345, -0.8779550556544422, -0.8085759962548469, 1.617249073071288, -0.7267778136775499, -0.17889251798246697, -0.9706488061453001, 0.14451178997828298, 0.9724115328810902, 0.4431937928806967, -0.056478911610613344, -0.3665315085197554, 1.4706647973257643, 1.0793725321251213, 1.2725629669071556, -0.46904411278933555, 0.9705431541092377, 0.4721543493614985, 0.6133737701669305, -0.6926445677194775, -0.38626481782906563, -0.5116775493011962, -0.17402305242104646, -0.8868159390836617, 0.7586183144458133, -0.5263940124457087, -0.19307695792384022, 0.14140577052884876, 0.765549194882965, 1.267056650385039, 0.20273682575360946, -0.7651921993618654, 1.1603919785827557},
    {1.0194788708925666, -0.33238228974457856, 1.2944036608553304, -0.29309980260864854, 0.8051949549701155, 0.04536742472288413, 1.3742040593926186, 1.130336757393071, -1.4154164396145081, -0.7416900681011853, 0.6404213926208571, 0.09434919914296146, -0.7309666489907057, 0.10000976417900553, 0.09932413418110146, 0.9404754472840409, -1.4103740695928153, -0.06773054332768784, -0.3278937081092274, 0.47131387209959436, -0.6976401436516244, 0.7010159872388477, 0.3473041608987921, -0.5543624651827049, 1.2126483928833875, -0.2756560142240871, 0.41526160878964624, 0.26976631424269615, -0.8172588862939356, 0.7877512532113566, 0.4734591484629736, 0.32287960562007734, -0.9307292012956233, 0.2570668674248684, 0.20157765725390436, -0.9692157476867699, -0.29506773481596477, -1.107005600086233, 0.05706685777139986, 1.1495023664619513, 1.1261654105311085, 0.6638386778963702, 0.15963509143032295, 1.6270944453156835, 0.49650087083113603, 1.0380559206834707, -0.5076312316743056, -0.058018851259327216, -1.2898324493270512, 0.2542747162686334, 1.1754336455214205, -0.5263524208232213, 0.735106367749636, 0.48836082767344763, 0.5088385756528815, 0.7390183377899756, 0.09775365431912307, 0.19839817206539803, -0.5875080658476003, -0.2866063895163577, 1.3706857053317665, 0.012653662505413806, -0.8641614918841908, -0.8535595052438095},
    {1.0035311448194364, -0.7813236521632665, 0.7150526999951698, 0.5541323469608659, 0.545476364780117, 0.9215505531851205, 0.18817060289031642, 0.15447457204650852, 0.48258305056672446, 0.2499088452461948, 0.2514630950991554, -0.1341589941443885, -0.4842561200652531, -0.5787299973044073, -0.17356365211141048, 1.0010326597380752, -0.47821666221334297, 0.7328568369097848, -0.21548194318685904, -0.8561617048313621, -0.5816653693672736, 0.4227004023502015, -0.42050360663448166, 0.7233283924347592, 1.319226700314855, 0.9174344479865564, -0.3877284484067218, 0.34553421923369165, 1.2305283342171829, 0.7410180272882657, -1.253240258316416, -0.11994699636032578, -0.10360553614102926, -0.6710432271264926, 1.3087112937584626, 0.4566383052343031, -0.7003199220794171, 0.08067405417802198, 0.727708548980708, 1.2900586999062333, 0.6865534722122477, 0.40445116485452215, 0.19963449882550652, 1.3395933643173368, 0.450931547852225, -0.36744632927690196, 0.45477477191828125, -0.4201680769592056, -1.2640720548084603, -0.44730565777517906, 0.9383836197659952, -0.34033549153108716, -0.06861935509148072, 1.0240671081341075, -0.6062044510756507, -1.3228988650892652, 0.6884421931030953, 0.40173741511277616, -0.1611275714665128, 0.12136572819661351, 1.5262516493904184, -0.45846102249093373, 1.0679965250458254, 0.5973665725007768},
    {0.9477354880367297, -0.8503504417257777, 0.5145657711078157, 0.7422727611288462, 0.7842340189325472, 0.43313920716248105, -0.04914831964575432, 1.1848135190269387, -0.912900618662981, 1.0542691880930468, 0.353742078220102, -0.9004224321730826, 0.1822803569201012, 1.1558795635720371, 0.5894855846360896, -0.007716632115860588, -0.13298118075756793, -0.7104288043312096, -1.1514292729769335, 0.09950159070885073, -1.2038986192910552, -1.6400035378735232, -0.45465796341351655, -0.09891040881733974, -0.29194374255967603, -0.2775685724756677, -1.1500779073538892, -0.9829801189589643, 0.9022323134866841, -0.007406872312744009, -1.0100039670317595, -0.6340757999892381, 0.6768364493648683, -0.7241253977035229, 0.9313749882141199, -0.10891841639281596, -0.7481400968373044, -0.6612710814769167, -0.20988450100279435, 1.3740339715070653, 1.0897519549600139, 0.4644969483967273, 0.581607027385293, -0.5723187447795481, 0.3303335284435025, 0.13657730306000188, 0.49008096492740294, 0.3332306230767248, 0.6237272084607864, 0.23373815372346504, -0.7558102232966432, 0.18079654005185253, 0.029131305933499694, -0.16822515329632687, -0.3945662330468141, -1.341953717632212, -0.8220983598257878, 0.4074497679940377, -0.6407512038298571, 0.3907793877686634, 1.3497971285389192, -1.4164455559971636, 0.0968763771035736, 0.4979228719685833},
    {1.366308278680362, -1.3123029620363427, 1.1556128940372958, -0.6707895441867888, -0.7102195927812336, 0.5089087158638546, 1.5515939965699366, 0.3588673217002044, -1.2045433093190658, 1.2113662514395194, 0.29612782814879535, -0.7426729492994824, 0.8501778894502855, 0.9581982775598008, -0.728716281770852, 0.1309038177791978, 0.10693331302940554, -0.735240478527298, -0.3491675035585435, 0.9259097073317729, -1.1373536774700856, -1.2677200237719564, -0.5358812314553649, 0.0798209612536421, 1.2946662535251818, 0.528271575773482, 0.5478554241433559, 0.4379510142272118, 0.7142576946302548, -0.003973320926298523, 0.05526242956137973, -0.7985392921943222, -0.6639330207152698, 0.15498511024799758, 0.8354468693206758, 0.25040828207040616, 0.019685687332208872, -1.2225899114600818, 0.6348801220481293, 1.221352755766812, 0.1564636210248957, -0.030373574091512947, -0.4888463983167317, 1.0073564183256167, 0.9183240990192085, 0.502958155113844, 1.3467310516789093, 0.42452744416851435, 0.717407163698958, 1.0436142894447702, -0.14263098963391363, -0.1276489410693345, 0.6886052080307186, 1.1806763544640542, -1.296852197870282, 0.7313119715686592, 1.0581734764883386, -0.5663241784695012, 0.8720741732243031, -0.24204098283602477, 0.9265026656800095, -0.5207567295893096, -0.9839749132944507, -0.6832767913369245},
    {-0.11018193509396898, -1.0068160529637324, 0.517421389965428, -0.37425015690132163, -0.10548946778274028, 0.1710939604913323, 0.2498222226405946, -0.06209858327962017, 0.8179937617151836, -0.13146237301413968, -0.7155267124918374, -1.3390119308814024, -0.8510540307955009, 0.6027795655679835, -1.1962566954234157, 1.2563317020484388, 0.5094734273926246, 0.9632643147838046, 0.9086644669007031, -0.04958095020070524, -0.7422119525527712, -1.2116979244415522, -1.1731227991104531, 1.2688867787706182, 0.5918099784980203, -0.24447359068052224, -0.18801276315970655, -0.7402480464973059, 0.45773092767311396, -0.06402051519542663, -0.6585576206360916, -0.5723529415273068, -0.1192083037743481, 0.9173024991709847, 1.53033101698026, -1.1098870204204379, 0.4118561733244991, -0.5830503803553707, 1.5086626336372433, 0.36570127320210644, 0.10246679386779903, -0.6453531181802481, -0.6025952344865061, 1.4982888385562994, -0.49240088689929234, 0.580673914303329, 1.5898358070730834, 0.8131436811722639, -0.801185687811083, 1.007179682002371, -0.27586109807731923, -0.3782815959664663, -0.02906227420983686, 0.3729362815455556, -0.24133675946818658, -0.8190762566180166, -0.5764707788572471, 0.3564421021731461, -0.10133516079676924, 0.34149723729208453, -0.3889648480315762, 0.04058118462396074, -0.28045916145353905, -0.5105632692435006},
    {0.4615280029518066, -0.8779509208387585, 0.9966792477267853, -0.7661730302573032, -0.1054873776556469, 0.37163068626729606, 0.5201982124067647, -0.5881052171448262, 0.8704346792543889, -0.3577051223148589, 0.5937885490551529, -1.0242051172910092, -1.1375464268679842, 1.351912721245336, -0.05388607230777875, 0.7095551619824292, 0.19820087557470845, 0.6641155516533407, -0.5887917554480233, 0.7846214427002611, 0.31388928455438037, -0.47726532604408917, -0.8639459414778563, 0.40685414116985713, 1.1753116554853, 0.9280030673133675, 0.13967277442143095, -1.235946290155426, -0.1068184191924463, -0.6300376048332094, 0.08489309883098102, 0.1400716189050434, 0.33886659812593745, 0.7294892985860374, 1.4193077017614715, 0.13424666925509326, -1.0060803001576037, -0.8511860501480544, 0.8244347708446842, 0.7187641481374965, -0.5227864297730503, 0.7579119785552323, 1.0101851998610292, 1.393428982752617, 0.01304856926933399, -0.010974208255157788, 0.35703231321182716, -0.9607271254833373, 0.3552982123998303, 0.1258272367326264, 0.8229505575051422, -0.8565360869054981, -0.9993103773817985, 0.9756137837988352, 0.7630025177864088, 0.8698215699113593, 0.0033288890210242915, 0.6138695229545577, 0.14637460978705452, 0.07509182518255271, 0.44479219768415934, -0.610936409877871, 0.3167312520473963, 0.6342133404298337},
    {1.545209628401316, -0.5726667431922844, -0.42502706548477276, -0.09352898884333213, 0.9629333304876803, -0.7724679122177867, -0.0984677425800947, 0.1735917295189943, 0.7419633187313696, -0.8448188262245038, -0.07602167581041479, -0.3901953553761226, -0.23060514618976044, 1.593146783087968, -0.7487397681882324, 0.8483571373141292, -1.327552871181728, 0.724613297716853, 0.9871894821507431, -0.2722411221345341, -0.15688771859927128, -1.536904628678508, -0.06727877442822289, 1.0892933948969452, 0.3932469919772554, 0.8606620992573137, -0.7531423598034851, 0.4983781856821028, -0.6160980328991347, 0.24243879118374054, -0.40916899981242827, 0.893448451805108, 0.9580738751162141, 1.3355446610199433, 1.2695293314275473, -0.14055915516790207, -0.8820704003957646, -1.0867073619659966, -0.26264930631881706, -0.0219279238711657, 0.8194218690130182, 0.9993474223870987, 0.4462459381167577, -0.1618426084923485, 0.7356149745087714, 0.7120685546725534, 1.5224186789660281, 0.7943775782572742, 0.03863933278320975, -0.6082436061147046, -0.8039042473248037, -0.5896684482807053, -0.3152231678182698, -0.7577365308884706, -0.7473589532860627, 0.09304167362475853, 0.8246167227029348, -0.5998945704199865, 0.8385827969351375, 0.3923018717646882, 1.192951084435039, -1.458835685622039, -0.5734072277423754, -0.6007846397596718},
    {0.5414896683056074, -0.5652349031917864, 0.4368467807309565, 0.6508602512405318, -0.32063574375516973, 0.37795087877955763, 0.6257285430601908, -0.6718938202587547, -0.5943221901501303, -0.7083565562591095, 0.07661403877259897, 0.07536385296679016, -0.4580054201571782, 0.29018604301191037, -0.6459026597524591, 0.5261902986663516, -1.3316327246276725, 0.26001459057702253, -0.42832244645253115, 0.22694548575021925, -0.5637585942986194, -1.2425486239479255, 0.2655912099322056, 0.7066956167262936, -0.7013436929187405, 1.1918126482068652, -1.4287573399628917, -1.534311019953109, 0.42792190099861366, -0.38556041607119945, -1.010216599591603, 1.3614760767298275, 0.7537661705961378, 0.8458598967454021, 0.7064291602186277, -0.7904233450995028, -1.481018257277727, 0.26489981537130736, 0.8642578967142288, 0.3566347542930329, -0.6563105646525893, 0.17075995236574473, 1.1978060407954014, 0.6532229693097822, -1.0348519967793648, 1.412732716782751, 1.217406090145272, 0.09340066835088656, -1.2757538425166004, -0.5425678049191599, 0.8800588623281638, -1.5782893738130201, -0.853642072661521, 0.6754019343406207, -0.9639423461502129, -1.2389910697526978, -0.3090933728970472, 0.7186690115969456, -0.9192443560140356, -0.8927215437253523, 1.297817570365876, 0.19252464189416238, 0.14178773597651803, 0.9485068895649117},
    {-0.44156990093915355, -1.1895036212783714, 1.228500019117875, 0.009060489606581823, -0.7450125068243216, 0.7915424081952847, 1.196172808237048, 0.03287905916654006, -1.0760462835680606, 0.2790916758089289, 0.5783907127753837, -1.2505884384643118, 0.8154110193206117, 1.4340426738581307, -1.2075906467002273, 1.120648403140395, -0.5436480168453866, 1.125508349799195, -0.6428846293853341, -0.480463653266076, -0.056520184315719285, -0.8779537146896861, -1.110047647217696, -0.2590812218866491, 0.09342841250524357, 1.1844876631614285, 0.703215416831005, -0.7423972863220791, 0.7396897553935754, 0.8946606364685487, -1.0980441865878665, 1.3427884014901712, 1.0390120901817563, -0.16297804902283086, 1.703786012804464, 0.24090497671166328, -1.2366041624819908, 0.09038229374944963, -0.0004306401519797474, 0.9915609505125362, 0.6034809535861855, -0.4390688371735821, 0.3805788774083406, 0.2721543197919396, -1.1045238050935813, 0.3819535475570952, 1.1287090327266909, 0.5872595567502876, -1.124947732711845, -0.06632575854053575, -0.5243218539161855, -0.999156714524402, -0.929352576289216, -0.775604407080776, -0.8141907795570512, 0.18746171967126185, 0.8810412495759332, -0.5384011451276934, 0.26114107103705825, -1.2608502642824817, 1.4897949217190638, -0.3161657194272509, -0.7952549003563296, 1.0903984089375276},
    {1.6790319346343119, -1.7209519365094796, -0.48248224037755083, 0.9998818798053553, 0.9941926923676343, 0.3014390556301294, 0.25034927862516554, -0.8787396334529157, 0.45284761501579557, 0.4408738081526283, -0.24835528491877168, -0.8917726275939085, -0.4877926301127378, 0.5836085787710732, -1.1778537176775312, 0.1109170353960756, 0.47961000370096507, 0.08127494982923267, -0.12492360060262114, 0.758826218611617, -1.0842194265678702, -1.1394004277836574, -0.42264703262432146, 0.6598184057890066, 1.1589610176173542, -0.12222875311488475, 0.06375294881298711, -0.9741834536581038, 0.028344400819338436, 1.0648027340710502, -1.1064998969190485, 0.15403817325453428, 1.16823636531234, 0.584509517981682, 0.6516911065843036, -0.4243094751044999, -0.875890806959483, 0.15725435318253253, -0.03514765577009889, 0.32389031298418686, 0.846451244153181, -0.9035030417248988, -0.1487745884510651, 0.3859618213643025, -0.32193059395435225, -0.11693020710464287, 1.0294938040461288, -0.18964533251198987, -1.1135941927974409, 1.1109808341483076, 0.332060640218536, -0.5885189682588482, -0.32690767825780515, 0.8845244460331706, 0.0032320912262745294, -0.6746681695353665, 0.585498428616158, -1.028613593999834, 0.1777627224875867, -0.3711932517177772, 0.12104823131541882, 0.33718725121970006, 0.07296557165967482, 0.30419665812629587},
    {0.7091105566763356, -0.8238820752769149, -0.11337452387168244, -0.03610541511295814, 0.5161961945046838, -0.43426221095416834, 1.618996466240144, -0.14207593706588453, -0.8170759314958621, -0.06029342049201423, -0.32723583692070013, -1.0312240665309145, -0.9731113345073376, 1.0958979679760192, 0.24501797950477086, 1.2131822952666451, -1.1021937599237854, 1.2521621108746892, 0.543504860433467, -0.6207111722878674, -0.10569873235219411, -1.043116485685093, -0.4184592704871665, -0.8446573456358196, -0.6921619457143993, -0.9137556828542082, -0.5193360370615705, -1.1256132252950082, 0.7343546562754392, 1.4422762335324824, -1.3930825927799682, 0.12116031364203586, 1.061968163497786, 1.1710937349693549, 1.245160008151483, -0.9863967872498454, 0.5651796322168647, -1.0286381787212666, 1.0804847948666143, 0.2238320683934652, 0.44767750489257313, -0.4953374503534761, 0.9694087280654762, 0.9643492704782182, -0.9374916048857117, 0.5351262355878361, 0.9982366139680583, -0.929781355051628, -0.8256031179138726, 0.36393691360677405, -0.4432201005813093, -0.9182960659893, -0.1987815913646478, 0.5319595583311898, 0.6073566901657724, -0.2870756674023122, 0.5624776927043226, -1.0597159977605946, -0.5885325398563287, 0.1402062771214399, 1.5259854372878927, -0.2573723201586907, 1.0130665331779303, 0.8442723837376425},
    {0.6469358332372196, -1.0651734670761621, 1.3131666990926312, 1.1726039112016573, 0.5910793097984264, -0.4532163982108104, 0.7206310852855244, -0.8823260485323651, -0.056048433856835514, 0.8514914900862687, -0.11056942961238571, -0.9349784818696617, 0.13227124406783597, 0.46163483738597283, -0.8686699590936849, 1.1629856252700956, -1.4864469189420841, 1.2842664654189426, 0.46188889598788857, -0.9029957413740777, 0.4404850297181701, -0.1261217154686963, -1.4663713386733421, -0.7595907898133286, 1.1098848306524909, 0.08495820161791491, -0.7756060305937884, -0.5696399595891818, -0.7377999824645461, 1.2774572176415513, -1.2280505790702398, 1.140877490387159, 0.6890970169126218, 0.6307258887292326, 0.7109557311461049, -0.8893629406389991, 0.4270774412323425, -1.200311822368666, 0.49460430920424137, 0.15054480394043343, 0.15038575980239657, 0.0037198471920736748, 1.22095286490794, 0.29372104011391204, -0.9207112521304892, 0.2161161188187382, 0.855337358501954, 0.33356918489399756, -0.16632047869301947, 1.133264428990842, -0.16621080677186578, -0.5045453195283384, -0.5713568502744775, -0.9015633963041189, -1.260709878128961, 0.28232885443739464, 0.6750190111318343, 0.2552053869136236, -0.7877560774032277, -1.2951812820708442, -0.16566043024428503, -0.9566056934609004, 1.003134018497309, 1.0790537457834117},
    {1.5120254436349456, -0.8187587248920211, 0.7109682421123505, 0.12022118788013239, 0.936250045356619, 0.16277822376900228, 1.3077916827417044, -0.30207860573165957, -1.4962951798524402, -0.02386264544819573, -0.24984758429956927, -0.24884813453491342, 0.5196819530146641, 0.2802235778323992, -1.4915496147052814, 1.0634218296356943, -1.589590467606927, -0.7942189565389461, -0.4350282340640464, 0.8473384659653272, -0.689123060297161, -1.161992814331004, -1.4227979055701223, 0.13243988885626462, 0.7231876813317754, 0.3699591092520884, -0.6343937324655923, -0.46575858398788356, 0.7110856263587907, 0.3946985820759913, 0.10046894309267024, 0.66451670715504, 0.20125215072255134, -0.36669377194379205, 0.1229102507283133, -0.7891094524253489, 0.5309967668453273, 0.21074125768256943, -0.5888397144261097, -0.3432652867709098, 0.8571935653955851, -0.033509601944118846, 0.6696244358721172, -0.12144419836165316, 0.45624838718532307, 0.8352639479130647, 0.5575732997915626, -0.6508996740980094, -1.2734910108992465, 1.1873650732770928, 0.790413882493507, -1.2449781500808974, -0.3635698463299126, -0.1946981485517981, -0.20466642754195505, -0.6312558972645361, 0.022953484297540683, -0.9581413651367844, -0.5267457308651053, -1.3676723608565944, 0.44614719449479145, -1.3716914032988243, 0.2537655810543835, -0.053898250684769965},
    {1.5351749043331397, -0.8698421282994216, 1.1283168456638302, 1.142701392034644, 0.5501690126879638, -0.1457358156956255, -0.3174573101557697, -0.523522288784638, -0.8233240457828556, 0.36618075099720754, -0.4073881846988294, -1.2267123003872118, -0.8153908318117077, 1.16701732298958, 0.09321918504376857, 1.2676714374553917, -0.8187715385775196, -0.4988732614317735, -0.3142965397672148, 0.8127746062428475, -1.3057648579336958, -0.37758556737967996, -0.3243417170392988, -0.4963824657217581, -0.5278503535070819, -0.07359890848142134, -1.1730880692766052, -0.31449322822508624, 0.41574713271140434, 0.28245683792616, 0.24505710123614827, 0.16511756979507766, 0.7419604927650445, 0.9458536692499242, 1.5998879202743668, -0.8256388211095902, 0.05099830597674384, -0.47333409319964476, -0.024246908800145784, 0.41181487627096375, -0.976887865860544, 0.817640373256752, -0.17730505230141036, 1.1132198003793505, -0.9808796496986902, -0.4714343937901585, 1.430269315082741, -0.031007000036995056, -0.3716907410648202, 0.04041736816039136, 1.1444801989443183, -0.2862440056259188, 0.5390053682333952, -0.15039888107286417, 0.3108264160168153, 0.1741990580784589, 0.8226466817603323, -0.4138343548768976, -0.43235531483409967, -0.8096580903251936, 0.6599001678933375, -0.4625313589885866, -0.7389060974069783, 1.150693812248384},
    {-0.4310752504768893, -0.7325451652051189, -0.5051031537229257, 0.8082997107008955, -0.3452948132897847, 0.9833996231042117, -0.390674812873879, 0.46781547884468977, 0.0852944730726558, -0.2935840500402189, 0.9042443451424371, -0.8938270352312178, -1.5462093652678977, -0.2671635540876093, 0.05421454018691448, 0.3320144124544272, 0.2575000362043265, -0.17223662785588786, -1.242333710666374, -1.4758171829390077, 0.5350434535651508, -0.32043018000861073, 0.627264330208193, -1.0539692338917854, -1.0682013707628175, 0.6781919334067649, -0.9260247390710308, 0.021041491560086875, 0.7864689254515872, -0.8024487147358017, -1.0006234957153812, -1.186978560730703, -0.3809179789894895, 0.11854369266572744, -0.8183054095402122, -0.3500438738465288, 0.31547300803810857, 0.6792552429299138, -0.5185288008385741, -0.5826942903849892, -1.4195930756513673, -0.041587007506648, 0.6456043823450802, -0.7156803693948873, 0.08475588849730044, -0.8858405213133749, 0.9039106029452658, -1.0431952634985966, 0.6672495535578451, 0.8931537339149628, 0.17613137224922965, 0.03420989471234179, -0.9452854323441687, -0.3086033379774271, 0.4659170955277457, -1.45760259480469, -0.2291371509043036, 0.2901067023916673, -0.6385389080686726, -0.5718899908148497, -1.1436056440758156, -1.5211790148885214, -0.8071140056972985, 1.3794184902636346},
    {0.5973374494663214, -1.1691658058969563, 0.33436744224765985, 0.4925109745894916, 0.8977819684450037, -0.06397782212876492, 1.0457613186990398, 1.0694553640661855, -0.009397600496331718, 0.8341419819480457, 0.7822069670096766, 0.4467449850346283, -0.23774953867750379, 0.01532105815242667, 0.6327195945710645, -1.2575544641112504, 0.6714322147177851, 0.7856182742997407, 0.17053334791153685, -1.2936010536306202, -0.8183309313898212, 0.7900986616344693, 1.033203250713306, -1.1286836774329991, -1.1343224396954081, -0.026858705806470394, -0.7139031651876969, 0.19496145257889355, 1.226825553382979, 1.0041296007206055, -0.9206141415281437, 1.0204902810605576, -0.42713812635269693, 1.2354939252261767, 0.7040662773243614, 0.2882775881042643, 0.13933453326917025, 0.323410141710204, -0.7522060761014581, 0.7274774614554356, -0.8226452501869637, -0.26055551583954994, -0.19751380570601318, 0.32898897584751113, -0.043226661273932654, -0.6785381665571626, -0.6876778516333629, 0.7170226776251668, 0.22841137506084908, 0.32835168615139254, 0.591480954487959, 0.1676579483174327, 0.45232933176056733, -1.2720888531169505, -0.8519239750696418, 0.33422900507576475, -1.172974509437785, 0.15722408776292038, -0.11642471582904076, -1.0731250821255751, -1.0500499001969354, -0.44965974663640174, 0.6146060996804102, -0.07709697978451217},
    {-1.0968597239954152, -1.157006089320552, -0.06205789006675551, -0.8539269026103581, 0.8077203969976904, -0.0203661455793044, -0.055188480922645305, -0.20626971058919816, -0.6134688029455811, -0.7048539205334435, -0.8810347764388438, -0.4685078811252835, 0.2636293087265052, 0.7686547638536, 0.10667916918767681, -1.2432912218890104, -0.9069839058850155, 0.5143883512893472, 0.03547224738354276, -0.11881822899948773, -0.33250833914158545, 0.5233965005273714, 0.8893672876957852, -1.476572947776578, -1.0693799259835073, 0.20925833204407493, 0.1445406430338115, -0.39817533805849187, 1.037666750999506, 0.7943653280005863, -0.7319480622217946, -0.6674450945743893, 0.6977469430959689, 1.0045300440856786, 0.07680134679174265, -0.8249310964085571, -0.9345361020089531, 0.307405992607527, -0.42068860302713984, -0.050286865928091964, -1.182401187874336, -0.7254872678636345, -0.967133399024283, 0.7339706371451529, -0.22318211268181132, -1.5670653809542383, -0.37531362842202465, 0.047222759111816816, 0.6975464051165676, 0.49619915045184165, 0.06377306274955477, -0.18834042499905862, 0.1791453247188172, -0.21126971737492292, -0.5268718244656119, -1.0726892820303624, -1.269713479656741, -0.13821934181226528, 0.05857128074006874, -0.1956988226322553, 0.6784419783805801, 0.603575918872077, 0.6741353759137605, -0.035786428019986695},
    {-0.37199998448475424, -1.3012390639158953, -0.30389846227065376, -0.9064361821031269, 0.6941977665578428, -0.41595691457038214, 0.04370674677353986, -0.5335908965541337, -0.7539554161104474, -0.19110710918630033, 0.4050073242752717, -0.8688591740165479, -1.1627802180883433, 0.17364552938722605, -1.225440069227024, -0.18596831022976504, -1.0875759677301509, -0.6377949822301975, 0.20599541415656503, -0.7524462388624635, 0.2399077509145188, -1.3403225721659664, 0.5424124467994853, -0.7498787911585044, -1.11261947128006, -1.0380205708630577, -1.0676512334590778, -0.5784562087191917, -0.9198121119217378, 0.4127297389782389, -0.4567986877902277, -0.2516323681546218, -0.7176354568121968, 0.8307949011874545, -0.22108747251538477, -0.8255532939055844, -0.24033194058385324, -0.12161243115257428, -1.2543661783982563, -0.6358506506502766, -0.3435818559946014, -0.5857312505034284, 0.8052110356309332, 0.4740716130650045, -0.9345557166479145, 0.33950143558430085, -0.9018097601538605, 0.609252425027357, 0.5750436726408245, 0.9051756571442665, 0.36390489416602495, -1.5802499687497478, -0.2356737808779189, 0.04733568143910289, 0.7708381947900663, -0.7452196289484934, 0.7760242374459683, 0.980697711196942, -0.7973957526961264, 0.8105522160367602, -0.5040692367557994, -0.457714418559271, -0.9176006189720523, 0.6261437006866587},
    {-0.8371377284791282, 0.4204535771138446, -0.5319367297505145, -1.3725775420180693, 0.6163654959188323, -0.5275894072563346, -0.4701451953719105, -0.6790732277059155, -0.673464235911912, -0.844451428648329, -0.3609681057859589, -0.1965904401704432, 0.3973168546618479, -1.341702671504642, -0.28754987032953, -0.5672733092889356, -0.7004242765737791, -0.036378868457863284, -1.4269745091882673, 0.05351337071351643, -0.34087987187753716, -0.1807632841017912, -0.17458442189219153, -0.5152438295349636, 0.4226901348383617, -1.218213790704083, 0.07831227141556046, 0.5081460735192093, -1.2648877950599278, -0.8342472002077076, -1.1812517607803066, -0.7707629277192756, 0.5821415129389407, -0.8297464609781477, -0.237720790469626, -1.4953422216198067, 0.010445140286213022, -0.8272933403083783, -0.9690915442194171, 0.5517705670245592, -0.616366546108436, 0.3220568139982947, -0.6321125152259874, -1.4185053584147511, 0.22160585253791254, -0.047281860274179396, -1.3530758973352408, 0.760554742412708, -1.164624486375384, -0.43985679642293457, -1.450983156241572, -0.7664339919281096, -0.19778922662526577, -0.9933794617947284, -0.9351648582714699, -0.23135724414465894, 0.3208803850958671, -0.8634572255922252, 0.32115798119192857, 0.0536861682622616, 0.24564728944625494, 0.7313846093011912, -1.266262057010529, -0.1747147441713504},
    {-0.841979672251776, -1.3116738407465591, -0.9578410496591568, -0.026952849471964198, -1.0941201246853085, 0.2350672445440626, 0.3138225588997023, -1.0701606990367056, -0.2995528100667932, 0.8052958107510146, 0.009815406563953532, 0.009112519359166746, -0.09943051220046142, -0.17269982320277943, 0.021119060028283804, -0.514775838207005, -1.4586666137674211, 0.9236660706041502, -0.48938483423283613, -0.3243204541889546, 0.25267917256848016, 0.5691366394913606, -0.9699563322884125, 0.0745065100591221, -0.23290476435808719, 0.32347664583788893, 0.47379846718350244, -1.029364997363302, 0.4805715004693544, -0.028878994234636676, -0.36990484969418275, 0.09566207422752172, 0.9115036754290671, 1.0938369733926676, 1.1140333254540242, 0.5014597681293719, 0.15877131711403952, 0.16634983816630058, -1.4299342137678444, 0.1777729881205985, 0.9119642941193027, 0.09791970711965405, -1.0555258165285208, 0.25506178105607213, 0.3404304752281349, 0.21125997524633155, -0.6361112618504262, -0.8247600154468047, 0.09103193629920399, -0.7761480584146593, 0.7414934797313594, -0.11102564047525826, -0.784697696843039, -0.7725366948235205, -0.18215999221691834, -0.20667842914995366, -0.3874342965030972, 0.3631271066223336, 0.06288217154038338, -0.8423660270577645, -0.17791124132200062, -0.19069369801911412, -1.399517507771999, -0.8765365358076024},
    {-0.9821605634433411, -0.6782068368442051, -0.28453677401215693, 0.4232143550369978, -0.7964004614391456, 0.12810110249299592, -0.7563477289057964, -1.1359178836194845, 0.2291205802200727, -0.860325246985003, -1.4839851255168914, -0.9201967780186882, -0.8273528290138984, 0.8059101208540702, -0.3970224799092001, 0.21691234702070755, -1.0881217041747484, 0.01243280010191559, -0.29550962160649014, -1.0828188439925794, -1.1579463841173783, -0.33617036115917337, 0.9305234176552193, -0.24775401552619658, -0.20436257219293205, 0.41808295791823763, -0.2719742537654817, -1.257764784926846, -0.006201834059917504, -0.38034469025401296, -1.5254744157185876, -0.9489586314160434, -0.8431452517351038, -0.9258685061137762, 0.2953494241218224, 0.1682539215670705, -1.2157764597705096, -0.3728581913625981, -0.05551969646694654, 0.3888687956919756, -0.9025597490853406, -0.6464594687491674, -0.6006598783198855, 0.6974209347350406, -0.055028201326409676, 0.09340040523086256, -1.44069551264685, -0.19276987754698663, 0.36136439081888494, -0.5300091040416849, -0.07819802847664084, -0.9079050077797206, -0.3541441688912955, 0.15973766136763823, -0.09794267124669438, 0.21471323335774978, 0.10390971552680767, -0.8063237145450975, 0.8080305995835295, -0.5062395043630278, -0.2204618346095271, -1.0697187951396794, -0.3442137550488538, 0.11980581611834194},
    {0.23005535332055635, -1.0420855563696805, 0.38716257318573044, 0.7495059727645549, 0.12540631059619645, 0.3848524358015537, 0.06981604449423594, -0.024102168127440295, 0.3723217413297661, 0.46052621067981153, 0.28800233434337763, -0.26137058702553695, -0.11947206335741128, -0.8925210157308265, -0.7588888488254576, -0.5818987638634231, -0.9053997912666827, 0.23673733913206516, -1.5251045040570461, -0.6118040123299827, -0.13819094175009197, -0.7584560187440721, -0.26595981067913554, -0.009456558857871807, -1.065254783062869, 0.5546359544910704, -1.164909289080315, -0.26041172221789893, -0.9130758940391503, 0.44702168057137914, -1.2929540305383076, 0.4360596685950429, -0.7630660763447058, 0.6547197083903251, 0.431847516529042, -1.1895584807453823, -0.048293104080184585, 0.6172605708167068, 0.0432827605559523, 0.7691981383045359, -0.03743991817014526, -0.4467780313034019, 0.5178747134517155, -1.0839953670575584, -1.1385015117123474, -0.3517958350527786, 0.18562321180434999, -0.6641169734784392, 0.0431465844205985, 0.050822949225213576, 0.7874518228012949, 0.42753228660956116, -0.8869930647681772, 0.12158966829833434, -0.31795957926662216, -0.6154209541342784, -0.14584250809042906, -0.768125812234565, -0.22979830162898987, 0.9594153146287152, -0.3098643926392729, 0.0617766049978622, -1.2098351117843733, 0.02679289207011597},
    {-0.11577345357102983, 0.24515360246375636, -1.0659595543930753, -1.2175075337144863, 0.3795566197149794, -1.160036362485278, -0.018779734184225096, 0.13814342130185564, 0.7958662603546364, 0.3716737115706727, 0.061600384196300206, 0.4906223285322081, -0.8109203023584948, -0.28771739587436285, 0.5993008129072734, -0.8450765941162036, 0.031972318826206214, 0.9736035720627124, -0.6655137584919417, 0.07943114553919305, -1.2159558796043743, -0.7103769924222425, 0.7460110812460926, 0.7484752572021205, 0.41637224714547894, -1.0967460848452169, -0.3652226502192566, -0.5992805990783665, -1.037628032741044, 0.6519361773927488, -0.3426584451145543, 0.595518407437964, -0.25927992172903996, -1.2422735760875254, -1.0940418571656785, -0.0283861906721256, -0.585784069007863, -0.6245935664036969, 0.8795104270378974, 0.20612752054637953, -0.11483586577832816, -0.9862713210781879, 0.7942864805091354, 0.217575589549577, -1.3732163451919055, -0.8220373468867438, -0.15735009089941915, -1.0692271167301879, 0.1172731366623575, 0.8207273386239962, 0.7937654193222833, -0.5956181973032353, 0.285480695417268, -1.367009301738805, 0.05096468630728645, -0.9893526575539981, -0.8649889453889757, 0.8888253989337848, 0.638570385443746, 0.10434727861109971, 0.07141408873969468, 0.7223468660646295, -1.0605403796792723, 1.1542513738183315},
    {0.6630132453322244, 0.30760085538790416, -0.6017661806627098, -0.7865250228077066, -0.43520330799140655, 0.25944974678940774, 0.3197096499033846, -0.9442895639905743, -0.35991424678777323, -0.5615769537737502, 0.23674602858806013, -1.0413090752395242, -0.39259542694072674, 0.5559495712775687, -1.0956314050315006, 0.11821154659496752, 0.25195992936348754, 0.6159588901542611, 0.12209681194338518, -1.364349956899313, 0.2707369860665489, -0.8396978681671927, 0.06812744868611618, -0.4769725084142262, -1.267182998897352, 0.05185642576371578, 0.6920255533121634, -0.8590906268095798, -1.1631243812430987, 0.3552630036629667, 0.8018514017575948, -0.3124736567637245, -0.18516148162947307, -0.46775179046646476, -0.057456517291957575, -0.05051763144514731, 0.900548549764028, -0.329138026969184, -0.3868380694104477, 0.814742027149521, 0.5031141536792314, 0.5848583643132753, 0.7422057685220574, -0.48330431683724306, -1.0712592669111756, -1.1240234813392833, 0.17967338949514078, 0.5097293826713781, -0.8553098434760943, -0.7703253680254636, 0.6814188250444537, -0.061855438491621825, -1.1260580963470184, -0.9942876708752252, -0.49869327119874673, -1.1838225678403338, -1.389392016656293, 0.603877567740501, -0.5792820092057249, 1.1142263971056978, 0.2358765612782377, -0.5258305607551385, -1.1092422144590335, 1.1982088796924717},
    {-0.9923962381244733, -1.1353644379224335, 0.04945641000629194, -0.670043105334172, -1.254653833129624, -0.7389104655423283, 0.313705533801707, -0.24576150733750124, -0.9827550108580209, -0.4587733468453744, -1.2716707579959274, -0.8079434212710792, 0.15886894848658062, -0.15179613477318607, -0.9052517359279937, 0.22328460756803287, 0.854669045906126, 0.9319733256945051, 0.3344975623688088, 0.33154836367650736, -0.5927701681816527, -0.6102843020462103, -1.0922134020442857, 0.2747795815748179, -0.34166028183663755, -1.396694281221925, -0.731857591701663, -1.485866812985959, -0.5150688256334274, -0.04828329887165956, -0.04822402132966196, -0.7009117931266987, 0.2275553704875067, 0.6553511614430901, -0.6883549641729921, 0.7144338253167628, 0.9010142993757712, -0.9432452912855545, 0.484779712279837, -0.9892942549554443, -1.2914523019121777, -1.0536976095951287, 0.6354769891891202, -0.2817456650088483, 0.8263013967140109, 0.745013103984501, -0.5457565700928999, -0.9889926931005802, 0.04136369829838843, -0.800286871589283, -0.9856996677812666, -0.32422308350835444, -0.7105955302017258, 0.6019757514057216, -0.37293410449555997, 0.022381477961508293, -0.8914611512666444, 0.7487217827021625, -0.566015552559529, 0.45393566539957336, 0.052440509111730135, 0.15527887118906522, 0.29431972106244825, 0.6443426542299383},
    {0.627868062400366, -1.2118356887027049, 0.48637158806373204, 0.21058677272465487, 0.9632358032605831, -0.5061296817707208, 0.22598246131438318, -0.2083794443136372, 0.6532707864973671, -0.7509400595367872, -0.7716647836601328, 0.9067691409237628, 0.08712500208744027, 0.8847174931037954, 0.047696475914308895, 0.5753799142872419, 0.17147999085901985, 0.4667984051981975, -0.9960108853980868, 0.20120956558461708, 0.9381220619489509, 0.8876364634359866, 0.6110581940576356, 0.30199966698989883, -0.02980228441327075, -1.068863712532142, 0.842749057181781, -1.2303781061541308, 0.43689465072214, -1.0611668257698197, -0.6481939891958891, 0.013863726831899457, 0.582781937156047, 0.16528610355859216, 0.8942560008408341, -0.3747923325274778, 0.6299275844057391, 0.19652801296157685, -0.8372308198361545, -0.8728088831498885, -0.8823919315626187, 0.34092377463108947, 0.942352176096665, -0.4837140681818324, -0.24169556224693528, -0.4755594537461909, -1.443130198425265, 0.6444962939277292, 0.4021270201736201, 0.7182610357165995, 0.5754386814575336, 0.08806375752749224, 0.046253138705581384, -1.1186704880500489, -0.9377622776948954, -0.6383407138922886, -1.008995457909948, -0.8744138416476902, -0.13559529023733055, -0.09093028777729247, -1.4205184015150614, 0.031459823198373836, -1.0211689087174265, -0.21411521572722497},
    {-1.2331040022588018, -0.6886480879525345, -1.4094834191110268, -0.3888327694303024, 0.45752629132722145, -1.0751290594714675, 0.37645725982163464, -0.9111442270068013, 0.09599404375934063, -0.34839076102780037, -0.7164726536101427, 0.6156350791595684, -0.6210457446708342, -0.7357616747049566, 0.03674625406664302, 0.6715201089778694, -0.1235682398860825, -0.9814683265747556, -0.5205014659093566, -0.9912012455668116, 0.21511380421168677, -0.7022422984292902, 0.3045875724300914, 0.5258473096457134, -0.4094865716940252, 0.4140397789351637, -0.3242042360210927, -0.7558351125969253, -0.11282251532092498, 0.04601227788329395, 0.16649560465303784, -0.9431039681445044, 0.524626514714177, 0.7282775493627178, -0.6091524514030144, -1.3701861074019221, 0.16972265486915755, 0.41412812258725085, -0.8525693464480845, 0.7423006800369085, 0.25429347419000253, 0.2430749426029851, 0.17837261329194587, 0.060942426782543545, 0.41083096307083866, -1.0009549656820558, -0.8348464014270532, 0.6835746476337853, -0.676484155829225, -0.6208073807524711, -0.43566863325026856, -0.7782757995716721, -1.3113078703942218, -1.3503211720606345, -1.008362805363715, -1.016127156366456, -0.9467007755889153, -0.18040900458453837, -0.382476270394683, 0.9666697506442641, 0.26812590960465355, -0.12973918266817272, 0.019705501943968085, -0.5292939004125222},
    {-1.1708421100078508, -0.32244431750894137, -0.18283046367298966, -0.6027854539429831, 0.11928774183764648, -0.6353728008727321, -1.23932768068855, -0.5621783923601282, -0.7709004873072318, -0.540644981836966, 0.5665153819636716, 0.6599682215652755, -0.5362911980528163, 0.42512827907861006, 0.7233641255239212, -0.6527404601172829, -0.3063943734513175, -0.7912660405318191, 0.33855528867109913, 0.5581982519716773, -0.5810240753395137, -0.7810276238881664, -0.6740422195181127, -0.199829224456776, 0.041297204188801846, -0.09608181874013037, -0.7804465879753275, 0.12887447621957285, 0.8781081169445609, -0.8637688792314894, 0.299316450126569, -0.787760256704335, 0.8793359252778177, 0.9276769987688277, 0.6730732696136752, -0.2770230715747819, -1.178003605019029, -0.606567760943137, -1.3812611762734244, 0.6937874409827633, -1.348123802409657, -0.09192548311832419, 0.9323718023900438, -0.6299818537560308, -1.421260726291358, -0.5024577492500208, -0.9534869164386182, -1.3299265646835912, 0.5479963822653076, -0.547178959097813, 0.619499852054769, -0.9896318455056825, -1.1001818240485186, -1.3336986910123132, 0.6693182224689224, -0.20440247191513428, -1.095116616544382, 0.5783097217967427, 0.26363347310404267, 0.17816108595545394, -0.4839592567465188, 0.3318143134712423, -1.0223108946719432, 0.6396544447693527},
    {-0.8085590466407264, 0.0014479442876768748, -0.7015771227099769, -0.8738546267836507, -1.1144980910962234, -1.1014342086668936, -0.15996083296363234, 0.6093376364662124, 0.42506245067138326, 1.089249405894234, -0.1724157709947519, -0.34745252460441134, 0.5126889424626426, -0.547120799462376, -0.9288171373740283, -1.2675011903241553, -0.6773521502515482, 0.6987656579379911, 0.8727416468129828, -0.8797302584058503, 0.25895504562601096, 0.8084492109846602, 0.1351072329740973, -0.9765445173318589, -0.10705891411699857, -0.8719318061064099, -1.203164035091467, -0.7343829094349488, 0.5868687940930261, 0.14406270478297573, -0.05986461924481336, -0.859694856770982, 0.0030088386541964104, -0.3215662713549995, 0.24754424967528474, 0.8180819461006434, 0.45782668257305814, 0.4951957057516544, -0.44088165513993144, 0.829362363967426, -0.35361671630926744, -0.10825996158875978, -0.3857560132469994, 0.5569964289897485, 0.7331244404478803, -0.8022899557364986, -1.1871127156813175, -1.6444907013735595, -0.6169166871149152, -0.7587071112628687, 0.48966115376270014, -0.27604777238501516, -0.1164498190992166, -0.13406532546518155, 0.834198905286654, -1.337134645097961, -0.06776528227778615, 0.3553797208322105, 0.36040947303653337, 0.46144887983252747, 0.17395233140054428, -0.7568370068861862, 0.5162894290410903, 0.9634315604564521},
    {-0.5667516844171181, -0.5837469557874001, 0.04471554679428791, 0.7376378659435001, -1.1958781560564176, -1.1317525454041941, -1.3915231127455592, -0.4120050971391114, -0.6542224594662537, 0.08275530423443306, -0.11829485180532817, -0.11278878904745564, -1.1282205534837655, -0.28031303339506797, -0.7091005962376198, -1.0041168552234576, 0.5990112815624627, 0.26088461230949267, 0.3334286097356671, -1.5775777240638493, -0.7051157656464478, 0.5329574274516835, 0.5764004680724584, 0.03439327756853532, -0.7655858404337479, 0.34107963019366705, -1.1955802184972886, -0.2671660884140428, -0.29914581371887633, -0.059391902600055065, -0.2897455108781001, -0.8625643248408574, -1.097909412507935, -0.6059095594221632, 0.5659816059441488, -0.3312393378528153, -1.0710548132738282, -0.011650204256428038, -1.108362846604698, -0.3430441458537833, -0.07852635483132821, -0.7472702287360314, -1.0688039198631312, -0.5296170255798467, -0.819044041609876, -0.2900572082061829, -0.8840698978376519, -0.5898202626066509, -0.5031677020729521, -0.042015566885805475, 0.5844415396070203, -0.5927063482349452, 0.31978802203990464, -0.1589655180631888, 0.1570360087103401, -0.8482996536573102, 0.3370880913975814, 0.6772563964417745, -0.0033551990567352364, 0.7997421196825408, -0.4357970822654324, -0.20135356124883083, -0.6517694386011704, -0.5094436958301376},
    {0.011267746629645062, -0.395590401135275, -0.5768816988786882, -0.7400770346798671, 0.7976180768455038, -0.08090524841249817, 0.7830930942630572, 0.666254102649979, 0.2222902491616795, 0.4225083854990978, -0.16082553255771034, 0.40118665706337725, -0.6251873079872633, 0.2882481967710673, -1.2821063332236615, 0.4630789369149391, -0.6545718862331235, 0.5187884872891578, -0.33776331465339215, -0.7767568691973509, 0.53694285355783, 0.0630841337272979, -0.6008230967614445, -0.4743650917864681, -1.4779069071292879, -0.014975852793555023, 0.10305661532854687, -0.350194630020233, 0.09102658139348392, 0.5166122390053745, 0.4109981596771532, -0.47932023710508337, -1.4498454822264724, -0.5038933790400164, -0.3035463667177557, -1.5072332115836524, -0.8888088653140566, 0.38679135794929276, 0.3191181221332494, 0.6705615076563869, 0.36775934265862115, -0.9350041280365168, 0.7552052591513548, 0.8265868720188608, 0.29263667690305323, -0.5782377112695253, 0.18213761213094717, -1.5889661545682068, -0.3131970948928054, 0.5094699945029948, 0.8031940608979733, 0.09179725829400184, 0.2864241388260435, -0.9500746395817047, 0.6725974044279321, -1.2009975023050596, 0.71611413199797, 0.9846874185421877, -0.9594870890895034, -0.1795156699350937, 0.07607635360533652, -0.04228393491862331, -0.3068006982292561, 0.8591572349530153},
    {-0.006408109620568635, -0.8134202519896924, 0.35676762385926786, -0.39071410080485924, -0.8355024517074418, -0.861760606427147, 0.3794635218680497, 0.23065126496835786, -0.46904675781717875, 0.18301514588268902, -0.6149510672945078, 0.376734816064231, 0.6004482672073632, 0.5736907197525051, 0.6858861242321288, -0.11675491528782865, -1.1276203820737276, 1.2257707383354257, 0.3358009426891425, -1.375263646881307, 0.5573567682441972, -0.3900570929110163, 0.57504335825202, 0.2851218854438908, 0.4146764444989646, 1.0229087056812987, -1.3851687289767742, -0.39346192145950054, -0.9496130711087832, 0.2903218185195393, -0.05068617384870866, 0.6766378264906862, -0.39884103972051194, -0.7393163810870171, 1.045164834165708, 0.19090336987658604, -0.7121227144278547, -0.8221151747894615, 0.7114625650902382, -0.24166592216159186, 0.620492695164535, -0.5144727254915971, 0.2801060776300622, 0.7050511544995406, 0.45436980689530176, -1.3201160293944947, 0.007609402467004222, -0.08399027037822519, 0.29352549575477505, 0.8023887122257826, 0.12313567796458919, -0.8048869524523705, -0.05640628251052743, 0.45603961074533195, 0.07860409637563537, -0.37410447640242334, -0.9389017039602103, 1.0103329786245605, -0.7783233653650637, 1.1416467560814973, -0.8517196917342079, -0.024717393320629888, -0.49978061860754575, -0.5286743178728411},
    {-0.3714670376714192, 0.43362328197478855, 0.33811239538460225, -0.7301683500985706, -1.0833879753866902, 0.21265994037288707, -0.07238346141917137, 0.6757803361030276, 0.5891744041772561, 0.0847486908818883, -0.7761774429886643, 0.5926436928012673, 0.8642952283362079, -1.1051116380742165, 0.6465281831545314, -1.0843972235438515, -1.0746043448059936, 0.7138268743815464, 0.41731137056808104, -1.5910860687871002, 0.37954711262825125, -0.7985689384518528, 0.5478780043541595, -0.9544701141483771, -0.9707157809417787, -0.7321785930874886, -1.3050512185514638, -0.005331502850276423, -0.49073284530497663, 0.11486965939690418, -0.7089219188554251, -0.5360042756027357, -1.025572667115345, 0.6730939320268958, 0.6675429014791375, -1.4737291485014627, -0.6885300035789126, 0.5275197062608536, -1.426393815425739, 0.5144794882186784, 0.39649430851750067, -0.6911274270097951, 0.18263106959499614, -0.28656813899503925, -0.5012349395847048, -0.7166135366937004, -0.35135225909158074, -0.77608949200675, 1.0440351984838732, -1.1652779295527136, 0.1449307311866517, -0.03190724875985024, -0.9698059163423286, -1.275080636122514, -0.9124685021411296, -0.339930168124725, -0.1444728830001186, -0.5986685579823711, -1.3756174158984058, -0.7010189286258541, -0.9460372803090277, -0.15866344486712364, 0.7535016763009654, -0.8259644118270892},
    {-1.4292690820556917, 0.614179498623657, 0.46054031057688183, -0.8548913988018227, -0.35032864807680686, -0.9300713172129881, -1.0296945934845663, -1.1620580828477796, -0.3821505620428159, -0.6842333015879802, -1.2242441965087458, 0.286589261137928, -0.341583583385673, -0.8634874392728992, -1.0969449326489997, 0.29423290384308776, -1.013153362426157, 0.44131663282499406, -0.32619487460337493, 0.10843175224914015, -0.3502463763403688, -1.0491015368648988, -0.006149104192453786, -0.525792320794082, -1.1048578036025323, -0.8283569581370562, -1.1991148293700473, -0.26262539655890005, 0.6304460717393553, -0.19920901635511679, -0.31650110572267814, -0.8735474682148838, -0.09974273885852471, 0.7588586650582502, 0.1352393646137309, 0.20440810322957512, -0.22857575783938794, -1.4560209949472414, -0.1621168191477399, -0.8906080305084015, -1.2540392309941681, -0.16519334583143783, 0.497413324531444, -0.12287189868295713, -1.3057870612458866, -1.4712917399955185, -1.4763039266801228, 0.5229525114713461, -0.21269796188217194, -0.20588684000460325, 0.7277446125967797, -0.27028538818257525, 0.08978353707501767, -1.5277452855374682, -0.14376228665512983, -0.5115690384335628, -0.20338740281648085, 0.6157957878349466, 0.5634812028552729, 0.4498831117640039, 0.5991783792259172, -0.7577284395432524, -0.06455605415013377, 0.39928121226677826},
    {-0.10443918869540901, -0.07817134320937161, -0.32502262532288795, 0.5657583446011253, -1.0587019495454857, -0.917220700977298, 0.6065053085398884, -0.22192511119005623, -0.633833636932349, 0.7876718079602305, -0.5523526781457709, -0.6955995015723189, 0.7913673727941773, 0.6173100570045087, 0.3550072991679305, -0.8022168117162263, -1.2191720998200088, 0.38977891498578277, 0.47690871404896185, -1.2948021529535552, 0.028385351635303587, -0.10914375627779592, 0.5830195973247322, -1.407014989263305, -0.7012242438112121, -1.1472508450865277, 0.2362701673688057, -0.14201194940150977, -1.0757921785350413, -1.2698509674141651, -0.9056492018186934, -0.9323813961788142, -1.1338402221573136, -0.7063599966593843, 0.9506895995112044, -0.0642196114791025, 0.048842421745589386, -1.3302659141930369, 0.12419710448639193, 0.8623457128203872, -0.25797304004513516, -1.1370727057896484, -0.08434198139060932, -0.7279428654617442, -1.3437043813895904, 0.09502794810578673, -0.873705787861521, -1.6760180438246965, 0.4299015396469977, -0.5500001324205451, -0.8919095145722336, -1.389330961967782, -0.5225648041521376, -0.09891462494132931, -0.7755682983621855, -1.4490805219091716, -0.6459975031955252, 0.5815825901092744, -0.7854226366189855, -0.37717131505470664, 0.5157416056552339, -0.6719657945943077, -0.09858459207303509, 0.8826182443625091},
    {-1.148150396987904, 0.10877253409040577, 0.6372561061533994, 0.19743442870385544, -1.207680460081656, 0.32842837368839295, 0.1662032300588477, -0.2753070741006912, -0.045514013822350485, 0.12330529176712586, -0.6306222067015113, 0.7140866567012604, 0.7003861654055862, 1.2315163065686021, -1.3291625213096743, -0.03622629903673804, -1.4532335724754737, 0.8638920218877749, 0.39448500716042334, -0.5075588152572499, -1.0349762678296048, 0.45485864273118465, -0.6485697249541937, -1.4255877166379756, -1.3909219574903136, 1.153808693689672, -0.4984286383208055, -0.3765166432883937, 0.17133399008096442, -0.09755050367798479, -0.5845147906263168, 0.7302434089185438, -0.1749968774334634, 0.8683649802024868, -0.6267483324126375, -1.161092843955094, -0.8115960885989696, -0.014496534419317619, -0.9052009324403103, 0.883810050722692, -0.22488864387898233, -1.31711510036251, 0.7040140806876212, -0.5384587927469224, 0.4539803090669136, -0.8057785813653675, -0.6273662144453934, -1.4032265280643696, -0.16282273415203288, -0.17529663409804913, 0.7158125052298765, 0.45574374467947265, -0.16458702100466932, -0.884871447225403, 0.12930121100101757, 0.05349919979090967, -0.602317103682943, 0.19930263720204608, -1.2212739389119829, -0.13869899342245084, -1.0050069122376204, -0.8121014551063029, -0.2228977713009755, 1.128744017274851},
    {-0.4000344465576498, 0.11653039670370349, -0.5330665168979745, -0.20648915597323658, -0.37558994565046167, 0.19531088721941361, -0.23666903724746477, -0.748367194545518, -1.0562020255362994, 1.3475692664077819, 0.776632694385636, -0.5094811508009234, 0.7919516212704649, -0.13443768114802435, -1.094316873190282, -0.8941250498520241, -0.0014765133508983935, 1.5084447444373337, 0.11612813822906563, 0.11531489976785862, -0.9307663901491618, 0.6392562720726348, -1.221465733875939, 0.42555345451808396, -1.7236596434860019, 1.0581542414985703, -0.18753573900272577, -0.34742657445177344, -0.6615925140469731, 0.2223578439055958, 0.2824661432881436, 0.6540411965650748, -1.0057802849799156, 1.6025043386163538, -0.4092242908422702, 0.20348951893801845, 0.1831381964278401, 0.06864542101040443, 0.6179128166527513, -0.3892433965308208, -1.5777070612881363, -0.9739775434370513, 1.4894733787008487, 0.8690748725800537, -0.9660428454653263, 0.16700594825537596, 0.6358947914841907, -0.613864387732139, 0.3040318025365732, -0.1126742014434076, -0.5317185808601885, -0.012702491662214356, 0.8907804026658294, -1.7022606111600345, 0.06454851534826961, -1.4976180342403094, -0.6795726010938926, -0.007259953300452406, 0.17924475728739003, 0.0747044814274604, 0.3751454868825418, -0.03749339435893074, 0.04331725730369082, 0.2709249023476828},
    {-0.9847696802396179, -0.5591599961140166, 0.3447052020189254, -0.7743465717640832, 0.7189652909171486, 0.8315398892650825, -0.43834421386174793, -0.7646681301525455, 0.6684707376757458, 1.146024461464561, -0.3132619601256195, -0.5604139384116922, -0.5820478626025841, 0.42509466999682793, -0.9747634209490456, -0.7420286292763218, -0.17605295403030763, 0.9021906003178652, -0.4728953417410411, -1.7432426014171594, -0.3348335234865622, 0.20107627324869387, -1.1383418237766811, -0.061764704923981874, -1.3200921588652887, 0.8824620374694133, -1.2330577830744027, -1.0432116905827342, 1.1849095822667062, 0.6348560186288599, -0.8811311641091591, 0.02372149692738767, -0.22587477905019174, 1.312866700167985, 1.1580334558524705, 0.010965104402757112, -0.6471933968765322, -1.0998520532755653, 0.5599839952227309, -0.5080970703159415, -0.7597561389466523, -0.5962283502288622, 0.3147456514669433, -0.22793416138870648, 0.19405721151765473, -0.4173435293504093, 0.44830680576947946, -0.5992400074517136, 0.44351055042955406, -0.14424310253797293, -1.0868201989297221, -0.05339079118959838, -0.9570027821032439, -1.3181133803662457, -1.0226350622599796, -0.3460632331085336, 0.012567773078809392, 1.2921547578447985, -1.117559385935545, -0.5894969335902746, -0.6147459805225735, -1.5435944386342093, -0.9206726079328532, -0.566843357101755},
    {0.05118525745630033, 0.09751129276845054, -1.138299085963186, -0.3890643925109382, -1.2499790909863457, -0.9961870861906459, -1.1429655322549181, 0.4920826915018002, 0.6280307477462689, -0.3139796811482028, 0.18542322146800633, -1.082006129264431, 0.6065363253224125, 0.20587490657395272, -0.2518945279239784, -1.5030799612036587, -0.9885597102100514, -0.3118131300928037, -0.6894584824598844, -1.7912196236753442, -1.2686675850517992, 0.2033645247663054, -0.9041240325229641, -0.45033387427014343, 0.07537439780930942, 0.1837238087163476, -1.1458057230757406, -0.2362436244910165, -0.06794108587979711, 0.7788329187886036, -0.6008513588522647, -0.3161992106354114, -0.24645577507361777, 0.44849351725263276, -0.4015509979804585, -0.8060882567654052, -1.2667342289382661, -1.2246945009786543, -0.7226588293807408, -0.03534479124102352, 0.15925556422506293, -0.8964832767086616, 0.20590112869841296, -0.5992479567386875, 0.2688250292282269, -0.47803693554460347, -0.1959112354037477, -0.05632531626548467, -0.0022700885957076047, -1.082527915537677, 0.006437103627335819, -0.681000797275274, 0.5272203180092963, -0.35675187834187666, -1.053219229609638, -1.3222806920979375, -0.5692305262041658, 0.5954076732230544, -0.7367113341999239, 0.4591971562625964, -1.2270145808013868, -1.7943306316154073, -1.1921216105208396, -0.7653654233175703},
    {-1.0194661409967518, 0.7483266220361005, 0.21033366664671282, -0.4910302764040225, 0.5663642350313457, -0.8877585144398502, -1.329644662966069, 0.16897637378007113, -1.2178199399086989, 0.9203110068156656, 0.8793665780134341, -1.280206802705871, -1.0019469053465964, -0.3903061574204216, -0.3176960216228243, -0.3279642948446171, -1.3707187871406583, -0.5490216839796972, -0.2032393718338874, -0.9822833761600808, 0.26012752550845747, 0.32956191298917165, -1.21153092196469, -1.2426437550006808, -1.322852709027954, -0.2066506391600535, 0.22516650272383046, -1.1382678504793289, 0.6633352399803772, 0.7183987125233002, 0.2033286435197564, 0.34375587680540604, -0.5771543042223777, -0.05241548744180669, -0.2028772402673262, -0.1800301867881634, 0.012517691562203236, -0.9429336077238634, -1.2316043199185336, 1.1716955148973696, -1.727897391656694, -0.7844224141083985, -0.22802790541583007, 0.3413759974205723, 0.27740399823099365, -1.2939336967042139, -0.609001153183439, -1.4607491082625477, 0.46793030729501645, -0.14553282773502674, -0.9573548107661518, -1.6056847593735635, -0.15652075156505627, -0.3196805004493104, 1.052602500099786, -0.993495660316692, 0.4151791546006148, 1.061223115234694, 0.20421401835005715, 0.0386181529275526, 0.3388008255887721, -1.1992785487468074, -0.6681982266169852, 1.139909499616068},
    {-0.9376349521283627, -0.04492545658412471, 0.11890346612889216, 0.8133168412882105, -1.0539080658351903, -0.8563249134466583, -0.035037902032509664, 0.8278920078949237, -0.8030371415952761, 1.3162764901649868, 0.6732464601205912, -0.3911663768964268, 0.49745152620763006, 0.7942326308191667, -0.040854283599735516, 0.00427682833920432, -1.1605938498996557, 1.1724920882558845, -1.0417507437841282, -0.5295110230136522, -0.9044069555036048, 0.707417117698767, 0.6924155286534436, 0.375698091923315, -0.03316255220860216, 0.38777667080283, 0.013661468568986637, 0.33626759851652954, 0.6506846686587204, -0.9788395312036839, -0.003343257098643001, -1.1642483442031994, -0.14595168268064515, 1.3690871126253434, -0.6882421074751734, -1.236441856904704, -0.47345584485996917, 0.09745542308009389, 0.4296317451644528, 0.9536717374343013, -1.6705480101742511, -0.897993501564919, -0.7275967283410915, 0.5445840378329706, -0.8545882967632705, -0.6954385898186162, -0.47059232838120507, -1.7292338569738004, 0.6409823645464202, -0.6925906621872829, -0.5859020716977533, -1.2473498395403981, 0.6344537478931013, -0.19439800301156687, 0.6004396484162203, -0.2179736621363812, 0.4755448686902177, 0.600574352171849, -1.1063889132195237, 0.9100253892588425, -0.9363174195659008, -1.120563864483707, -1.3526760763500059, -0.6059654828779051},
    {-0.6060378734925042, -0.1480746906599832, -1.247622225894562, -0.13955016663936548, 0.6744641796737548, -0.7853535807159077, 0.7688625837874594, 0.5960717755513041, 0.44838164272418685, 0.8106495331749582, -1.1111068164722302, -1.3884644878986203, 0.11200413845137114, 1.1450117406975933, -1.3063622250535871, -0.30961075867726195, 0.31758366208982236, 0.6920094264940354, -1.3315658973808349, -0.7383096740996695, -1.158349214206797, 0.2218168467458729, -0.5872862286405499, -0.40571685386237877, -0.5101098474759426, 0.603786041143932, -1.461018854177008, -1.6740268200663049, -0.07991133357426694, -0.21752659167659516, 0.03304724697338257, -0.22877532376062085, -0.8777363572203448, 0.9199272315124842, 0.9922616806761706, -0.23114600098069096, -1.5346801614216175, -0.6946820915259103, -1.5054635081022805, 1.0469128843705158, -0.8524181178174817, -1.2207365030607442, 0.872413104649882, -0.5729282801999128, -0.8212696157895953, -0.48488834353032323, 0.3599478788559718, -0.13579914243460328, 1.0203452385209928, -0.5924232545212995, -0.2957122185421904, -0.3810279520672132, -0.7547162698516877, -1.8663749687231055, 0.03275366638151491, -1.3355990022308637, -0.665889596651749, 0.001470129336668578, 0.6120974014893533, -0.12710917829250432, -0.9786352588702246, -1.4790925173949019, -0.974668799673221, 1.1679269793405833},
    {-1.1072718656487586, -0.3335425083525156, -0.9193615100175649, 0.5724869000335271, -1.337864536825624, -0.09338559095624091, -0.4164425505151015, 0.6325469028686753, 0.274601878187892, -0.42688478012490166, 0.10471659190442274, -1.2162169596169303, 0.9501221422949047, -0.3325218951455283, -1.0758973261356481, -0.9921817340080141, -0.6330060590990573, 1.0584224615089914, -0.237066143313048, -0.21156461800335052, -0.9129335661782818, -0.011024980480207693, -1.2608664084342454, -0.9574008121043841, -0.8806333687709689, -0.5593542148690396, 0.5086499800622277, -0.18295120111963215, 1.127246307672408, -1.0914323999168465, -0.36817546540143264, 0.5046535422289864, 0.19988609916077985, 0.8919003577596616, 0.8857836554842495, -1.6110148198380712, -1.4706774588516267, 0.4658466946772723, 0.3118644534890865, -0.09908484570136218, -1.34880345560493, -0.5364936512579616, 0.7348389074397235, -0.8750649939375915, -0.2733571202355788, -0.9588822441134919, -1.0554673350520427, -0.24896850909657978, 1.089259285679881, -0.6775871748060209, -0.1593199271610993, -0.03691035189607951, 0.6879489976015747, -0.5444270730231815, 0.27545041983008633, -1.367269762755093, 0.16513600115170937, 0.7211923730006412, -1.0032707694721952, -1.0586035573427401, -0.6994703117951796, -1.5324523734385882, -1.4272974732030244, 0.47444553624032276},
    {-0.9468171530684218, -0.6315339932420467, -0.5265893371990983, -0.1964998077810586, -1.3127716106395542, -0.3424614596000401, 0.49968547335492647, -0.2694392341332049, -0.8133611003202327, 1.4426914747929789, 1.0636693349485824, -0.6876391073707846, -0.9085748668300603, 1.0386902052800775, -1.5666579094400834, -0.8724266127159418, -0.645520546889771, -0.4547770516628323, -0.6594306331200493, -0.5281112210220744, 0.01257808048614743, -0.07382201258743637, 0.527537589126947, -0.03931519933705353, -0.5122166675516657, 1.1910464212627523, -1.2506437361903129, -0.17302358698607673, 0.2972477478948426, -0.9586177583278629, 0.28594690256257077, -1.2347723042518282, -0.21500812933113056, 1.1680844456180581, 0.7092817362869489, -0.2833659955474735, -1.5942782815710188, 0.7996598740641544, -0.49812546157792065, 0.7916455103546374, -1.3252274021339714, -0.03610602781239658, 0.49754295269731746, 0.07226619833885721, 0.7827707319830612, 0.5084050483434697, 0.07500032956288151, -1.4698921713552071, -0.2838664055395434, 0.7031415042853318, 0.5676050375980676, -1.418428782480988, -0.0016561288759382176, -1.5827166433629636, -0.06789508037851978, -1.2166131273558625, -0.8478595338528842, 0.1966088750217521, 0.21870055410203243, 0.3921105114391007, -1.358122523704094, -0.6858359010389601, 0.4901422626203361, 1.2351505394179036}
};

static const float b1[64] = {1.5101248349265102, 1.350267315366463, 1.4400022434839133, 1.4657053768767696, 0.8607527256483968, 1.3253687012865345, 1.5262124083137116, 1.3945072933513822, 1.284867537629078, 1.11439478307051, 1.487800157158322, 1.4955383593668776, 1.411374188760797, 1.4718856346211906, 1.3782551899583009, 1.4997715552043696, 1.327058221425237, 0.8370580473044117, 1.481227195572871, 1.3703018372947386, 0.8404084437807721, 1.4631156503320144, 1.278558848691886, 1.4929928275039483, 1.3405199572984734, 1.4450318464263694, 1.3267541651443504, 1.5105807387333592, 1.4399706899986446, 1.41241436105383, 1.193723474779905, 1.1458763645966121, 1.1060275248774076, 1.2562121885557658, 1.4469249875588743, 1.4831030137043895, 1.2904758052839378, 1.3701483065138358, 1.5968512702977624, 0.8757328099304404, 1.530358658546303, 1.4169683680726486, 1.439736398539231, 1.4594230636611574, 1.3507830530310696, 1.3704139970446383, 1.4865052643022927, 1.5244573241656327, 1.4066668785550462, 1.4262857147469286, 1.471995468782888, 1.4704024655090957, 1.418496384288004, 1.4455843736056837, 1.4725523811688959, 1.4056870172067497, 1.2973248500419567, 0.885331998904453, 1.4929659915981879, 1.3740342634628686, 1.240083914878137, 1.4709630059322463, 1.337225560874151, 0.9244341731803897};

static const float w2[64][32] = {
    {0.016422723030267258, 1.3423353418019728, 1.8534729171011437, 1.1368512931781134, -0.014479633977515364, 1.3098408254047285, 1.1968067357541852, 0.45927594637160224, 0.2703043858335503, 1.6158210402384334, 1.8159446889786512, 0.8237021336459613, -0.8661657027561568, 1.1055480690393633, 1.6570181715769545, -0.14858328440841298, 1.0853346399797, 1.429237417152843, 1.825884589998988, 0.2099810744702947, -0.8436482790820056, -0.010814376945767536, 2.157251592911373, -0.5086241504343452, -0.33669758865991584, 0.18569644077805547, 1.743507327978399, -0.13155227426825833, 0.30779652866169466, 0.7418640678294124, -0.6219679933151381, 1.1178782325929957},
    {1.0496623295033893, 0.30067489520757557, 0.41297606679180704, 0.6689716943103091, -0.39321596108622203, 1.2392689325595851, 1.6388060573999124, 1.1666559635498253, 0.9233923814521385, 0.9327066117927354, 1.5070216764773579, 0.4987700831634434, -0.1915947073511725, 0.3367693094807495, 2.108088642795432, -0.7718852180712953, 2.0346931563912545, 1.4514292296666458, 0.608926536994053, 0.0445024363102712, 0.6781456134546627, -0.5197271594329268, 0.4887599206835919, -0.1564878540707252, 0.703402338242003, 1.689897568359196, 1.593114724187655, 1.7260267530716138, 1.7672132444148496, -0.1678173572261964, 0.7769480760266063, 0.790936344283398},
    {0.9766260041294437, 1.6441124926812292, 0.29321145779823166, 0.6546579020763116, 0.7805556690836951, 0.33688367084403825, 0.8203792763851564, 1.44024755456751, 0.23605497778918558, 1.2246155327036916, 1.9441604465568405, 0.8433225918739681, 0.7484485743964427, 1.41764457377693, 2.025061310809323, 0.16968542368922557, 1.1021658837540096, 1.9373600357090877, 1.623889667055335, -0.027297726488861272, -0.6522878357892249, -0.49247153017000195, 1.954790626914484, -0.5210300620930498, -0.8883064087677298, 1.2208061471020282, 1.1907592642922855, 1.621288275650051, 1.0535398279198094, 1.6562802687317653, -0.6054993900399014, 1.9872797596542793},
    {-0.08798866990960127, 0.19949659238556516, 1.9206249246194638, 0.29077108208479263, 0.1285453053016024, 0.16014789631145812, 0.19990011908276667, 0.7901185605115304, -0.05992091552094419, 1.6977749526086985, 2.2097720967839596, 0.6151034193034688, -0.6181325885952711, 1.5315010398856694, 1.6180824834729572, -0.7145151946530557, 1.1440665498312403, 0.3481853090034002, 1.241680348225206, 1.1180805078216778, -0.3559620647739155, -0.44891754206545403, 0.56799358553774, 0.5691967584718993, -1.0569621426728866, 0.09817115513458019, 0.5561817457822487, 0.11060818401848777, 1.3561913618796764, 1.0781123797944387, -1.0047449388848688, 0.4856645893617737},
    {1.3267228442890031, 1.2600446246777586, 0.23240225297347092, 0.5850328029874341, -1.0447307725968527, 1.0817994198891199, 1.2999386470946863, 0.7655431609160802, 0.7900721803400074, 0.3114968766662912, 1.4804278830640576, 0.9345744248713044, 0.42043925188229353, 1.9783714940983919, 1.3970809970470655, 0.7724975698235468, 0.30844404898335975, 0.11464354453197938, 0.2193535080578163, -0.43692841372129654, -0.5627342001408004, -0.067048402381514, 0.6122888341204077, -0.5397654210714651, -0.4366464743912128, 0.7190769040061106, 1.253533464673313, 1.215795489525888, 1.408522676551904, 0.8042549287360937, 0.7979147955818214, 1.8106929242887586},
    {1.2067367873900852, 1.0945043355768256, 1.1422260880092434, 0.7371415963421613, -0.0657704797525784, 1.8736993343379653, 1.077240344104915, 1.508898973893882, 0.406912254542556, 1.7167952368534598, 1.4479424358483641, 1.3452138176367452, -0.8720873275372895, 1.132686129651603, 0.26505542166869717, 0.4520102595576955, 1.343845556557549, 0.11728718521845728, 1.8553814221051559, 0.17156447972613606, 0.31098640295974456, 0.3350570809440329, 0.7132767365778893, -0.9893943867161308, 0.06594764930255223, 1.7020919682333218, 0.9789748450445057, 1.238170895806391, 1.72443000838672, 1.0827409196970168, -0.9254600787644064, 1.511481195679862},
    {0.3112489308938187, 0.9885399036122986, 0.7788952521374864, 1.0351379116451733, -0.9965463572098264, 0.5185318678931428, 0.9148101398566609, 0.4568420027892801, 1.3964766910110216, 1.664473967539205, 0.8152604529273452, 0.6659141406276954, 0.07427860025489114, 1.5364463933952277, 2.181718746418448, 0.33215918756561746, 1.8730681701506589, 1.2711100969765845, 1.301041605242834, 0.694229107126308, 0.06894678839367653, -1.0096158009791896, 1.361929000548516, -0.6108385463443519, -0.5035715073188274, 1.6659317453426465, 1.845335313602663, 1.302990235420627, 0.8825981884630703, 1.1905795693051697, 0.05477524414191806, 0.3102844930699126},
    {0.5428810081649529, 1.0181304152889326, 2.065556041205383, 0.9027489322674209, 0.43160166304338876, 1.1134394559569627, 1.6047742418202549, 0.06755905405937303, 0.5729315067965682, 1.34877773601618, 1.0448195397493039, 1.1914534851055474, 0.11676287603784133, 0.9556501397125876, 0.7062058970860621, -0.27619331501704686, 1.6028743608771279, 1.7213084599275799, 0.4213800236947104, 0.9704699356109271, -0.7042962285170656, -0.5905021873787528, 2.0620972285399493, 0.4687388308565011, -0.6639238402968222, 1.900213588560305, 0.6492563686292399, 0.0762911593543724, 1.2223741414814504, 0.7257294351608696, 0.5405842700209911, 0.716367156265409},
    {0.7285699027881407, 1.121813222641708, 1.4969828646865608, 1.122660241041132, 0.3960744679138972, 0.4974412655531592, 1.0543697349056542, 0.9998641561183835, 0.23580667169355204, 0.7878364693733907, 1.0147378815117267, 1.5997665452352963, 0.6642444225317925, 1.091329786410414, 0.7410081459384309, 0.6146331680889968, 1.915612483159021, 0.5726830654255634, 1.3157159578212894, -0.10705889216909074, -0.6730130096941023, -0.07300869333902882, 1.130759304269441, -0.5212774015427408, -0.422660410892701, 0.4557205116188009, 1.865772039515009, 0.2099581967967271, 1.942737571411073, 1.144577902388976, -0.5930935260857797, 0.16870851752346874},
    {0.721421729637551, 1.3962717602059982, 1.6948724106115587, 0.23903511182222834, 0.2649952037984118, 0.1792878801418276, 0.41832272639602697, 1.3749856982160118, 1.3611665313424928, 1.3047416886660683, 0.6374907082923512, 0.465100762455477, 0.6706172514129508, 0.5751058328713273, 1.1704936419136058, 0.3155096354620826, 0.6892767397794739, 0.37018873175847666, 0.8281045022392212, 1.20395913718355, -0.1109206130166051, -0.7772277821650254, 1.0788902633846713, 0.37645199074909574, -0.11489398802709155, 1.911208816891188, 0.7870737636388571, 1.2532435072728865, 1.9324502927669274, 0.5991952544321794, 0.6290278422956473, 1.6095657053504313},
    {0.6944631615897806, -0.06263405272640162, 2.098544673478852, 0.04937516248477516, 0.15609487592636215, 1.0096579937332526, 1.2260289453927011, 1.1663211007308543, 0.4330369645627471, 1.1290050776770866, 1.1102815262323562, 1.6719385315906112, -0.1824739029107078, 1.9686478438149364, 1.8776751067780149, -0.5578815080660801, 1.2734799052835106, 0.4360409895423116, 1.5824804493018374, 0.5631100928594427, -0.7795028095071063, 0.3356132894584295, 1.078646957308687, 0.6501424463024447, -0.19489971364099132, 2.1079557890041363, 0.8963103259803842, 0.7424329307868756, 0.8722724407806923, 0.8873911633517042, -0.040867438201878346, 0.42777759178667357},
    {1.5070103104758943, 0.8758528558633834, 0.8850052905843342, -0.019088907535849905, 0.5392468110678362, 1.8532935898820773, 0.2962959198329162, 0.8764401842304029, 0.5390119893693129, 1.4171611193168674, 2.0918775222348898, 1.9282351318678996, -0.10198645460503125, 0.280506314992935, 1.700386745453929, 0.40141208178142357, 1.1283112327206444, 1.771245068399169, 1.8919192567109266, 0.4056438265083755, -0.3377972436289996, 0.5561847186990273, 2.0092768441129025, -1.0481234977742262, -1.0853675524492579, 0.14250251916722506, 0.7115668498262169, 0.27763314889884644, 0.15202718239046142, 0.5529065754752135, 0.20863494552988351, 1.4102212364243558},
    {0.28600702175160275, 0.4231927413767538, 1.4346837766894078, 1.1419663099101827, 0.4256777212854894, 0.6059881664736037, 1.4849888574318995, 1.706090358146771, 0.6815144457421867, 1.1051976386181666, 0.7400362406847227, 1.461462055375616, -0.907054674264241, 0.18452606959259912, 1.9305710723348668, -0.9783973783652431, 0.8369608198357479, 1.398716096013593, 1.5901048453772153, 0.1860316631127323, 0.3467155085011847, -0.6051246696384196, 0.9075293675757343, 0.18334586667806835, 0.15444949710508216, 2.1478849321700957, 1.7277190696874252, 0.3643987693619792, 1.9749411341634768, 1.2371567514045831, -0.9374611165560895, 1.6118717198307069},
    {1.3983825047731733, 1.1920144775122954, 2.0136996251209793, 0.9680221027908309, 0.8388957935097124, 0.30335275815266527, 1.2839421605660228, 1.650834451473036, 0.7562048729826693, 1.614999249769412, 1.4021751373673255, 1.9564073401749285, -0.5580898625450084, 1.364115277079814, 1.882009198800469, 0.059953569632806625, 0.48506238087652176, 1.3980354679539917, 1.7198540856153872, 1.4722622424126146, -0.7293866638308777, 0.13783554282166474, 0.8626349936128338, -0.4868688461290384, -0.5421366861727662, 1.810934768174458, 1.3301975865282756, 1.4535952556866203, 1.460515222629653, 0.7604693452023764, -0.8361142003797251, 0.8457591695682779},
    {-0.05070988332481486, 1.6978805779903592, 1.9601194297744804, -0.3130653113210644, 0.350210570372792, 1.763645386640569, 0.5612738668969381, 1.5977444173096151, 0.5029759378976661, 1.3963956983926795, 1.9623021046636775, 1.5958993753721489, -0.1832376055331595, 2.0753228397239396, 1.1824302977707415, -0.07107838329065347, 0.35777404833230375, 0.428534982209292, 0.1779998719528285, 1.0458684965700948, 0.39084261707881246, 0.39500453895827753, 0.5894396895441003, -0.19380303909395635, -0.5594322664604796, 0.6147141383573602, 1.0300829306775738, 1.7712381115500522, 0.7938153288460577, 0.5676389590554712, 0.428579544892842, 0.8769382450930239},
    {1.6165303704268636, 1.7263688707084777, 0.27837646937041494, 1.1838985470121242, 0.3229434105137506, 0.5863501240065762, 0.9582873983898113, 1.4209447048914923, 1.004501113369819, 1.769517734354333, 1.4380274745163086, 1.6884015099666727, -0.5303275912276322, 1.3325315476348736, 1.4184531539426302, -0.3655287180662072, 2.129852143270026, 0.26688385160673267, 1.9572802028735596, 1.4320706073225908, -0.8277328407038637, 0.4232975062261829, 1.9358136471258154, 0.6967736366054615, 0.2227199552991386, 0.2798435392004637, 0.24694319297557896, 0.8245496008178587, 0.8195983429961919, -0.09558740849961156, -0.10456349110536568, 0.07104985122238656},
    {0.9557755133372872, 1.0697206653573341, 0.232131815473153, 0.45625648236298455, -0.7550722476069084, 0.7787681315720297, 0.8512521429296935, 0.10336470037419013, 0.39222501949810945, 1.7727366419882908, 1.647191052273202, 1.8009672395314185, 0.2544085254489423, 0.40135624108709544, 0.6917936733201433, 0.05174950374771386, 0.6369536528736555, 1.6772832497690715, 0.026517219618146556, -0.08824721655386902, -0.6405762477767657, -0.48133909761536425, 1.0019920950990748, 0.17044115702242754, 0.39578634332413487, 1.6680892734105273, 0.7665082201384185, 1.3304653119951577, 1.750263388342254, 0.5445873071333666, 0.25917098362425633, 0.07745205939727072},
    {1.0598246118105576, 0.5518450953600268, 0.5633636061213695, -0.24364793026990822, 0.6431895089781459, 1.2520265895644875, 0.8841619351526011, 0.7045443045167671, 0.45842225176995627, 1.3419657965437402, 0.6346758585241868, 0.30615785234575477, -0.022127799628737208, 0.9008016797719518, 0.7966522130873738, -0.7086760060318945, 0.36654603455522283, 0.2042890705805591, 1.4790776524949947, 1.306044209544782, -0.27434354307700687, -0.11176832707221537, 0.438229159288199, 0.5817515989828196, -1.0591364012321327, 0.2778228543129739, 0.5496132934701171, 1.508993227721436, 0.9622555920097565, 0.8325703941803805, -0.7882813721256016, 0.23210314254114636},
    {-0.33132356913953603, 0.386612549803148, 0.4500080895534218, 1.1917604450819872, -0.3235420010015745, 1.9722796775754081, 0.6649991258375585, 0.3124564364239087, 1.517237362899225, 1.9376749515633187, 1.8431444513221107, 0.5112679460141073, -0.38373556426682287, 1.6038775933346774, 2.087134154788554, -0.8720597181019026, 1.7530484466685146, 0.5773629753552545, 1.6573291477828336, 1.1194887894750722, 0.5415749209305392, -0.6159235530752902, 0.9695639441388719, -0.9318785824540017, -0.5020887275107553, 0.8594474797969605, 1.803892341786624, 0.9033816307304269, 0.03831205344454693, 1.2097422235639343, 0.38521817271429654, 0.031940067498470434},
    {1.2309849815478036, 1.6157770347181366, 1.2083338091110334, 0.06978183073744242, 0.2308698936844551, 0.2103878049505425, -0.10606690848886972, 0.8925722391048871, 0.1970319962894434, 0.807093875655583, 2.0862106053206437, 1.2486295198098718, 0.40402785978819655, 0.7558776356396657, 0.763539983261801, 0.5242069088964934, 1.3020349634026083, 1.3854011549959542, 0.1606813263732431, 0.2903246076337838, -0.6905704266355707, 0.734607238559898, 1.6657804163186445, 0.6477813795492889, 0.7079009533630571, 1.3187901277332237, 0.7287629251454564, 0.7226228254310573, 0.9322059716167233, 0.09522483084808954, -0.1645198324454812, 0.2085015195932692},
    {0.45347650369072695, 1.3940944652628957, 0.7067690248765371, 0.2726652763232475, -0.5219947804839038, 0.28185655658221526, 1.0069898883681425, -0.16949834424515386, 1.580174257322541, 0.8352191919598965, 0.5834992271931542, 1.4548182114090429, -0.4577859221098014, 1.8430402464092237, 0.7403732895433408, 0.22052243483684836, 0.9887741431794757, 0.4889425483008361, 0.2386298307622326, -0.43009249837578833, -0.05150576901332371, -0.8633729718451456, 0.802404443694006, -0.8321071317979526, -0.1402919607902623, 0.9675447137322594, 0.5635907596964338, 0.17951320855654518, 2.0325401446210827, -0.11386497104152715, 0.26008033294708965, 0.878165859560531},
    {0.8128907790393733, 1.2339660883745407, 1.830863684473792, -0.5399088036358812, 0.4176106734867326, 1.1685127180610988, 0.673538876033098, 0.5077193980586607, 0.23509341476108392, 1.246112227600894, 0.7017810038585282, 1.5111423492817975, 0.18711543316938128, 1.831218182251403, 1.2871724263452762, 0.13971020425415193, 1.254243186992819, 1.5215982794328644, 1.8140771706938157, -0.16987092061690526, -0.8834193465372879, 0.08787667127028084, 2.1834922990478, -0.6699246346433073, -0.300031186105527, 0.8384127098015337, 1.934639722319466, 1.0590829048015367, 1.4208612410763788, 0.32621822885233026, 0.518026157272814, 0.8255228059173635},
    {0.6018802311863498, -0.07156582457163468, 0.28729587786393773, -0.28746835084427963, -0.011454711286704626, 1.9761815136176453, 0.9208718069720888, 0.06925353725696255, 0.9852504554671838, 1.3737057728980713, 1.8870499194003314, 0.7885168346231507, 0.23360602232844796, 0.8029746021862034, 0.4367462509685581, -0.36440228767369665, 0.17393930260458193, 0.894184304934541, 1.669045611647131, 1.0055597055473562, 0.7578351950496333, -0.6981027264281859, 1.310193546267868, 0.19229525372057935, -0.19855907072332707, 1.2169074984176986, 1.918126813811815, 1.3661540229462796, 1.5072986245098663, 1.1592718482054236, -0.7608586965201234, 1.0581126829491696},
    {1.6430163770507107, 1.1743716448968546, 1.3824715574403688, -0.47296725982956733, -0.5050987767925864, 1.0408278869574508, 0.6457291733546633, 0.04755601588835996, 1.7347486919296808, 0.946807075512105, 2.157452332078517, 0.9990453916736444, -0.558519870720383, 1.0764651644614665, 1.4843706301038933, 0.40793444968675663, 0.47515586189642617, 1.7317574038869037, 1.3360097411332894, 0.6307129217685442, -0.2850871850766038, 0.8915406755562922, 2.0700720351663926, -0.3532122874106576, -1.0725165387897808, 0.9468940975509262, 0.7220971652207459, -0.06232157451449299, 1.8493030114717735, 0.1559194645267814, -0.03894880371662242, 1.726454424171595},
    {0.6176710621659818, 1.2134231132705209, 1.9270273799566537, -0.007481462547088413, -0.11324395679423338, 0.3542514240346543, 1.6021497337373567, -0.0475218503315334, 1.1965409609122566, 0.7179109069090468, 1.1085419350527903, 0.385442791363984, 0.49315062378968916, 1.3387799818482709, 2.1353918466391932, -1.067885557264921, 1.974968737208193, 1.6944930682474193, 0.5549759283339908, -0.09274439437754028, 0.09040046873732226, -1.0475121316625455, 1.0515075047258706, -0.9818000564261121, -0.41268924584751715, 1.3770538458791688, 1.976438680625786, 1.8957630822671576, 1.3581079995439131, -0.0008046784455217554, 0.8026605206452195, 1.9683483391863419},
    {0.1791600386823978, 1.859232140472609, 0.4019142506312255, 1.1297444491090878, -0.46332399062251894, 1.7135991101453782, 0.3567742041089375, -0.22296696012545433, 0.7820825731720973, 1.6135172277008552, 1.6651262431224638, 0.3491129503240097, 0.6834067116064951, 0.5479149991080714, 1.7479376476457777, -0.1017237419768488, 0.5975883991449762, 1.136648281165269, 1.0271730411628, 0.913182627448829, -0.9819606536807128, -0.7807284904510836, 0.4677165101452276, -0.9750842251500457, -0.14841768640191746, 1.439410438049297, 1.4199874174384135, 1.3303204485527043, 1.08498857381904, -0.12345533706118511, -0.46218297658540913, 1.411690698619928},
    {0.6810102137445913, 0.28873845355488564, 0.4261781317549446, -0.20840417018323007, 0.4487717435377954, 0.9841483777184505, 1.5135411576188607, 0.2191895474516264, 1.9561764872608272, 0.5168207142695257, 1.3808281117728172, 1.9152416449191256, 0.6102323491239059, 0.813772256815608, 1.8369524974967841, 0.732685263622869, 2.0644539132466346, 1.6728365225712207, 2.090595657010079, 0.6621857738367949, 0.22370698785952203, 0.32119536550256883, 1.3685714475532715, -0.3372113105621128, -0.4348440417671527, 1.8138904098065365, 1.1495078263265792, 1.3793270857759556, 0.449091795247068, 0.6005099296519658, 0.6838948656075423, 0.4516744205693647},
    {0.278383529126604, 0.7933628253218823, 0.2124890289149766, 0.5209076674675521, -0.021304972284229767, 1.6730494390431556, 0.7328408431106933, 0.9828406461253548, 1.6661059255917612, 2.230042502073097, 2.1194445303069998, 0.8239078100148901, -0.3111082064557647, 0.3201015538328685, 2.051582051459514, 0.35857854531089933, 0.5475711354278314, 1.161362982117358, 1.8350862483560721, -0.06571419137950454, 0.5506658488629812, -0.5124858155072115, 2.1530545085146695, -0.09356773013147554, -0.8055656870617365, 0.5520933732032773, 1.4221044626932635, 0.10924193393779248, 1.9801248412723802, -0.11797255675371614, 0.538977654728136, 1.648709740672252},
    {0.7442017555338367, 0.7140199839987693, 1.108943651399307, 0.35869059549730675, -0.9896344196467254, 0.3812801098735967, -0.19891804325863993, 1.1896677482044302, 0.5851256549463458, 1.1470599772657317, 1.687311549538339, 1.9221775255101858, -0.4056260770975298, 0.14341525529790872, 1.8876939312015784, 0.3218625646781499, 0.48543019924813896, 0.4737453470939638, 1.9049877168053275, 0.08003040830660707, -0.31213266085718094, 0.781083067747663, 1.3880622801842066, -0.5887611139189294, 0.7456683412058056, 1.3303084201038082, 0.7501195683690159, 1.6048955702552843, 1.873285542098293, -0.053361301496528055, 0.060021712520787605, 1.3710753268844118},
    {0.17706452206516798, 0.6269236072387835, 1.360313280861396, -0.13487586149669034, -1.0109088323707378, 1.292360252643219, 1.4595203814185314, 0.9851509467291587, 0.21835348228570317, 2.1942086695618386, 2.1889927186642453, 0.3357276431627644, -0.6234383596720283, 0.11221358280745822, 0.9272284054707888, 0.8179424168095172, 0.2360239277827562, 1.643198337801659, 1.1533236916127392, -0.17360728667846118, -0.34880157659316074, -0.7196764072847612, 2.1317341813401134, 0.8613724938579116, 0.28432200498433685, 1.5970540248138527, 1.1374302824837192, 1.5908118869442915, 0.394009863265528, 0.7151429946701697, 0.5129441484283892, 0.16154262271145647},
    {0.1342424209345577, 0.9826833446757037, 1.9455877916431876, 0.7938984728365829, 0.18481606966394254, 2.0106257919925694, 0.4397851275172551, 1.5158510710741118, 1.560646470437194, 0.9853012559632275, 1.5717243625029464, 0.2754720832043783, -0.3557369245740215, 0.9596376522475545, 0.23962434539682012, 0.6779407296309348, 0.43201583328976817, 0.8898165071692788, 1.3108024211882783, 1.0767478920512654, -0.8054857983217821, 0.8383190774185824, 1.1441831274352463, -0.9899421301091634, -0.5601941953970891, 1.2931276853755076, 0.92064378939152, 0.7569371275146893, 1.1020035057251354, 1.4306317124513284, -1.0185654664143429, 1.6091177478330665},
    {-0.1703797156868974, 0.14086296058631248, 0.4538440330344097, -0.4918075065775662, 0.8645191181492241, 0.8405088697545153, -0.2841583337760845, 1.4793246717982316, 1.785111357908018, 0.2763116876114557, 1.7706051544600028, 1.8007489524452551, -0.040024785259411354, 0.7324841256637252, 0.4939758266012514, -0.0035293876940736407, 0.8608699655728443, 0.9002565646923592, 0.9105185122437088, 0.8741632760715817, 0.446050859839451, -0.18511197874132787, 1.201338105691797, -0.5160774393939376, -0.8722817586794778, 0.34875181551984547, 1.4711289635090203, 0.18825673687265992, 0.6678139986938305, 1.5192110857211971, 0.08831273109159864, 0.8012482353717326},
    {-0.08687833264105392, 1.3722030304356656, 1.0852664241312253, -0.08101278327617793, -0.9926464539436879, 1.8827404716255591, 1.6388225543056585, 0.8601798937387273, 0.7163587355073864, 0.4444217414097512, 0.508956140032919, 1.0149997082081936, 0.38495933475575966, 0.26626347658378113, 0.17280385347103772, -0.2272809389764349, 1.4620670827436193, 0.7157114718103145, 1.8096481379051497, -0.23165362885887794, -0.4878351828954132, -0.7137157734420386, 0.9878220483178891, -0.9224536936229146, 0.5425670435054168, 1.8399882234501845, 1.8744398756632348, 0.8269063959989106, 1.3281434435841741, 0.2477582086660476, 0.2772326897306017, 0.0325885443236857},
    {0.6720625736755018, 0.8033769881818796, 1.0020846491571864, -0.2777748958118985, -0.835434555664324, 1.8596784967310407, 0.2715833365347126, 1.141050736764132, 0.8968828817388849, 1.7019208505446242, 0.7141036670077358, 1.3830266926551344, -0.38949324053289164, 0.38826624411127925, 1.4552351326680415, -0.9263459793488883, 1.0129944423639434, 1.6019543858497072, 0.20397550419795957, 1.344824655400202, 0.7094546391332613, -0.5830044585757868, 0.1802102889862504, 0.8785410151288826, -0.16897204955381653, 0.7177896400525702, 0.9659619756574575, -0.06263811222078762, 1.9696438595132402, 0.9695239858721599, -0.6077889388373667, 0.9208396375078308},
    {0.30927421282475887, 1.3462311023048772, 1.176887601017062, -0.46497604804896525, 0.30078244854045305, 0.206881994997746, 0.49045528140949146, 0.029667261037980765, 0.8948066713385266, 0.3649421054047336, 2.1326636107599937, 1.3769418722785047, -0.3650574598006226, 1.2042653036290791, 0.8468491374684142, -0.20739030170868852, 2.1014134158359843, 1.0620075692933282, 1.9459122593950797, 0.9604817439588834, 0.5475200560960861, 0.18590274959025632, 0.29087348978038136, -0.8500308013429275, -0.6356634857269375, 1.6763919191187582, 0.7361466311700601, 0.7697949358477791, 1.7484546246150463, 0.02365221992029278, -0.6442305772791127, 1.6321061707752467},
    {-0.19630212400439134, 0.04356758411626565, 1.8462449640874563, 0.6688115331215218, -0.37150719511851654, 0.65430801094491, 0.28060915041200557, -0.1944937853497415, 0.2540447120622495, 1.6851887354524044, 2.01431562661686, 0.49383993503046114, -0.9582985418397344, 0.6871871551613988, 2.207605081252817, -0.8771457574209705, 2.1047189406052422, 1.7776448056820937, 2.056715555093875, -0.2905941392450625, -0.6281431855728579, -0.41072988190545084, 2.0761287969160724, -0.9434193785395203, -1.0127465621691658, 1.5772330912920534, 1.1241796402836461, 0.7801153886510412, 1.1076763512961934, 0.7769466411051711, -0.23933263014099052, 1.0133307040081123},
    {1.4563626660082218, 1.3941957146768615, 2.012909685853395, -0.6220959745275856, 0.3233081473218998, 1.837637762218599, 1.7587208248072859, 0.4845135792684161, 1.7671962839429898, 0.5464834334737342, 0.996939071316482, 1.7679509511715517, -0.8034647987261643, 1.1510471882229205, 0.5091469623518777, 0.46374034811418946, 1.7641686750514105, 1.5848856644835432, 1.5629303070737697, 0.6376013610211653, 0.22165989458890673, -0.8964449445949483, 0.4173421933507295, -0.21199889931184387, 0.663430234812092, 1.09510815582802, 1.0200393135142043, 1.8340145393900822, 1.8458784506085886, 0.9101999847058437, -0.7918000761923226, 0.5351094042009739},
    {1.175168538436561, 1.1390805303082263, 0.8514195977296763, 0.8458954941322482, -0.2929471927192834, 1.8524240805114962, -0.0647179325482738, 0.08123790750662847, 1.520596059898128, 1.6369617950815964, 0.6298102150879731, 1.0899962069103482, 0.3554888043319691, 1.2094176933526266, 0.24075905308154616, -1.0048611813487656, 1.989518438347694, 0.3146317923556562, 1.4375817283345433, -0.09526478603586704, -0.02150127990578611, -0.8713453806404324, 2.01595970796279, -0.34560786053718884, 0.36540451602906093, 0.5847450717445426, 1.3816908988988281, -0.0855840648382218, 1.1431461596823262, 0.782803899209816, -0.19497627968266187, 0.9475078264185972},
    {0.9570568709804731, 0.890447092924582, 1.4674980735067882, 0.2836115736727975, 0.5849912813762952, 1.145281128934386, 0.4963369338748039, 0.5211557100237892, 1.9556390517580449, 1.6130321299661123, 2.1625652827059834, 1.5020599404940973, -0.339209721352821, 1.505592261691228, 0.45693588106964006, -0.25297607590971155, 1.992594787200772, 0.6531634375862544, 1.3012411677390974, -0.10590370816773366, 0.31206600185944056, -0.6367822038401697, 2.03869597265756, -0.3877237208372083, -0.634795304686275, 0.8765706879669096, 0.2210381584610066, 0.15694117876620067, 1.0104530887344803, 0.6436488481150824, 0.2175268441449562, 1.9291551835983602},
    {-0.08347841899961586, 0.009393064255919386, 0.5826296956606968, -0.4834760802423296, -0.4305014906602176, 1.6836367871407727, 0.7726363583828483, 1.485721514155941, 1.5965283972490798, 0.5035086150550897, 0.5637366127344723, 0.2835137463710251, 0.25111358543528395, 1.8787054588692338, 1.9073694452084846, 0.6309869651039995, 0.9666358067250818, 0.05413088945298198, 0.31676526835805546, 1.1953522452588095, 0.5107964530831819, 0.7527336783104751, 0.2235617509956529, -0.8251705622232722, 0.2349066740742974, 1.459064803907809, 1.569310579546545, 0.5437613333019022, 0.12118967152332702, 0.5363846459850824, -0.12086141577205813, 1.1374089408840373},
    {0.39021173957380995, 0.8030573301709106, 0.5426078560628911, 0.5633506970143073, -0.9347838336462442, 0.3952408861353548, 1.2922168943923125, 1.2373585314272701, 1.1554451811665398, 1.5922920655467974, 2.1375610492924175, 0.9460020210953983, -0.115104564956412, 1.0545527706475293, 2.0540233828956254, -0.299902087351537, 0.725941786086436, 0.9157799686002724, 0.7193953878409465, -0.41343951277300517, -1.0198113979200671, -0.6393924923503901, 1.697916812625674, -0.35638442876447846, -0.8949994005268741, 1.6560425183704792, 0.758203790569262, 1.9363387069932934, 1.4062965115712172, 0.8433337472196498, -0.7645996069054627, 1.2863100706908852},
    {0.514396873290235, 1.1001492504185542, 1.0016290140581747, 1.2762767879917982, -0.29056249022412495, 2.114193290417426, 0.26434783312848953, 1.3350083070411316, 1.8398055282534804, 1.4323313104788742, 1.4422361963252233, 0.9074911963952119, -1.1828692623535255, 2.0020912276782465, 1.3916370974389407, -0.2630568893694275, 0.8347457517533927, 1.4098049896707945, 0.3329459054552357, -0.14060826012853503, 0.21491696859778125, 0.060740968999494147, 2.1473730308743755, -0.9217988816295083, -0.3744349627407497, 0.6492409455969721, 1.3174791424153116, 1.1479629383808587, 0.8268472213891324, -0.09609230477473864, -0.9003095464604698, 1.7345173980395001},
    {-0.1250576102943542, 0.4236886576134342, 1.8974816597429962, 0.23260148366536407, 0.8745686104415407, 1.9253468610134412, 1.6765699454077465, 0.4836357192595118, 1.6487720910060661, 1.730766246944513, 0.5119386759058645, 0.4424407100042019, -0.9963901210551308, 0.5302198361963246, 1.7988299835998183, 0.006439062132553663, 2.1269905394317608, 0.6420594267323776, 0.3380863480133781, -0.12600504804636878, -0.3107968340648668, -0.6057282425520891, 2.0786316566109204, -0.857717386657809, 0.36655608089176195, 0.25336630813043626, 0.255098135322424, 1.2483308677809013, 0.7269931387575752, 1.0102772479758606, 0.5614866261485673, 0.7647552071328523},
    {0.8012229719875772, 0.12700187350096553, 0.8533115461833265, 1.2173797027693725, -0.9130985480464898, 2.083072264251565, 1.1204086260923538, 0.7569532092779326, 1.4972643665721908, 1.0207188552343385, 1.621779061141188, 1.3945408344530938, 0.4556265012322381, 0.28066113982133123, 1.5219646266080629, -0.6149421227517323, 0.17318196992924353, 1.528590589003071, 0.5763282921589853, 1.1620513332548128, -0.9935732019205643, -0.7612014812078706, 1.8708489046863859, -0.11869213037701212, 0.6788767116835333, 0.5479625527561206, 1.0522168999628665, 1.2784452729598859, 0.7421584028770742, 0.7747658453494821, -1.09441601455737, 1.4946442038815566},
    {1.2710517764356892, 1.2784398237046446, 1.170666806220364, 0.729472111451467, -0.051547691436032446, 0.5620895343111855, 0.6028206186151973, 1.322038669946959, 1.0664102017102244, 0.9246426081011614, 0.9802597020087616, 1.5169790490447161, 0.4455190531899707, 1.521030447770871, 0.7502890056368229, -0.5044008536747429, 1.4964728928707178, 1.356254010029452, 1.5437073360090847, 0.3814730681496403, 0.5458440137889063, -0.023419847360153845, 1.281597430852517, 0.18057897703697867, 0.4874515521029642, 0.936312996641417, 1.5372958591936503, 1.0467210087425154, 0.31592271173673725, 0.2620390181507894, 0.15371954008730637, 0.3503023478507085},
    {1.1558826740803698, 1.7518150970867161, 0.8985274211343595, 0.20997232339939753, 0.06190539156003859, 1.480811670448702, 1.2484457398504185, 0.30852669760611784, 0.4937944941114382, 0.4380110179495041, 1.0536882849319944, 0.6133194084307785, -0.7406093098786716, 0.6615095990445725, 1.7189073312386767, 0.08145665613208786, 1.3194929798463344, 1.0977210893103186, 1.5389700636085066, 0.8575480787252804, 0.9036356567180867, 0.8721176399892218, 1.4990691404973817, 0.5557742320709339, 0.892918203203678, 1.436424751884524, 0.6711733516458291, 1.2673120498813943, 0.2691343137236145, 0.3007271302604745, -0.29782443459616015, 0.0733914137251217},
    {1.6027200630986433, 0.15693335432506544, 1.9358804885204672, 0.7035475774412762, -0.2701553662997091, 0.8486737592064258, 0.6570475407276565, 0.15157203436590155, 0.2955924303746064, 2.148841793737415, 1.9398976556169731, 2.107531172138681, 0.5309826964309642, 1.7269696850381557, 0.9202004653163113, 0.5540439600574982, 1.5781821615678804, 1.9390326099438746, 1.5012106497108375, 0.7794546563526572, 0.7054562281447092, 0.505911088363823, 1.0151637664667394, 0.5848704657118028, 0.24116321934741108, 0.6402965958879032, 0.929059515138759, 0.6014940047064472, 1.14260863137646, 1.1199139904026538, -0.8399374097486132, 1.3060469751298271},
    {1.1536705422600466, 0.6458810333176223, 0.8511361536440807, 0.5219186255563388, -0.13042556204608702, 1.1889461527014327, 1.301198760929557, 0.8740407945575985, 1.8672729300257311, 1.0179816852387378, 1.569035599463844, 2.1117014569232864, -0.8932874380752962, 2.059039807857415, 2.0068500544960166, -1.1056107089118181, 0.4848319514382349, 1.3958748901504503, 1.3766547739597221, 0.6551625970145429, 0.25964200901771833, 0.7943368341500477, 1.4580145815673151, -0.951547952585219, 0.06267090312704318, 0.9280827870902267, 0.18043407666448225, 1.0517380437932398, 0.3152074612224177, 1.4501808213554812, -0.3472282963725643, 0.9906974438829713},
    {1.3951099103667732, 0.6740356529422049, 1.1582333026661804, 0.507985319577778, 0.7556333803198642, 0.6110664099236323, 0.9032258889280144, 0.15279191939117165, 0.7643608149933832, 1.885704917163022, 1.294908217735185, 1.0451235688210037, 0.6729468414069022, 1.1272950410296005, 1.2162155531245245, -0.904622232804, 1.0682560643471626, 1.4356020528540931, 0.43497095793325896, 0.5896514401064633, -0.5201924061252432, 0.7430524813415098, 1.9588636905483474, -0.2867407819807993, -0.6607594814020242, 1.5498924945450518, 1.9409505134564558, 1.5845935698374878, 1.2835004703908592, 1.3385148393015611, -0.9387180528884452, 1.638080320157339},
    {0.408368635955482, -0.15336320144202076, 0.4746756045266318, 0.7407473115625881, -0.8903973049121292, 1.818517692061673, 0.595656331642026, 0.11062528909190542, 1.8436259437669817, 2.074751788731492, 1.992018945935238, 1.91752262524634, -1.1287590203105917, 0.7003582606898817, 1.3492376998328939, -0.32974112138854034, 2.0232568914921223, 0.48807607151238186, 1.4891410410086112, -0.4322541331144, 0.11019741133767966, -0.6236246172184439, 1.192338063125929, 0.16344840541804878, -0.6892052626344028, 2.0060305944785823, 1.4328374652183729, 0.6546902134078745, 0.6662717431927969, 0.14347627243742284, -0.20730167838021693, 0.40429993055314173},
    {1.1191605764754324, 0.685357192345165, 1.640716688717838, -0.07792298484974834, -0.730950137709162, 1.2421155254532874, 1.326416032011947, 0.5238079708856, 1.6706344385777552, 1.3242351126612792, 1.4735556726819743, 1.7028639907948526, -0.16449066540012186, 0.7492625121189881, 2.0775984735312787, 0.40627323696357315, 1.6077783790363143, 1.8813401293734588, 1.3547252168912405, 0.2949642640056131, -0.20518100208524787, 0.017589468480992004, 1.6600701206059618, -0.17158544842750295, 0.8059887742711069, 0.4853139315014541, 1.0414492530645598, 0.7161616684932385, 0.6582923016525105, 0.06695223352815288, 0.43987389967188506, 1.4536279736856714},
    {0.9984163298670304, 1.7277693716492957, 0.8426087214585523, -0.15618617943579333, -0.9482331968979592, 1.8661402314581186, 0.7330774442219734, 1.4060555585322119, 0.5503392384274858, 0.8804771887238292, 1.54123419106722, 1.7960201521202976, -0.923822929544528, 1.676203456746757, 0.7846984196740056, 0.6142100930521284, 1.4003772492071274, 0.8109129839034125, 0.9572455383440245, -0.3472532455410627, -0.28141988923079536, -0.22096380875381344, 1.7768926013675372, 0.9165430150661733, -0.08349503832369343, 1.6689653433313447, 0.3203580116462212, 0.9499435219092917, 1.7543110782108835, 0.1908126130862881, 0.039981173742520096, 0.5964639408944775},
    {1.1276156723412305, 1.3002871148808455, 1.6933976794592072, 0.05227629897251623, 0.6224147112870656, 0.20297584334691693, 1.5512517057585258, 0.8437682602697575, 0.7956277501809084, 0.49316859446541106, 1.9650914963430774, 1.657084426563151, 0.22498076955850072, 1.7124939320807895, 1.2711581929361924, 0.11897835734149795, 1.38847979717327, 0.21172617343964695, 1.8027721113181914, 1.1388997823475724, 0.6617230214424529, -0.8187425270663938, 1.7975791689358969, -0.7163282021188007, -0.009795010687597227, 0.8584120262674001, 0.5295306668310722, 0.9290346914016335, 1.9433035173638118, -0.025116551953090198, -0.9693613759296364, 1.4514100038614046},
    {0.9899089925594103, 0.9248798529612446, 1.5206698029445254, -0.22030636975690346, -0.6707977432277209, 1.562760477530808, 0.6780812662390456, 1.4176997348790077, 0.5087934266901573, 1.5695533911128101, 1.6301383341244209, 1.922588702959161, -0.02480236640968263, 1.9457727312382973, 0.9198594495705018, 0.8024577091551502, 0.8372859417838335, 1.4798631524013983, 0.7980721497457445, 1.352246393744404, -0.08604625133804192, 0.8769127238086754, 1.2651098570804855, -0.23880586576811674, -0.40152138863350634, 1.069216628884952, 0.49318563692566986, 1.242349854303592, 1.246282776175062, 0.6480455649099717, 0.3141988377917236, 1.7889065949163163},
    {1.5705275658601445, 1.3974992454898798, 1.8866094114288492, -0.47620964625715484, -0.5040141956997383, 2.023814367227577, 1.2624452209522614, 1.547245296214411, 0.5858199572930869, 0.9785617506314511, 1.9995594416321616, 1.2199731292662848, -1.1762358295515571, 1.1058903921357481, 1.6490088167375576, -0.1314609245860605, 1.876241937658445, 0.8070028480164539, 1.75185680892824, 1.3629238594880504, 0.43326032517700236, 0.11568116431864241, 2.0342195124629825, -0.8186579638908834, -0.20362648985894147, 0.10677678024395519, 0.6099977022082042, 0.12508849996000626, 0.153230266959882, 1.2517209814555148, 0.3126838575059839, 1.717789978209641},
    {1.0602462517019355, 1.8231686412848076, 0.8657328722170294, 0.46576791166877085, -0.8755100284508247, 1.9829584854400937, 0.5934950179939575, 1.1350016391315643, 0.44404641842044634, 0.4721904631410133, 1.6935159270541624, 1.1652342200409862, -0.37553395597453243, 1.6916401459304646, 1.6068039188055263, 0.693051783274436, 1.7098952596924268, 0.21979581526366423, 0.06225342252506906, 1.060781643381, -0.6378991919877082, -0.6830553442075017, 0.25134731580655995, 0.21913458234125163, -0.5668603465339419, 0.3408050701812553, 1.2556329675412417, 1.8433927767063218, 0.983957934110892, 0.39671791777986976, -0.3751298619117401, 0.12083269393375966},
    {1.3538570442365119, 0.8089986848826913, 1.64973423844479, -0.5134775567081651, -0.5117074012924188, 0.26481016554510495, 1.541323420180398, 0.33109285469442856, 1.8547560441550277, 1.5242426294517561, 1.4279564042148587, 1.2526933906282711, 0.4180852025437329, 0.8487612783236058, 1.1958364795581282, -1.0485319060106892, 0.6075019032353602, 0.9423469589515535, 0.8502707892140509, 0.39080346922345677, -1.0059172198883208, -1.0106786579948095, 0.6573888396789097, -0.2735297824938264, -0.13220673230876326, 0.6827242881283295, 1.319424145917934, 0.35132939006574854, 1.1033764158574664, 0.3177294974798328, 0.41384328887987665, 1.2219643771321924},
    {0.8444692244220754, 1.6149499476690852, 1.37222335292227, -0.11097371001926057, -0.3357546204949401, 0.2527219953746426, 1.4436393457077534, 0.982699789070671, 1.2582797035985744, 1.1958504970438986, 0.3671491338530454, 0.14399616239655805, -0.23239469754326966, 1.5167863159595927, 0.2012224912648423, 0.807358590335036, 0.7977725057504528, 0.9797067126322221, 0.4643970616125145, 1.4018602092703518, -0.8739046690740182, 0.013824328670827338, 0.08008748207652536, -0.24938127929306853, 0.13466026307082324, 0.8960005701170138, 0.7673486059768037, 0.8167753418119296, 1.3395018863801953, 0.7271674548730377, -0.8289430363960877, 0.584333352106353},
    {1.6259621701828388, 0.2574417132788793, 1.994153214161564, -0.2398118625263157, -1.0094557701097284, 0.6668535183860974, 0.5122508251559703, 1.6508717625833715, 1.2612441282884266, 0.944015116378867, 0.686612253578599, 0.9095083089094402, -0.20057403024618828, 1.3998683751429701, 1.3089841884385178, -1.0206653545673652, 1.5041106674848175, -0.005444175406375097, 0.956447793555481, -0.1651246894407999, 0.5427995438106524, -0.8344384329657499, 2.2394002901089185, -0.7755088833144824, 0.6590135827125978, 0.5007293903191525, 1.9041402529937994, 1.435388786530322, 0.37333108337381155, 0.9419493985075403, -0.4729733087737248, 0.5479036480819431},
    {1.4295691269121833, 1.7554068541016183, 1.515394517739148, -0.6122485924280497, -0.3709925925506851, 1.6571379633081798, 1.528717981115011, 1.3802933360174996, 0.08273047383404629, 1.3459814005522823, 1.676804188113351, 1.0333406903928444, 0.4297450057659704, 1.5344001162383538, 1.2031920173846895, -0.2529247182617305, 0.9788255324537597, 1.511761666453143, 1.0442609807647087, 0.9047056154958665, -0.2765580165595831, -0.620438501258767, 0.8341127138974763, -0.6563774688607714, -0.7571382794843616, 0.6506120590211895, 0.5967425885751216, 0.31115357310969843, 1.1918954922204288, 0.49452583836682, -0.1296774090789331, 1.231140128099271},
    {0.4873907760683912, 1.2213168943700683, 0.2608986657861885, 0.9548646509094787, 0.5458427764244562, 0.5623822428954752, 1.3809799578062882, 0.801704244037791, 0.5684565455470635, 1.8405440739994652, 0.8489711866224074, 0.5436457072382008, 0.6507058945775257, 0.8518648220267526, 1.1791508449663581, -0.773589409035525, 2.1335278279764527, 1.146964809767413, 0.557938006441448, 0.8074407268411284, 0.015595841138463214, 0.48514307858380007, 0.49070224417599934, 0.03138328631368134, -0.9797967700073505, 2.0295241459778732, 1.1122323737833792, 1.8463567914154109, 1.3730020090817472, 1.5209919719609428, 0.06851408645151297, 1.110030925844707},
    {0.9840637124295363, 0.76070092610039, 1.8971886457266032, 1.3589369047533892, 0.12863774301285372, 1.961521067533569, -0.1626586901836288, -0.1385853651257628, 1.4639392901009889, 1.7210373863798303, 2.1695018360569547, 0.5712738620211177, -0.33381696302855235, 1.8380075372962494, 0.513791542256124, -1.2385618429084044, 0.4638195302717144, 0.23291096303106165, 0.27941259921663597, 0.7656850826153822, -0.5007200871515385, -0.23633170706316683, 1.6780655269971971, 0.4921313043856352, 0.3638353110728917, 1.2732184499608765, 1.13066932703534, -0.002411187409281264, 0.6662964434063733, 0.8276305914686812, -0.2060741302865745, 0.007608229564954329},
    {0.016899560455475422, 0.6238302729432169, 0.34746455877618465, 0.44954217961499215, -0.8401983920690269, 1.0032252484055015, 0.21099261354567625, 0.5067639298595957, 0.5632636923489606, 0.633063976234624, 1.6066349278613832, 0.7250593703193975, 0.2418699872742511, 1.6521113588459053, 1.4868727158300616, -0.35049573029998515, 0.5956277287044783, 0.6669788014275971, 1.9583816376937324, -0.3696388100400811, 0.37106207177924094, -0.8783045869927475, 0.5682085378906543, 0.5910372896546711, 0.42322817632763643, 1.1771379965311133, 0.09576634931740234, -0.05993407543612984, 0.822236789769334, 0.19593356809980333, 0.4366359465658211, 0.1045871151998507},
    {0.2803581969275359, 0.06470910933251552, 1.4092943774724072, 1.3054288992648349, -0.4995983475857229, 0.817280323255929, 1.1523281612281757, 0.4434209548815543, 0.3554146309631721, 0.9166898718713336, 0.35965225738837275, 0.4123921028763307, 0.13550749114033814, 1.2487819656733241, 0.09294266095303402, -0.8409265361711719, 0.7890118902465028, 1.8093236777733124, 1.9361776886372761, 0.4282465447301595, -0.999561175169331, -0.1952286598094361, 1.1755290228845299, 0.3955351418350198, 0.7859663672929493, -0.004418179609875342, 1.5581136775237108, 0.7710398947167366, 1.6393211864817563, 0.9721232274577313, -0.15219942226756958, 0.20611657043266482}
};

static const float b2[32] = {1.0081277342835269, 1.0277312344111562, 1.3129329401670569, 0.4958916499471452, -0.13877592861392526, 1.2984587553078353, 0.9068739996442365, 0.9197597652034272, 1.2054521726016625, 1.4174855583747517, 1.4264114558723566, 1.3642225440658327, -0.3133258532366231, 1.2788717807696333, 1.3779027222313966, -0.25121751469562215, 1.353147669077752, 1.1539233633936274, 1.2464480585982725, 0.7339771660089218, -0.11443384130587171, -0.10990337561041245, 1.432692849793439, -0.08360324477486496, -0.17441229330674435, 1.302773588311521, 1.237535671043152, 1.1170008057010818, 1.315532850518027, 0.8055800728728354, -0.25323276380219517, 1.1831197550178543};

static const float w3[32][16] = {
    {0.545268672738523, 1.3803406279939148, 0.5694256255702089, -0.12316616076787139, -0.8633362600075912, -1.000263685916363, 0.9591508739202285, 0.3953816040616211, 1.4466079849381432, -0.11228668967162296, 1.372663197543542, 1.6899074098666287, 1.152005150237829, -0.4919492237336706, -0.7811235975080465, 0.14309644489020573},
    {0.6548902215051884, 0.5367876417896744, 0.7642592500141278, -0.8552477080244462, -0.7481663507198083, -0.6319395583335736, 0.35785542365944273, 1.4001838462241631, 0.3464224346139341, -0.9452024253139617, 1.7805044411005628, 0.9488623514264207, 2.206933735000665, -0.9954272027565328, -0.16257043797678625, 0.36666806724415163},
    {1.7647561890117665, 1.8169805995934853, -0.08136729124037466, 0.054539511365932616, 0.7522446807061021, 0.3110444268897973, 1.0645184974435604, 1.8671806907183681, 0.6081745060474805, -0.9231566550100972, 0.718861015556892, 2.1576378529823006, 1.489962237673725, -0.7125140217959985, 0.2788460196914772, -0.3591428910188614},
    {0.14797236113398332, 1.1396775895941558, 0.45822260889470945, -0.7082047289489983, -0.01832402097632741, -0.5681188662326059, 0.7057964292316669, 0.12442429612494472, 0.28411336218898897, 0.31640093134201597, 1.319434284718206, -0.07812500223551475, 0.7575673845966597, -0.700990210219853, 0.923699666583173, 0.7750210123452843},
    {1.163625907354764, -0.33344709412269435, 0.5065628181508838, 0.1957216945782831, 0.06746689216434917, -0.41094537042808504, 0.787839747210591, -0.40459269197206627, -0.5145564287166744, -0.49072605301464195, -0.33047557892976903, 0.777625990734735, 0.5495623727803562, 0.48170609657302343, -0.3756404322121372, 0.45817811821902854},
    {2.2368467711147857, 2.129843623489382, 0.6874216616506269, -0.1602262821300926, -0.07604396942942847, 0.95149408743043, 1.1120221911000847, 1.9542461467282046, 1.6295329508638534, -0.9417795676487057, 0.9201966419415396, 0.4917760585768036, 1.9276663280241733, 0.6663260452626991, 0.16708548235429962, 0.26794384876520944},
    {0.39969057983403783, 1.4389125899890387, -0.814004550323602, -0.7103192314080612, -0.3810890078693445, -0.5549180105637747, 0.8555748819992312, 0.9741518231589139, 1.5006350753541466, -0.42700231445229603, 0.5256024848330669, 1.4853468587229077, 2.1515599106339067, 0.9371973254728727, -0.5643111298087703, 0.6507504463803474},
    {1.9323683119352022, 0.681439398284757, -0.5817872538790894, 0.51913636547096, -0.8635786167483608, 0.38326186459137596, 0.7721645546375122, 1.2496503988717877, 0.5134385529168812, 0.07542568775119105, 2.335217927956721, 0.772321016259022, 0.7067946187349745, 0.5669509350033315, -0.4790965540152153, 0.7058222467625934},
    {1.5538924049500165, 0.7853909818850457, 0.33541964905516924, -0.507088440314931, 0.6843343998035205, -0.3635670057138941, 0.3306059044632392, 2.520036837765011, 0.4547681825836528, -0.24833589163929443, 2.2416849782025423, 0.7735264732424115, 1.0951387172044786, -0.2699047645301732, 0.9513796672610194, 0.708888458779221},
    {1.551045078142226, 1.2805578096550931, -0.7791966997827863, -0.8420901831900798, -0.8749573936587263, 0.8904679277850802, 1.043321123966776, 2.3665562097407564, 1.2391555723136105, -0.5921035298232554, 1.6728364659812809, 1.076129324200622, 2.2775715609124862, -0.9838036594291403, -0.4231363517090466, 1.1208585928896055},
    {1.5740537300015662, 1.7932045348886465, -1.0208172766928583, 0.24415903129213076, 0.5979195850246228, -0.6711160512733176, 1.2899948393064447, 2.1722728184030218, 1.0518727368953924, -0.1482687820176269, 1.612127110541016, 1.6414306482212133, 1.8759872650192952, 0.808226530135881, -0.6420564100769544, 0.0350024397133698},
    {1.1025646677583216, 2.0801412583953898, -0.4201351637143336, -0.9003122426780341, 0.16038724204447105, -0.04941835623637858, 1.0900684090761914, 1.7040009873050863, 1.634759936249552, -0.4254693907040447, 0.7219403493106203, 1.9683013376282978, 1.9025733620650027, -0.9699624476501058, 0.528458238142307, 0.07039986250815326},
    {-0.46106638978718206, -0.6300295002862046, -0.6229266076103452, -0.6688312974410491, 0.07729886846591556, -0.8356667497652787, 0.9954858054538906, -0.6806111555207599, -0.7262484942032212, 0.3521340843934676, -0.8230579589986463, 0.342799736710405, -0.05062381422054597, -0.25080398326464654, 0.41583991171372037, 0.4484444359642357},
    {1.3402194341023947, 1.0226824758343025, 0.04542559348676494, -0.34712699176640044, -0.7994794271895228, -0.9861448336884767, 1.174221349178254, 2.3212941969377012, 0.5573382013602817, -0.09907774505962393, 1.4642439065551813, 1.6267689979674336, 0.46115332152508687, -0.9152036012908705, -0.8178307904668062, -0.5519274086675359},
    {2.2319205193573826, 2.0899742792420986, -0.9774980684792689, -0.5006199425757678, -0.45808068980511274, -0.19242155870725194, 1.888195843156705, 2.3103314666012107, 1.8358671577629881, 0.6839545520170637, 0.5836156274368767, 1.746614717476972, 2.0634854071344018, -0.021612088663515758, -0.7642849627015657, 0.8600821073414334},
    {0.8804903730661061, -0.5308166722150879, -0.10780309335536868, -0.15214545385749123, -0.2662472779078898, 0.24210555797269517, -0.06860245704186478, 0.0957452570391462, 0.6857423257763515, -0.31958240342051675, -0.29959197208474403, -0.7922558680830767, -0.4699174384964835, -0.33322748791365425, 0.8457035622971182, -0.9403984473491583},
    {2.1156396604930263, 1.787092415904075, 0.9180928821448651, -0.8429005943109547, -0.8333521084166445, -0.9162287788364365, 1.9412832134387366, 1.9572466894431912, 2.001494219895507, -0.7870442001509608, 1.4283989039690408, 0.7776589677610394, 1.192281545375709, -0.2961609578601041, -0.6579464522609052, 0.24104179482814508},
    {2.2350748293829303, 1.7620468204775777, -0.7867657032722493, 0.8814655398083958, 0.5157827057222616, 0.7537914381800428, 1.5502298096526514, 0.7511004065337313, 0.34189589004518345, -0.3181786839891304, 2.158360840250984, 1.535071008443925, 1.1113473698276426, -0.56884396170811, -0.07208105803757733, 1.251288428357587},
    {0.7126123456187956, 1.3270141540550884, 0.4992407313339393, -0.8247592664331633, 0.47455936841921886, -0.4626011844198904, 1.9490502315947285, 0.8455677230679803, 1.9133400347324412, -0.7512211978415513, 1.5541153577251945, 1.4105290775990842, 2.2350182184809686, -0.7043425984938573, 0.7605799327930205, -0.048767711679111925},
    {0.8850599208611655, 0.7455848576829898, -0.5112924385332036, -0.3786698555980805, 0.5883318482512272, 0.8764841838472812, 0.29108315475003094, 1.3850793752693016, 1.2605265156491787, -0.34550222773664924, 0.6508857102972313, 1.4314748572387879, 0.16543065317677305, 0.30331556754817923, 0.08334734331099387, 0.8497759776584312},
    {-0.7198552964448713, 0.5303320528900552, -0.9548306711307567, -0.30200711347530684, -0.39316096311167986, 0.92664950345452, 0.2831706449503433, 0.5731059726655274, 0.44676006248202904, -0.4843535495701559, -0.2291065022030132, -0.7033245071819609, -0.7051334012333802, -1.0270398337644002, 0.2348631656291584, -0.8296323376316633},
    {-0.8524439838650523, 0.3304771112979363, -0.37241589081978826, 0.9724588443923478, 0.11014136294665669, -0.9623958678943939, 0.17035131541781112, -0.042564635867098494, 0.5885464749106535, 0.7449949752956395, -0.14734030218393643, -0.8875464184416515, -0.8917716086638847, -0.34855766847215647, 0.04405843258058814, 0.4639394292549809},
    {0.6795514197205798, 1.4696955224187702, 0.21950031481307092, 0.8832054229823748, -0.4806046814803722, -0.9423250705807834, 0.8367398220998005, 2.3305917482869067, 1.1107332169561845, -0.20189143520113587, 2.2396478938212523, 1.2275936102783838, 1.716304289024514, 0.03799429075827206, 0.4210246614080862, 0.03373565518515943},
    {-0.5846855747438142, 0.7616053608510948, 0.4290248813192272, -0.48957243788731963, -0.23848827741568912, -0.5697720753149724, -0.43706513078546605, -0.8489097507530992, 0.01953916134541236, -0.6816522939490516, -0.24221309570616645, 0.8915529115711432, -0.2981780708194118, -0.5890984138043399, -0.19875420370346392, 0.14750551844248175},
    {-0.4874620876495531, 0.1692860899744361, -0.7129134882423918, 0.8187631710544998, -0.5318103278653357, 0.6538870244499524, -0.12078714344919134, -0.631881435665224, -0.7418300765907517, -0.8344828750553579, -0.27067805041496956, -0.4623590399048276, 0.5382929246025663, -0.07234905966727814, 0.5153621948449503, 0.26677633751020197},
    {2.166900323248323, 1.5282357905902269, 0.2825697985485928, 0.15074863691995932, 0.8286046372682346, 0.44960611453392163, 1.0335199763591378, 2.2019343601353727, 1.4081255110882183, 0.054825095868163295, 1.6945861106275897, 0.8981962367552271, 1.2542157866532981, 0.7030100941356119, 0.5854955482826629, 0.9861755994671043},
    {1.4178913836382114, 2.0543888942330475, -0.4101389380939555, 0.1332992350046986, -0.19591893584920209, 0.03142533168356864, 0.2786631611187037, 1.6363765485561974, 1.1457453256690826, -0.6339184517472105, 0.9030930193704015, 1.716850254674469, 1.8463733234813353, 0.7126686852104066, -0.12836484255648473, 0.9584658630593087},
    {0.915998636331551, 0.5860743402502763, -1.0116367203519663, -0.7393035609047982, -0.11340095199813545, -0.6619423251104324, 0.7647149996065103, 1.3077485075379962, 1.6334287895549997, -0.5876360162441783, 1.9670406875168711, 0.7729207352330077, 1.8112992410241424, -0.9700410934734138, -0.6394388393599381, -0.3744399422436262},
    {1.9312514444922104, 1.4034718765294119, -0.36070494171294804, 0.5028620955672378, -0.00022390806437008162, -0.2640737849194811, 0.831439994134366, 0.7308375246150972, 0.3290063356747232, 0.5487052392930222, 1.9585137957760361, 1.68590408029542, 2.0371494996616115, -0.9980086040172523, -0.4602867142301059, 1.2185157877908217},
    {1.2707816105237184, 0.22029364288441317, 0.2245032606095389, -0.8587230134847421, 0.6217593826741464, -0.6209015003423414, 1.0448446451862647, 0.8840670417856382, 1.8425803328995853, -0.7076896230146265, 1.2898776444830953, 0.44819581823073584, 1.112084204875547, 0.4584237697806314, 0.011941224157501392, -0.3184973063098322},
    {-0.7308217398923947, 0.2149658964449796, -0.05425945819245091, -0.38780515438433644, -0.33017067906181913, 0.93309392319856, -0.9228188037048581, -0.6398509824909564, 0.25790352513363796, 0.9683932256199757, 0.11253056024918758, 0.6035705161331858, -0.5456534932049641, -0.02472503248592508, 0.6887565038470209, 0.5206607512084439},
    {1.6077249912938583, 0.8376593160331732, 0.4337043637600828, 0.3509646869831083, 0.6918869060926347, 0.4301761502798495, 1.2242472921041403, 1.2874707802682426, 1.44009836716687, -0.23130639013269544, 1.713128677830732, 0.6865293484640919, 1.866682008095064, -0.29732388574442525, 0.05266189780970591, -0.2849744457632842}
};

static const float b3[16] = {0.8931771288883373, 0.8965819082737672, -0.05116963132292421, -0.0766322357132559, -0.057732478057595724, -0.03928792374892171, 0.7340510399575314, 1.0579263824690337, 0.7922216857093495, -0.032975261457591006, 0.9506945351213999, 0.7773850174157733, 0.8678043547049353, -0.07813670978276151, -0.0012205536304320701, 0.20467486578356905};

static const float w4[16][12] = {
    {-1.5429059301356152, -0.8979184676280925, -0.45188230936525337, -1.1623628255825007, -0.29997492916778223, -1.429816138240954, -0.7624862049146361, -0.981817505430459, -0.4532804440927562, -0.5822944443387201, -1.4600227934249261, -0.9058176206614538},
    {-0.29985289254215647, -0.7794394571453436, -0.38370564481720304, -0.046753197550948485, -1.1911843578670127, -0.8804564032177716, -1.34593584938459, -1.8322007652271206, -1.7283068463934803, -0.8712802627871948, -1.1056935059346513, -1.4386785250588454},
    {0.4138205901896047, -0.9003057287357106, 0.29357566160650855, -0.40413933610840963, 0.034740319702865355, 0.6166363396464851, 0.23094048035606363, 0.8600760668278342, 0.6459436899244302, -0.8170283204842507, 0.3416326236421384, -0.6997436665076648},
    {-0.7237446047535686, 0.7433587495612093, 0.6304091550307314, -0.6069944278786273, 0.3687283301558848, 0.5143161473551535, -0.49097107703428744, 0.7647289266772548, -0.7463873533185605, -0.42367439613336333, -0.057635557671200155, 0.049288575861074116},
    {0.5824145587957601, -0.7740888970798403, 0.5108196817965769, -0.9307199449051801, -0.7748782586656043, 0.8181671000235159, -0.6141383196379354, 0.67133004572079, -0.1644959913098501, -1.0969118477483215, -0.8633407124045642, -1.0408151607787275},
    {-0.6438912466277381, 0.8508686599127925, 0.47382596022268625, -0.7124283365634487, -0.12132298045386482, 0.050902364570319256, 0.02556290133768857, 0.6935598836749797, 0.5177577799229839, -0.6057840770673975, 0.9368591781958744, 0.8713730108369445},
    {-0.9281935735815662, -1.2367430694417525, -0.8875443986233057, -0.062220043549650134, -0.935592665228617, -1.385318787003102, -0.8372291876757615, -1.3277700001533406, -1.4500972651779227, -0.32177351336222826, -0.49004038973245967, 0.24824792841407878},
    {-1.272810703090144, -0.19683812190612976, -0.6584506724314872, -0.7599345605875194, -1.6910184912376098, -0.9304006133089332, -0.6105468897504303, -1.083800558920417, -1.205047828489, -1.1700688535458672, -1.5947815381343113, -1.1651315850318311},
    {0.2527205775122491, -1.0891561974832724, -1.398607717153064, -1.7216297552305195, -0.4220747310415324, -0.19877087497119864, -1.7263779729403326, -0.5952868642028566, -0.3987237908587592, -1.3959342353526825, -1.3916527144782531, -1.522383404141509},
    {0.5460371006810377, 0.3904256667415459, -0.10398737420695517, -0.5134326475296539, 0.02327250071178239, 0.33641845721455976, 0.8127549740810276, -0.6805904989798176, 0.7258534747932368, -0.8756008185317095, 0.16523758936937227, -0.35095540335076625},
    {-1.5598439707194802, -1.001790541744576, -1.4711833992339065, -1.4361932964798665, -0.43328059487400494, -1.3357878948268909, -1.5435054440746758, -0.2737716921839611, -0.5416968180493492, -0.7066791881981925, -1.585473837776574, -0.3879385231582746},
    {-0.5004792660509972, -1.4376801625565592, -1.0998377354582904, -1.1149343128368914, -0.2588603473963664, -0.9263257623017643, -0.2935276653477608, -1.5783399362040405, -0.6405512305627927, -1.0675742705520672, -0.058683939063462254, -1.2546829742096401},
    {-1.4596084160396021, -1.424857105530044, -1.5278054527081086, -1.144468670182288, -1.8333320890519569, -0.8787273839817002, -0.839337345575303, -0.08841180431560944, -1.3871256143781978, -1.6020449765932265, -0.14345049551699773, -1.1684476133957808},
    {-0.3865687957611693, -0.5060549894899128, 0.22007640310143065, -0.8590165285999661, -0.35861581154179517, 0.102372287059209, 0.7476044308652857, 0.22361834717447196, -0.4654321380502103, 0.2192183680182174, -0.11599468291069645, 0.4900379827590224},
    {-0.22177034403461812, -0.9259686277720475, 0.6826483260129722, 0.723882330418639, 0.25753268712401783, -0.9951253405266196, 0.5086880628911056, 0.3905240300135581, 0.3761588197659723, 0.5289190778688689, -0.6888598205485392, -0.8839452057220254},
    {-0.8465320282900897, -0.076653928686661, -0.22106970297530207, -1.4727581667792544, -1.4383490366183653, 0.17940093759549752, -0.026491450203543907, -1.3779502133860924, -0.05660591804502711, -0.14866335905602182, 0.08892322122570528, -1.0235736033036502}
};

static const float b4[12] = {-0.5311583184058006, -0.3602473793797546, -0.4143455351985663, -0.4574410233181344, -0.48403915100110684, -0.4642740357268714, -0.39812086336073466, -0.3973595453065637, -0.3967934655173408, -0.4775345282225992, -0.42390290910462164, -0.4183387707460837};

    // Input Layer 
    float z1[64];
    for (int i = 0; i < 64; i++)
    {
        z1[i] = b1[i];
        for (int j = 0; j < 120; j++)
        {
            z1[i] += x[j] * w1[j][i];
        }
        z1[i] = relu(z1[i]);
    }

    // Hidden Layers 
    float z2[32];
    for (int i = 0; i < 32; i++)
    {
        z2[i] = b2[i];
        for (int j = 0; j < 64; j++)
        {
            z2[i] += z1[j] * w2[j][i];
        }
        z2[i] = relu(z2[i]);
    }

    // Hidden Layers 
    float z3[16];
    for (int i = 0; i < 16; i++)
    {
        z3[i] = b3[i];
        for (int j = 0; j < 32; j++)
        {
            z3[i] += z2[j] * w3[j][i];
        }
        z3[i] = relu(z3[i]);
    }

    // Output Layer
    float z4[12];
    for (int k = 0; k < 12; k++)
    {
        z4[k] = b4[k];
        for (int j = 0; j < 16; j++)
        {
            z4[k] += z3[j] * w4[j][k];
        }
    }
    softmax(z4, 12, y_pred);

    return y_pred;
}
void free_prediction(float* prediction) {
    delete[] prediction;
}

protected:
float relu(float x)
{
    return x > 0 ? x : 0;
};

void softmax(float* input, int size, float* output) {
    float max_val = input[0];
    for (int i = 1; i < size; i++) {
        if (input[i] > max_val) max_val = input[i];
    }
    float sum = 0.0f;
    for (int i = 0; i < size; i++) {
        output[i] = std::expf(input[i] - max_val);
        sum += output[i];
    }
    for (int i = 0; i < size; i++) {
        output[i] /= sum;
    }
}

};
}
}
